#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD7PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold7pt7bBitmaps[] PROGMEM = {
  0x00, 0xE8, 0xC0, 0xB4, 0x6F, 0x6E, 0xA0, 0x79, 0xF4, 0xD6, 0xBA, 0x74,
  0x80, 0x66, 0x5B, 0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xEB, 0x80, 0x5D,
  0x00, 0xE0, 0xC0, 0xC0, 0x29, 0x28, 0x76, 0xD6, 0x74, 0x92, 0xE5, 0xAE,
  0xE5, 0x1E, 0x2E, 0xF2, 0x73, 0x9E, 0x73, 0xD6, 0xE5, 0xA4, 0xF5, 0x5E,
  0x77, 0x9C, 0xC3, 0xC3, 0x80, 0x38, 0x80, 0xE3, 0x80, 0xC7, 0x00, 0xC5,
  0x04, 0x75, 0xF7, 0xF4, 0x18, 0x66, 0x6E, 0x90, 0xEE, 0xEF, 0xE0, 0x7A,
  0x66, 0xEF, 0xDF, 0xE0, 0xFB, 0xEE, 0xFB, 0xEC, 0x7C, 0xBD, 0x70, 0xDD,
  0xFD, 0xD0, 0xD5, 0xC0, 0xFF, 0xE8, 0xFE, 0xEE, 0xF0, 0xDB, 0x6E, 0xDE,
  0xEF, 0x7A, 0x80, 0xDD, 0xBB, 0x90, 0x69, 0x9D, 0x60, 0xFF, 0xEC, 0x69,
  0x9D, 0x63, 0xEE, 0xEE, 0xF0, 0xF1, 0x1E, 0xE9, 0x24, 0x99, 0x99, 0x60,
  0x9A, 0x66, 0x60, 0xAD, 0x6E, 0xB5, 0x80, 0xAD, 0x3A, 0xAD, 0xA4, 0xED,
  0x6E, 0xEA, 0xB0, 0x89, 0x22, 0xD5, 0x70, 0x46, 0xB0, 0xE0, 0xC0, 0xEE,
  0xF0, 0x9E, 0xDE, 0x72, 0x30, 0x2E, 0xD6, 0x77, 0x30, 0x7F, 0xC0, 0x76,
  0xB3, 0x80, 0x9E, 0xDA, 0xF8, 0xFE, 0x8B, 0xAE, 0xB0, 0xF8, 0xFD, 0x6B,
  0x50, 0xF6, 0xD0, 0x76, 0xB0, 0xF6, 0xF9, 0x00, 0x76, 0xB2, 0x40, 0xEA,
  0xD1, 0xE0, 0x7A, 0x40, 0xB6, 0xB0, 0xB5, 0xA0, 0xAD, 0x74, 0xA0, 0xA9,
  0x50, 0xB5, 0xA5, 0x00, 0xC9, 0x70, 0x57, 0x50, 0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 5, 2, 0, -5 },
  { 3, 3, 2, 3, 0, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 3, 5, 3, 0, -5 },
  { 9, 5, 5, 6, 0, -5 },
  { 13, 4, 5, 4, 0, -5 },
  { 16, 1, 2, 2, 0, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 3, 3, 3, 0, -5 },
  { 23, 3, 3, 3, 0, -4 },
  { 25, 2, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -2 },
  { 27, 2, 1, 2, 0, -1 },
  { 28, 3, 5, 3, 0, -5 },
  { 30, 3, 5, 3, 0, -5 },
  { 32, 3, 5, 3, 0, -5 },
  { 34, 3, 5, 3, 0, -5 },
  { 36, 3, 5, 3, 0, -5 },
  { 38, 3, 5, 3, 0, -5 },
  { 40, 3, 5, 3, 0, -5 },
  { 42, 3, 5, 3, 0, -5 },
  { 44, 3, 5, 3, 0, -5 },
  { 46, 3, 5, 3, 0, -5 },
  { 48, 3, 5, 3, 0, -5 },
  { 50, 2, 4, 2, 0, -4 },
  { 51, 2, 5, 2, 0, -4 },
  { 53, 3, 3, 3, 0, -4 },
  { 55, 3, 3, 3, 0, -4 },
  { 57, 3, 3, 3, 0, -4 },
  { 59, 3, 5, 3, 0, -5 },
  { 61, 5, 6, 5, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 3, 5, 3, 0, -5 },
  { 73, 4, 5, 4, 0, -5 },
  { 76, 3, 5, 3, 0, -5 },
  { 78, 3, 5, 3, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 2, 5, 2, 0, -5 },
  { 88, 2, 7, 2, 0, -5 },
  { 90, 4, 5, 4, 0, -5 },
  { 93, 3, 5, 3, 0, -5 },
  { 95, 5, 5, 6, 0, -5 },
  { 99, 4, 5, 5, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 3, 5, 4, 0, -5 },
  { 107, 4, 6, 4, 0, -5 },
  { 110, 4, 5, 4, 0, -5 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 4, 5, 4, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 5, 5, 5, 0, -5 },
  { 127, 3, 5, 3, 0, -5 },
  { 129, 3, 5, 3, 0, -5 },
  { 131, 3, 5, 3, 0, -5 },
  { 133, 2, 6, 2, 0, -5 },
  { 135, 3, 5, 3, 0, -5 },
  { 137, 2, 6, 2, 0, -5 },
  { 139, 4, 3, 4, 0, -5 },
  { 141, 3, 1, 3, 0, 0 },
  { 142, 2, 1, 2, 0, -5 },
  { 143, 3, 4, 3, 0, -4 },
  { 145, 3, 5, 4, 0, -5 },
  { 147, 3, 4, 3, 0, -4 },
  { 149, 3, 5, 4, 0, -5 },
  { 151, 3, 4, 3, 0, -4 },
  { 153, 2, 5, 2, 0, -5 },
  { 155, 3, 6, 4, 0, -4 },
  { 158, 3, 5, 4, 0, -5 },
  { 160, 1, 5, 2, 0, -5 },
  { 161, 1, 7, 2, 0, -5 },
  { 162, 4, 5, 4, 0, -5 },
  { 165, 1, 5, 2, 0, -5 },
  { 166, 5, 4, 5, 0, -4 },
  { 169, 3, 4, 4, 0, -4 },
  { 171, 3, 4, 4, 0, -4 },
  { 173, 3, 6, 4, 0, -4 },
  { 176, 3, 6, 4, 0, -4 },
  { 179, 2, 4, 3, 0, -4 },
  { 180, 3, 4, 3, 0, -4 },
  { 182, 2, 5, 2, 0, -5 },
  { 184, 3, 4, 4, 0, -4 },
  { 186, 3, 4, 3, 0, -4 },
  { 188, 5, 4, 5, 0, -4 },
  { 191, 3, 4, 3, 0, -4 },
  { 193, 3, 6, 3, 0, -4 },
  { 196, 3, 4, 3, 0, -4 },
  { 198, 2, 6, 2, 0, -5 },
  { 200, 1, 7, 3, 1, -5 },
  { 201, 2, 6, 2, 0, -5 },
  { 203, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold7pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD7PT7B_H_
