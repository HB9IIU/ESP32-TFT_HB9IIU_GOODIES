#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0x00, 0x73,
  0xFF, 0xF7, 0x80, 0xF9, 0xFF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x79, 0xE0, 0x0E, 0x78, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x73, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x73, 0x81, 0xCE, 0x07, 0x38, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0x8E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E,
  0x70, 0x7B, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x83, 0xFE, 0x7F, 0xF7, 0xFE,
  0xFE, 0x2F, 0x60, 0xF6, 0x07, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0xE0, 0x7E,
  0x07, 0xF0, 0x6F, 0x06, 0xFC, 0x6F, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xF0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x01, 0xF8, 0x1E, 0x07, 0xF0,
  0x70, 0x3D, 0xC3, 0xC0, 0xE7, 0x8E, 0x03, 0x9E, 0x38, 0x0E, 0x79, 0xE0,
  0x39, 0xE7, 0x00, 0xE7, 0xBC, 0x03, 0x9E, 0xE7, 0xCF, 0x73, 0xBF, 0x9F,
  0xDE, 0xFF, 0x7E, 0x73, 0x9C, 0x63, 0xDE, 0x70, 0x0E, 0x79, 0xC0, 0x39,
  0xE7, 0x01, 0xE7, 0x9C, 0x07, 0x1E, 0x70, 0x1C, 0x39, 0xC0, 0xE0, 0xFF,
  0x03, 0x81, 0xF8, 0x1E, 0x07, 0xC0, 0x07, 0x00, 0x0F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFE, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F,
  0xE0, 0x0F, 0xE0, 0x07, 0xE3, 0xCF, 0xF3, 0xE7, 0xFD, 0xF7, 0xDF, 0xFB,
  0xCF, 0xF9, 0xE3, 0xFC, 0xF0, 0xFC, 0x7C, 0x7E, 0x3F, 0xFF, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xFC, 0xFC, 0xFF, 0xDE, 0xF7, 0xBD, 0xE0, 0x0F, 0x0F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F,
  0x0F, 0xF0, 0x78, 0x38, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x7C, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x0C, 0xE2, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF0, 0x3F, 0x87, 0xFC, 0x79, 0xE3, 0x9C, 0x10, 0x80,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7B,
  0xDE, 0xF7, 0xFB, 0xDE, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0xFF, 0xF7, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xFC,
  0x3F, 0xC7, 0xFE, 0x79, 0xE7, 0x9F, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0xFF, 0x8F, 0xF9, 0xF7, 0x9F,
  0x7F, 0xE7, 0xFE, 0x3F, 0xC1, 0xF8, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F,
  0xFF, 0xF7, 0xBC, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xF8,
  0x7F, 0xCF, 0xFE, 0x73, 0xE6, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07, 0xFC, 0xFF, 0xE7, 0xFE,
  0x63, 0xF4, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE3, 0xFC, 0x3F, 0x83, 0xFC,
  0x3F, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC7, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xEF, 0x07, 0xFC, 0x1D, 0xF0, 0xF7, 0xC3, 0x9F, 0x1E, 0x7C,
  0x71, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x78, 0x07,
  0x80, 0x78, 0x07, 0xF8, 0x7F, 0xC7, 0xFE, 0x7F, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0x7F, 0x80,
  0x03, 0xE0, 0xFE, 0x1F, 0xE3, 0xFE, 0x7E, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0xF3, 0xCF, 0x7E, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F,
  0xF8, 0xF7, 0x9F, 0x7F, 0xF7, 0xFE, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0xFF, 0xF9,
  0xFF, 0x8F, 0xF8, 0xF7, 0x9F, 0x7F, 0xE3, 0xFC, 0x1F, 0x83, 0xFC, 0x7F,
  0xE7, 0x9F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xF7, 0xFF, 0x7F,
  0xE3, 0xFC, 0x0E, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0xF9, 0xEF, 0x9F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x7F, 0xF3, 0xEF, 0x1C,
  0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x6F, 0xE7, 0xFC, 0x7F, 0x87, 0xF0, 0x67,
  0xBF, 0xFF, 0x10, 0x00, 0x00, 0x00, 0x07, 0x7B, 0xFE, 0xF0, 0x31, 0xE7,
  0xDF, 0x78, 0x40, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0x9E, 0x79, 0xEF,
  0x3C, 0xF0, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3,
  0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x80,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x07, 0xF1, 0xFE, 0x3F, 0xC1, 0xF8, 0x0F,
  0x00, 0x60, 0x00, 0x0E, 0x0F, 0xF3, 0xFF, 0x3F, 0xF6, 0x3E, 0x83, 0xC0,
  0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x78, 0x1F, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xF0, 0x7C, 0x3C, 0x01, 0xC3, 0x80,
  0x0E, 0x78, 0xFE, 0xE7, 0x1F, 0xE7, 0x73, 0xDE, 0x7F, 0x39, 0xE7, 0xE7,
  0x9E, 0x7E, 0x79, 0xE7, 0xE7, 0x9E, 0x7E, 0x79, 0xE7, 0xE7, 0x9E, 0x7E,
  0x39, 0xEE, 0xF3, 0xF7, 0xE7, 0x1F, 0x7C, 0x70, 0x41, 0x07, 0x80, 0x00,
  0x3C, 0x01, 0x01, 0xF8, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78,
  0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x1E, 0x3C, 0x3E, 0x3C, 0x3F, 0xFC,
  0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xC7, 0xFF, 0xBF, 0xFD, 0xE3, 0xEF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xDE, 0x3E, 0xFF, 0xE7, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xBF, 0xFD, 0xFF,
  0xCF, 0xF8, 0x00, 0x03, 0xC0, 0x7F, 0xC7, 0xFE, 0x7F, 0xF3, 0xE3, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xF0, 0x4F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x07, 0xF8, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF0, 0xFB,
  0xC3, 0xEF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xBC, 0x3E, 0xF1, 0xFB, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xEF, 0xFB, 0xFE, 0xFF, 0xBC,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE3, 0xF1, 0xCF, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x1F,
  0xDE, 0x0F, 0xBC, 0x1F, 0x7C, 0x3E, 0xF8, 0x7C, 0xFF, 0xF9, 0xFF, 0xF1,
  0xFF, 0xE0, 0xFF, 0x00, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7C, 0xFF, 0xFF, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF,
  0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0xBF, 0xFF, 0xFE, 0xFC, 0x20, 0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0xBC,
  0x7C, 0xF1, 0xF3, 0xCF, 0x8F, 0x7C, 0x3D, 0xF0, 0xF7, 0x83, 0xFE, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xEF, 0x8F, 0x1E, 0x3C, 0x7C, 0xF1, 0xF3,
  0xC3, 0xEF, 0x0F, 0xBC, 0x1F, 0xF0, 0x7C, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0x71, 0xFF, 0xF7, 0x1F, 0xFF, 0x79, 0xDF, 0xF7,
  0x9D, 0xFF, 0x3B, 0xDF, 0xF3, 0xBD, 0xFF, 0x3F, 0x9F, 0xF3, 0xF9, 0xFF,
  0x1F, 0x9F, 0xF1, 0xF9, 0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xFF, 0x0F, 0x1F,
  0xF0, 0xE1, 0xF0, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xCF, 0xF7, 0x9F, 0xEF, 0x3F, 0xCF, 0x7F,
  0x9E, 0xFF, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x1E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x78, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0xFF, 0xEF, 0x3F, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x3F, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF, 0xE0,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x78, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x3F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0xFC,
  0xF1, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF0, 0xFF, 0xC3, 0xCF, 0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xF3, 0xC7,
  0xCF, 0x0F, 0xBC, 0x3E, 0xF0, 0x7C, 0x0F, 0x07, 0xFD, 0xFF, 0xBF, 0xFF,
  0xDD, 0xF0, 0xBE, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFC,
  0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x7F, 0xFF, 0xFF, 0xEF, 0xFC, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFE, 0x1E, 0xF8, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xC0, 0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x7C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xF0, 0x3C, 0x1F, 0xF0, 0xF8,
  0x3F, 0xE1, 0xF0, 0xFB, 0xC3, 0xE1, 0xF7, 0x87, 0xC3, 0xEF, 0x0F, 0xC7,
  0x9E, 0x3F, 0x8F, 0x3E, 0x7F, 0x1E, 0x3C, 0xEE, 0x7C, 0x79, 0xDC, 0xF8,
  0xF3, 0xBD, 0xE1, 0xEF, 0x7B, 0xC3, 0xDE, 0x77, 0x83, 0xFC, 0xEF, 0x07,
  0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0xF8, 0xF0,
  0xF3, 0xE1, 0xE7, 0xC3, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xFC,
  0x1F, 0x78, 0x3E, 0xF8, 0x78, 0xF1, 0xF1, 0xF3, 0xC3, 0xEF, 0x83, 0xE0,
  0xF8, 0x3E, 0xF0, 0x79, 0xF1, 0xF1, 0xE3, 0xC3, 0xC7, 0x87, 0xDF, 0x07,
  0xBC, 0x0F, 0x78, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1E, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x1E,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x0F, 0x07, 0xFC, 0x7F, 0xE3, 0xFE, 0x21, 0xF0, 0x1F, 0x01, 0xF3,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0xBF, 0xFF, 0xF7,
  0xEF, 0x7C, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF3, 0x8F, 0x7C, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xBF, 0xFF, 0xEF, 0xFE,
  0xE7, 0xC0, 0x0F, 0x83, 0xFC, 0xFF, 0x3F, 0xE7, 0xC5, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x82, 0xFB, 0x9F, 0xF1, 0xFE,
  0x1F, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x73, 0xE7, 0xFF, 0x7F, 0x7B, 0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3E, 0xFB, 0xF7, 0xFF,
  0x9F, 0xBC, 0xF9, 0xE0, 0x0F, 0x03, 0xFC, 0x3F, 0xE7, 0xFE, 0x78, 0xFF,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0xC6, 0x7F, 0xE3, 0xFE, 0x1F, 0xE0, 0x0F, 0x87, 0xF1, 0xFC, 0xFE, 0x3E,
  0x0F, 0x03, 0xC1, 0xFE, 0xFF, 0xBF, 0xE3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x1C,
  0x79, 0xFB, 0xDF, 0xDE, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xBF, 0xFD, 0xFF, 0xE7,
  0xFF, 0x3E, 0xF8, 0x07, 0xC0, 0x3E, 0x81, 0xE7, 0xFF, 0x3F, 0xF1, 0xFF,
  0x87, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF3,
  0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF0, 0x7B, 0xFE, 0xF3, 0x01, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xE0, 0x1E, 0x3C, 0xF8, 0xF0, 0xC0, 0x07, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x7F, 0xFF, 0xFF, 0xDF, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x1E, 0xF1, 0xF7, 0x9F, 0x3C,
  0xF1, 0xEF, 0x8F, 0x78, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0x9E,
  0x3C, 0xF9, 0xE3, 0xCF, 0x1F, 0x78, 0x7B, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0x87, 0x9D,
  0xFD, 0xFB, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xBF, 0xE3, 0xE3, 0xFC,
  0x7C, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3E, 0x3F, 0xC7, 0xC7, 0xF8,
  0xF8, 0xFF, 0x1F, 0x1F, 0xE3, 0xE3, 0xFC, 0x7C, 0x7F, 0x8F, 0x8F, 0xF1,
  0xF1, 0xE0, 0xE3, 0x8E, 0xFC, 0xEF, 0xEF, 0xFF, 0xF9, 0xFF, 0x1F, 0xF1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0x8F,
  0x7C, 0x7F, 0xE3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xF1, 0xF7,
  0x8F, 0x3E, 0xF9, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0xE3, 0x8E, 0x7C, 0xFF,
  0xEF, 0xFE, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xF7, 0xCF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x79, 0xFB, 0xDF,
  0xDE, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xF1, 0xFF, 0x8F, 0xBF, 0xFD, 0xFF, 0xE7, 0xFF, 0x3E, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xE3,
  0xF3, 0xBB, 0xDF, 0xEF, 0xF7, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0xFF, 0xFB, 0xFE,
  0xF0, 0xBC, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0x87, 0xFF,
  0xFF, 0xFB, 0xFE, 0xFF, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x7F, 0xBF,
  0xEF, 0xF8, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3E, 0xCF, 0xF1, 0xFC, 0x7F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF1, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0x7C, 0xF0, 0xF8, 0x7F, 0xE1, 0xF7,
  0x87, 0x9E, 0x1E, 0x78, 0xF9, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0,
  0x77, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0x80, 0xF8, 0xF8, 0x7B, 0xC7, 0xC7, 0xDE, 0x3F, 0x3C, 0xF3, 0xF9,
  0xE7, 0x9D, 0xCF, 0x3E, 0xEE, 0x78, 0xF7, 0x77, 0xC7, 0xBB, 0xBC, 0x3D,
  0xDF, 0xE1, 0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x01, 0xF1, 0xF8, 0xF8, 0xFB, 0xE7, 0x8F,
  0x7C, 0x7B, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE,
  0x07, 0xF8, 0x7B, 0xC3, 0xDF, 0x3E, 0x79, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F,
  0xE1, 0xF7, 0x87, 0x9E, 0x1E, 0x7C, 0xF8, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C,
  0x3E, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x83, 0xE1,
  0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x41, 0xF0, 0xFC, 0x3F, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0xFE, 0x3E, 0x0F, 0xE1, 0xF8, 0x1E, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7F, 0x0F, 0xC3, 0xF0, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x7C, 0x3F, 0x1F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xC1, 0xF8, 0x3C, 0x7E, 0x7F, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF1, 0xF8, 0xFC, 0x7C, 0x38, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xF8, 0x1E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 21, 8, 1, -21 },
  { 15, 12, 7, 14, 1, -21 },
  { 26, 14, 21, 16, 1, -21 },
  { 63, 12, 25, 14, 1, -23 },
  { 101, 22, 22, 24, 1, -22 },
  { 162, 17, 22, 18, 1, -22 },
  { 209, 5, 7, 7, 1, -21 },
  { 214, 8, 27, 10, 1, -22 },
  { 241, 8, 27, 10, 0, -22 },
  { 268, 12, 13, 14, 1, -23 },
  { 288, 12, 15, 14, 1, -18 },
  { 311, 5, 8, 8, 1, -4 },
  { 316, 8, 4, 9, 1, -10 },
  { 320, 5, 5, 8, 1, -5 },
  { 324, 12, 22, 12, 0, -22 },
  { 357, 12, 22, 14, 1, -22 },
  { 390, 10, 21, 14, 1, -21 },
  { 417, 12, 22, 14, 1, -22 },
  { 450, 12, 22, 14, 1, -22 },
  { 483, 14, 21, 14, 0, -21 },
  { 520, 12, 21, 14, 1, -21 },
  { 552, 12, 22, 14, 1, -22 },
  { 585, 12, 21, 14, 1, -21 },
  { 617, 12, 22, 14, 1, -22 },
  { 650, 12, 22, 14, 1, -22 },
  { 683, 5, 17, 8, 2, -17 },
  { 694, 6, 21, 8, 1, -17 },
  { 710, 13, 14, 14, 1, -18 },
  { 733, 13, 9, 14, 1, -15 },
  { 748, 13, 14, 14, 1, -18 },
  { 771, 11, 22, 12, 0, -22 },
  { 802, 20, 24, 22, 1, -22 },
  { 862, 16, 21, 16, 0, -21 },
  { 904, 13, 21, 16, 2, -21 },
  { 939, 13, 22, 15, 1, -22 },
  { 975, 14, 21, 17, 2, -21 },
  { 1012, 10, 21, 13, 2, -21 },
  { 1039, 10, 21, 13, 2, -21 },
  { 1066, 15, 22, 17, 1, -22 },
  { 1108, 14, 21, 18, 2, -21 },
  { 1145, 8, 21, 10, 1, -21 },
  { 1166, 8, 28, 8, -2, -21 },
  { 1194, 14, 21, 16, 2, -21 },
  { 1231, 10, 21, 12, 2, -21 },
  { 1258, 20, 21, 24, 2, -21 },
  { 1311, 15, 21, 19, 2, -21 },
  { 1351, 16, 22, 18, 1, -22 },
  { 1395, 12, 21, 15, 2, -21 },
  { 1427, 16, 27, 18, 1, -22 },
  { 1481, 14, 21, 16, 2, -21 },
  { 1518, 11, 22, 13, 1, -22 },
  { 1549, 13, 21, 13, 0, -21 },
  { 1584, 14, 21, 17, 2, -21 },
  { 1621, 16, 21, 16, 0, -21 },
  { 1663, 23, 21, 23, 0, -21 },
  { 1724, 15, 21, 15, 0, -21 },
  { 1764, 15, 21, 15, 0, -21 },
  { 1804, 12, 21, 13, 1, -21 },
  { 1836, 8, 27, 9, 1, -22 },
  { 1863, 12, 22, 12, 0, -22 },
  { 1896, 7, 27, 9, 1, -22 },
  { 1920, 16, 13, 16, 0, -21 },
  { 1946, 14, 3, 14, 0, 2 },
  { 1952, 8, 5, 10, 1, -23 },
  { 1957, 12, 17, 14, 1, -17 },
  { 1983, 12, 23, 15, 2, -23 },
  { 2018, 11, 17, 12, 1, -17 },
  { 2042, 13, 23, 15, 1, -23 },
  { 2080, 12, 17, 14, 1, -17 },
  { 2106, 10, 23, 9, 0, -23 },
  { 2135, 13, 24, 15, 1, -17 },
  { 2174, 12, 23, 15, 2, -23 },
  { 2209, 5, 23, 8, 1, -23 },
  { 2224, 7, 30, 8, -1, -23 },
  { 2251, 13, 23, 15, 2, -23 },
  { 2289, 4, 23, 8, 2, -23 },
  { 2301, 19, 17, 23, 2, -17 },
  { 2342, 12, 17, 15, 2, -17 },
  { 2368, 13, 17, 15, 1, -17 },
  { 2396, 12, 24, 15, 2, -17 },
  { 2432, 13, 24, 15, 1, -17 },
  { 2471, 9, 17, 11, 2, -17 },
  { 2491, 10, 17, 12, 1, -17 },
  { 2513, 10, 20, 10, 0, -20 },
  { 2538, 12, 17, 15, 2, -17 },
  { 2564, 14, 17, 14, 0, -17 },
  { 2594, 21, 16, 21, 0, -16 },
  { 2636, 13, 16, 13, 0, -16 },
  { 2662, 14, 24, 14, 0, -17 },
  { 2704, 10, 17, 11, 1, -17 },
  { 2726, 10, 27, 11, 0, -22 },
  { 2760, 3, 30, 13, 5, -23 },
  { 2772, 9, 27, 11, 1, -22 },
  { 2803, 13, 5, 14, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD30PT7B_H_
