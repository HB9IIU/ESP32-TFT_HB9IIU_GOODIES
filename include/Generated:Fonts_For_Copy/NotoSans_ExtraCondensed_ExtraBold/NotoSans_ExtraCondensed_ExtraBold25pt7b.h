#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x00, 0x7F, 0xF7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x7F, 0x3F, 0x9D, 0xCE, 0x1C, 0xC1, 0xDC, 0x1D, 0xC1, 0xDC,
  0x19, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3B, 0x83, 0xB8, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE3, 0x30, 0x73, 0x07, 0x70, 0x77, 0x07, 0x70, 0x0C, 0x03, 0x03,
  0xF9, 0xFF, 0xFF, 0xBB, 0x2E, 0xC3, 0xF0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F,
  0x0F, 0xC3, 0x7C, 0xDF, 0xFE, 0xFF, 0x8F, 0x80, 0xC0, 0x30, 0x78, 0x1C,
  0x1F, 0x06, 0x0E, 0xE3, 0x83, 0xB8, 0xE0, 0xCE, 0x70, 0x33, 0x9C, 0x0C,
  0xE6, 0x03, 0xBB, 0x9C, 0xEE, 0xEF, 0x9F, 0x77, 0xF3, 0x9D, 0xDC, 0x06,
  0x73, 0x03, 0x9C, 0xC0, 0xE7, 0x70, 0x71, 0xDC, 0x1C, 0x77, 0x06, 0x0F,
  0xC3, 0x81, 0xE0, 0x1F, 0x00, 0xFE, 0x07, 0xF8, 0x1C, 0xF0, 0x73, 0xC1,
  0xEE, 0x07, 0xF8, 0x0F, 0xC0, 0x3E, 0x39, 0xFD, 0xEF, 0xF7, 0xBD, 0xFE,
  0xE3, 0xF3, 0x8F, 0xCF, 0x1E, 0x3F, 0xFC, 0x7F, 0xF8, 0xFD, 0xF0, 0xFF,
  0xFF, 0xFF, 0x70, 0x1E, 0x38, 0xE1, 0xC7, 0x8E, 0x1C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xF0, 0xE1, 0xC1, 0xC3, 0xC0, 0xF0,
  0xE0, 0xE1, 0xC3, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8E, 0x1C, 0x78, 0xE1, 0xC7, 0x1E, 0x00, 0x0E, 0x01, 0xC1, 0x38, 0xBF,
  0xF7, 0xFF, 0xFF, 0xC7, 0xC1, 0xFC, 0x7B, 0xC7, 0x30, 0x44, 0x00, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x77, 0xFF, 0xEE, 0xFF, 0xFF, 0xC0, 0x7F, 0xF7, 0x01, 0xC0,
  0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x00, 0x1E, 0x1F, 0xC7,
  0xFB, 0xCE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x39, 0xFE, 0x7F, 0x8F, 0xC0, 0x07, 0x0F, 0x1F, 0x3F,
  0x7F, 0xF7, 0x67, 0x27, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x3E, 0x1F, 0xCF, 0xFB, 0x9E, 0x43, 0xC0, 0xE0, 0x38, 0x1E,
  0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7E, 0x3F, 0xEF, 0xF9, 0x9E, 0x03, 0xC0, 0xE0, 0x78, 0xFC, 0x3E,
  0x0F, 0xC1, 0xF8, 0x0F, 0x03, 0xC0, 0xF8, 0x7F, 0xFE, 0xFF, 0xBF, 0x80,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0xC3, 0xBC,
  0x3B, 0xC7, 0x3C, 0x73, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1C, 0x07, 0x43,
  0xFC, 0xFF, 0x9F, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x7F, 0xFE, 0xFF,
  0xBF, 0x80, 0x0F, 0x8F, 0xE3, 0xF9, 0xE0, 0x70, 0x3C, 0x0E, 0x73, 0xBE,
  0xFF, 0xBE, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3D, 0xFE, 0x7F, 0x8F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x1E, 0x00,
  0x3F, 0x1F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xF7, 0xF9, 0xFE, 0x3E, 0x1F,
  0xC7, 0xFB, 0xCF, 0xE3, 0xF8, 0x7F, 0x3F, 0xFF, 0x7F, 0x8F, 0xC0, 0x3E,
  0x1F, 0xCF, 0xFB, 0xCE, 0xF3, 0xF8, 0xFE, 0x3F, 0xCF, 0xF7, 0xFF, 0xF7,
  0xDC, 0xEF, 0x03, 0xC0, 0xE0, 0x79, 0xFC, 0x7F, 0x1F, 0x00, 0x7F, 0xF7,
  0x00, 0x00, 0x00, 0x7F, 0xF7, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x07, 0x7F,
  0xFE, 0xE0, 0x00, 0x40, 0x70, 0x7C, 0x7F, 0x7E, 0x3E, 0x0F, 0x81, 0xF8,
  0x1F, 0xC1, 0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x83, 0xF8, 0x1F, 0x81, 0xF0, 0x7C,
  0x7E, 0x7E, 0x3E, 0x0E, 0x02, 0x00, 0x3E, 0x7F, 0xBF, 0xEC, 0xF0, 0x38,
  0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x00, 0x70, 0x78,
  0x3C, 0x1E, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x87, 0x87, 0x01, 0xC7,
  0x08, 0x73, 0x9F, 0xBB, 0x9F, 0xCD, 0xCE, 0xE7, 0xEE, 0x73, 0xF7, 0x39,
  0xFB, 0x9C, 0xFD, 0xCE, 0x6E, 0xE7, 0x77, 0x3F, 0xF3, 0x8E, 0x78, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x1C, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x77, 0x81, 0xDE, 0x07, 0x38,
  0x3C, 0xE0, 0xF3, 0xC3, 0xCF, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0x87,
  0x9E, 0x1E, 0xF0, 0x7B, 0xC0, 0xF0, 0xFE, 0x1F, 0xF3, 0xFF, 0x73, 0xEE,
  0x3D, 0xC7, 0xB8, 0xF7, 0xFC, 0xFF, 0x1F, 0xF3, 0x8F, 0x71, 0xEE, 0x1F,
  0xC7, 0xB8, 0xF7, 0xFE, 0xFF, 0x9F, 0xE0, 0x0F, 0xC3, 0xFC, 0xFF, 0x3E,
  0x67, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xF0, 0x1F, 0x13, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x1F, 0xF3, 0xFF,
  0x77, 0xEE, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC7, 0xF9, 0xF7, 0xFC, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0xE1, 0xFF,
  0x3F, 0xE7, 0xC2, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x78, 0xF3, 0xFF, 0x3F, 0xF0, 0xFE,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1C, 0xFF, 0xFF, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x7E, 0xFF, 0xFC, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0xFF, 0xFF, 0x80, 0xE1,
  0xFE, 0x1E, 0xE3, 0xCE, 0x3C, 0xE7, 0x8E, 0xF8, 0xEF, 0x0E, 0xF0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xE7, 0x8E, 0x7C, 0xE3, 0xCE, 0x3C, 0xE1,
  0xEE, 0x1F, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x77, 0xFC, 0x77, 0xEE, 0x77,
  0xEE, 0x7F, 0xEE, 0xEF, 0xEE, 0xEF, 0xE7, 0xEF, 0xE7, 0xEF, 0xE7, 0xCF,
  0xE7, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0x8F, 0xF0, 0x7F, 0x87, 0xF8,
  0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xFE, 0x7E, 0xE7, 0xEF, 0x7E, 0xF7, 0xE7,
  0x7E, 0x7F, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0x0F,
  0xC1, 0xFF, 0x1F, 0xFC, 0xF9, 0xE7, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xBC, 0x3D, 0xE3, 0xCF,
  0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0xFE, 0x3F, 0xCF, 0xFB, 0x9F, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xEF, 0xBF, 0xEF, 0xF3, 0xF8, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xF9, 0xE7, 0x8F,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xBC, 0x3D, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0xFC, 0x1F, 0xF3, 0xFE, 0x73, 0xEE, 0x3D, 0xC7,
  0xB8, 0xF7, 0x1E, 0xFF, 0x9F, 0xE3, 0xFC, 0x77, 0x8E, 0x79, 0xCF, 0x38,
  0xF7, 0x1E, 0xE3, 0xFC, 0x3C, 0x3F, 0x3F, 0xFF, 0xFF, 0x6F, 0x07, 0x83,
  0xC1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF0, 0x7C, 0x3F, 0x9F, 0xFF, 0xFF,
  0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0xFF,
  0xFE, 0x7F, 0xC7, 0xE0, 0xF0, 0x7F, 0x83, 0xDC, 0x1E, 0xE0, 0xE7, 0x87,
  0x3C, 0x78, 0xE3, 0xC7, 0x1C, 0x3C, 0xE1, 0xEF, 0x07, 0x78, 0x3B, 0x81,
  0xDC, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0xE0,
  0xFF, 0x0F, 0x1E, 0xF0, 0xF1, 0xEF, 0x1F, 0x1E, 0x71, 0xF1, 0xE7, 0x1F,
  0x1E, 0x79, 0xF1, 0xC7, 0x9B, 0xBC, 0x7B, 0xBB, 0xC3, 0xBB, 0xBC, 0x3B,
  0xBB, 0xC3, 0xB9, 0xB8, 0x3F, 0x9B, 0x83, 0xF1, 0xF8, 0x1F, 0x1F, 0x81,
  0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF0, 0xF0, 0xF0, 0xF7, 0x9E, 0x79, 0xE3,
  0x9E, 0x3F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF8, 0x1F, 0x81,
  0xF8, 0x3F, 0xC3, 0xDC, 0x39, 0xE7, 0x9E, 0x78, 0xFF, 0x0F, 0xF0, 0xF7,
  0x0F, 0x78, 0xF7, 0x9E, 0x39, 0xE3, 0xDC, 0x3F, 0xC1, 0xFC, 0x1F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x7F, 0xCF, 0xF9, 0xFF, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xF0, 0xF0, 0x1C, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0xFF, 0xFE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF, 0xFC, 0x03, 0x00, 0x38, 0x01,
  0xE0, 0x1F, 0x00, 0xFC, 0x0E, 0xE0, 0x77, 0x87, 0x9C, 0x38, 0xF3, 0xC3,
  0xBC, 0x1E, 0xFF, 0xFF, 0xFC, 0xF1, 0xE3, 0x87, 0x3F, 0x1F, 0xE7, 0xF9,
  0x0F, 0x03, 0xC3, 0xF7, 0xFF, 0xFF, 0xF3, 0xF8, 0xFE, 0x3F, 0xFF, 0xFD,
  0xDE, 0x70, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xEF, 0x3F, 0xF7,
  0xFE, 0xFB, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xFF, 0xDF, 0xFB, 0x9E, 0x00, 0x1F, 0x1F, 0xDF, 0xDF, 0x2F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x2F, 0xF7, 0xF9, 0xF8, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xCF, 0x77, 0xDD, 0xFF, 0xF3, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xCF, 0xFF, 0xDF, 0xF3, 0xDC, 0x1E, 0x1F, 0xE7,
  0xFB, 0xCF, 0xF3, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x3C, 0x0F, 0x05, 0xFE,
  0x7F, 0x8F, 0xE0, 0x1F, 0x3F, 0x3F, 0x3C, 0x38, 0x7F, 0xFF, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3D, 0xDF,
  0xF7, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F,
  0xFF, 0x7F, 0xCF, 0x70, 0x1C, 0x07, 0xC3, 0xFF, 0xEF, 0xF9, 0xF8, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xEF, 0x3F, 0xF7, 0xFE, 0xFB, 0xDE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0x80, 0x7F, 0xF2, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1C, 0xF3, 0xC2, 0x00, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFE, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0x8F, 0x78, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF8, 0xF3, 0x8F, 0x3C, 0xF1, 0xCF, 0x1E, 0xF1, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x9E,
  0x77, 0xFF, 0xBF, 0xFF, 0xFF, 0x7C, 0xFF, 0x1E, 0x7F, 0x8E, 0x3F, 0xC7,
  0x1F, 0xE3, 0x8F, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0x71, 0xFE, 0x38, 0xFF,
  0x1C, 0x7F, 0x8E, 0x3C, 0xE7, 0x9D, 0xFB, 0xFF, 0x7D, 0xEF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xC0,
  0x1F, 0x07, 0xF1, 0xFF, 0x79, 0xEF, 0x1D, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1,
  0xFE, 0x3B, 0xCF, 0x3F, 0xE7, 0xF8, 0x3E, 0x00, 0xE7, 0x9F, 0xFB, 0xFF,
  0x7C, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xE7, 0xFF,
  0xEF, 0xFD, 0xEF, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00,
  0x3D, 0xDF, 0xF7, 0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x3F, 0xFF, 0x7F, 0xCF, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0xE7, 0xEF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x3E, 0xFF, 0xFE, 0xE2, 0xE0, 0xF8, 0xFC, 0x7E, 0x1F,
  0x0F, 0x8F, 0xFF, 0xFE, 0xFC, 0x18, 0x38, 0x38, 0x3F, 0xFF, 0xFF, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xCF, 0xBF, 0xF7, 0xFE, 0x79, 0xC0, 0xF0, 0xFF, 0x0E, 0x71, 0xE7, 0x9E,
  0x79, 0xC3, 0x9C, 0x3B, 0xC3, 0xBC, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF0,
  0x1F, 0x00, 0xF0, 0xF1, 0xE3, 0xFC, 0x78, 0xE7, 0x3E, 0x39, 0xCF, 0x9E,
  0x7B, 0xF7, 0x9E, 0xDD, 0xC7, 0xB7, 0x70, 0xFC, 0xDC, 0x3F, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x80, 0xF1,
  0xEF, 0x39, 0xEF, 0x1D, 0xE3, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x87,
  0xF0, 0xEE, 0x3D, 0xE7, 0x9D, 0xE3, 0xC0, 0xF0, 0xFF, 0x0E, 0x71, 0xE7,
  0x9E, 0x79, 0xC3, 0x9C, 0x3B, 0xC3, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x07, 0xE0, 0x7C, 0x07,
  0x80, 0x7F, 0xBF, 0xDF, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x7C, 0xF8, 0xF8, 0xFC, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1F, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0xF8, 0xF8, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3E, 0x1F,
  0x1F, 0x3F, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF8, 0xF8, 0xE0, 0x78,
  0x7F, 0xFF, 0xFE, 0x3F,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 18, 7, 1, -18 },
  { 10, 9, 7, 12, 1, -18 },
  { 18, 12, 18, 13, 1, -18 },
  { 45, 10, 20, 12, 1, -19 },
  { 70, 18, 18, 20, 1, -18 },
  { 111, 14, 18, 15, 1, -18 },
  { 143, 4, 7, 6, 1, -18 },
  { 147, 7, 22, 8, 1, -18 },
  { 167, 7, 22, 8, 0, -18 },
  { 187, 11, 11, 11, 0, -19 },
  { 203, 10, 12, 12, 1, -15 },
  { 218, 4, 6, 6, 1, -3 },
  { 221, 6, 3, 8, 1, -8 },
  { 224, 4, 4, 7, 1, -4 },
  { 226, 10, 18, 10, 0, -18 },
  { 249, 10, 18, 12, 1, -18 },
  { 272, 8, 18, 12, 1, -18 },
  { 290, 10, 18, 12, 1, -18 },
  { 313, 10, 18, 12, 1, -18 },
  { 336, 12, 18, 12, 0, -18 },
  { 363, 10, 18, 12, 1, -18 },
  { 386, 10, 18, 12, 1, -18 },
  { 409, 10, 18, 12, 1, -18 },
  { 432, 10, 18, 12, 1, -18 },
  { 455, 10, 18, 12, 1, -18 },
  { 478, 4, 14, 7, 1, -14 },
  { 485, 4, 17, 7, 1, -14 },
  { 494, 10, 12, 12, 1, -15 },
  { 509, 10, 8, 12, 1, -13 },
  { 519, 10, 12, 12, 1, -15 },
  { 534, 9, 18, 10, 0, -18 },
  { 555, 17, 20, 19, 1, -18 },
  { 598, 14, 18, 14, 0, -18 },
  { 630, 11, 18, 14, 2, -18 },
  { 655, 11, 18, 12, 1, -18 },
  { 680, 11, 18, 14, 2, -18 },
  { 705, 8, 18, 11, 2, -18 },
  { 723, 8, 18, 11, 2, -18 },
  { 741, 12, 18, 14, 1, -18 },
  { 768, 11, 18, 15, 2, -18 },
  { 793, 7, 18, 8, 1, -18 },
  { 809, 6, 23, 7, -1, -18 },
  { 827, 12, 18, 13, 2, -18 },
  { 854, 8, 18, 10, 2, -18 },
  { 872, 16, 18, 20, 2, -18 },
  { 908, 12, 18, 16, 2, -18 },
  { 935, 13, 18, 15, 1, -18 },
  { 965, 10, 18, 13, 2, -18 },
  { 988, 13, 22, 15, 1, -18 },
  { 1024, 11, 18, 13, 2, -18 },
  { 1049, 9, 18, 11, 1, -18 },
  { 1070, 11, 18, 11, 0, -18 },
  { 1095, 11, 18, 14, 2, -18 },
  { 1120, 13, 18, 13, 0, -18 },
  { 1150, 20, 18, 19, 0, -18 },
  { 1195, 12, 18, 12, 0, -18 },
  { 1222, 12, 18, 12, 0, -18 },
  { 1249, 11, 18, 11, 0, -18 },
  { 1274, 6, 22, 8, 1, -18 },
  { 1291, 10, 18, 10, 0, -18 },
  { 1314, 5, 22, 8, 1, -18 },
  { 1328, 13, 11, 13, 0, -18 },
  { 1346, 11, 2, 11, 0, 2 },
  { 1349, 6, 4, 8, 1, -19 },
  { 1352, 10, 14, 12, 1, -14 },
  { 1370, 11, 19, 13, 1, -19 },
  { 1397, 9, 14, 10, 1, -14 },
  { 1413, 10, 19, 13, 1, -19 },
  { 1437, 10, 14, 12, 1, -14 },
  { 1455, 8, 19, 8, 0, -19 },
  { 1474, 10, 20, 13, 1, -14 },
  { 1499, 11, 19, 13, 1, -19 },
  { 1526, 4, 19, 6, 1, -19 },
  { 1536, 6, 25, 6, -1, -19 },
  { 1555, 12, 19, 13, 1, -19 },
  { 1584, 4, 19, 6, 1, -19 },
  { 1594, 17, 14, 19, 1, -14 },
  { 1624, 11, 14, 13, 1, -14 },
  { 1644, 11, 14, 13, 1, -14 },
  { 1664, 11, 20, 13, 1, -14 },
  { 1692, 10, 20, 13, 1, -14 },
  { 1717, 8, 14, 9, 1, -14 },
  { 1731, 8, 14, 10, 1, -14 },
  { 1745, 8, 17, 9, 0, -17 },
  { 1762, 11, 14, 13, 1, -14 },
  { 1782, 12, 14, 12, 0, -14 },
  { 1803, 18, 14, 18, 0, -14 },
  { 1835, 11, 14, 11, 0, -14 },
  { 1855, 12, 20, 12, 0, -14 },
  { 1885, 9, 14, 9, 0, -14 },
  { 1901, 8, 22, 9, 0, -18 },
  { 1923, 3, 25, 11, 4, -19 },
  { 1933, 8, 22, 9, 1, -18 },
  { 1955, 10, 4, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD25PT7B_H_
