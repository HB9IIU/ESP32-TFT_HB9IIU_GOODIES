#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD17PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0x1B, 0xE0, 0xDF, 0x3C, 0xF3, 0x1B, 0x0D, 0x04,
  0x8F, 0xF7, 0xF9, 0xB0, 0xD9, 0xFE, 0xFF, 0x12, 0x0B, 0x0D, 0x80, 0x10,
  0xEF, 0xF5, 0xD3, 0xC7, 0x8F, 0x1E, 0x7F, 0xFE, 0x10, 0x40, 0x78, 0xC3,
  0xC4, 0x12, 0x61, 0x9B, 0x04, 0xF0, 0x3D, 0xB9, 0xEB, 0x60, 0xDB, 0x06,
  0xD8, 0x66, 0xC3, 0x3E, 0x30, 0xE0, 0x3E, 0x0F, 0x87, 0x61, 0xD8, 0x3E,
  0x0F, 0x77, 0xDD, 0xBE, 0xE7, 0xB9, 0xC7, 0xF8, 0xF7, 0xFF, 0x36, 0x6E,
  0xCC, 0xCC, 0xCC, 0xCE, 0x67, 0x30, 0xE3, 0x0C, 0x63, 0x1C, 0xE7, 0x39,
  0x8C, 0x67, 0x33, 0x00, 0x18, 0x18, 0x7E, 0xFF, 0x3C, 0x7E, 0x24, 0x30,
  0x60, 0xC7, 0xFF, 0xE6, 0x0C, 0x18, 0xFB, 0x60, 0xFF, 0xFE, 0xDF, 0x00,
  0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0C, 0x18, 0x70, 0xC1, 0x87, 0x00, 0x79,
  0xFB, 0x36, 0x6C, 0xD9, 0xF3, 0xE6, 0xCD, 0x9B, 0xF3, 0xC0, 0x19, 0xDF,
  0xF5, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x7D, 0xFD, 0x38, 0x30, 0xE1, 0xC7,
  0x1C, 0x30, 0xE3, 0xFF, 0xF0, 0xFB, 0xF8, 0xC3, 0x1D, 0xC7, 0xC3, 0x0E,
  0x7F, 0xFE, 0x0E, 0x1E, 0x1E, 0x3E, 0x3E, 0x6E, 0x6E, 0xCE, 0xFF, 0xFF,
  0x0E, 0x0E, 0xFF, 0xFC, 0x30, 0xFB, 0xF9, 0xC3, 0x0E, 0x7F, 0xFE, 0x3C,
  0xFB, 0x86, 0x0D, 0x9F, 0xB3, 0x67, 0xCF, 0x9B, 0xF3, 0xC0, 0xFF, 0xFF,
  0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x3C, 0x7E,
  0x66, 0x66, 0x7E, 0x3C, 0x7E, 0x66, 0xE7, 0x67, 0x7E, 0x3C, 0x3C, 0x7E,
  0x66, 0xE6, 0xE7, 0x67, 0x7E, 0x36, 0x06, 0x0E, 0x7C, 0x78, 0xFD, 0x00,
  0x37, 0xE0, 0xFD, 0x00, 0x07, 0xDB, 0x00, 0x03, 0x0F, 0x3C, 0xF0, 0xF8,
  0x3E, 0x07, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81, 0xC1, 0xE0,
  0xF3, 0xFF, 0x38, 0x40, 0xFB, 0xF8, 0xC3, 0x1C, 0xE3, 0x0C, 0x00, 0xC7,
  0x0C, 0x1F, 0x0E, 0x39, 0x83, 0x67, 0xBD, 0xB7, 0xB6, 0xE4, 0xDC, 0x9B,
  0xDF, 0x5B, 0xBB, 0x00, 0x38, 0xC3, 0xF8, 0x1C, 0x0F, 0x0F, 0x86, 0xC3,
  0x61, 0xB9, 0xDC, 0xFE, 0x7F, 0x31, 0xF8, 0xFC, 0x70, 0xFC, 0xFE, 0xEE,
  0xE6, 0xEE, 0xFC, 0xFE, 0xE6, 0xE7, 0xEE, 0xFE, 0xFC, 0x3E, 0xFF, 0x8F,
  0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC5, 0xF9, 0xF0, 0xFC, 0xFE, 0xEE, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xEE, 0xFE, 0xF8, 0xFF, 0xFE, 0x38, 0xE3,
  0xEF, 0xB8, 0xE3, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0xE3, 0xEF, 0xB8, 0xE3,
  0x8E, 0x38, 0x3F, 0x7E, 0xE1, 0xE0, 0xE0, 0xCF, 0xCF, 0xE7, 0xE7, 0xE7,
  0x7F, 0x3F, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0xFF, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xFB, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0x9F, 0xF0, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xFB, 0xDC, 0xE7, 0xEE, 0xEE, 0xFC,
  0xFC, 0xF8, 0xFC, 0xFC, 0xEE, 0xEE, 0xE7, 0xE7, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xF0, 0xFE, 0x3F, 0xC7, 0xFC, 0xFD, 0x9F,
  0xB6, 0xFE, 0xDF, 0xFB, 0xEF, 0x7D, 0xCF, 0xB9, 0xF7, 0x30, 0xE3, 0xF9,
  0xFC, 0xFF, 0x7D, 0xBE, 0xFF, 0x3F, 0x9B, 0xCF, 0xE3, 0xF1, 0xF8, 0x70,
  0x3E, 0x3F, 0xB9, 0xDC, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0x73, 0x9F,
  0xC7, 0xC0, 0xFD, 0xFF, 0xBF, 0x7E, 0xFD, 0xFF, 0x7C, 0xE1, 0xC3, 0x87,
  0x00, 0x3E, 0x3F, 0xB9, 0xDC, 0x6C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0x73,
  0x9F, 0xC7, 0xC0, 0xE0, 0x38, 0x1C, 0xFC, 0xFE, 0xEE, 0xE6, 0xEE, 0xFE,
  0xFC, 0xFC, 0xEC, 0xEE, 0xE6, 0xE7, 0x7F, 0xFC, 0x70, 0xE3, 0xC7, 0x87,
  0x1E, 0x7F, 0xBE, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0x7E, 0x7C, 0xE3, 0xF1, 0xD8, 0xCC, 0x67, 0x73, 0xB8, 0xD8, 0x6C, 0x36,
  0x1F, 0x07, 0x03, 0x80, 0xE7, 0x1F, 0x39, 0xF9, 0xCE, 0xCE, 0x76, 0x5B,
  0x36, 0xD9, 0xF6, 0xCF, 0xBE, 0x3D, 0xF1, 0xE7, 0x0E, 0x38, 0x71, 0xC0,
  0xE7, 0x66, 0x7E, 0x3E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3E, 0x76, 0x67, 0xE7,
  0xE3, 0x67, 0x76, 0x76, 0x3E, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0xFF, 0xFC, 0x38, 0x61, 0xC3, 0x0E, 0x18, 0x70, 0xC3, 0xFF, 0xF0, 0xFF,
  0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE0, 0xC1, 0x81, 0x83, 0x06,
  0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0xF0, 0x08, 0x0E, 0x07, 0x06, 0xC3, 0x63, 0x19, 0x8D, 0xC3, 0xFF,
  0xFF, 0xE6, 0x30, 0x08, 0xFC, 0xB8, 0x33, 0xEF, 0xD9, 0xF3, 0x7E, 0xEC,
  0xC1, 0x83, 0x06, 0x4D, 0xDF, 0xFB, 0xE3, 0xC7, 0x8F, 0xBF, 0xFD, 0xC0,
  0x11, 0xFF, 0xB0, 0xC3, 0x0C, 0x39, 0xF9, 0xE0, 0x0E, 0x1C, 0x39, 0x7F,
  0xFF, 0xF3, 0xE7, 0xCF, 0x9F, 0x3F, 0xF7, 0x60, 0x11, 0xEF, 0xF3, 0xFF,
  0xFC, 0x31, 0xFD, 0xF0, 0x3D, 0xE7, 0x1C, 0xFB, 0xE7, 0x1C, 0x71, 0xC7,
  0x1C, 0x70, 0x21, 0xEF, 0xFE, 0x7C, 0xF9, 0xF3, 0xE7, 0xFE, 0xFC, 0x3C,
  0x7F, 0xDF, 0x00, 0xC1, 0x83, 0x06, 0x4F, 0xDF, 0xFB, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xE0, 0xF4, 0xFF, 0xFF, 0xC0, 0x33, 0x10, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xCE, 0xCC, 0xDC, 0xF8,
  0xF8, 0xFC, 0xCC, 0xCE, 0xC7, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x9F, 0xBF,
  0xFF, 0xF7, 0x3C, 0xE7, 0x9C, 0xF3, 0x9E, 0x73, 0xCE, 0x79, 0xCC, 0x09,
  0xFB, 0xFF, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9C, 0x10, 0xFB, 0xF6, 0x7C,
  0xF9, 0xF3, 0xE7, 0xFC, 0xF0, 0x09, 0xBB, 0xFF, 0x7C, 0x78, 0xF1, 0xF7,
  0xFF, 0xBB, 0x06, 0x0C, 0x18, 0x00, 0x21, 0xEF, 0xFE, 0x7C, 0xF9, 0xF3,
  0xE7, 0xFE, 0xFC, 0x38, 0x70, 0xE1, 0xC0, 0x0E, 0xFF, 0xCC, 0x63, 0x18,
  0xC6, 0x00, 0x11, 0xF6, 0xF8, 0x71, 0xF1, 0xE3, 0xFF, 0xE0, 0x33, 0xBF,
  0xF7, 0x39, 0xCE, 0x73, 0xCE, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xFB, 0xFF,
  0x76, 0xE7, 0x66, 0x66, 0x6E, 0x7E, 0x3C, 0x3C, 0x3C, 0x18, 0xEF, 0x7E,
  0xF7, 0x6F, 0x66, 0xF6, 0x6F, 0x66, 0x9E, 0x39, 0xC3, 0x9C, 0x39, 0xC0,
  0xEE, 0x6E, 0x7C, 0x3C, 0x38, 0x3C, 0x7C, 0x6E, 0xE7, 0xE7, 0x66, 0x66,
  0x7E, 0x7E, 0x3C, 0x3C, 0x3C, 0x18, 0x18, 0x38, 0x70, 0x70, 0xFF, 0xF1,
  0x8E, 0x31, 0xC6, 0x3F, 0xFC, 0x3C, 0xF3, 0x0C, 0x30, 0xCF, 0x38, 0x70,
  0xC3, 0x0C, 0x30, 0xF1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0xC3,
  0x0C, 0x30, 0xC3, 0xC7, 0x38, 0xC3, 0x0C, 0x33, 0xCE, 0x00, 0x01, 0xFF,
  0xFF, 0x84,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 12, 4, 1, -12 },
  { 6, 6, 4, 8, 1, -12 },
  { 9, 9, 12, 9, 0, -12 },
  { 23, 6, 14, 8, 1, -13 },
  { 34, 13, 12, 14, 0, -12 },
  { 54, 10, 12, 10, 0, -12 },
  { 69, 2, 4, 4, 1, -12 },
  { 70, 4, 15, 5, 1, -12 },
  { 78, 5, 15, 5, 0, -12 },
  { 88, 8, 7, 8, 0, -13 },
  { 95, 7, 8, 8, 1, -10 },
  { 102, 3, 4, 4, 1, -2 },
  { 104, 5, 3, 5, 0, -6 },
  { 106, 3, 3, 4, 1, -3 },
  { 108, 7, 12, 7, 0, -12 },
  { 119, 7, 12, 8, 1, -12 },
  { 130, 5, 12, 8, 1, -12 },
  { 138, 7, 12, 8, 0, -12 },
  { 149, 6, 12, 8, 1, -12 },
  { 158, 8, 12, 8, 0, -12 },
  { 170, 6, 12, 8, 1, -12 },
  { 179, 7, 12, 8, 1, -12 },
  { 190, 8, 12, 8, 0, -12 },
  { 202, 8, 12, 8, 0, -12 },
  { 214, 8, 12, 8, 0, -12 },
  { 226, 3, 9, 5, 1, -9 },
  { 230, 3, 11, 5, 1, -9 },
  { 235, 8, 8, 8, 0, -10 },
  { 243, 7, 6, 8, 1, -9 },
  { 249, 7, 8, 8, 1, -10 },
  { 256, 6, 12, 7, 0, -12 },
  { 265, 11, 13, 13, 1, -12 },
  { 283, 9, 12, 9, 0, -12 },
  { 297, 8, 12, 9, 1, -12 },
  { 309, 7, 12, 8, 1, -12 },
  { 320, 8, 12, 10, 1, -12 },
  { 332, 6, 12, 7, 1, -12 },
  { 341, 6, 12, 7, 1, -12 },
  { 350, 8, 12, 10, 1, -12 },
  { 362, 8, 12, 10, 1, -12 },
  { 374, 5, 12, 6, 0, -12 },
  { 382, 5, 16, 5, -1, -12 },
  { 392, 8, 12, 9, 1, -12 },
  { 404, 6, 12, 7, 1, -12 },
  { 413, 11, 12, 13, 1, -12 },
  { 430, 9, 12, 11, 1, -12 },
  { 444, 9, 12, 10, 1, -12 },
  { 458, 7, 12, 9, 1, -12 },
  { 469, 9, 15, 10, 1, -12 },
  { 486, 8, 12, 9, 1, -12 },
  { 498, 6, 12, 7, 1, -12 },
  { 507, 7, 12, 8, 0, -12 },
  { 518, 8, 12, 10, 1, -12 },
  { 530, 9, 12, 9, 0, -12 },
  { 544, 13, 12, 13, 0, -12 },
  { 564, 8, 12, 8, 0, -12 },
  { 576, 8, 12, 8, 0, -12 },
  { 588, 7, 12, 7, 0, -12 },
  { 599, 4, 15, 5, 1, -12 },
  { 607, 7, 12, 7, 0, -12 },
  { 618, 4, 15, 5, 0, -12 },
  { 626, 9, 8, 9, 0, -12 },
  { 635, 8, 2, 8, 0, 1 },
  { 637, 4, 3, 6, 1, -13 },
  { 639, 7, 10, 8, 0, -10 },
  { 648, 7, 13, 9, 1, -13 },
  { 660, 6, 10, 7, 1, -10 },
  { 668, 7, 13, 9, 1, -13 },
  { 680, 6, 10, 8, 1, -10 },
  { 688, 6, 13, 5, 0, -13 },
  { 698, 7, 14, 9, 1, -10 },
  { 711, 7, 13, 9, 1, -13 },
  { 723, 2, 13, 4, 1, -13 },
  { 727, 4, 17, 4, -1, -13 },
  { 736, 8, 13, 9, 1, -13 },
  { 749, 2, 13, 4, 1, -13 },
  { 753, 11, 10, 13, 1, -10 },
  { 767, 7, 10, 9, 1, -10 },
  { 776, 7, 10, 9, 1, -10 },
  { 785, 7, 14, 9, 1, -10 },
  { 798, 7, 14, 9, 1, -10 },
  { 811, 5, 10, 6, 1, -10 },
  { 818, 6, 10, 7, 0, -10 },
  { 826, 5, 11, 6, 0, -11 },
  { 833, 7, 9, 9, 1, -9 },
  { 841, 8, 9, 8, 0, -9 },
  { 850, 12, 9, 12, 0, -9 },
  { 864, 8, 9, 8, 0, -9 },
  { 873, 8, 13, 8, 0, -9 },
  { 886, 6, 9, 6, 0, -9 },
  { 893, 6, 15, 6, 0, -12 },
  { 905, 2, 17, 7, 3, -13 },
  { 910, 6, 15, 6, 0, -12 },
  { 922, 8, 4, 8, 0, -8 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD17PT7B_H_
