#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x60, 0x6F, 0xFE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0x0C, 0xC1, 0xB8, 0x37, 0x0E, 0xC1, 0xD8, 0xFF, 0xDF,
  0xF8, 0xCC, 0x1B, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0x30, 0x66, 0x0C, 0xC1,
  0xB8, 0x08, 0x04, 0x0F, 0xCF, 0xEF, 0xF7, 0x43, 0xA1, 0xF0, 0x7C, 0x0F,
  0x83, 0xC1, 0x78, 0xBF, 0x7B, 0xFC, 0xFC, 0x08, 0x04, 0x00, 0x70, 0x30,
  0xF8, 0x70, 0xDC, 0x60, 0xCC, 0xE0, 0xCC, 0xC0, 0xCC, 0xC0, 0xCD, 0xCC,
  0xDD, 0xBE, 0xFB, 0xBF, 0x73, 0x37, 0x03, 0x33, 0x07, 0x73, 0x06, 0x33,
  0x0E, 0x37, 0x0C, 0x3E, 0x1C, 0x1E, 0x0F, 0x01, 0xFC, 0x0F, 0xE0, 0x77,
  0x03, 0xB8, 0x1D, 0xC0, 0xFC, 0x03, 0xCF, 0x3F, 0x73, 0xBB, 0x9D, 0xFD,
  0xE7, 0xC7, 0x1E, 0x3F, 0xF1, 0xFF, 0xC7, 0xEF, 0xFF, 0xFF, 0xC0, 0x1C,
  0xE3, 0x9C, 0x71, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x1C, 0x70,
  0xE3, 0xC0, 0xE1, 0xC3, 0x0E, 0x38, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x73, 0x8E, 0x39, 0xCF, 0x00, 0x0E, 0x03, 0x04, 0xC9, 0xFE, 0xFF, 0xC7,
  0x83, 0xF1, 0xFE, 0x33, 0x04, 0x80, 0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF,
  0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0xFF, 0xEE, 0xEC, 0xFF, 0xFE,
  0x6F, 0xFE, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x38, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC1, 0xC0, 0x3C, 0x3F, 0x1F, 0xDC,
  0xEE, 0x77, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xEE, 0x73, 0xF9,
  0xF8, 0x7C, 0x0E, 0x3C, 0xFB, 0xFF, 0xFD, 0xD3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x3C, 0xFE, 0xFF, 0xC7, 0x47, 0x07, 0x07, 0x0F,
  0x1E, 0x1C, 0x38, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0x7C, 0x7F, 0xBF, 0xC8,
  0xE0, 0x70, 0x38, 0x78, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x7F, 0xFB,
  0xFD, 0xF8, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x1F, 0x86, 0xE3, 0xF8, 0xDE,
  0x77, 0x99, 0xEF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x78, 0x1E, 0x7F, 0x3F,
  0x9F, 0xCC, 0x0E, 0x07, 0x03, 0xF9, 0xFE, 0x7F, 0x03, 0x81, 0xE0, 0xF8,
  0x77, 0xFB, 0xFD, 0xF8, 0x0F, 0x1F, 0x9F, 0xCE, 0x0E, 0x07, 0x03, 0xF9,
  0xFE, 0xF7, 0xF3, 0xF8, 0xFC, 0x7E, 0x7F, 0xF9, 0xFC, 0x7C, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x83,
  0x81, 0xC1, 0xE0, 0xE0, 0x3C, 0x3F, 0xBF, 0xDC, 0xEE, 0x77, 0xB9, 0xFC,
  0x7C, 0x7E, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0xBF, 0xFC, 0xFC, 0x3C, 0x3F,
  0x3F, 0xDC, 0xEE, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF, 0xBD, 0xCC, 0xC0, 0xE0,
  0x77, 0xF3, 0xF9, 0xF0, 0xFF, 0xF6, 0x00, 0x00, 0x6F, 0xFF, 0xFF, 0xF6,
  0x00, 0x00, 0x07, 0xFE, 0xEE, 0xE0, 0x01, 0x83, 0xC7, 0xEF, 0xCF, 0x87,
  0x81, 0xF0, 0x3F, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x80, 0x70, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0xFD, 0xF8, 0xF0,
  0x60, 0x00, 0x3C, 0xFE, 0xFF, 0x47, 0x07, 0x07, 0x0E, 0x1E, 0x3C, 0x38,
  0x38, 0x00, 0x10, 0x38, 0x38, 0x38, 0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3,
  0x80, 0xC6, 0x3C, 0xDC, 0xFD, 0xB3, 0xBB, 0x66, 0x67, 0xCC, 0xCF, 0x99,
  0x9B, 0x33, 0x36, 0x7F, 0xEE, 0xF7, 0x8C, 0x00, 0x1C, 0x00, 0x1C, 0x38,
  0x1F, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0x0E, 0xF0, 0xFF, 0x0F, 0xFE, 0x3F, 0xEF, 0xFB, 0xCF, 0xF3, 0xFC, 0xFF,
  0x7B, 0xFC, 0xFF, 0xBC, 0xFF, 0x1F, 0xC7, 0xF3, 0xFF, 0xFF, 0xFB, 0xFC,
  0x0F, 0x1F, 0xDF, 0xEF, 0x1F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x3C,
  0x1E, 0x07, 0x0B, 0xFC, 0xFE, 0x3F, 0xFC, 0x1F, 0xE3, 0xFE, 0x79, 0xEF,
  0x1D, 0xE3, 0xBC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0x78, 0xEF, 0x3D,
  0xFF, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xFE, 0xFE,
  0xFE, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xF0, 0xF0, 0xFE, 0xFE, 0xFE, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0x0F, 0x8F, 0xF7, 0xFD, 0xE1, 0xF0, 0x3C, 0x0F, 0x03, 0x9F, 0xE7, 0xF9,
  0xFF, 0x1F, 0xC7, 0x71, 0xDF, 0xF3, 0xFC, 0x7F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xFF, 0x9C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xEF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xBE, 0xE0, 0xF1, 0xFE,
  0x3B, 0xCF, 0x79, 0xCF, 0x79, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0xE3,
  0xDC, 0x7B, 0xCF, 0x39, 0xE7, 0xBC, 0x77, 0x8F, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC7, 0xFD, 0x8F, 0xFB,
  0x9B, 0xFF, 0x77, 0xFE, 0xEF, 0xED, 0xDF, 0xDF, 0x3F, 0xBE, 0x7F, 0x7C,
  0xFE, 0x71, 0xFC, 0xE3, 0xF9, 0xC7, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC7,
  0xFC, 0x7F, 0xE7, 0xEE, 0x7E, 0xE7, 0xE7, 0x7F, 0x77, 0xF3, 0xFF, 0x3F,
  0xF3, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xFF,
  0x1F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x77, 0x1E,
  0xFF, 0x8F, 0xF0, 0xFC, 0xFC, 0x7F, 0xBF, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xEF, 0xFF, 0xFF, 0xBF, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x1F, 0x07,
  0xF1, 0xFF, 0x38, 0xFF, 0x1F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0xC3, 0xF8, 0x77, 0x1E, 0xFF, 0x8F, 0xF0, 0xFC, 0x03, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0xFC, 0x1F, 0xE3, 0xFE, 0x79, 0xCF, 0x3D, 0xE7, 0xBC, 0xE7,
  0xFC, 0xFF, 0x1F, 0xE3, 0xDC, 0x7B, 0xCF, 0x79, 0xE7, 0x3C, 0xF7, 0x8F,
  0x3E, 0x7F, 0xFF, 0xE2, 0xE0, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07,
  0x8F, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xDF, 0xF7, 0xF8, 0xFC, 0xE0, 0xFF, 0x0E, 0x70, 0xE7, 0x0E,
  0x71, 0xE7, 0x1C, 0x39, 0xC3, 0x9C, 0x39, 0xC3, 0xB8, 0x1B, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x0F, 0x00, 0xF0, 0xE1, 0xC3, 0xF0, 0xE1, 0xFC, 0x71,
  0xFE, 0x3C, 0xF7, 0x3E, 0x73, 0x9F, 0x39, 0xCD, 0x9C, 0xE6, 0xCE, 0x7F,
  0x6F, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0,
  0x78, 0xF0, 0x3C, 0x78, 0xF1, 0xCE, 0x39, 0xEF, 0x1D, 0xC3, 0xB8, 0x7E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xE0, 0xFC, 0x1D, 0xC3, 0xB8, 0xE7, 0x9C,
  0x77, 0x8F, 0xF1, 0xFE, 0x39, 0xC7, 0x3D, 0xE3, 0xB8, 0x77, 0x0F, 0xE0,
  0xF8, 0x1F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E,
  0x0F, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0xF0, 0xE0, 0x30, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0C,
  0x07, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1F, 0xFF, 0xFF, 0x06, 0x01, 0xC0, 0x3C, 0x07, 0x81, 0xF8, 0x37,
  0x0E, 0x71, 0xCE, 0x70, 0xFE, 0x1C, 0xFF, 0xFF, 0xF0, 0xF3, 0x8E, 0x30,
  0x7E, 0x7F, 0x67, 0x07, 0x1F, 0x7F, 0xFF, 0xE7, 0xE7, 0xEF, 0xFB, 0x7B,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xCF, 0xFB, 0xDE, 0xF3, 0xB8,
  0xEE, 0x3F, 0x8E, 0xE3, 0xBC, 0xEF, 0x7B, 0xFE, 0xEF, 0x00, 0x3F, 0x7E,
  0xF6, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFE, 0x7E, 0x3E, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x3B, 0xDD, 0xFF, 0xEF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0xDE, 0xFF, 0x7B, 0x80, 0x3E, 0x3F, 0xBD, 0xDC, 0x7E, 0x3F,
  0xFF, 0xFF, 0xC0, 0xE0, 0x79, 0x9F, 0xC7, 0xE0, 0x1E, 0x7C, 0xF9, 0xC3,
  0x8F, 0xFF, 0xFF, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7B,
  0xBF, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xDF, 0xEF,
  0x70, 0x38, 0x1F, 0xBF, 0xFE, 0xFE, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x7B, 0xFF, 0xFF, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0x80, 0x7F, 0xA1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x19, 0xCE,
  0x20, 0x1C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xFF, 0xF8,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFE, 0x3B, 0x9C, 0xEF, 0x3B,
  0x8F, 0xE3, 0xF8, 0xF7, 0x39, 0xCE, 0x3B, 0x8E, 0xE3, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xEF, 0x7D, 0xFF, 0xFB, 0xFF, 0xFF, 0x9C,
  0xFE, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F,
  0x8E, 0x3F, 0x1C, 0x70, 0xEF, 0x7F, 0xFF, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xC7, 0xC0, 0xEF, 0x3F, 0xEF, 0x7B,
  0xCE, 0xE3, 0xB8, 0xFE, 0x3B, 0x8E, 0xF3, 0xBF, 0xEF, 0xFB, 0xBC, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x7B, 0xBF, 0xFD, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xFF, 0xDF, 0xEF, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0xEF, 0xFF, 0xFF, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x00, 0x7F, 0xFB, 0x97, 0x0F, 0x1F, 0x9F, 0x0F, 0x8F, 0xFF, 0xF7, 0xE0,
  0x38, 0x70, 0xE3, 0xFF, 0xFF, 0xDE, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0xE7,
  0xCF, 0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xFF, 0xDF, 0xEF, 0x30, 0xE1, 0xFC, 0x77, 0x39, 0xCE, 0x73, 0x8E, 0xE3,
  0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xE0, 0x78, 0xE3, 0xCF, 0xE7, 0x9D, 0xDF,
  0x3B, 0xBE, 0x77, 0x6D, 0xCE, 0xDF, 0x8D, 0xBF, 0x1F, 0x3E, 0x3E, 0x7C,
  0x7C, 0xF0, 0xF9, 0xE0, 0xE3, 0xC0, 0xF3, 0xDC, 0xE7, 0xF0, 0xFC, 0x3F,
  0x07, 0x81, 0xE0, 0xFC, 0x3F, 0x1D, 0xE7, 0x3B, 0xCF, 0xF1, 0xDC, 0x77,
  0x39, 0xCE, 0x7B, 0x8E, 0xE3, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xE0, 0x38,
  0x1E, 0x07, 0x07, 0xC1, 0xF0, 0x78, 0x00, 0x7F, 0x7F, 0x7F, 0x0E, 0x1E,
  0x1C, 0x3C, 0x38, 0x78, 0x7F, 0xFF, 0xFF, 0x0E, 0x3C, 0x78, 0xE1, 0xC3,
  0x87, 0x1E, 0x79, 0xF3, 0xE1, 0xC3, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x78,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xE3,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0x7C, 0xFB, 0xC7, 0x0E, 0x1C, 0x38,
  0x71, 0xE3, 0xC4, 0x00, 0x60, 0xFE, 0xFF, 0xF1, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 11, 16, 11, 0, -16 },
  { 37, 9, 18, 11, 1, -17 },
  { 58, 16, 16, 18, 1, -16 },
  { 90, 13, 16, 13, 0, -16 },
  { 116, 3, 6, 5, 1, -16 },
  { 119, 6, 19, 7, 1, -16 },
  { 134, 6, 19, 7, 0, -16 },
  { 149, 10, 10, 10, 0, -17 },
  { 162, 9, 11, 11, 1, -13 },
  { 175, 4, 6, 6, 1, -3 },
  { 178, 5, 3, 7, 1, -7 },
  { 180, 4, 4, 6, 1, -4 },
  { 182, 9, 16, 9, 0, -16 },
  { 200, 9, 16, 11, 1, -16 },
  { 218, 7, 16, 11, 1, -16 },
  { 232, 8, 16, 11, 1, -16 },
  { 248, 9, 16, 11, 1, -16 },
  { 266, 10, 16, 11, 0, -16 },
  { 286, 9, 16, 11, 1, -16 },
  { 304, 9, 16, 11, 1, -16 },
  { 322, 9, 16, 11, 1, -16 },
  { 340, 9, 16, 11, 1, -16 },
  { 358, 9, 16, 11, 1, -16 },
  { 376, 4, 12, 6, 1, -12 },
  { 382, 4, 15, 6, 1, -12 },
  { 390, 9, 10, 11, 1, -13 },
  { 402, 9, 7, 11, 1, -11 },
  { 410, 9, 10, 11, 1, -13 },
  { 422, 8, 16, 8, 0, -16 },
  { 438, 15, 18, 16, 1, -16 },
  { 472, 12, 16, 12, 0, -16 },
  { 496, 10, 16, 12, 1, -16 },
  { 516, 9, 16, 11, 1, -16 },
  { 534, 11, 16, 13, 1, -16 },
  { 556, 8, 16, 10, 1, -16 },
  { 572, 8, 16, 10, 1, -16 },
  { 588, 10, 16, 13, 1, -16 },
  { 608, 11, 16, 13, 1, -16 },
  { 630, 6, 16, 7, 1, -16 },
  { 642, 6, 21, 6, -1, -16 },
  { 658, 11, 16, 12, 1, -16 },
  { 680, 8, 16, 9, 1, -16 },
  { 696, 15, 16, 17, 1, -16 },
  { 726, 12, 16, 14, 1, -16 },
  { 750, 11, 16, 13, 1, -16 },
  { 772, 9, 16, 11, 1, -16 },
  { 790, 11, 20, 13, 1, -16 },
  { 818, 11, 16, 12, 1, -16 },
  { 840, 8, 16, 10, 1, -16 },
  { 856, 9, 16, 10, 0, -16 },
  { 874, 10, 16, 13, 1, -16 },
  { 894, 12, 16, 12, 0, -16 },
  { 918, 17, 16, 17, 0, -16 },
  { 952, 11, 16, 11, 0, -16 },
  { 974, 11, 16, 11, 0, -16 },
  { 996, 9, 16, 10, 0, -16 },
  { 1014, 5, 20, 7, 1, -16 },
  { 1027, 9, 16, 9, 0, -16 },
  { 1045, 6, 20, 7, 0, -16 },
  { 1060, 11, 10, 12, 0, -16 },
  { 1074, 10, 2, 10, 0, 2 },
  { 1077, 5, 4, 7, 1, -17 },
  { 1080, 8, 12, 11, 1, -12 },
  { 1092, 10, 17, 11, 1, -17 },
  { 1114, 8, 12, 9, 1, -12 },
  { 1126, 9, 17, 11, 1, -17 },
  { 1146, 9, 12, 10, 1, -12 },
  { 1160, 7, 17, 7, 0, -17 },
  { 1175, 9, 17, 11, 1, -12 },
  { 1195, 9, 17, 11, 1, -17 },
  { 1215, 3, 17, 6, 1, -17 },
  { 1222, 5, 22, 6, -1, -17 },
  { 1236, 10, 17, 11, 1, -17 },
  { 1258, 3, 17, 6, 1, -17 },
  { 1265, 15, 12, 17, 1, -12 },
  { 1288, 9, 12, 11, 1, -12 },
  { 1302, 9, 12, 11, 1, -12 },
  { 1316, 10, 17, 11, 1, -12 },
  { 1338, 9, 17, 11, 1, -12 },
  { 1358, 7, 12, 8, 1, -12 },
  { 1369, 7, 12, 8, 1, -12 },
  { 1380, 7, 15, 8, 0, -15 },
  { 1394, 9, 12, 11, 1, -12 },
  { 1408, 10, 12, 10, 0, -12 },
  { 1423, 15, 12, 16, 0, -12 },
  { 1446, 10, 12, 10, 0, -12 },
  { 1461, 10, 17, 10, 0, -12 },
  { 1483, 8, 12, 8, 0, -12 },
  { 1495, 7, 20, 8, 0, -16 },
  { 1513, 3, 22, 9, 3, -17 },
  { 1522, 7, 20, 8, 1, -16 },
  { 1540, 9, 4, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD22PT7B_H_
