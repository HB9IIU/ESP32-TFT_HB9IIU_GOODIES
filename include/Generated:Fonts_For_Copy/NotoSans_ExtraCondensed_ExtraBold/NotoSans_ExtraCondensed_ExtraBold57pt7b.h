#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xDF, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x04,
  0x00, 0xFF, 0x87, 0xFD, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0xDF, 0xE1, 0xFF,
  0x7F, 0x87, 0xFD, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0x9F, 0xE1, 0xFE, 0x7F,
  0x83, 0xF9, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x83,
  0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x03, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xDE, 0x1C, 0xFE, 0x78, 0x13, 0xF9, 0xE0, 0x0F, 0xE7, 0x80,
  0x3F, 0x9E, 0x00, 0xFF, 0x78, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x7B, 0xFC, 0x01, 0xE7, 0xF0, 0x07, 0x9F, 0xE0, 0x1E, 0x7F, 0xE0,
  0x7B, 0xFF, 0xE1, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0xE7, 0xF0,
  0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x0F,
  0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x1F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC7, 0xE1, 0xFF,
  0x0F, 0xE7, 0xF1, 0xF8, 0xFF, 0xE1, 0xFF, 0xFC, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFE, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0x9F, 0xCF, 0xFF, 0xE3, 0xFF, 0xC7,
  0xE3, 0xF1, 0xF8, 0x7F, 0xE1, 0xF8, 0xFC, 0x7F, 0x07, 0xF0, 0xFC, 0x7F,
  0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0xFC,
  0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC7,
  0xF0, 0x00, 0xFC, 0x03, 0xF1, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x3F,
  0xE0, 0xFF, 0xFC, 0x1F, 0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0x8F,
  0xF8, 0x7F, 0xFF, 0xE7, 0xFC, 0x7F, 0xDF, 0xFB, 0xFE, 0x3F, 0xE7, 0xFD,
  0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0x8F, 0xF8, 0x3F,
  0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0xC3, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xE7, 0xFE, 0x03,
  0xFF, 0xC1, 0xFF, 0x80, 0x08, 0x00, 0x00, 0x00, 0xFF, 0xBF, 0xDF, 0xEF,
  0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xF9,
  0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x20, 0x7E, 0x06, 0x7C, 0x7E, 0x3E, 0x7F, 0x7E, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x0F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8,
  0x07, 0x81, 0xE0, 0x03, 0x81, 0xC0, 0x01, 0x00, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xCF, 0xF3,
  0xFC, 0xFF, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF3, 0xFC,
  0xFE, 0x3F, 0x8F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x04, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xF7, 0xFC, 0x7F, 0xC7, 0xFC, 0xFF, 0x07, 0xF9,
  0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xEF, 0xF0, 0x7F, 0xDF, 0xE0, 0xFF,
  0x3F, 0xC1, 0xFE, 0x7F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFE, 0xFF, 0x3F, 0xC7, 0xC7, 0xF8, 0x70, 0xFF, 0x04, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0x87, 0xFE, 0x1E, 0x03,
  0xFE, 0x1C, 0x03, 0xFE, 0x08, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x07, 0xFE,
  0x38, 0x07, 0xFC, 0x20, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x1F, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xDF,
  0xE0, 0x0F, 0xEF, 0xF0, 0x07, 0xE7, 0xF8, 0x07, 0xF3, 0xFC, 0x03, 0xF1,
  0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0xFC,
  0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7E, 0x07, 0xF8, 0x7F, 0x03, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x80, 0x0F, 0xFB, 0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC3, 0xE0, 0x7F, 0x9F, 0xF0, 0xFF, 0x7F, 0xF1, 0xFE, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFD, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xBF, 0xC0, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F,
  0xFB, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFE,
  0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xCF, 0xF8, 0xFF, 0x8F, 0xF9,
  0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x7F, 0xEF, 0xFC, 0xFF, 0x8F, 0xFB, 0xFE, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x1F, 0xFB, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xE7, 0xFE, 0xFF, 0x87, 0xFD, 0xFF, 0x07, 0xFB,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xFD, 0xFE, 0x1F, 0xF3, 0xFC, 0x1F, 0xC7,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x3F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x0C, 0x00, 0x0E, 0x0F,
  0xE3, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x3F, 0xC7, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0xFF, 0x3F, 0xDF, 0xF7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xC3, 0xFF, 0x38, 0x0F, 0xF8,
  0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7F, 0xF8, 0x7E,
  0x3F, 0x03, 0xFF, 0xF1, 0xF8, 0xFC, 0x1F, 0xFF, 0xC7, 0xE7, 0xF0, 0xFF,
  0xFF, 0x0F, 0xDF, 0x83, 0xF8, 0xFC, 0x3F, 0x7E, 0x1F, 0xC3, 0xF0, 0xFD,
  0xF8, 0x7E, 0x0F, 0xC3, 0xFF, 0xE3, 0xF8, 0x3F, 0x0F, 0xFF, 0x0F, 0xE0,
  0xFC, 0x3F, 0xFC, 0x3F, 0x03, 0xF0, 0xFF, 0xF0, 0xFC, 0x0F, 0xC3, 0xFF,
  0xC3, 0xF0, 0x7F, 0x0F, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0xFC, 0x3F, 0x07,
  0xF0, 0xFF, 0xF0, 0xFC, 0x1F, 0xC3, 0xFF, 0xC3, 0xF0, 0x7E, 0x0F, 0xBF,
  0x0F, 0xE1, 0xF8, 0x7E, 0xFC, 0x1F, 0x8F, 0xF1, 0xF9, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC7, 0xE1, 0xFF, 0xEF, 0xFF, 0x1F, 0x83, 0xFF, 0xBF, 0xF8, 0x7F,
  0x07, 0xFC, 0x7F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x04, 0x00,
  0x40, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF0, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF9, 0xFE, 0x3F, 0xFC, 0xFF, 0x03, 0xFF, 0x7F, 0x80, 0xFF, 0xBF,
  0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0, 0x1F, 0xF7, 0xF8, 0x0F, 0xF3,
  0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF9, 0xFE, 0x1F, 0xFC, 0xFF, 0x03, 0xFF, 0x7F, 0x80,
  0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x03, 0xFF, 0x7F,
  0x83, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xF8, 0x7C, 0x1F, 0xF8, 0x06, 0x1F, 0xF8, 0x01, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x02, 0x0F, 0xFE, 0x07, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0x3F, 0xC0, 0xFF, 0xEF, 0xF0, 0x1F,
  0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xBF,
  0xC0, 0x3F, 0xEF, 0xF0, 0x1F, 0xFB, 0xFC, 0x0F, 0xFC, 0xFF, 0x07, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7C, 0x1F, 0xFC, 0x00, 0x83, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0x7F, 0xC3, 0xFF,
  0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x01,
  0xFF, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xCF,
  0xF0, 0x1F, 0xF9, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x3F,
  0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xE1, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0x7F,
  0x8F, 0xFC, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x7F, 0xE0, 0x3F, 0xCF, 0xF8,
  0x07, 0xFB, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFB,
  0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x81,
  0xFE, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0x03,
  0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x8F,
  0xF0, 0x1F, 0xF9, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xF7, 0xF8, 0x03,
  0xFE, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xFF,
  0xFB, 0xF8, 0x0F, 0xDF, 0xFF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x7F, 0x07,
  0xF7, 0xFF, 0xFB, 0xF8, 0x3F, 0xBF, 0xFF, 0xDF, 0xC1, 0xF9, 0xFF, 0xFE,
  0xFE, 0x1F, 0xCF, 0xFF, 0xF3, 0xF8, 0xFE, 0x7F, 0xFF, 0x9F, 0xC7, 0xF3,
  0xFF, 0xFC, 0xFE, 0x3F, 0x1F, 0xFF, 0xE7, 0xF3, 0xF8, 0xFF, 0xFF, 0x1F,
  0xDF, 0xC7, 0xFF, 0xF8, 0xFE, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0x81,
  0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0x80, 0xFF,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF,
  0xDF, 0xE0, 0xFF, 0xFE, 0x7F, 0x87, 0xFF, 0xF3, 0xFC, 0x3F, 0xFF, 0xDF,
  0xF1, 0xFF, 0xFE, 0x7F, 0x8F, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0x8F, 0xF3,
  0xFF, 0xFC, 0x7F, 0x9F, 0xFF, 0xE1, 0xFE, 0xFF, 0xFF, 0x0F, 0xF7, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE3,
  0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF7, 0xF8, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE3,
  0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0x07, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F,
  0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC,
  0x0F, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC1, 0xFF, 0x0F, 0xF3, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF1,
  0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x0F,
  0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF,
  0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0,
  0x7F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xC0, 0xE7,
  0xFC, 0x01, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFE, 0x03,
  0xFE, 0x7F, 0xC0, 0x7F, 0xCF, 0xFC, 0x1F, 0xF9, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x02, 0x80, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0xDF, 0xE0,
  0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0xFF, 0x8F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F,
  0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0,
  0x03, 0xFD, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0x8F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE3,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x7F,
  0x81, 0xFF, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xFF, 0x03, 0xFC, 0x1F, 0xE0,
  0x7F, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x3F,
  0xFF, 0x0F, 0xF8, 0x1F, 0xE1, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xEF,
  0xC3, 0xFC, 0x07, 0xF8, 0x7E, 0x7E, 0x1F, 0xE0, 0x3F, 0xC3, 0xF3, 0xF0,
  0xFF, 0x00, 0xFF, 0x3F, 0x9F, 0xCF, 0xF8, 0x07, 0xF9, 0xFC, 0xFE, 0x7F,
  0x80, 0x3F, 0xCF, 0xE7, 0xF3, 0xFC, 0x01, 0xFE, 0x7F, 0x3F, 0x9F, 0xE0,
  0x0F, 0xF3, 0xF8, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0x87, 0xE7, 0xF8, 0x01,
  0xFD, 0xFC, 0x3F, 0x7F, 0xC0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF,
  0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x07,
  0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x07, 0xF9, 0xFE,
  0x00, 0xFF, 0x9F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC,
  0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF8, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0x9F,
  0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0xC0,
  0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0x81, 0xFF, 0x08, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0xFC,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFD, 0xFF, 0xF7, 0xF3, 0xFF,
  0x8F, 0xC7, 0xF8, 0x3F, 0x03, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0x80, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F,
  0xF0, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xE7, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0xE7, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xF8, 0xFE, 0x3F,
  0xF0, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFE, 0x1E, 0x7F, 0xC0, 0x47, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0x7F, 0xC0, 0x77, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x01, 0xE0, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xFC, 0xFF,
  0x1F, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xE7, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0x7F, 0x81, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xE7, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFE, 0x7F, 0x0F, 0xFC, 0x7F,
  0x07, 0xF8, 0x7F, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x3F, 0xE1, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x0C, 0xFF, 0xC0, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xEE,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x0F, 0xFE, 0x7F, 0x1F,
  0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xE7, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0x7F,
  0x81, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0x0F, 0xFC, 0xFF, 0x07,
  0xF8, 0xFF, 0x00, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x40, 0x01, 0xFE, 0x70, 0x03, 0xFE, 0x7F, 0x1F, 0xFE, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x7E, 0x0F, 0xF3, 0xFF, 0x1F, 0xEF, 0xFF,
  0x3F, 0xDF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8,
  0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xE0, 0x01, 0xE0, 0x0F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF,
  0xCF, 0xFE, 0x3F, 0xF8, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF8,
  0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F,
  0xC0, 0xFF, 0x1F, 0xF0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFD,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0,
  0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F,
  0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F,
  0xEF, 0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x1F, 0x03, 0xF8, 0xFF, 0xC1, 0xFF, 0x0F, 0xE7, 0xFF, 0x8F,
  0xFE, 0x3F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFE, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0x07,
  0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0x81, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0x01,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xFC, 0x07,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0x81, 0xFF,
  0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F,
  0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xC1, 0xFC, 0x7F,
  0xE3, 0xF9, 0xFF, 0xE7, 0xF7, 0xFF, 0xCF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xC7, 0xFC, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0xBF, 0xE0,
  0x3F, 0xDF, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC,
  0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xF9,
  0xFE, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0xC1, 0xFE, 0x1F, 0xFB, 0xFF,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xF0, 0xFF, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF,
  0xC3, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFE, 0xFF,
  0xC3, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0x7F, 0xFC, 0xFF, 0x7F, 0xF8, 0xFF, 0x3F, 0xF0, 0xFF, 0x1F, 0xE0, 0xFF,
  0x01, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x0F,
  0xFE, 0x7F, 0x1F, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xE7, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0x0F,
  0xFC, 0xFF, 0x07, 0xF8, 0xFF, 0x00, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xC3,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC,
  0x1C, 0xFF, 0x01, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x01, 0x80, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x82, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x00, 0x80, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xF3, 0xFF, 0xEF, 0xE3, 0xFF, 0x9F, 0xC3,
  0xFE, 0x1F, 0x80, 0x40, 0x00, 0xFF, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7,
  0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F,
  0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x03,
  0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0x7F, 0x81, 0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFF, 0x81,
  0xFE, 0x7F, 0x81, 0xFF, 0xC1, 0xFE, 0x7F, 0x81, 0xFF, 0xC1, 0xFE, 0x3F,
  0xC3, 0xFF, 0xC1, 0xFE, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xC3, 0xFF,
  0xC3, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xC3, 0xF7, 0xE3, 0xFC,
  0x1F, 0xE3, 0xE7, 0xE3, 0xFC, 0x1F, 0xE7, 0xE7, 0xE7, 0xF8, 0x1F, 0xE7,
  0xE7, 0xE7, 0xF8, 0x1F, 0xE7, 0xE7, 0xE7, 0xF8, 0x1F, 0xE7, 0xE7, 0xE7,
  0xF8, 0x0F, 0xE7, 0xE3, 0xE7, 0xF0, 0x0F, 0xE7, 0xC3, 0xF7, 0xF0, 0x0F,
  0xEF, 0xC3, 0xF7, 0xF0, 0x0F, 0xFF, 0xC3, 0xF7, 0xF0, 0x07, 0xFF, 0xC3,
  0xFF, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0,
  0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xBF, 0xE0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F,
  0xE0, 0xFF, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xEF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF8,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F,
  0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x3F, 0xC0, 0x1F,
  0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x80,
  0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x9F, 0xFC, 0x00, 0xDF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFE, 0xC0, 0x07, 0xFE, 0x40, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 42, 15, 3, -41 },
  { 49, 22, 15, 26, 2, -41 },
  { 91, 28, 41, 30, 1, -41 },
  { 235, 22, 46, 27, 3, -43 },
  { 362, 42, 41, 46, 2, -41 },
  { 578, 33, 42, 34, 1, -41 },
  { 752, 9, 15, 14, 2, -41 },
  { 769, 15, 50, 18, 3, -41 },
  { 863, 15, 50, 18, 1, -41 },
  { 957, 24, 24, 26, 1, -43 },
  { 1029, 24, 28, 27, 2, -34 },
  { 1113, 10, 15, 15, 2, -7 },
  { 1132, 14, 8, 18, 2, -19 },
  { 1146, 9, 10, 15, 3, -9 },
  { 1158, 23, 42, 24, 0, -41 },
  { 1279, 23, 42, 27, 2, -41 },
  { 1400, 19, 41, 27, 2, -41 },
  { 1498, 24, 41, 27, 1, -41 },
  { 1621, 23, 42, 27, 2, -41 },
  { 1742, 25, 41, 27, 1, -41 },
  { 1871, 22, 42, 27, 3, -41 },
  { 1987, 23, 42, 27, 2, -41 },
  { 2108, 23, 41, 27, 2, -41 },
  { 2226, 23, 42, 27, 2, -41 },
  { 2347, 23, 42, 27, 2, -41 },
  { 2468, 9, 33, 15, 3, -32 },
  { 2506, 10, 40, 15, 2, -32 },
  { 2556, 24, 27, 27, 2, -34 },
  { 2637, 24, 18, 27, 2, -29 },
  { 2691, 24, 27, 27, 2, -34 },
  { 2772, 21, 42, 22, 0, -41 },
  { 2883, 38, 45, 42, 2, -41 },
  { 3097, 31, 41, 31, 0, -41 },
  { 3256, 25, 41, 31, 4, -41 },
  { 3385, 25, 42, 28, 2, -41 },
  { 3517, 26, 41, 33, 4, -41 },
  { 3651, 18, 41, 25, 4, -41 },
  { 3744, 18, 41, 25, 4, -41 },
  { 3837, 28, 42, 33, 2, -41 },
  { 3984, 26, 41, 34, 4, -41 },
  { 4118, 17, 41, 19, 1, -41 },
  { 4206, 15, 53, 16, -3, -41 },
  { 4306, 27, 41, 30, 4, -41 },
  { 4445, 19, 41, 24, 4, -41 },
  { 4543, 37, 41, 45, 4, -41 },
  { 4733, 29, 41, 37, 4, -41 },
  { 4882, 30, 42, 35, 2, -41 },
  { 5040, 23, 41, 29, 4, -41 },
  { 5158, 30, 51, 35, 2, -41 },
  { 5350, 26, 41, 30, 4, -41 },
  { 5484, 21, 42, 25, 2, -41 },
  { 5595, 23, 41, 25, 1, -41 },
  { 5713, 27, 42, 33, 3, -41 },
  { 5855, 30, 41, 30, 0, -41 },
  { 6009, 45, 41, 44, 0, -41 },
  { 6240, 28, 41, 28, 0, -41 },
  { 6384, 28, 41, 28, 0, -41 },
  { 6528, 23, 41, 25, 1, -41 },
  { 6646, 13, 50, 18, 3, -41 },
  { 6728, 23, 42, 24, 0, -41 },
  { 6849, 14, 50, 18, 1, -41 },
  { 6937, 29, 26, 31, 1, -41 },
  { 7032, 26, 6, 26, 0, 4 },
  { 7052, 14, 9, 18, 2, -44 },
  { 7068, 22, 33, 27, 2, -32 },
  { 7159, 24, 44, 29, 3, -43 },
  { 7291, 20, 33, 24, 2, -32 },
  { 7374, 24, 44, 29, 2, -43 },
  { 7506, 23, 33, 27, 2, -32 },
  { 7601, 19, 44, 18, 0, -44 },
  { 7706, 24, 46, 29, 2, -32 },
  { 7844, 23, 43, 29, 3, -43 },
  { 7968, 9, 44, 14, 3, -44 },
  { 8018, 14, 58, 14, -2, -44 },
  { 8120, 26, 43, 29, 3, -43 },
  { 8260, 8, 43, 14, 3, -43 },
  { 8303, 38, 32, 44, 3, -32 },
  { 8455, 23, 32, 29, 3, -32 },
  { 8547, 25, 33, 29, 2, -32 },
  { 8651, 24, 46, 29, 3, -32 },
  { 8789, 24, 46, 29, 2, -32 },
  { 8927, 17, 32, 21, 3, -32 },
  { 8995, 18, 33, 22, 2, -32 },
  { 9070, 17, 39, 19, 1, -38 },
  { 9153, 23, 32, 29, 3, -31 },
  { 9245, 26, 31, 27, 0, -31 },
  { 9346, 40, 31, 40, 0, -31 },
  { 9501, 25, 31, 25, 0, -31 },
  { 9598, 26, 45, 27, 0, -31 },
  { 9745, 19, 31, 21, 1, -31 },
  { 9819, 18, 50, 20, 1, -41 },
  { 9932, 7, 57, 25, 9, -44 },
  { 9982, 18, 50, 20, 2, -41 },
  { 10095, 25, 10, 27, 1, -25 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD57PT7B_H_
