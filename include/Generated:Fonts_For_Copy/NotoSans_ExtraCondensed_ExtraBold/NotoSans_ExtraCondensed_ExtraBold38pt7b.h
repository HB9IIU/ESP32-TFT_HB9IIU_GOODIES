#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD38PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDE, 0x79, 0xE0, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0xFC, 0xFF,
  0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xBE, 0x1E,
  0xF8, 0x7B, 0xE1, 0xE0, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE1, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x3C, 0x78, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x38, 0xF0, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0xF1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1E, 0x03, 0xCF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7F,
  0x83, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x7F, 0xBC, 0xFB, 0x09, 0xF6, 0x03,
  0xEC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x0D, 0xF0, 0x19, 0xE0, 0x33, 0xF0, 0x67, 0xB8, 0xDF,
  0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE1, 0xFF, 0x80, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0xC0, 0x78, 0x07, 0xFC, 0x0F, 0x80, 0x7B, 0xE0, 0xF0, 0x0F, 0x9E, 0x0F,
  0x00, 0xF1, 0xE1, 0xE0, 0x0F, 0x1E, 0x1E, 0x00, 0xF1, 0xE1, 0xE0, 0x0F,
  0x1E, 0x3C, 0x00, 0xF1, 0xE3, 0xC0, 0x0F, 0x1E, 0x78, 0x70, 0xF9, 0xE7,
  0x9F, 0xC7, 0xBE, 0x79, 0xFE, 0x7F, 0xCF, 0x3F, 0xE3, 0xFC, 0xF3, 0xDF,
  0x1F, 0x9E, 0x7C, 0xF0, 0x41, 0xE7, 0x8F, 0x00, 0x1E, 0x78, 0xF0, 0x03,
  0xC7, 0x8F, 0x00, 0x3C, 0x78, 0xF0, 0x07, 0x87, 0x8F, 0x00, 0x78, 0x7C,
  0xF0, 0x07, 0x83, 0xCF, 0x00, 0xF0, 0x3F, 0xF0, 0x0F, 0x03, 0xFE, 0x01,
  0xE0, 0x1F, 0xE0, 0x1E, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x1F, 0xE1, 0xF8, 0xFF, 0xC7, 0xE7, 0xFF, 0x1F, 0x1F,
  0xFE, 0xFC, 0xFD, 0xFF, 0xF3, 0xF3, 0xFF, 0xCF, 0xC7, 0xFE, 0x3F, 0x0F,
  0xF8, 0xFC, 0x3F, 0xC3, 0xF0, 0x7F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xC0, 0xFF, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x63, 0xCE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3E, 0xFC, 0x7C, 0x7E, 0x1C,
  0x78, 0x08, 0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x3E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E,
  0xF9, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x1F, 0xF3,
  0xFF, 0x7F, 0xFF, 0xDF, 0xF9, 0xF7, 0x9F, 0x31, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x01, 0x00, 0x3F,
  0xE0, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xCF, 0xBF, 0xDC, 0x1F, 0x90, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE,
  0x3C, 0xFE, 0x20, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x03, 0xFC, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0x7C, 0x07, 0xFE, 0x07, 0xBF, 0x03, 0xDF, 0x83,
  0xCF, 0xC3, 0xE7, 0xE1, 0xE3, 0xF1, 0xF1, 0xF8, 0xF0, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF2, 0x03, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x9F, 0xFF, 0x9C, 0xFF,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xD0,
  0x1F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE1, 0xFF, 0x00, 0x03,
  0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xC2, 0x3F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xF0, 0xFD, 0xFC, 0xFB, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7E, 0x3E, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x0F,
  0xF0, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC, 0x3F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFE, 0xFC, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xDF, 0x1F, 0xBF, 0x0F, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0xFC, 0x67, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7B,
  0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF,
  0xFF, 0xFF, 0x78, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7D, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E,
  0x79, 0xF0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF,
  0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80,
  0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x03, 0x00, 0xFF, 0x87,
  0xFF, 0x3F, 0xFE, 0x7F, 0xFD, 0xF7, 0xF2, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0x80,
  0x1E, 0x07, 0xC0, 0x03, 0xC3, 0xE0, 0x20, 0xF8, 0xF0, 0xFF, 0x9E, 0x3C,
  0x7F, 0xE7, 0x9E, 0x3F, 0xF8, 0xE7, 0x8F, 0x1E, 0x3D, 0xE7, 0xC7, 0x8F,
  0x79, 0xE1, 0xE3, 0xFC, 0x78, 0x78, 0xFF, 0x1E, 0x1E, 0x3F, 0xC7, 0x87,
  0x8F, 0xF1, 0xE3, 0xE3, 0xBC, 0x78, 0xF9, 0xE7, 0x9F, 0x3E, 0x79, 0xE3,
  0xFF, 0xFC, 0x78, 0xFF, 0xFF, 0x1E, 0x1F, 0x9F, 0x83, 0xC1, 0x81, 0x80,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x06, 0x00, 0xFF, 0xBF,
  0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0x7E,
  0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0x7E, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xF0,
  0x7F, 0xF8, 0x3E, 0xFC, 0x1F, 0x7E, 0x1F, 0xBF, 0x1F, 0xDF, 0xFF, 0xCF,
  0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFD, 0xF8, 0xFE, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0x40, 0x07, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0x04, 0x7E, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x02, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7E, 0xFC, 0x3F, 0xBF, 0x1F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFB, 0xE7, 0xF0,
  0x11, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x83, 0xF7, 0xF0,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xE3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xCF, 0xE0, 0xFC,
  0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x87, 0xE7, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xF7,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0x9F, 0x83, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x81,
  0xFB, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1E, 0xFF,
  0xF7, 0x87, 0xBF, 0xFD, 0xF3, 0xEF, 0xFF, 0x7C, 0xFB, 0xFF, 0xDF, 0x3C,
  0xFF, 0xF3, 0xDF, 0x3F, 0xFC, 0xFF, 0xCF, 0xFF, 0x3F, 0xE3, 0xFF, 0xCF,
  0xF8, 0xFF, 0xF1, 0xFE, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF, 0x1F, 0xC3, 0xFF,
  0xC7, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0x83,
  0xFF, 0xC3, 0xE0, 0xFC, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xDF, 0x1F, 0xFD, 0xF9,
  0xFF, 0xCF, 0x9F, 0xFC, 0xF9, 0xFF, 0xCF, 0xDF, 0xFC, 0x7D, 0xFF, 0xC7,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xF0,
  0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xFF, 0x7F, 0x9F, 0x83, 0xF7, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7E, 0xFC, 0x1F, 0xDF, 0xC3, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0x7F, 0x9F, 0x83, 0xF7, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7E, 0xFC, 0x1F, 0xDF, 0xC3, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF,
  0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0xFF, 0xE0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0x1F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF1,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xCF,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC0, 0xFC, 0x01,
  0x80, 0x1F, 0xF0, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xBF, 0x86,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xBC, 0x3F, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3,
  0xFF, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x87, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3E,
  0x07, 0xE3, 0xE0, 0x7C, 0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF0,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x3E, 0x03, 0xEF,
  0xC0, 0xFC, 0x1F, 0xBF, 0x03, 0xF0, 0x7E, 0x7C, 0x1F, 0xC1, 0xF9, 0xF0,
  0x7F, 0x07, 0xE7, 0xE1, 0xFC, 0x1F, 0x1F, 0x87, 0xF8, 0x7C, 0x7E, 0x1F,
  0xE3, 0xF0, 0xF8, 0xFF, 0x8F, 0xC3, 0xE3, 0xDE, 0x3F, 0x0F, 0x8F, 0x78,
  0xF8, 0x3F, 0x3D, 0xF3, 0xE0, 0xFC, 0xF7, 0xCF, 0x81, 0xF7, 0xCF, 0x7E,
  0x07, 0xDF, 0x3D, 0xF8, 0x1F, 0x7C, 0xF7, 0xE0, 0x7D, 0xE3, 0xDF, 0x01,
  0xF7, 0x8F, 0x7C, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0,
  0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x0F,
  0xCF, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x3E, 0x7E,
  0x07, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xF0,
  0x7E, 0x3E, 0x0F, 0xC7, 0xE1, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC1, 0xFB,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xEF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x07, 0xC7, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF,
  0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x3F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1,
  0xFF, 0xF1, 0xC7, 0xE2, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0xFE, 0x7F,
  0xFD, 0xFF, 0xFB, 0xFD, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x3F,
  0xFC, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFC, 0xF3, 0xF1, 0xE0, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF9, 0xF8, 0xFB, 0xFC, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC, 0xF9, 0xF8, 0x07, 0xF8, 0x7F, 0xF3,
  0xFF, 0x8F, 0xFE, 0x7F, 0xF9, 0xF8, 0x27, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x81,
  0x7F, 0x39, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x0F, 0x9F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E,
  0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0x7F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x8F, 0x07, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x02, 0x7F, 0x0E, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07,
  0xF8, 0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0xF3, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x00, 0x0F, 0x8F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E,
  0x3F, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0x7F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x60, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F,
  0xE0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7B,
  0xFF, 0xFF, 0xF9, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x0F, 0xC7,
  0xE3, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x7F, 0xBF,
  0xDF, 0xEF, 0xE7, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0xFE,
  0x1F, 0xBF, 0x0F, 0x9F, 0x8F, 0xCF, 0xCF, 0xC7, 0xE7, 0xC3, 0xF7, 0xE1,
  0xF7, 0xE0, 0xFB, 0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x87, 0xF7, 0xC3, 0xF3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x7E, 0x1F, 0x3F,
  0x0F, 0xDF, 0x83, 0xEF, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xF8, 0x7E, 0x7D, 0xFE, 0x7F, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0xFF, 0xF0,
  0xFC, 0x7F, 0xF8, 0x7E, 0x1F, 0xFC, 0x3E, 0x0F, 0xFE, 0x1F, 0x07, 0xFF,
  0x0F, 0x83, 0xFF, 0x87, 0xC1, 0xFF, 0xC3, 0xE0, 0xFF, 0xE1, 0xF0, 0x7F,
  0xF0, 0xF8, 0x3F, 0xF8, 0x7C, 0x1F, 0xFC, 0x3E, 0x0F, 0xFE, 0x1F, 0x07,
  0xFF, 0x0F, 0x83, 0xFF, 0x87, 0xC1, 0xFF, 0xC3, 0xE0, 0xF8, 0xF1, 0xF8,
  0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x7E, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0x07, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xC7, 0xF7, 0xF3, 0xF1, 0xF9, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xE0, 0xF9, 0xF0, 0x7C,
  0xFC, 0x7E, 0x7F, 0x7F, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7F,
  0x00, 0xF9, 0xF8, 0xFB, 0xFC, 0xFB, 0xFC, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0xFF,
  0xFE, 0xFB, 0xFE, 0xFB, 0xFC, 0xF9, 0xF8, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x0F, 0x8F, 0x1F, 0xDF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E,
  0x3F, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7F, 0x7F, 0x7F,
  0xFF, 0x3F, 0xFF, 0x1F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0xF0, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x1F, 0xE1, 0xFF, 0x9F, 0xFD, 0xFF,
  0xEF, 0xC6, 0x7C, 0x13, 0xF0, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xF3, 0xF7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F,
  0xB1, 0xFF, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0x3F, 0xDF, 0x1F,
  0x9F, 0xFC, 0x0F, 0xFF, 0x03, 0xE7, 0xC1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3F, 0x3E, 0x07, 0xCF, 0x81,
  0xF3, 0xE0, 0x7D, 0xF0, 0x0F, 0x7C, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x3F, 0x87, 0xFF, 0x87, 0xF0, 0xF9, 0xF0, 0xFE, 0x1F, 0x3E,
  0x1F, 0xC3, 0xE7, 0xC7, 0xF8, 0xFC, 0xFC, 0xFF, 0x1F, 0x0F, 0x9E, 0xF3,
  0xE1, 0xF3, 0xDE, 0x7C, 0x3E, 0x7B, 0xCF, 0x87, 0xCF, 0x7B, 0xF0, 0xFB,
  0xCF, 0x7C, 0x0F, 0xF9, 0xEF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE,
  0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC,
  0x3F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0xBF, 0x1F, 0x9F, 0x8F, 0xC7, 0xEF, 0xC3, 0xF7, 0xE0, 0xFB,
  0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xF0, 0x3E, 0xF8, 0x3F, 0x7E,
  0x1F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xEF, 0xC1, 0xF8, 0xFC, 0x0F, 0xDF,
  0x03, 0xE7, 0xC1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3,
  0xF0, 0xFC, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF,
  0xFF, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1,
  0xF8, 0xFF, 0x8F, 0xF0, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xF8, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xF0, 0xFF, 0x1F, 0xF1, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x1C, 0x01, 0x7F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 27, 10, 2, -27 },
  { 22, 14, 10, 18, 2, -27 },
  { 40, 18, 27, 20, 1, -27 },
  { 101, 15, 31, 18, 2, -29 },
  { 160, 28, 28, 31, 1, -28 },
  { 258, 22, 27, 23, 1, -27 },
  { 333, 6, 10, 9, 2, -27 },
  { 341, 10, 34, 12, 2, -28 },
  { 384, 10, 34, 12, 0, -28 },
  { 427, 16, 16, 17, 1, -29 },
  { 459, 16, 19, 18, 1, -23 },
  { 497, 7, 10, 10, 1, -5 },
  { 506, 10, 5, 12, 1, -13 },
  { 513, 6, 6, 10, 2, -6 },
  { 518, 16, 27, 16, 0, -27 },
  { 572, 16, 28, 18, 1, -28 },
  { 628, 12, 27, 18, 2, -27 },
  { 669, 15, 28, 18, 1, -28 },
  { 722, 16, 28, 18, 1, -28 },
  { 778, 17, 27, 18, 1, -27 },
  { 836, 15, 27, 18, 2, -27 },
  { 887, 16, 27, 18, 1, -27 },
  { 941, 16, 27, 18, 1, -27 },
  { 995, 16, 27, 18, 1, -27 },
  { 1049, 16, 27, 18, 1, -27 },
  { 1103, 6, 21, 10, 2, -21 },
  { 1119, 7, 26, 10, 1, -21 },
  { 1142, 16, 19, 18, 1, -23 },
  { 1180, 16, 13, 18, 1, -20 },
  { 1206, 16, 19, 18, 1, -23 },
  { 1244, 14, 28, 15, 0, -28 },
  { 1293, 26, 30, 28, 1, -27 },
  { 1391, 21, 27, 21, 0, -27 },
  { 1462, 17, 27, 21, 2, -27 },
  { 1520, 16, 28, 19, 2, -28 },
  { 1576, 18, 27, 22, 2, -27 },
  { 1637, 13, 27, 17, 2, -27 },
  { 1681, 13, 27, 16, 2, -27 },
  { 1725, 18, 28, 22, 2, -28 },
  { 1788, 18, 27, 23, 2, -27 },
  { 1849, 11, 27, 13, 1, -27 },
  { 1887, 10, 35, 11, -2, -27 },
  { 1931, 19, 27, 20, 2, -27 },
  { 1996, 13, 27, 16, 2, -27 },
  { 2040, 26, 27, 30, 2, -27 },
  { 2128, 20, 27, 24, 2, -27 },
  { 2196, 19, 28, 23, 2, -28 },
  { 2263, 16, 27, 19, 2, -27 },
  { 2317, 19, 34, 23, 2, -28 },
  { 2398, 18, 27, 20, 2, -27 },
  { 2459, 15, 28, 17, 1, -28 },
  { 2512, 15, 27, 17, 1, -27 },
  { 2563, 18, 27, 22, 2, -27 },
  { 2624, 20, 27, 20, 0, -27 },
  { 2692, 30, 27, 29, 0, -27 },
  { 2794, 19, 27, 19, 0, -27 },
  { 2859, 19, 27, 19, 0, -27 },
  { 2924, 15, 27, 17, 1, -27 },
  { 2975, 9, 34, 12, 2, -28 },
  { 3014, 16, 27, 16, 0, -27 },
  { 3068, 9, 34, 12, 1, -28 },
  { 3107, 19, 17, 20, 1, -27 },
  { 3148, 17, 3, 17, 0, 3 },
  { 3155, 9, 6, 12, 2, -29 },
  { 3162, 15, 21, 18, 1, -21 },
  { 3202, 16, 29, 19, 2, -29 },
  { 3260, 14, 21, 16, 1, -21 },
  { 3297, 16, 29, 19, 1, -29 },
  { 3355, 16, 21, 18, 1, -21 },
  { 3397, 13, 29, 12, 0, -29 },
  { 3445, 16, 30, 19, 1, -21 },
  { 3505, 16, 29, 20, 2, -29 },
  { 3563, 6, 29, 10, 2, -29 },
  { 3585, 9, 38, 10, -1, -29 },
  { 3628, 17, 29, 19, 2, -29 },
  { 3690, 6, 29, 10, 2, -29 },
  { 3712, 25, 21, 29, 2, -21 },
  { 3778, 16, 21, 20, 2, -21 },
  { 3820, 17, 21, 19, 1, -21 },
  { 3865, 16, 30, 19, 2, -21 },
  { 3925, 16, 30, 19, 1, -21 },
  { 3985, 11, 21, 14, 2, -21 },
  { 4014, 13, 21, 15, 1, -21 },
  { 4049, 12, 25, 13, 0, -25 },
  { 4087, 16, 21, 20, 2, -21 },
  { 4129, 18, 21, 18, 0, -21 },
  { 4177, 27, 21, 27, 0, -21 },
  { 4248, 17, 21, 17, 0, -21 },
  { 4293, 18, 30, 18, 0, -21 },
  { 4361, 13, 21, 14, 1, -21 },
  { 4396, 12, 33, 14, 0, -27 },
  { 4446, 5, 38, 16, 6, -29 },
  { 4470, 12, 33, 14, 1, -27 },
  { 4520, 16, 7, 18, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD38PT7B_H_
