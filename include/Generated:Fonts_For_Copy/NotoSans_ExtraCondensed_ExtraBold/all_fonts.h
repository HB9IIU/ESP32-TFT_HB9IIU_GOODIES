#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraCondensed_ExtraBold
// Headers: 67

#include "NotoSans_ExtraCondensed_ExtraBold6pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold7pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold8pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold9pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold10pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold11pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold12pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold13pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold14pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold15pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold16pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold17pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold18pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold19pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold20pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold21pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold22pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold23pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold24pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold25pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold26pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold27pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold28pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold29pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold30pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold31pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold32pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold33pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold34pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold35pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold36pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold37pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold38pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold39pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold40pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold41pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold42pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold43pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold44pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold45pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold46pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold47pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold48pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold49pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold50pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold51pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold52pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold53pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold54pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold55pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold56pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold57pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold58pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold59pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold60pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold61pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold62pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold63pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold64pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold65pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold66pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold67pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold68pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold69pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold70pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold71pt7b.h"
#include "NotoSans_ExtraCondensed_ExtraBold72pt7b.h"
