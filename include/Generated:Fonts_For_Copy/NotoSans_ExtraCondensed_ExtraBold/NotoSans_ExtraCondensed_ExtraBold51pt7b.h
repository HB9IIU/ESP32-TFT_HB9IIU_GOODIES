#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD51PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xF9, 0xFF,
  0xFF, 0xFF, 0xBF, 0xDF, 0xC7, 0xE0, 0x80, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC3, 0xFB,
  0xF8, 0x7F, 0x7F, 0x0F, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0xBF, 0x07, 0xF7,
  0xE0, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x3F, 0x00,
  0x3F, 0x1F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF8,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x07, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x83,
  0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00,
  0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0x71, 0xCF, 0xE7,
  0x04, 0xFE, 0x70, 0x0F, 0xE7, 0x00, 0xFE, 0x70, 0x07, 0xF7, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0x7F,
  0x00, 0x73, 0xF0, 0x07, 0x3F, 0x80, 0x73, 0xFE, 0x07, 0x3F, 0xF8, 0x77,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF,
  0xF0, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x03,
  0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x7C, 0x00, 0x1F, 0x9F, 0x80,
  0xF8, 0x00, 0x3E, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x3E, 0x07, 0xC0, 0x01,
  0xF8, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF8,
  0x7C, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE3, 0xE0, 0x00,
  0x1F, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x1F, 0x0F, 0xE0, 0x7E, 0x7E,
  0x3E, 0x3F, 0xF0, 0xFC, 0xFC, 0xFC, 0xFF, 0xE0, 0xFF, 0xF1, 0xF1, 0xFF,
  0xE1, 0xFF, 0xE7, 0xE7, 0xFF, 0xC1, 0xFF, 0x8F, 0x8F, 0xCF, 0xC1, 0xFE,
  0x1F, 0x1F, 0x1F, 0x81, 0xF8, 0x7E, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xFC,
  0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0xFC, 0x00,
  0x0F, 0x87, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F,
  0x87, 0xC0, 0x01, 0xF8, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x3F, 0x00,
  0x07, 0xC0, 0x7E, 0x7E, 0x00, 0x1F, 0x80, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0xFF, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF9,
  0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x1F,
  0xC0, 0xFF, 0xF0, 0xFF, 0x07, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0x8F, 0xF1,
  0xFF, 0xFF, 0x3F, 0x87, 0xFB, 0xFF, 0xFE, 0x1F, 0xC7, 0xFF, 0xF8, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFC, 0x3F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFC, 0x3F, 0xC0,
  0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x7F,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xF7, 0xFC, 0x07, 0xFF, 0x0F, 0xFC,
  0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0x83, 0xE0, 0xC7,
  0xCF, 0x8F, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x03, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x03,
  0xC1, 0xF0, 0x07, 0x03, 0x00, 0x08, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0xFE, 0x7F, 0x3F, 0x9F,
  0xCF, 0xC7, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC,
  0x7E, 0x08, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0xF1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFE, 0x0F,
  0xEF, 0xF0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF8,
  0x3F, 0xBF, 0xC1, 0xFD, 0xFE, 0x1F, 0xE7, 0xF0, 0xFF, 0x3F, 0x87, 0xF1,
  0xFE, 0x7F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFF, 0x3F, 0xFF, 0xBF, 0xDF, 0xFF, 0xEF, 0xEF, 0xE7, 0xF3, 0xE3,
  0xF8, 0xE1, 0xFC, 0x20, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xC1, 0xFE, 0x1C,
  0x0F, 0xF0, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0x81, 0xFE,
  0x20, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x08, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0x7F, 0x00, 0x7E, 0xFE, 0x00, 0xF9, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xC7,
  0xF0, 0x1F, 0x8F, 0xE0, 0x3E, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF0, 0x7F,
  0x07, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x30, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE1, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0x83, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x87, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x1F, 0x03, 0xF9, 0xFE, 0x1F,
  0xDF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xBF,
  0xEF, 0xF0, 0xFF, 0x7F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0x3F, 0x87, 0xF9, 0xFE, 0x3F, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x9F, 0xE1,
  0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0x8F, 0xE1, 0xFE,
  0x3F, 0xC7, 0xF0, 0xFF, 0x3F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x03, 0xF9,
  0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0x7F, 0x03, 0xFD, 0xFC,
  0x0F, 0xF7, 0xF8, 0x3F, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x87,
  0xF9, 0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xDF, 0xC0, 0xFF, 0x7F, 0x07, 0xFD, 0xFE,
  0x1F, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFD, 0xF8, 0x7F, 0xF7,
  0xE1, 0xFF, 0xBF, 0x83, 0xFC, 0xFE, 0x01, 0x83, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x10, 0x3F, 0x3F, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7E, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xCF, 0xE7, 0xF3, 0xFB,
  0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9, 0xC0, 0xFF, 0x30, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xC0, 0x08, 0x07, 0xC3, 0xF0, 0x3F, 0xF1, 0xF8, 0xF8, 0x3F, 0xFE,
  0x3E, 0x7E, 0x1F, 0xFF, 0x8F, 0x9F, 0x07, 0xFF, 0xE3, 0xF7, 0xC3, 0xF1,
  0xF8, 0xFF, 0xF0, 0xF8, 0x7E, 0x1F, 0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0x1F,
  0x87, 0xE1, 0xFF, 0x87, 0xC1, 0xF8, 0x7F, 0xE1, 0xF0, 0x7E, 0x1F, 0xF8,
  0x7C, 0x1F, 0x87, 0xFE, 0x1F, 0x07, 0xC1, 0xFF, 0x87, 0xC1, 0xF0, 0xFF,
  0xE1, 0xF0, 0x7C, 0x3E, 0xF8, 0x7E, 0x3F, 0x0F, 0xBE, 0x1F, 0x8F, 0xC3,
  0xEF, 0xC7, 0xF7, 0xF9, 0xF3, 0xF0, 0xFF, 0xFF, 0xFC, 0x7C, 0x3F, 0xF7,
  0xFE, 0x1F, 0x87, 0xF8, 0xFF, 0x07, 0xE0, 0x7C, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x02, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC,
  0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x7F, 0x83, 0xFE, 0xFF, 0x03,
  0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F,
  0x9F, 0xE1, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xF0, 0xFF, 0xDF,
  0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x01, 0xFD, 0xFE,
  0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x7F, 0xDF, 0xE3,
  0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFC, 0x1C, 0x3F, 0xE0, 0x10, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x63, 0xFF, 0x87, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x10, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F,
  0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03,
  0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xF0, 0x1C, 0x3F, 0xE0, 0x02, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF,
  0xE0, 0x1F, 0xEF, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9, 0xFF, 0x03, 0xFC,
  0xFF, 0xC3, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x30,
  0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x83, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x3F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0x9F, 0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0xC7,
  0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF7, 0xFC,
  0x07, 0xFB, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0x81, 0xFE, 0x3F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xFC,
  0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFB, 0xF0, 0x3F,
  0x7F, 0xFE, 0xFC, 0x0F, 0xDF, 0xFF, 0xBF, 0x03, 0xF7, 0xFF, 0xEF, 0xE1,
  0xF9, 0xFF, 0xF9, 0xF8, 0x7E, 0x7F, 0xFE, 0x7E, 0x1F, 0x9F, 0xFF, 0x9F,
  0x87, 0xE7, 0xFF, 0xE7, 0xF3, 0xF1, 0xFF, 0xFC, 0xFC, 0xFC, 0x7F, 0xFF,
  0x3F, 0x3F, 0x1F, 0xFF, 0xCF, 0xCF, 0xC7, 0xFF, 0xF3, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xF8, 0x7F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0x87,
  0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0x0F, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0xFC, 0x1F,
  0xE0, 0x7F, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0x01, 0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xFE,
  0x1F, 0xFF, 0xBF, 0x87, 0xFF, 0xEF, 0xF1, 0xFF, 0xF9, 0xFC, 0x7F, 0xFE,
  0x7F, 0x9F, 0xFF, 0x8F, 0xE7, 0xFF, 0xE3, 0xF9, 0xFF, 0xF8, 0x7F, 0x7F,
  0xFE, 0x1F, 0xDF, 0xFF, 0x87, 0xFB, 0xFF, 0xE0, 0xFE, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8,
  0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFD,
  0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xE7, 0xFC, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xFE, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF9, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0xBF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x3F,
  0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xFC,
  0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x1F, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0xFF, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFF,
  0x01, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFC, 0x3C, 0xFF, 0x01, 0x9F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x03, 0xFF, 0x80, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xFC, 0xFF, 0xDF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFD,
  0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF, 0x00,
  0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07,
  0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0xFF, 0x00,
  0xFF, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x7F, 0x01, 0xFF, 0x01,
  0xFE, 0x7F, 0x01, 0xFF, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x01, 0xFC, 0x7F,
  0x81, 0xFF, 0x81, 0xFC, 0x3F, 0x81, 0xFF, 0x83, 0xFC, 0x3F, 0x83, 0xFF,
  0x83, 0xFC, 0x3F, 0x83, 0xFF, 0x83, 0xFC, 0x3F, 0x83, 0xFF, 0x83, 0xF8,
  0x3F, 0xC3, 0xEF, 0xC3, 0xF8, 0x1F, 0xC3, 0xEF, 0xC3, 0xF8, 0x1F, 0xC7,
  0xEF, 0xC7, 0xF8, 0x1F, 0xC7, 0xEF, 0xC7, 0xF8, 0x1F, 0xC7, 0xE7, 0xC7,
  0xF0, 0x1F, 0xC7, 0xE7, 0xE7, 0xF0, 0x0F, 0xE7, 0xE7, 0xE7, 0xF0, 0x0F,
  0xEF, 0xE7, 0xEF, 0xF0, 0x0F, 0xEF, 0xC7, 0xEF, 0xF0, 0x0F, 0xEF, 0xC7,
  0xEF, 0xE0, 0x0F, 0xEF, 0xC3, 0xEF, 0xE0, 0x07, 0xEF, 0xC3, 0xEF, 0xE0,
  0x07, 0xEF, 0xC3, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x07, 0xFF,
  0x83, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x3F, 0xC0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xC0, 0xFF,
  0x1F, 0xE0, 0x7F, 0x8F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03,
  0xFB, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x03, 0xFB, 0xF8, 0x03, 0xFD, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFE,
  0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F,
  0xE3, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3,
  0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE,
  0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0xFE, 0x7E, 0x00,
  0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xE7, 0xF0, 0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x1F, 0x00, 0x38, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x7F, 0xC1, 0x80, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFB, 0xFC, 0x3F,
  0xDF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFE, 0x7E,
  0x7F, 0xE3, 0xF1, 0xFE, 0x1F, 0x81, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0x01, 0xFC, 0x7F, 0x0F, 0xE7, 0xFC, 0x7F, 0x7F, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0xBF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0x7F, 0xE3,
  0xF1, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0xFF, 0xFC,
  0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFE, 0x0C, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x27, 0xF8, 0x19, 0xFF, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x40, 0xFE, 0x1F, 0xC7, 0xF1, 0xFF, 0xBF, 0x9F,
  0xFD, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFC, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0x7F, 0x8F, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3,
  0xFF, 0xDF, 0x8F, 0xFC, 0xFC, 0x3F, 0xC7, 0xE0, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0x7F, 0x80, 0x67, 0xFF, 0x7E, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01,
  0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xCC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF,
  0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0x80, 0x00, 0x7F, 0x8F, 0xC7, 0xFE, 0x7E, 0x7F, 0xF3, 0xF3, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFD, 0xFE, 0x3F,
  0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFE, 0xFE, 0x3F,
  0xF7, 0xF0, 0xFE, 0x3F, 0x80, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xFB, 0x00, 0x3F, 0xDE, 0x07, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0x01, 0xFC, 0xFF, 0x0F, 0xEF, 0xFC, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFC, 0x7F, 0xBF,
  0xC1, 0xFD, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xE0, 0x3E, 0x7F, 0x7F, 0xFF, 0x7F,
  0x7F, 0x7F, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x03, 0xE0,
  0x7F, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0xFF, 0xCF,
  0xFC, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0xEF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0x83, 0xFC, 0x7F, 0x07,
  0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF3, 0xFC,
  0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFB, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE,
  0x0F, 0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0,
  0x3F, 0xDF, 0xC0, 0x7F, 0xBF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x20, 0x7E,
  0x3F, 0xC1, 0xFE, 0x3F, 0x3F, 0xF1, 0xFF, 0x9F, 0xBF, 0xFD, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xF8, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0x83, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03,
  0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0,
  0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC,
  0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xF0, 0x3F,
  0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFE, 0x07,
  0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x04, 0x07, 0xE3, 0xFC,
  0x3F, 0x3F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xF1, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0x80,
  0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x07,
  0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0x03, 0xF9, 0xFC, 0x1F,
  0xE7, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x04, 0x07, 0xE3, 0xFC, 0x3F, 0x3F, 0xF1, 0xF9, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xF1, 0xFE, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xBF, 0xF9, 0xFC, 0xFF,
  0x8F, 0xE3, 0xF8, 0x7F, 0x06, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x7F, 0x8F, 0xC7, 0xFE, 0x7E, 0x7F, 0xF3, 0xF3, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFD, 0xFE, 0x3F, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFE, 0xFE, 0x3F, 0xE7,
  0xF0, 0xFE, 0x3F, 0x80, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0D, 0xF8, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFE, 0xFF, 0xE5, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x07, 0xFE, 0x07, 0xFF,
  0xE7, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFE, 0x7D, 0xFE, 0x04, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xC3, 0xFF, 0x80, 0x04, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x11, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x0F, 0xF8, 0x01, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFB, 0xFF, 0xDF,
  0xCF, 0xFC, 0xFE, 0x3F, 0xC3, 0xF0, 0x30, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xF8,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x0F, 0xC7, 0xF0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xEF, 0xE0,
  0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x0F, 0xF7, 0xF0, 0x7F, 0xE0, 0xFE, 0x7F, 0x07, 0xFE, 0x0F, 0xE7, 0xF0,
  0x7F, 0xE0, 0xFE, 0x7F, 0x07, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0xE1, 0xFE,
  0x3F, 0x87, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0xF1, 0xFC, 0x3F, 0x8F, 0xFF,
  0x1F, 0xC3, 0xF8, 0xFB, 0xF1, 0xFC, 0x1F, 0xCF, 0x9F, 0x3F, 0x81, 0xFC,
  0xF9, 0xF3, 0xF8, 0x1F, 0xCF, 0x9F, 0x3F, 0x81, 0xFD, 0xF9, 0xF3, 0xF8,
  0x1F, 0xDF, 0x9F, 0xBF, 0x80, 0xFD, 0xF0, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F,
  0xBF, 0x00, 0xFD, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xF8, 0xFE, 0x1F, 0xE1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xFB, 0xF8, 0x07,
  0xF7, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFE, 0x07, 0xF3, 0xFC, 0x1F, 0xE3, 0xFC,
  0x3F, 0x87, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xF7, 0xF8, 0x1F, 0xF0,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xC3, 0xFC,
  0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x27, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x05,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 37, 13, 2, -36 },
  { 43, 19, 13, 24, 2, -36 },
  { 74, 25, 36, 27, 1, -36 },
  { 187, 20, 42, 24, 2, -39 },
  { 292, 39, 37, 41, 1, -37 },
  { 473, 30, 38, 30, 1, -37 },
  { 616, 8, 13, 12, 2, -36 },
  { 629, 14, 45, 16, 2, -37 },
  { 708, 14, 45, 16, 0, -37 },
  { 787, 22, 22, 23, 1, -39 },
  { 848, 21, 24, 25, 2, -30 },
  { 911, 9, 14, 13, 2, -7 },
  { 927, 14, 7, 16, 1, -17 },
  { 940, 9, 9, 13, 2, -8 },
  { 951, 21, 37, 21, 0, -37 },
  { 1049, 21, 38, 24, 2, -37 },
  { 1149, 17, 36, 24, 2, -36 },
  { 1226, 21, 37, 24, 1, -37 },
  { 1324, 20, 38, 24, 2, -37 },
  { 1419, 23, 36, 24, 1, -36 },
  { 1523, 20, 37, 24, 2, -36 },
  { 1616, 21, 38, 24, 2, -37 },
  { 1716, 22, 36, 24, 1, -36 },
  { 1815, 22, 38, 24, 1, -37 },
  { 1920, 22, 38, 24, 1, -37 },
  { 2025, 8, 29, 14, 3, -28 },
  { 2054, 9, 35, 14, 2, -28 },
  { 2094, 22, 25, 25, 1, -31 },
  { 2163, 21, 16, 25, 2, -26 },
  { 2205, 21, 25, 25, 2, -31 },
  { 2271, 19, 38, 20, 0, -37 },
  { 2362, 34, 41, 38, 2, -37 },
  { 2537, 28, 36, 28, 0, -36 },
  { 2663, 23, 36, 28, 3, -36 },
  { 2767, 22, 38, 25, 2, -37 },
  { 2872, 24, 36, 29, 3, -36 },
  { 2980, 17, 36, 22, 3, -36 },
  { 3057, 17, 36, 22, 3, -36 },
  { 3134, 25, 38, 29, 2, -37 },
  { 3253, 24, 36, 31, 3, -36 },
  { 3361, 15, 36, 17, 1, -36 },
  { 3429, 14, 47, 14, -3, -36 },
  { 3512, 25, 36, 27, 3, -36 },
  { 3625, 18, 36, 21, 3, -36 },
  { 3706, 34, 36, 40, 3, -36 },
  { 3859, 26, 36, 33, 3, -36 },
  { 3976, 27, 38, 31, 2, -37 },
  { 4105, 21, 36, 26, 3, -36 },
  { 4200, 27, 46, 31, 2, -37 },
  { 4356, 24, 36, 27, 3, -36 },
  { 4464, 19, 38, 22, 2, -37 },
  { 4555, 21, 36, 23, 1, -36 },
  { 4650, 23, 37, 30, 3, -36 },
  { 4757, 27, 36, 27, 0, -36 },
  { 4879, 40, 36, 40, 0, -36 },
  { 5059, 25, 36, 25, 0, -36 },
  { 5172, 25, 36, 25, 0, -36 },
  { 5285, 21, 36, 22, 1, -36 },
  { 5380, 12, 45, 16, 3, -37 },
  { 5448, 21, 37, 21, 0, -37 },
  { 5546, 12, 45, 16, 1, -37 },
  { 5614, 25, 23, 27, 1, -36 },
  { 5686, 23, 5, 23, 0, 4 },
  { 5701, 12, 8, 17, 2, -39 },
  { 5713, 21, 30, 24, 1, -29 },
  { 5792, 21, 40, 26, 3, -39 },
  { 5897, 18, 30, 21, 2, -29 },
  { 5965, 21, 40, 26, 2, -39 },
  { 6070, 20, 30, 24, 2, -29 },
  { 6145, 17, 39, 16, 0, -39 },
  { 6228, 21, 41, 26, 2, -29 },
  { 6336, 21, 39, 26, 3, -39 },
  { 6439, 8, 39, 13, 2, -39 },
  { 6478, 12, 51, 13, -2, -39 },
  { 6555, 23, 39, 26, 3, -39 },
  { 6668, 7, 39, 13, 3, -39 },
  { 6703, 33, 29, 39, 3, -29 },
  { 6823, 21, 29, 26, 3, -29 },
  { 6900, 22, 30, 26, 2, -29 },
  { 6983, 21, 41, 26, 3, -29 },
  { 7091, 21, 41, 26, 2, -29 },
  { 7199, 15, 29, 18, 3, -29 },
  { 7254, 17, 30, 20, 1, -29 },
  { 7318, 15, 35, 17, 1, -34 },
  { 7384, 21, 29, 26, 3, -28 },
  { 7461, 24, 28, 24, 0, -28 },
  { 7545, 36, 28, 36, 0, -28 },
  { 7671, 23, 28, 23, 0, -28 },
  { 7752, 24, 40, 24, 0, -28 },
  { 7872, 17, 28, 19, 1, -28 },
  { 7932, 16, 45, 18, 1, -37 },
  { 8022, 6, 51, 22, 8, -39 },
  { 8061, 17, 45, 18, 1, -37 },
  { 8157, 22, 9, 25, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD51PT7B_H_
