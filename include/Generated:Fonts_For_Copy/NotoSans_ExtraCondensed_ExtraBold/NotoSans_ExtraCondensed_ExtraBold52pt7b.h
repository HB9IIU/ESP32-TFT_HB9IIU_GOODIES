#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF9, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0xF3, 0xF0, 0x40, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7,
  0xF0, 0xFE, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x07, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC1, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00,
  0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0,
  0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xBF, 0x1F, 0x9C, 0x19, 0xFC, 0xE0, 0x0F, 0xE7, 0x00, 0x7F,
  0x38, 0x01, 0xFD, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x77, 0xF0, 0x03, 0x9F, 0x80, 0x1C, 0xFE,
  0x00, 0xE7, 0xFC, 0x07, 0x3F, 0xF0, 0x39, 0xFB, 0xF1, 0xDF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x3E, 0x00, 0x1F, 0x9F, 0x80,
  0xFC, 0x00, 0x3F, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x3F, 0x07, 0xE0, 0x00,
  0xF8, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x1F, 0x00, 0x07, 0xE1, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0x00,
  0x1F, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x1F, 0x8F, 0x83, 0xE0, 0x7E, 0x3F,
  0x3F, 0x1F, 0xF0, 0xFC, 0xFC, 0x7C, 0x7F, 0xF1, 0xFF, 0xF9, 0xF8, 0xFF,
  0xE1, 0xFF, 0xF3, 0xF3, 0xFF, 0xE3, 0xFF, 0xC7, 0xC7, 0xEF, 0xC3, 0xFF,
  0x1F, 0x9F, 0x8F, 0xC3, 0xFC, 0x3E, 0x3F, 0x1F, 0x80, 0xC0, 0xFC, 0x7E,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0xFC, 0x00,
  0x0F, 0xC3, 0xF1, 0xF8, 0x00, 0x1F, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0x3F, 0x1F, 0x80,
  0x07, 0xE0, 0x7E, 0x3F, 0x00, 0x0F, 0x80, 0x7C, 0x7E, 0x00, 0x3F, 0x00,
  0xFF, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0xC0,
  0x03, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFE, 0x7F, 0x80,
  0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0x87, 0xFF, 0xC1,
  0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0xFC, 0xFF,
  0x1F, 0xE7, 0xFB, 0xFC, 0x7F, 0x1F, 0xFF, 0xE3, 0xFC, 0x3F, 0xFF, 0x8F,
  0xF0, 0x7F, 0xFE, 0x3F, 0xC1, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xC3, 0xFC,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xCF, 0xF8, 0x1F, 0xFC, 0x1F, 0xF0, 0x06, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0x03, 0xF0,
  0x27, 0x8F, 0xC7, 0x9F, 0xBF, 0x7E, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x3F, 0x83, 0xF8, 0xFF,
  0x07, 0xE1, 0xF8, 0x07, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x3F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xF9, 0xFC, 0xFE,
  0x7F, 0x7F, 0x3F, 0x9F, 0xCF, 0xC7, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0xDF, 0xEF,
  0xFF, 0xFB, 0xFD, 0xFE, 0x7E, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF3, 0xF8,
  0x7F, 0xBF, 0xC1, 0xFD, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xE7, 0xF0, 0x7F, 0x3F, 0x87, 0xF9, 0xFE, 0x3F, 0xCF, 0xFB, 0xFC, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F,
  0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xEF, 0xE7, 0xF3, 0xE3, 0xF8, 0xE1, 0xFC,
  0x30, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x87,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xE1, 0xFE, 0x3C, 0x07,
  0xF8, 0xC0, 0x3F, 0xC2, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0x83, 0xFE, 0x30, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xDF, 0x07, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3E,
  0xFE, 0x00, 0xFD, 0xFC, 0x01, 0xF3, 0xF8, 0x07, 0xE7, 0xF0, 0x1F, 0x8F,
  0xE0, 0x3F, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xE0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE8, 0x00, 0xFF, 0x70, 0x0F, 0xFB, 0xF0, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x40, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFE, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x1F, 0xDF, 0xF8, 0xFE, 0xFF, 0xE7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xF8, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFD, 0xFE, 0x1F,
  0xEF, 0xF9, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xE1, 0xFE, 0xFF, 0x07, 0xF7,
  0xF8, 0x3F, 0xBF, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x3F, 0xC7,
  0xF8, 0xFF, 0x7F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xF1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x1F, 0xF3, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x0F, 0xE7, 0xF0,
  0x3F, 0xDF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xDF, 0xC0, 0xFF, 0x7F, 0x03, 0xFD, 0xFE, 0x1F, 0xF7, 0xFC, 0xFF, 0xDF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xF7, 0xF1, 0xFF, 0xDF, 0xC3, 0xFE,
  0x7F, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x08, 0x0F, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x08, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0x7F, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0x7F, 0xBF, 0xDF, 0xEF, 0xE7, 0xF3, 0xF9, 0xFD,
  0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF9, 0xE0, 0xFF, 0x30, 0x1F, 0xE4, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x07, 0xF8, 0x7E, 0x1F, 0x83, 0xFF, 0xC7, 0xE3, 0xE0,
  0xFF, 0xF8, 0xFC, 0xFC, 0x3F, 0xFF, 0x0F, 0x9F, 0x07, 0xF7, 0xE1, 0xF3,
  0xE1, 0xF8, 0x7C, 0x3E, 0xFC, 0x3F, 0x0F, 0x87, 0xFF, 0x8F, 0xC1, 0xF0,
  0xFF, 0xF1, 0xF8, 0x3E, 0x1F, 0xFE, 0x3F, 0x07, 0xC3, 0xFF, 0x87, 0xE1,
  0xF8, 0x7F, 0xF0, 0xFC, 0x3F, 0x0F, 0xFE, 0x1F, 0x87, 0xE1, 0xF7, 0xC3,
  0xF0, 0xFC, 0x3E, 0xF8, 0x7E, 0x1F, 0x87, 0xDF, 0x8F, 0xC3, 0xF0, 0xFB,
  0xF1, 0xF8, 0xFE, 0x3E, 0x7E, 0x1F, 0xFF, 0xEF, 0xCF, 0xC3, 0xFF, 0xBF,
  0xF0, 0xF8, 0x3F, 0xE7, 0xFE, 0x1F, 0x83, 0xFC, 0x7F, 0x83, 0xF0, 0x3E,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x0F, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF,
  0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFF,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF,
  0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00,
  0xFF, 0x9F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0x7F, 0x83, 0xFE,
  0xFF, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xEF,
  0xF0, 0x3F, 0xDF, 0xE0, 0xFF, 0x3F, 0xC7, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xDF, 0xE0, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFE, 0x1E, 0x3F, 0xE0,
  0x18, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x01, 0x8F, 0xFF, 0x3E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFE, 0x0F,
  0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0xDF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD,
  0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F,
  0x9F, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F, 0xE7, 0xF8, 0x7F, 0xE3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xF8, 0x3C, 0x3F,
  0xF0, 0x02, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xF7, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0x3F,
  0xF1, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x08, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE7, 0xF8, 0x3F,
  0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x8F,
  0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3, 0xFC, 0x07, 0xFB,
  0xFE, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x3F, 0xC0, 0xFF, 0x1F, 0xF0,
  0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F,
  0x87, 0xF8, 0x3F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xFC, 0xFF, 0x01,
  0xFE, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xFD,
  0xFC, 0x1F, 0xBF, 0xFF, 0xDF, 0x83, 0xF7, 0xFF, 0xFB, 0xF0, 0x7E, 0xFF,
  0xFF, 0x7E, 0x1F, 0xDF, 0xFF, 0xEF, 0xE3, 0xF3, 0xFF, 0xFC, 0xFC, 0x7E,
  0x7F, 0xFF, 0x9F, 0x8F, 0xCF, 0xFF, 0xF3, 0xF3, 0xF9, 0xFF, 0xFE, 0x7F,
  0x7E, 0x3F, 0xFF, 0xC7, 0xEF, 0xC7, 0xFF, 0xF8, 0xFD, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0x07,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF,
  0x81, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x01, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07,
  0xFF, 0xEF, 0xE0, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xBF, 0xC3, 0xFF, 0xF3,
  0xF8, 0x7F, 0xFF, 0x7F, 0x8F, 0xFF, 0xE7, 0xF1, 0xFF, 0xFC, 0xFE, 0x3F,
  0xFF, 0x9F, 0xE7, 0xFF, 0xF1, 0xFC, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xC3,
  0xFB, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF,
  0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF7,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xC3, 0xFE, 0xFF,
  0x07, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x0F, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0,
  0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF7,
  0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF7, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF,
  0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x3F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFE, 0x7F,
  0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE,
  0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0x01, 0xDF, 0xE0, 0x13, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0x81, 0xFE, 0x7F,
  0xE7, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x01,
  0xFE, 0x7F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xC0, 0x3F,
  0xDF, 0xE0, 0x1F, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F, 0xF0, 0x0F, 0xF3, 0xF8,
  0x07, 0xF8, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xFF,
  0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0xC0, 0xFF,
  0x0F, 0xE0, 0x7F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xF8, 0x3F, 0x83, 0xFC,
  0x3F, 0xFC, 0x1F, 0xC1, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xDF,
  0x0F, 0xF0, 0x3F, 0x87, 0xEF, 0x87, 0xF8, 0x1F, 0xC3, 0xF7, 0xE3, 0xF8,
  0x0F, 0xE3, 0xF3, 0xF1, 0xFC, 0x07, 0xF9, 0xF9, 0xF9, 0xFE, 0x03, 0xFC,
  0xFC, 0xFC, 0xFF, 0x00, 0xFE, 0x7E, 0x7E, 0x7F, 0x80, 0x7F, 0x3F, 0x1F,
  0xBF, 0x80, 0x3F, 0xBF, 0x8F, 0xDF, 0xC0, 0x1F, 0xDF, 0x87, 0xEF, 0xE0,
  0x0F, 0xEF, 0xC3, 0xF7, 0xF0, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x01, 0xFF,
  0xF0, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x9F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC1, 0xFE, 0x07,
  0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF7, 0xF8,
  0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x3F,
  0xCF, 0xE0, 0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xDF,
  0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xCF, 0xC0,
  0x07, 0xF3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xE0, 0x01, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3C, 0x3F, 0xE1, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xF0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xC3,
  0xFB, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFD, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFE, 0x7E, 0x3F, 0xE3, 0xF0, 0xFE, 0x1F, 0x81, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xC0, 0xFE, 0x7F, 0xC3, 0xFB,
  0xFF, 0x8F, 0xEF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0x3F,
  0xEF, 0xF8, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xBF, 0xC0, 0xFE, 0xFF, 0x07, 0xFB, 0xFE, 0x1F, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0x8F, 0xCF, 0xFC, 0x3F, 0x0F,
  0xE0, 0x00, 0x04, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFE, 0x79, 0xFE, 0x02, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x17, 0xFC, 0x1D, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xF8, 0xFF, 0x0F, 0xF3, 0xFC,
  0x7F, 0xEF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF,
  0x7F, 0xF7, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFD, 0xFE, 0x1F, 0xF7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xF7, 0xF1, 0xFF, 0x9F, 0xC1,
  0xFC, 0x3F, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0xCF,
  0xE0, 0xFE, 0xFF, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x09, 0xFE, 0x01, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x08, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x3F, 0xE7, 0xF1,
  0xFF, 0x9F, 0xCF, 0xFF, 0x7F, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFD,
  0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xF7, 0xF8, 0xFF, 0xDF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFE, 0xFF, 0x07,
  0xF3, 0xFC, 0x02, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF9, 0x00, 0x1F, 0xE7, 0x80, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x0F, 0xE7, 0xFC, 0x7F, 0x7F, 0xF3,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x7C, 0xFE, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x03, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0xFF, 0x47, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xE7, 0xFF, 0x3F, 0xF1, 0xFE,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFF,
  0xE0, 0x3F, 0xDF, 0xC0, 0x7F, 0xBF, 0x81, 0xFE, 0x7F, 0x07, 0xF8, 0xFE,
  0x0F, 0xF1, 0xFC, 0x3F, 0xC3, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x0F, 0xE7,
  0xF8, 0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xF7, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xF1,
  0xFC, 0x1F, 0xE3, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0xDF,
  0xC0, 0x7F, 0xBF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x1F, 0xF0, 0xFF, 0x8F, 0xCF, 0xFE, 0x7F, 0xF3, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xC1, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFE, 0x07,
  0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8,
  0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F,
  0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0xF8, 0x1F, 0xE0,
  0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFC,
  0x3F, 0x87, 0xE3, 0xFE, 0x3F, 0x3F, 0xF9, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFC, 0xFF, 0x9F,
  0xE1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF8, 0x7F, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0xFC, 0x3F, 0x03, 0xF1, 0xFF, 0x0F, 0xCF, 0xFE, 0x3F,
  0xBF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFC, 0xFF, 0xBF, 0xC1,
  0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x0F, 0xEF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0x07,
  0xFB, 0xFC, 0x1F, 0xEF, 0xF8, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xEF, 0xFE, 0x3F, 0x9F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8,
  0x10, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x3F,
  0xE7, 0xF1, 0xFF, 0x9F, 0xCF, 0xFF, 0x7F, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFD, 0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xF7, 0xF8, 0xFF, 0xDF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFE,
  0xFF, 0x07, 0xF3, 0xFC, 0x02, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0xFC, 0x1F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xF0, 0x73,
  0xFC, 0x04, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F,
  0xF8, 0x00, 0x20, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE1,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE,
  0x00, 0x60, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFE,
  0xFE, 0x7F, 0xE3, 0xF0, 0xFE, 0x1F, 0x80, 0x80, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFE, 0x7F, 0x81, 0xFE,
  0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xC3, 0xFC,
  0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xE3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xE7, 0xF0,
  0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0xFF, 0x03, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0x7F, 0x03, 0xFE,
  0x07, 0xF7, 0xF0, 0x3F, 0xE0, 0xFF, 0x7F, 0x87, 0xFE, 0x0F, 0xF7, 0xF8,
  0x7F, 0xF0, 0xFE, 0x3F, 0x87, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0xF0, 0xFE,
  0x3F, 0x87, 0xDF, 0x1F, 0xE3, 0xF8, 0xFD, 0xF1, 0xFC, 0x3F, 0xCF, 0xDF,
  0x1F, 0xC1, 0xFC, 0xFD, 0xF9, 0xFC, 0x1F, 0xCF, 0x9F, 0x9F, 0xC1, 0xFC,
  0xF9, 0xF9, 0xFC, 0x1F, 0xCF, 0x8F, 0xBF, 0x81, 0xFD, 0xF8, 0xFB, 0xF8,
  0x0F, 0xDF, 0x8F, 0xBF, 0x80, 0xFF, 0xF8, 0xFB, 0xF8, 0x0F, 0xFF, 0x0F,
  0xBF, 0x80, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xFB, 0xFC, 0x07, 0xF7, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFE, 0xFE, 0x01,
  0xFD, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xE3, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x07, 0xF1, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xEF, 0xF0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFE, 0x7F,
  0x81, 0xFE, 0x3F, 0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F,
  0xC3, 0xFC, 0x1F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xE3, 0xF8, 0x0F,
  0xE3, 0xF8, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x07,
  0xF7, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x23, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x0F,
  0x80, 0x02, 0x7F, 0xE0, 0x0D, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x1F, 0xFE, 0x80, 0x07,
  0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 38, 14, 2, -37 },
  { 44, 20, 13, 24, 2, -37 },
  { 77, 25, 37, 27, 1, -37 },
  { 193, 21, 42, 25, 2, -39 },
  { 304, 39, 38, 42, 1, -38 },
  { 490, 30, 39, 31, 1, -38 },
  { 637, 8, 13, 13, 2, -37 },
  { 650, 14, 46, 17, 2, -38 },
  { 731, 14, 46, 17, 0, -38 },
  { 812, 22, 22, 24, 1, -40 },
  { 873, 21, 25, 25, 2, -31 },
  { 939, 9, 14, 13, 2, -7 },
  { 955, 13, 8, 16, 2, -18 },
  { 968, 9, 9, 14, 2, -8 },
  { 979, 21, 38, 22, 0, -38 },
  { 1079, 21, 39, 25, 2, -38 },
  { 1182, 17, 37, 25, 2, -37 },
  { 1261, 21, 38, 25, 1, -38 },
  { 1361, 21, 39, 25, 2, -38 },
  { 1464, 23, 37, 25, 1, -37 },
  { 1571, 21, 38, 25, 2, -37 },
  { 1671, 21, 39, 25, 2, -38 },
  { 1774, 21, 37, 25, 2, -37 },
  { 1872, 21, 39, 25, 2, -38 },
  { 1975, 22, 39, 25, 1, -38 },
  { 2083, 8, 30, 14, 3, -29 },
  { 2113, 9, 36, 14, 2, -29 },
  { 2154, 22, 25, 25, 1, -31 },
  { 2223, 21, 17, 25, 2, -27 },
  { 2268, 22, 25, 25, 2, -31 },
  { 2337, 19, 39, 20, 0, -38 },
  { 2430, 35, 42, 39, 2, -38 },
  { 2614, 29, 37, 29, 0, -37 },
  { 2749, 23, 37, 28, 3, -37 },
  { 2856, 22, 39, 26, 2, -38 },
  { 2964, 25, 37, 30, 3, -37 },
  { 3080, 17, 37, 23, 3, -37 },
  { 3159, 17, 37, 23, 3, -37 },
  { 3238, 25, 39, 30, 2, -38 },
  { 3360, 25, 37, 31, 3, -37 },
  { 3476, 15, 37, 17, 1, -37 },
  { 3546, 14, 48, 15, -3, -37 },
  { 3630, 25, 37, 28, 3, -37 },
  { 3746, 18, 37, 22, 3, -37 },
  { 3830, 35, 37, 41, 3, -37 },
  { 3992, 27, 37, 33, 3, -37 },
  { 4117, 27, 39, 32, 2, -38 },
  { 4249, 22, 37, 26, 3, -37 },
  { 4351, 27, 47, 32, 2, -38 },
  { 4510, 25, 37, 27, 3, -37 },
  { 4626, 19, 39, 23, 2, -38 },
  { 4719, 21, 37, 23, 1, -37 },
  { 4817, 24, 38, 30, 3, -37 },
  { 4931, 28, 37, 28, 0, -37 },
  { 5061, 41, 37, 40, 0, -37 },
  { 5251, 26, 37, 26, 0, -37 },
  { 5372, 26, 37, 26, 0, -37 },
  { 5493, 21, 37, 23, 1, -37 },
  { 5591, 12, 46, 16, 3, -38 },
  { 5660, 21, 38, 22, 0, -38 },
  { 5760, 12, 46, 16, 1, -38 },
  { 5829, 26, 23, 28, 1, -37 },
  { 5904, 24, 5, 23, 0, 4 },
  { 5919, 13, 8, 17, 2, -40 },
  { 5932, 21, 30, 25, 1, -29 },
  { 6011, 22, 41, 27, 3, -40 },
  { 6124, 18, 30, 22, 2, -29 },
  { 6192, 22, 41, 27, 2, -40 },
  { 6305, 21, 30, 24, 2, -29 },
  { 6384, 18, 40, 16, 0, -40 },
  { 6474, 22, 41, 27, 2, -29 },
  { 6587, 21, 40, 27, 3, -40 },
  { 6692, 8, 40, 13, 3, -40 },
  { 6732, 13, 52, 13, -2, -40 },
  { 6817, 23, 40, 26, 3, -40 },
  { 6932, 7, 40, 13, 3, -40 },
  { 6967, 34, 29, 40, 3, -29 },
  { 7091, 21, 29, 27, 3, -29 },
  { 7168, 22, 30, 26, 2, -29 },
  { 7251, 22, 41, 27, 3, -29 },
  { 7364, 22, 41, 27, 2, -29 },
  { 7477, 15, 29, 19, 3, -29 },
  { 7532, 18, 30, 20, 1, -29 },
  { 7600, 16, 35, 18, 1, -34 },
  { 7670, 21, 30, 27, 3, -29 },
  { 7749, 24, 29, 24, 0, -29 },
  { 7836, 36, 29, 37, 0, -29 },
  { 7967, 23, 29, 23, 0, -29 },
  { 8051, 24, 41, 24, 0, -29 },
  { 8174, 18, 29, 20, 1, -29 },
  { 8240, 16, 45, 19, 1, -37 },
  { 8330, 6, 52, 22, 8, -40 },
  { 8369, 16, 45, 19, 2, -37 },
  { 8459, 23, 9, 25, 1, -23 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD52PT7B_H_
