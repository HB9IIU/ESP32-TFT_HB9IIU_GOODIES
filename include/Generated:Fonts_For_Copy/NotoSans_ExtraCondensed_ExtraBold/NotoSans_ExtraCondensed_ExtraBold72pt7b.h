#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3F, 0xE3, 0xFF, 0x1F, 0xFC, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x0F, 0xF8,
  0x0E, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xC1, 0xFF, 0xDF, 0xF8,
  0x3F, 0xFB, 0xFF, 0x07, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xF9,
  0xFF, 0x81, 0xFF, 0x3F, 0xF0, 0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x80,
  0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0xC0, 0x7F, 0xCF,
  0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC,
  0x7F, 0xEF, 0x8F, 0xCF, 0xFC, 0xF8, 0x18, 0xFF, 0xCF, 0x80, 0x8F, 0xF8,
  0xF8, 0x00, 0xFF, 0x8F, 0x80, 0x0F, 0xFC, 0xF8, 0x00, 0xFF, 0xCF, 0x80,
  0x07, 0xFE, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFB, 0xFF, 0x00, 0x0F, 0x9F, 0xF0, 0x00, 0xF9, 0xFF,
  0x00, 0x0F, 0x9F, 0xF8, 0x00, 0xF9, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0x00,
  0xF9, 0xFF, 0xFC, 0x0F, 0xBF, 0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xF0,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x78, 0x03,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xFC, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F,
  0xF8, 0x1F, 0xE3, 0xFE, 0x3F, 0xC3, 0xFF, 0xF0, 0x7F, 0xCF, 0xF0, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x1F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC3, 0xFC, 0x7F, 0xC7, 0xF8, 0x3F, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F,
  0xE0, 0x7F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F,
  0xC3, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFE, 0x7F, 0xF0, 0xFF, 0xE7, 0xFF, 0xBF, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF,
  0xF7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x18, 0x07, 0xF0, 0x0C, 0x3E, 0x0F, 0xE0, 0xF8, 0x7F, 0x1F, 0xC7, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF,
  0xBF, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x08, 0x02, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0xFE, 0x3F,
  0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F,
  0xE3, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0x03,
  0xFF, 0x9F, 0xFC, 0x07, 0xFE, 0x7F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F,
  0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xFD,
  0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x01,
  0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0x7F,
  0xF7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xF0, 0x1F, 0xF9,
  0xFF, 0xC0, 0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF,
  0x3F, 0xE7, 0xFF, 0x1F, 0xC7, 0xFF, 0x0F, 0x87, 0xFF, 0x07, 0x07, 0xFF,
  0x02, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0x1F, 0xFF, 0x8F, 0xE0, 0x3F,
  0xFC, 0x3E, 0x00, 0xFF, 0xE0, 0xE0, 0x07, 0xFF, 0x06, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0x87, 0x80, 0x1F, 0xFC, 0x18, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0xE0, 0x00,
  0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0x7F, 0xE0, 0x01, 0xFE, 0x7F, 0xE0, 0x01,
  0xFE, 0x7F, 0xE0, 0x03, 0xFC, 0x7F, 0xE0, 0x03, 0xFC, 0x7F, 0xE0, 0x07,
  0xF8, 0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0x7F,
  0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0xE0, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x40, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x0F, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x7F, 0xC7, 0xFF, 0x81, 0xFF, 0x3F, 0xFF, 0x07, 0xFD, 0xFF, 0xFE, 0x3F,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0x1F, 0xFE, 0xFF, 0xF8, 0x3F, 0xFB, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xDF,
  0xFC, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0xFF, 0xE3, 0xFF,
  0x83, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE,
  0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x07,
  0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x01, 0xFF,
  0x8F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0xCF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0xFC, 0x0F,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFB,
  0xFF, 0x80, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xBF, 0xF8, 0x07, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xBF, 0xF1, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xF3, 0xFE, 0x07,
  0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x06, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x87, 0xFC, 0xFF, 0xEF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x7F, 0xC3, 0xF8,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x03, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x0F, 0x00, 0x07, 0xE0, 0x7F, 0xC1,
  0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xC7, 0xF8, 0x7F, 0xF8, 0x78, 0x07, 0xFF, 0x0C, 0x00, 0x7F, 0xF1,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0x83, 0xFC,
  0x3F, 0xC0, 0x3F, 0xFF, 0xE1, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xE1, 0xFE,
  0x3F, 0x80, 0xFF, 0xFF, 0xE1, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0xFE,
  0x7F, 0x83, 0xFF, 0xBF, 0xE0, 0xFE, 0x7F, 0x03, 0xFE, 0x1F, 0xE0, 0xFE,
  0x7F, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE,
  0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFC, 0xFF, 0x07, 0xF8, 0x7F, 0xE3, 0xFC,
  0xFF, 0x07, 0xFF, 0xFF, 0xF7, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0x03, 0xFF, 0xFB, 0xFF, 0xF0, 0x7F, 0x81, 0xFF, 0xF3, 0xFF, 0xE0,
  0x7F, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x04, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xE0, 0x3F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF,
  0xE0, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0x87, 0xF0, 0x7F, 0xFC, 0x01, 0xC0, 0xFF, 0xF0,
  0x00, 0x83, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x08, 0x7F, 0xFE, 0x00, 0x30, 0x7F, 0xFE,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFE, 0x03, 0xFF, 0xF3, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFF,
  0xBF, 0xF8, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x0F,
  0xFE, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80,
  0x1F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xCF, 0xFE,
  0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x00, 0x3C,
  0x0F, 0xFF, 0x80, 0x01, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0x7F, 0xF7, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xE3,
  0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x83, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x3F, 0xFC,
  0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0x8F, 0xFC, 0x03, 0xFF,
  0xC3, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF,
  0x1F, 0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0xC0, 0x0F,
  0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xDF, 0xFC, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFE, 0x00, 0xFF,
  0xE3, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x03,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x00,
  0x7F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xBF,
  0xE0, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xC0, 0x3F, 0xEF, 0xFF, 0xFF, 0x7F,
  0x80, 0x7F, 0xDF, 0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0x01, 0xFE, 0x7F, 0xFF, 0xFB, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xF3, 0xFC,
  0x0F, 0xF9, 0xFF, 0xFF, 0xE7, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF, 0xCF, 0xF8,
  0x3F, 0xC7, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xE1,
  0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xC7,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F,
  0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0x7F, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0xFF,
  0xEF, 0xFC, 0x0F, 0xFF, 0xFF, 0x3F, 0xF0, 0x7F, 0xFF, 0xF9, 0xFF, 0x83,
  0xFF, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xF9,
  0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC7, 0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F,
  0xF9, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xFF, 0x07, 0xFF, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFB, 0xFF, 0xFF, 0xC0, 0xFF, 0xDF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x7F, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFE, 0x7F,
  0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x07,
  0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF,
  0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x83, 0xFF, 0xEF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0xF8,
  0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xE0,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x7F, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFE, 0x7F,
  0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x07,
  0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x8F,
  0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x7F,
  0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFE, 0x3F,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0,
  0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFE,
  0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFE, 0x3F,
  0xF8, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x1F, 0xFC,
  0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xE0, 0x7E, 0x3F, 0xF8, 0x01, 0xC7, 0xFF, 0x00, 0x08, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x1F,
  0xFD, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF8, 0x07,
  0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x01,
  0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x0F,
  0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF,
  0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x7F, 0xC0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF1, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC1, 0xFE, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0xFF, 0x7F, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0x9F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xCF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFC,
  0x1F, 0xE7, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F, 0xF8,
  0x01, 0xFF, 0x8F, 0xF9, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0xFF,
  0x8F, 0xFC, 0x00, 0x7F, 0xE3, 0xFC, 0x7F, 0xCF, 0xFE, 0x00, 0x3F, 0xF1,
  0xFE, 0x1F, 0xE7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x0F, 0xF3, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x87, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC3, 0xFC,
  0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE1, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xDF,
  0xE0, 0x7F, 0xBF, 0xF0, 0x00, 0x7F, 0xEF, 0xF0, 0x3F, 0xDF, 0xF8, 0x00,
  0x1F, 0xF7, 0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC3, 0xFF,
  0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F,
  0xF1, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xBF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x03,
  0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xE7, 0xFF,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF,
  0xF7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x00,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0xFF, 0xF0, 0x38, 0x03,
  0xFF, 0x80, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xF3,
  0xFF, 0xFC, 0xFF, 0x8F, 0xFF, 0xC7, 0xFC, 0x7F, 0xFC, 0x1F, 0xE0, 0xFF,
  0xC0, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x3F,
  0xFE, 0x0F, 0xFC, 0xFF, 0xFC, 0x3F, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xF8, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF, 0xC0, 0xFF, 0xEF, 0xFF,
  0x87, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF7, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF,
  0xC3, 0xFE, 0x1F, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0x01, 0xC3, 0xFF, 0x80, 0x10,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x23, 0xFF, 0xC0, 0x38, 0xFF, 0xF8, 0x3E, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x7F, 0x83, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0x8F, 0xFC,
  0x1F, 0xFF, 0x9F, 0xF8, 0x7F, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xF8, 0x3F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF,
  0x80, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xDF, 0xF8,
  0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x07,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0xC0, 0x3F,
  0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x01, 0xFF, 0xE7, 0xFF, 0x03, 0xFF,
  0xCF, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xBF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xE0, 0x7F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE,
  0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xE7, 0xFE, 0x00, 0xFF, 0x9F,
  0xF8, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x43, 0xFF, 0x80, 0x03, 0x0F,
  0xFF, 0x00, 0x7C, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFC, 0x10, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x87, 0xFC,
  0x1F, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0x7F, 0xE3,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0xFD, 0xFF, 0xE0, 0x7F, 0xFB, 0xFF,
  0x80, 0xFF, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xDF, 0xF8,
  0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x07,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFD, 0xFF, 0x80, 0x3F,
  0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF, 0xFE, 0x03, 0xFF,
  0xCF, 0xFE, 0x07, 0xFF, 0x9F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xBF, 0xF0,
  0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0x80,
  0xFF, 0xC3, 0xFF, 0x00, 0x3C, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC4, 0x00,
  0x01, 0xFF, 0x8E, 0x00, 0x07, 0xFF, 0x1F, 0x00, 0x3F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0xC7, 0xFF, 0x87, 0xFE,
  0x7F, 0xFE, 0x3F, 0xF7, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0x8F, 0xFB, 0xFF, 0x7F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF0, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0,
  0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFB,
  0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0,
  0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x01, 0xFE, 0x00, 0x7F,
  0x81, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC3, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x3F, 0xFC, 0x3F, 0xE3, 0xFF,
  0xF1, 0xFF, 0x3F, 0xFF, 0xCF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F,
  0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xFF, 0xF8, 0x3F, 0xE3,
  0xFF, 0xF0, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0xFF,
  0xEF, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xBF, 0xFF, 0x3F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF7,
  0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xE3, 0xFF, 0x3F, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF8, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC0, 0x78, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x03,
  0xFE, 0x03, 0xFF, 0x87, 0xFC, 0x0F, 0xFF, 0x8F, 0xF8, 0x3F, 0xFF, 0x3F,
  0xF0, 0xFF, 0xFF, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x7F, 0xFD,
  0xFF, 0xE0, 0x7F, 0xFB, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0x00, 0xFF, 0xEF,
  0xFE, 0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x7F,
  0xE0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0,
  0x1F, 0xFD, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00,
  0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xCF, 0xFE, 0x0F, 0xFF, 0x9F, 0xFE, 0x3F,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0x7F, 0xE0, 0xFF, 0xFC, 0xFF,
  0xC0, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0x38, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xE0, 0xF8, 0xFF, 0xC0, 0x38, 0xFF, 0xC0, 0x08, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x43, 0xFF, 0xCF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xDF, 0xF3, 0xFF, 0xFC, 0xFF, 0x8F, 0xFF, 0xE7, 0xFC, 0x3F,
  0xFE, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE,
  0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF8, 0xFF,
  0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0xFF,
  0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F,
  0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFB, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFE, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x7F, 0xBF, 0x83, 0xFF, 0x07, 0xFE, 0x1F, 0xEF, 0xF0, 0xFF, 0xC1, 0xFF,
  0x87, 0xF3, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFC, 0xFF, 0x1F, 0xF8, 0x0F,
  0xFC, 0x7F, 0x1F, 0xC7, 0xFE, 0x03, 0xFF, 0x3F, 0xC7, 0xF1, 0xFF, 0x80,
  0xFF, 0xCF, 0xF1, 0xFC, 0x7F, 0xE0, 0x3F, 0xF3, 0xFC, 0x7F, 0x9F, 0xF0,
  0x07, 0xFC, 0xFE, 0x1F, 0xEF, 0xFC, 0x01, 0xFF, 0x3F, 0x87, 0xFB, 0xFF,
  0x00, 0x7F, 0xCF, 0xE0, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xF8, 0x3F, 0xBF,
  0xE0, 0x03, 0xFF, 0xFE, 0x0F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x83, 0xFB,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x3F,
  0xBF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x7F, 0xF0, 0x0F,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F,
  0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F,
  0xFE, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0xE0,
  0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFC,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x1F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x02, 0x3F, 0xF8, 0x00, 0x04, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFB, 0x80, 0x0F, 0xFF, 0xE4, 0x00, 0x07,
  0xFF, 0x88, 0x00, 0x01, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 52, 19, 3, -51 },
  { 86, 27, 18, 33, 3, -51 },
  { 147, 35, 51, 38, 2, -51 },
  { 371, 28, 59, 34, 3, -55 },
  { 578, 54, 53, 58, 2, -52 },
  { 936, 41, 53, 43, 2, -52 },
  { 1208, 11, 18, 18, 3, -51 },
  { 1233, 19, 63, 23, 3, -52 },
  { 1383, 19, 63, 23, 1, -52 },
  { 1533, 31, 31, 33, 1, -55 },
  { 1654, 30, 35, 35, 2, -43 },
  { 1786, 14, 19, 19, 2, -9 },
  { 1820, 19, 10, 23, 2, -24 },
  { 1844, 12, 13, 19, 3, -12 },
  { 1864, 29, 53, 30, 0, -52 },
  { 2057, 30, 53, 34, 2, -52 },
  { 2256, 24, 51, 34, 3, -51 },
  { 2409, 29, 52, 34, 2, -52 },
  { 2598, 29, 53, 34, 2, -52 },
  { 2791, 32, 51, 34, 1, -51 },
  { 2995, 28, 52, 34, 3, -51 },
  { 3177, 30, 53, 34, 2, -52 },
  { 3376, 30, 51, 34, 2, -51 },
  { 3568, 30, 53, 34, 2, -52 },
  { 3767, 30, 53, 34, 2, -52 },
  { 3966, 12, 41, 19, 4, -40 },
  { 4028, 14, 50, 19, 2, -40 },
  { 4116, 30, 35, 35, 2, -43 },
  { 4248, 30, 23, 35, 2, -37 },
  { 4335, 31, 35, 35, 2, -43 },
  { 4471, 27, 53, 28, 0, -52 },
  { 4650, 48, 58, 54, 3, -52 },
  { 4998, 39, 51, 39, 0, -51 },
  { 5247, 32, 51, 39, 4, -51 },
  { 5451, 31, 53, 36, 3, -52 },
  { 5657, 34, 51, 41, 4, -51 },
  { 5874, 23, 51, 32, 5, -51 },
  { 6021, 23, 51, 31, 5, -51 },
  { 6168, 35, 53, 42, 3, -52 },
  { 6400, 33, 51, 43, 5, -51 },
  { 6611, 20, 51, 24, 2, -51 },
  { 6739, 20, 67, 20, -4, -51 },
  { 6907, 34, 51, 38, 5, -51 },
  { 7124, 25, 51, 30, 4, -51 },
  { 7284, 47, 51, 57, 5, -51 },
  { 7584, 37, 51, 46, 5, -51 },
  { 7820, 38, 53, 44, 3, -52 },
  { 8072, 30, 51, 36, 4, -51 },
  { 8264, 38, 64, 44, 3, -52 },
  { 8568, 34, 51, 38, 4, -51 },
  { 8785, 27, 53, 31, 2, -52 },
  { 8964, 30, 51, 32, 1, -51 },
  { 9156, 33, 52, 42, 4, -51 },
  { 9371, 38, 51, 38, 0, -51 },
  { 9614, 57, 51, 56, -1, -51 },
  { 9978, 36, 51, 36, 0, -51 },
  { 10208, 36, 51, 36, 0, -51 },
  { 10438, 29, 51, 32, 1, -51 },
  { 10623, 17, 64, 22, 4, -52 },
  { 10759, 29, 53, 30, 0, -52 },
  { 10952, 17, 64, 22, 2, -52 },
  { 11088, 36, 32, 39, 1, -51 },
  { 11232, 33, 6, 32, 0, 6 },
  { 11257, 17, 11, 23, 3, -55 },
  { 11281, 29, 41, 34, 2, -40 },
  { 11430, 30, 56, 37, 4, -55 },
  { 11640, 26, 41, 30, 2, -40 },
  { 11774, 31, 56, 37, 2, -55 },
  { 11991, 30, 41, 34, 2, -40 },
  { 12145, 23, 55, 22, 1, -55 },
  { 12304, 31, 57, 37, 2, -40 },
  { 12525, 29, 55, 37, 4, -55 },
  { 12725, 11, 55, 18, 4, -55 },
  { 12801, 17, 72, 18, -2, -55 },
  { 12954, 32, 55, 36, 4, -55 },
  { 13174, 10, 55, 18, 4, -55 },
  { 13243, 47, 40, 55, 4, -40 },
  { 13478, 29, 40, 37, 4, -40 },
  { 13623, 32, 41, 36, 2, -40 },
  { 13787, 30, 57, 37, 4, -40 },
  { 14001, 31, 57, 37, 2, -40 },
  { 14222, 21, 40, 26, 4, -40 },
  { 14327, 24, 41, 28, 2, -40 },
  { 14450, 22, 49, 25, 1, -48 },
  { 14585, 29, 41, 37, 4, -40 },
  { 14734, 33, 40, 34, 0, -40 },
  { 14899, 50, 40, 51, 0, -40 },
  { 15149, 32, 40, 32, 0, -40 },
  { 15309, 33, 57, 34, 0, -40 },
  { 15545, 25, 40, 27, 1, -40 },
  { 15670, 23, 64, 26, 1, -52 },
  { 15854, 9, 72, 31, 11, -55 },
  { 15935, 23, 64, 26, 2, -52 },
  { 16119, 31, 13, 35, 2, -32 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD72PT7B_H_
