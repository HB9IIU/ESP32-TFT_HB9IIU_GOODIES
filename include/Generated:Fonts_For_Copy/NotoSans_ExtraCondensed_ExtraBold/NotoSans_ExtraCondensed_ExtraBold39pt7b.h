#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xDF, 0x7D, 0xF7, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xF0, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x03,
  0xE7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE1, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3F, 0x01, 0xFF, 0xCF, 0xFF, 0xDF, 0xFF,
  0x7F, 0xFE, 0xFB, 0x89, 0xF7, 0x03, 0xEE, 0x07, 0xDC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3B, 0xE0, 0x77, 0xE0, 0xEF, 0xF1, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xE1, 0xFF, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1F,
  0x80, 0x3C, 0x01, 0xFE, 0x03, 0xE0, 0x1F, 0xF0, 0x1E, 0x00, 0xFF, 0xC0,
  0xF0, 0x0F, 0x9E, 0x0F, 0x80, 0x7C, 0xF0, 0x78, 0x03, 0xE7, 0xC7, 0xC0,
  0x1E, 0x3E, 0x3C, 0x00, 0xF1, 0xF1, 0xE0, 0x07, 0x8F, 0x9F, 0x00, 0x3C,
  0x7C, 0xF0, 0x01, 0xF3, 0xC7, 0x8F, 0x87, 0x9E, 0x78, 0xFE, 0x3F, 0xF3,
  0xCF, 0xF9, 0xFF, 0x3E, 0xFF, 0xC7, 0xF9, 0xE7, 0x9F, 0x1F, 0x8F, 0x3C,
  0x78, 0x00, 0xF1, 0xE3, 0xC0, 0x07, 0x8F, 0x1E, 0x00, 0x7C, 0x78, 0xF0,
  0x03, 0xC3, 0xC7, 0x80, 0x1E, 0x1E, 0x3C, 0x01, 0xE0, 0xF1, 0xE0, 0x0F,
  0x07, 0x9F, 0x00, 0xF8, 0x3F, 0xF0, 0x07, 0x80, 0xFF, 0x80, 0x3C, 0x03,
  0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x04, 0x7F, 0x87, 0xE3, 0xFF, 0x1F, 0x9F, 0xFE,
  0x7E, 0x7F, 0xFD, 0xFB, 0xF3, 0xFF, 0xCF, 0xC7, 0xFF, 0x3F, 0x1F, 0xFC,
  0xFC, 0x3F, 0xE3, 0xF0, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0,
  0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x43, 0xC2, 0xFB, 0xDE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7E, 0x7E, 0x3C, 0x7C, 0x1C, 0x38, 0x04, 0x20, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x7D, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x79, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFD, 0xF0,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0x7E, 0x7E, 0x7E, 0x3E, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7E, 0x3F, 0x7E, 0x7E, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF,
  0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0xFD, 0xFB, 0xCF, 0xCC, 0x7E, 0x23, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE,
  0x78, 0x7E, 0x30, 0x7E, 0x20, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0,
  0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x30, 0x7E, 0x20, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0xFC, 0x1F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x07, 0xBE, 0x07, 0xDF, 0x03, 0xCF, 0x83, 0xE7, 0xC1, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0xCF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0x9F, 0xFF, 0xBF, 0xFF, 0x10, 0xFF,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xF0,
  0x3F, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE, 0x00, 0x01,
  0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x80, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7D, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7F, 0xFF, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F,
  0x7E, 0x7E, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x3F, 0x7E, 0x7E, 0x3F,
  0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFE, 0x3F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0x7F, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x9F, 0x02,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x77, 0xFC, 0x7F,
  0xF8, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC0, 0x38, 0xFB, 0xF7, 0xFF, 0xDF,
  0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFB, 0xF7,
  0xFF, 0xCF, 0x80, 0x1C, 0x3E, 0x7E, 0x7F, 0x7E, 0x7E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0xE1, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0,
  0x00, 0x60, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x7F,
  0xFD, 0xC3, 0xF2, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x7E, 0x3C, 0x3C, 0x3F, 0xF3, 0xCF,
  0x8F, 0xFE, 0x79, 0xE3, 0xF7, 0x8F, 0x3C, 0x78, 0xF1, 0xE7, 0x8F, 0x1E,
  0x3C, 0xF3, 0xE3, 0xC3, 0xFE, 0x7C, 0x78, 0xFF, 0xCF, 0x0F, 0x1E, 0xF9,
  0xE1, 0xE3, 0xDF, 0x3C, 0x3C, 0x79, 0xE7, 0xC7, 0x8F, 0x3C, 0x79, 0xF3,
  0xE7, 0x8F, 0xFF, 0xF8, 0xF0, 0xFE, 0xFE, 0x1F, 0x1F, 0x8F, 0x81, 0xE0,
  0x40, 0x40, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x20,
  0x07, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xFC,
  0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0xF8, 0x1F, 0x87, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F,
  0xBF, 0x07, 0xEF, 0xC3, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x3F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0x7F, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x7F, 0x06, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x02, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFE, 0x07, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xF8, 0xFF, 0x3F, 0x07, 0xF7, 0xE0, 0xFE, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x3F,
  0x7E, 0x07, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0x3F, 0x1F, 0xE7, 0xFF, 0xF8,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xFF,
  0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xE0, 0x67,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xF7,
  0xF0, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F,
  0xFC, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1,
  0xFC, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xF3, 0xF8, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x83, 0xFB, 0xE0,
  0xFC, 0xF8, 0x7F, 0x3E, 0x1F, 0x8F, 0x8F, 0xE3, 0xE3, 0xF0, 0xF9, 0xFC,
  0x3E, 0xFE, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0xC3, 0xE3,
  0xF0, 0xF8, 0xFE, 0x3E, 0x1F, 0x8F, 0x87, 0xF3, 0xE0, 0xFC, 0xF8, 0x3F,
  0xBE, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0x7F, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xF7, 0xFF, 0xF0, 0xFB, 0xFF, 0x7C, 0x7D, 0xFF, 0xBE, 0x3E,
  0xFF, 0xDF, 0x1E, 0x7F, 0xEF, 0x9F, 0x3F, 0xF3, 0xEF, 0x9F, 0xF9, 0xF7,
  0x8F, 0xFC, 0xFB, 0xC7, 0xFE, 0x3F, 0xE3, 0xFF, 0x1F, 0xF1, 0xFF, 0x8F,
  0xF0, 0xFF, 0xC7, 0xF8, 0x7F, 0xE1, 0xFC, 0x3F, 0xF0, 0xFE, 0x1F, 0xF8,
  0x7E, 0x0F, 0xFC, 0x3F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xF0,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xFF, 0xBE, 0x3F, 0xFB, 0xF3, 0xFF, 0x9F, 0x3F, 0xF9,
  0xFB, 0xFF, 0x9F, 0xBF, 0xF8, 0xFB, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0,
  0xFE, 0x7E, 0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFE, 0x07, 0xE7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE3, 0xFB, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7,
  0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7E,
  0x0F, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xE7, 0xE0, 0x7E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xF8, 0xFE, 0x3F, 0x0F, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3,
  0xF0, 0xFE, 0x7E, 0x1F, 0x8F, 0xCF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xFC, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7F, 0x7E, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF,
  0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xC7, 0xBF, 0x01, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF8, 0x0F,
  0xFC, 0x3F, 0xFF, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xFD,
  0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xF0, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x3F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F, 0x80, 0x7E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0xFC, 0x07, 0xC0, 0xFF, 0xF8, 0x1F, 0x81, 0xFB, 0xF0, 0x3F, 0x03,
  0xF7, 0xE0, 0x7E, 0x07, 0xE7, 0xC0, 0xFC, 0x0F, 0xCF, 0x81, 0xFC, 0x1F,
  0x1F, 0x87, 0xF8, 0x7E, 0x3F, 0x0F, 0xF0, 0xFC, 0x7E, 0x1F, 0xE1, 0xF8,
  0x7C, 0x3F, 0xC3, 0xF0, 0xF8, 0x7F, 0xC7, 0xE1, 0xF1, 0xFF, 0x8F, 0x83,
  0xF3, 0xEF, 0x3F, 0x07, 0xE7, 0xDE, 0x7E, 0x07, 0xCF, 0x3C, 0xFC, 0x0F,
  0x9E, 0x79, 0xF8, 0x1F, 0x7C, 0xFB, 0xE0, 0x3E, 0xF9, 0xF7, 0xC0, 0x7F,
  0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF,
  0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0xFE, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8, 0x7F, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x3E, 0x7E, 0x07, 0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x01, 0xFB, 0xF0, 0x3F, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0xFE, 0x03, 0xF0, 0xFC, 0x07, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x07, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x0F,
  0xC7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x01, 0xF7, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x01, 0xF3, 0xE0,
  0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x03, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x18, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFF, 0xFF,
  0x7F, 0xDF, 0x7F, 0x9F, 0x3F, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x70, 0x7E, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xF7, 0xF1, 0xFB,
  0xF0, 0xFD, 0xF8, 0x3E, 0xFC, 0x1F, 0x7E, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7D, 0xF8, 0x7E, 0xFE, 0x3F, 0x7F,
  0xBF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xBF, 0xC7, 0xCF, 0xC0, 0x03, 0xE0,
  0x3F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xF9, 0xFC, 0x67, 0xE0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x05, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F,
  0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0x1F, 0x8F, 0xEF, 0xCF, 0xFF,
  0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF1, 0xFD, 0xF8, 0x7E, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x3F, 0xBF, 0xBF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF1, 0xFE, 0xF8, 0x7E, 0x7C, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFE, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x02, 0x7F, 0x0E, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07,
  0xFC, 0x03, 0xE0, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x03, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0x80, 0x0F, 0xE7, 0xCF, 0xFB, 0xE7, 0xFF, 0xF7, 0xFF,
  0xFB, 0xF1, 0xFD, 0xF8, 0x7E, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xF8, 0x3F,
  0x7E, 0x3F, 0xBF, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFD, 0xF8, 0x7C,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x30, 0x1F, 0x9F, 0xFF, 0xCF,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0x7F, 0xC0, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0xF0, 0xFD, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xFF, 0xEF,
  0xF7, 0xF3, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x07, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xCF,
  0xC3, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xEF, 0xC3, 0xF1, 0xF0, 0xFC, 0x7E, 0x3F,
  0x0F, 0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x3C, 0x3E, 0x7F, 0x1F, 0xCF, 0xBF, 0xEF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xE7, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F,
  0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC,
  0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0,
  0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF,
  0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x0F, 0xC3, 0xF0, 0x00, 0xF0,
  0xF9, 0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xF1, 0xF9, 0xF8, 0x7E, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD,
  0xF0, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0x3F, 0xBF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0xF0, 0x7C, 0xFE, 0x3E, 0xFF, 0x9F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8, 0x3E, 0xFC, 0x1F,
  0x7E, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7D, 0xF8, 0x7E, 0xFE, 0x3F, 0x7F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF,
  0xDF, 0xC7, 0xE7, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07,
  0x80, 0x0F, 0xE7, 0xCF, 0xFB, 0xE7, 0xFF, 0xF7, 0xFF, 0xFB, 0xF1, 0xFD,
  0xF8, 0x7E, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x3F, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFD, 0xF8, 0x7C, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x9F, 0xFB, 0xFF, 0xBE, 0xFF,
  0xEF, 0xFE, 0xFF, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x0F, 0x81, 0xFF, 0x9F, 0xFE, 0xFF, 0xEF, 0xFF, 0x7E, 0x1B,
  0xF0, 0x1F, 0x80, 0xFF, 0x03, 0xFC, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x03,
  0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFE,
  0x3F, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xFB,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F,
  0xDF, 0x1F, 0x9F, 0xFC, 0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xF9, 0xF8, 0x7E,
  0x7E, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0xFC, 0x1F, 0x3F, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x83, 0xEF, 0x87, 0xF0, 0xFD, 0xF0, 0xFF,
  0x1F, 0xBF, 0x1F, 0xE3, 0xE7, 0xE3, 0xFC, 0x7C, 0xFC, 0xFF, 0x8F, 0x8F,
  0x9E, 0xF3, 0xF1, 0xF3, 0xDE, 0x7E, 0x3E, 0x7B, 0xEF, 0x87, 0xEF, 0x3D,
  0xF0, 0x7D, 0xE7, 0xBE, 0x0F, 0xFC, 0xF7, 0xC1, 0xFF, 0x1F, 0xF8, 0x3F,
  0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E,
  0x0F, 0xE0, 0xFE, 0x1F, 0xBF, 0x1F, 0x8F, 0xCF, 0xC7, 0xE7, 0xC1, 0xF7,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x3E, 0xFC,
  0x3F, 0x7E, 0x1F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC3, 0xFF, 0xC1, 0xF8, 0xFC,
  0x0F, 0xDF, 0x03, 0xF7, 0xE0, 0xF9, 0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x87,
  0xC3, 0xF1, 0xF0, 0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xFB, 0xE0,
  0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F,
  0xE0, 0xFF, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x0F, 0xF1, 0xFF, 0x1F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x07, 0xFA, 0x00, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 14, 10, 18, 2, -28 },
  { 40, 19, 28, 20, 1, -28 },
  { 107, 15, 32, 19, 2, -30 },
  { 167, 29, 28, 31, 1, -28 },
  { 269, 22, 28, 23, 1, -28 },
  { 346, 6, 10, 9, 2, -28 },
  { 354, 10, 34, 12, 2, -28 },
  { 397, 11, 34, 12, 0, -28 },
  { 444, 16, 17, 18, 1, -30 },
  { 478, 17, 19, 19, 1, -23 },
  { 519, 7, 10, 10, 1, -5 },
  { 528, 10, 5, 12, 1, -13 },
  { 535, 6, 6, 10, 2, -6 },
  { 540, 16, 28, 16, 0, -28 },
  { 596, 16, 28, 19, 1, -28 },
  { 652, 13, 28, 19, 2, -28 },
  { 698, 16, 28, 19, 1, -28 },
  { 754, 16, 28, 19, 1, -28 },
  { 810, 17, 28, 19, 1, -28 },
  { 870, 15, 28, 19, 2, -28 },
  { 923, 16, 28, 19, 1, -28 },
  { 979, 16, 28, 19, 1, -28 },
  { 1035, 16, 28, 19, 1, -28 },
  { 1091, 16, 28, 19, 1, -28 },
  { 1147, 7, 22, 10, 2, -22 },
  { 1167, 8, 27, 10, 1, -22 },
  { 1194, 17, 18, 19, 1, -23 },
  { 1233, 17, 13, 19, 1, -20 },
  { 1261, 17, 18, 19, 1, -23 },
  { 1300, 14, 28, 15, 0, -28 },
  { 1349, 27, 31, 29, 1, -28 },
  { 1454, 21, 28, 21, 0, -28 },
  { 1528, 18, 28, 21, 2, -28 },
  { 1591, 16, 28, 19, 2, -28 },
  { 1647, 19, 28, 22, 2, -28 },
  { 1714, 12, 28, 17, 3, -28 },
  { 1756, 12, 28, 17, 3, -28 },
  { 1798, 18, 28, 23, 2, -28 },
  { 1861, 18, 28, 23, 3, -28 },
  { 1924, 11, 28, 13, 1, -28 },
  { 1963, 10, 36, 11, -2, -28 },
  { 2008, 18, 28, 21, 3, -28 },
  { 2071, 14, 28, 16, 2, -28 },
  { 2120, 25, 28, 31, 3, -28 },
  { 2208, 20, 28, 25, 3, -28 },
  { 2278, 20, 28, 24, 2, -28 },
  { 2348, 17, 28, 20, 2, -28 },
  { 2408, 20, 35, 24, 2, -28 },
  { 2496, 19, 28, 21, 2, -28 },
  { 2563, 15, 28, 17, 1, -28 },
  { 2616, 16, 28, 17, 1, -28 },
  { 2672, 18, 28, 23, 2, -28 },
  { 2735, 21, 28, 21, 0, -28 },
  { 2809, 31, 28, 30, 0, -28 },
  { 2918, 19, 28, 19, 0, -28 },
  { 2985, 19, 28, 19, 0, -28 },
  { 3052, 15, 28, 17, 1, -28 },
  { 3105, 9, 34, 12, 2, -28 },
  { 3144, 16, 28, 16, 0, -28 },
  { 3200, 9, 34, 12, 1, -28 },
  { 3239, 19, 18, 21, 1, -28 },
  { 3282, 18, 4, 18, 0, 3 },
  { 3291, 9, 6, 13, 2, -30 },
  { 3298, 16, 22, 19, 1, -22 },
  { 3342, 17, 30, 20, 2, -30 },
  { 3406, 14, 22, 16, 1, -22 },
  { 3445, 17, 30, 20, 1, -30 },
  { 3509, 16, 22, 18, 1, -22 },
  { 3553, 13, 30, 12, 0, -30 },
  { 3602, 17, 31, 20, 1, -22 },
  { 3668, 16, 30, 20, 2, -30 },
  { 3728, 6, 30, 10, 2, -30 },
  { 3751, 9, 39, 10, -1, -30 },
  { 3795, 18, 30, 20, 2, -30 },
  { 3863, 6, 30, 10, 2, -30 },
  { 3886, 26, 22, 30, 2, -22 },
  { 3958, 16, 22, 20, 2, -22 },
  { 4002, 17, 22, 20, 1, -22 },
  { 4049, 17, 31, 20, 2, -22 },
  { 4115, 17, 31, 20, 1, -22 },
  { 4181, 12, 22, 14, 2, -22 },
  { 4214, 13, 22, 15, 1, -22 },
  { 4250, 13, 26, 13, 0, -26 },
  { 4293, 16, 21, 20, 2, -21 },
  { 4335, 18, 21, 18, 0, -21 },
  { 4383, 27, 21, 28, 0, -21 },
  { 4454, 17, 21, 17, 0, -21 },
  { 4499, 18, 30, 18, 0, -21 },
  { 4567, 13, 21, 15, 1, -21 },
  { 4602, 13, 34, 14, 0, -28 },
  { 4658, 5, 39, 17, 6, -30 },
  { 4683, 12, 34, 14, 1, -28 },
  { 4734, 17, 7, 19, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD39PT7B_H_
