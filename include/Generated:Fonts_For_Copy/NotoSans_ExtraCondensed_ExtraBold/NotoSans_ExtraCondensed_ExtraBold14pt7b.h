#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD14PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0xF0, 0xDE, 0xF7, 0xB0, 0x34, 0x68, 0xF3, 0xF2, 0xC5,
  0xBF, 0xB4, 0x68, 0xF0, 0x23, 0xBF, 0x5E, 0x78, 0xE7, 0xBF, 0x88, 0x40,
  0x71, 0x0A, 0x63, 0x68, 0x6F, 0x05, 0x7C, 0xEA, 0xC3, 0x58, 0x4B, 0x19,
  0x63, 0x38, 0x38, 0x6C, 0x6C, 0x7C, 0x38, 0x7B, 0xDF, 0xCE, 0x7E, 0x7B,
  0xFF, 0x6B, 0x6D, 0xB6, 0xD9, 0x30, 0xC6, 0x63, 0x33, 0x33, 0x36, 0x6C,
  0x30, 0xCF, 0xDF, 0x79, 0xB0, 0x10, 0x4F, 0xFF, 0x10, 0x40, 0x6D, 0xE0,
  0xFF, 0xF0, 0x0C, 0x61, 0x84, 0x30, 0xC6, 0x18, 0x43, 0x00, 0x39, 0xF6,
  0xDB, 0xEF, 0xB6, 0xDB, 0x7C, 0xE0, 0x37, 0xFB, 0x33, 0x33, 0x33, 0x7B,
  0xF4, 0xC3, 0x18, 0x63, 0x18, 0xFF, 0xF0, 0xF9, 0xF0, 0xC3, 0x38, 0xF0,
  0xC3, 0xFF, 0xE0, 0x1C, 0x73, 0xCB, 0x7D, 0x7F, 0xFF, 0x1C, 0x70, 0xFF,
  0xF1, 0x8F, 0x5C, 0x63, 0xFF, 0x80, 0x3D, 0xF6, 0x16, 0xFF, 0xBE, 0xDB,
  0x7C, 0xE0, 0xFF, 0xF0, 0xC3, 0x18, 0x63, 0x8C, 0x31, 0xC0, 0x79, 0xF6,
  0xDB, 0x39, 0xE6, 0xF3, 0x7D, 0xE0, 0x79, 0xFE, 0xF3, 0xED, 0xF2, 0xC3,
  0x79, 0xC0, 0xFC, 0x0F, 0x6D, 0x80, 0x1B, 0x78, 0x0C, 0xFF, 0x3C, 0x3C,
  0x10, 0xFC, 0x00, 0x3F, 0xC1, 0xC1, 0xC7, 0x73, 0x00, 0xF7, 0xC6, 0x33,
  0x11, 0x80, 0x63, 0x00, 0x3E, 0x31, 0xB2, 0x53, 0xBB, 0x5D, 0x2E, 0xD7,
  0x7E, 0xC0, 0x31, 0x0F, 0x80, 0x38, 0x3C, 0x3C, 0x3C, 0x6C, 0x66, 0x7E,
  0x7E, 0xE6, 0xC7, 0xFB, 0xFC, 0xF3, 0xFB, 0xFC, 0xF3, 0xFF, 0xE0, 0x7F,
  0xEC, 0x30, 0xC3, 0x0C, 0x30, 0xF9, 0xE0, 0xFB, 0xFC, 0xF3, 0xCF, 0x3C,
  0xF3, 0xFB, 0xC0, 0xFF, 0xF1, 0x8F, 0x7B, 0x18, 0xFF, 0xC0, 0xFF, 0xCC,
  0xFF, 0xCC, 0xCC, 0x7F, 0xFC, 0x30, 0xDF, 0x7C, 0xF3, 0xFD, 0xF0, 0xCF,
  0x3C, 0xF3, 0xFF, 0xFC, 0xF3, 0xCF, 0x30, 0xF7, 0x66, 0x66, 0x66, 0x7F,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xCF, 0xBB, 0x67, 0xCF, 0x1F,
  0x36, 0x6C, 0xCD, 0x9C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xC0, 0xE3,
  0xF1, 0xF8, 0xFE, 0xFF, 0x7F, 0xAF, 0x57, 0xBB, 0xDD, 0xE4, 0xC0, 0xE7,
  0xCF, 0x9F, 0xBF, 0x7B, 0xF7, 0xE7, 0xCF, 0x9C, 0x79, 0xFB, 0x3E, 0x3C,
  0x78, 0xF1, 0xE7, 0xFC, 0xF0, 0xFB, 0xED, 0xF3, 0xDB, 0xEE, 0x30, 0xC3,
  0x00, 0x79, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xE7, 0xFC, 0xF0, 0x70, 0x70,
  0xFB, 0xED, 0xF7, 0xFB, 0xED, 0xB6, 0xDF, 0x30, 0x7D, 0xEE, 0x18, 0x70,
  0xE1, 0xE3, 0xFB, 0xE0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFD, 0xE0, 0xC7, 0x8D, 0x9B, 0x36,
  0xCD, 0x8B, 0x1E, 0x38, 0x70, 0xCC, 0x79, 0xCF, 0x3B, 0x37, 0x66, 0xAC,
  0xF5, 0x9E, 0xB3, 0xDE, 0x3B, 0x86, 0x70, 0xEE, 0xD9, 0xB1, 0xC3, 0x87,
  0x0E, 0x36, 0x6D, 0x9C, 0xC6, 0xD9, 0xB3, 0x63, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xFF, 0xF1, 0x86, 0x30, 0xC6, 0x18, 0xFF, 0xF0, 0xFB, 0x6D, 0xB6,
  0xDB, 0x70, 0xC1, 0x06, 0x18, 0x30, 0xC1, 0x06, 0x18, 0x30, 0xF3, 0x33,
  0x33, 0x33, 0x33, 0x3F, 0x18, 0x70, 0xE1, 0x66, 0x58, 0xC0, 0xFC, 0xC9,
  0x80, 0x39, 0xF0, 0xCF, 0x7F, 0x3F, 0xDF, 0xC3, 0x0C, 0x3C, 0xFB, 0x7C,
  0xF3, 0xCF, 0xEF, 0x80, 0x3B, 0xD9, 0xCE, 0x31, 0xE7, 0x0C, 0x30, 0xCF,
  0x7D, 0xBE, 0xFB, 0x6D, 0xF7, 0x40, 0x39, 0xF6, 0xFF, 0xFD, 0x87, 0xCF,
  0x33, 0xD8, 0xEF, 0x31, 0x8C, 0x63, 0x18, 0x35, 0xF6, 0xFB, 0xED, 0xB7,
  0xDF, 0x0D, 0x37, 0x80, 0xC6, 0x31, 0xFF, 0xEF, 0x7B, 0xDE, 0xF6, 0xF3,
  0xFF, 0xFC, 0x6C, 0x36, 0xDB, 0x6D, 0xBF, 0x80, 0xC3, 0x0C, 0x33, 0xDB,
  0xEF, 0x3C, 0xDB, 0x6C, 0xC0, 0xFF, 0xFF, 0xFC, 0xBB, 0x7F, 0xF7, 0x7B,
  0x3D, 0x9E, 0xCF, 0x67, 0xB3, 0xBF, 0xF7, 0xBD, 0xEF, 0x7B, 0x38, 0xF9,
  0xB7, 0x7E, 0xED, 0x9F, 0x1C, 0xB3, 0xED, 0xF3, 0xCF, 0x3F, 0xBE, 0xC3,
  0x0C, 0x00, 0x35, 0xF6, 0xFB, 0xED, 0xB7, 0xDF, 0x0C, 0x30, 0xC0, 0xBF,
  0xCC, 0xCC, 0xCC, 0x73, 0xF0, 0xE7, 0x8F, 0xFE, 0x63, 0xBC, 0xC6, 0x31,
  0x8F, 0x78, 0xDE, 0xF7, 0xBD, 0xEF, 0xFD, 0xCF, 0x36, 0xDB, 0x79, 0xE3,
  0x8C, 0xCC, 0xF3, 0x37, 0xD9, 0xFE, 0x7F, 0x9D, 0xE7, 0x30, 0xCC, 0xCD,
  0xB7, 0x8E, 0x39, 0xE7, 0xF3, 0xCF, 0x36, 0xDB, 0x78, 0xE3, 0x8C, 0x31,
  0xC6, 0x00, 0xFF, 0xCE, 0x67, 0x33, 0xFF, 0x39, 0xCC, 0x63, 0x73, 0x8E,
  0x31, 0x8C, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x18, 0xC6, 0x1C, 0xEE,
  0x63, 0x19, 0xC0, 0xF7, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 5, 4, 6, 1, -10 },
  { 7, 7, 10, 7, 0, -10 },
  { 16, 5, 12, 7, 1, -11 },
  { 24, 11, 10, 11, 0, -10 },
  { 38, 8, 10, 8, 0, -10 },
  { 48, 2, 4, 3, 1, -10 },
  { 49, 3, 12, 4, 1, -10 },
  { 54, 4, 12, 4, 0, -10 },
  { 60, 6, 6, 6, 0, -11 },
  { 65, 6, 6, 7, 0, -8 },
  { 70, 3, 4, 4, 0, -2 },
  { 72, 4, 2, 4, 0, -5 },
  { 73, 2, 2, 4, 1, -2 },
  { 74, 6, 10, 6, 0, -10 },
  { 82, 6, 10, 7, 0, -10 },
  { 90, 4, 10, 7, 1, -10 },
  { 95, 6, 10, 7, 0, -10 },
  { 103, 6, 10, 7, 0, -10 },
  { 111, 6, 10, 7, 0, -10 },
  { 119, 5, 10, 7, 1, -10 },
  { 126, 6, 10, 7, 0, -10 },
  { 134, 6, 10, 7, 0, -10 },
  { 142, 6, 10, 7, 0, -10 },
  { 150, 6, 10, 7, 0, -10 },
  { 158, 2, 8, 4, 1, -8 },
  { 160, 3, 10, 4, 0, -8 },
  { 164, 6, 6, 7, 0, -8 },
  { 169, 6, 4, 7, 0, -7 },
  { 172, 6, 6, 7, 0, -8 },
  { 177, 5, 10, 5, 0, -10 },
  { 184, 9, 11, 10, 1, -10 },
  { 197, 8, 10, 8, 0, -10 },
  { 207, 6, 10, 8, 1, -10 },
  { 215, 6, 10, 7, 1, -10 },
  { 223, 6, 10, 8, 1, -10 },
  { 231, 5, 10, 6, 1, -10 },
  { 238, 4, 10, 6, 1, -10 },
  { 243, 6, 10, 8, 1, -10 },
  { 251, 6, 10, 8, 1, -10 },
  { 259, 4, 10, 5, 0, -10 },
  { 264, 4, 13, 4, -1, -10 },
  { 271, 7, 10, 7, 1, -10 },
  { 280, 5, 10, 6, 1, -10 },
  { 287, 9, 10, 11, 1, -10 },
  { 299, 7, 10, 9, 1, -10 },
  { 308, 7, 10, 8, 1, -10 },
  { 317, 6, 10, 7, 1, -10 },
  { 325, 7, 12, 8, 1, -10 },
  { 336, 6, 10, 7, 1, -10 },
  { 344, 6, 10, 6, 0, -10 },
  { 352, 6, 10, 6, 0, -10 },
  { 360, 6, 10, 8, 1, -10 },
  { 368, 7, 10, 7, 0, -10 },
  { 377, 11, 10, 11, 0, -10 },
  { 391, 7, 10, 7, 0, -10 },
  { 400, 7, 10, 7, 0, -10 },
  { 409, 6, 10, 6, 0, -10 },
  { 417, 3, 12, 4, 1, -10 },
  { 422, 6, 10, 6, 0, -10 },
  { 430, 4, 12, 4, 0, -10 },
  { 436, 7, 6, 8, 0, -10 },
  { 442, 6, 1, 6, 0, 1 },
  { 443, 3, 3, 5, 1, -11 },
  { 445, 6, 8, 7, 0, -8 },
  { 451, 6, 11, 7, 1, -11 },
  { 460, 5, 8, 6, 0, -8 },
  { 465, 6, 11, 7, 0, -11 },
  { 474, 6, 8, 7, 0, -8 },
  { 480, 5, 11, 4, 0, -11 },
  { 487, 6, 11, 7, 0, -8 },
  { 496, 5, 11, 7, 1, -11 },
  { 503, 2, 11, 4, 1, -11 },
  { 506, 3, 14, 4, 0, -11 },
  { 512, 6, 11, 7, 1, -11 },
  { 521, 2, 11, 4, 1, -11 },
  { 524, 9, 8, 11, 1, -8 },
  { 533, 5, 8, 7, 1, -8 },
  { 538, 7, 8, 7, 0, -8 },
  { 545, 6, 11, 7, 1, -8 },
  { 554, 6, 11, 7, 0, -8 },
  { 563, 4, 8, 5, 1, -8 },
  { 567, 5, 8, 5, 0, -8 },
  { 572, 5, 9, 5, 0, -9 },
  { 578, 5, 8, 7, 1, -8 },
  { 583, 6, 8, 7, 0, -8 },
  { 589, 10, 8, 10, 0, -8 },
  { 599, 6, 8, 6, 0, -8 },
  { 605, 6, 11, 7, 0, -8 },
  { 614, 5, 8, 5, 0, -8 },
  { 619, 5, 12, 5, 0, -10 },
  { 627, 2, 14, 6, 2, -11 },
  { 631, 5, 12, 5, 0, -10 },
  { 639, 6, 2, 7, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold14pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD14PT7B_H_
