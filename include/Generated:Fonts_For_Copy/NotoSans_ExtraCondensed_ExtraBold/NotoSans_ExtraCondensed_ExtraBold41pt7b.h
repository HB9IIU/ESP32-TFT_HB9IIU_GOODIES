#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFB, 0xF7, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x0E, 0x3E, 0xFF, 0xFF,
  0xFF, 0xF7, 0xC0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xF8, 0x03, 0xE7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xE1, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF8, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0xF9, 0x84, 0xF9, 0x80, 0xF9, 0x80, 0xFD, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x01, 0xFF, 0x01, 0xBF, 0x01, 0x9F, 0x81, 0x9F, 0xC1, 0xBF, 0xF9,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x07, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x3C,
  0x00, 0xFF, 0x80, 0xF8, 0x03, 0xFF, 0x01, 0xE0, 0x07, 0xFF, 0x07, 0xC0,
  0x0F, 0x3E, 0x0F, 0x80, 0x3E, 0x3C, 0x1E, 0x00, 0x7C, 0x78, 0x7C, 0x00,
  0xF8, 0xF0, 0xF0, 0x01, 0xF1, 0xE1, 0xE0, 0x03, 0xE3, 0xC7, 0xC0, 0x07,
  0xC7, 0x8F, 0x00, 0x0F, 0x8F, 0x3E, 0x3E, 0x0F, 0x3E, 0x78, 0xFE, 0x1F,
  0xFC, 0xF3, 0xFE, 0x3F, 0xF3, 0xEF, 0xFE, 0x3F, 0xE7, 0x9F, 0x7C, 0x3F,
  0x9F, 0x3C, 0x78, 0x1C, 0x3C, 0x78, 0xF8, 0x00, 0x78, 0xF1, 0xF0, 0x01,
  0xF1, 0xE3, 0xE0, 0x03, 0xC3, 0xC7, 0xC0, 0x0F, 0x87, 0x8F, 0x80, 0x1E,
  0x0F, 0x1F, 0x00, 0x3C, 0x1E, 0x3C, 0x00, 0xF8, 0x3E, 0x78, 0x01, 0xE0,
  0x7F, 0xF0, 0x07, 0xC0, 0x7F, 0xC0, 0x0F, 0x00, 0x7F, 0x80, 0x3E, 0x00,
  0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x3F,
  0xF8, 0xFC, 0x3F, 0xF8, 0xFC, 0x7F, 0xFC, 0xFC, 0xFE, 0xFF, 0xFC, 0xFC,
  0x7F, 0xF8, 0xFC, 0x7F, 0xF8, 0xFC, 0x3F, 0xF0, 0xFC, 0x1F, 0xF0, 0xFC,
  0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x06, 0x3E, 0x37, 0xFE, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xF7, 0xC3,
  0xF3, 0xF8, 0xF8, 0xF8, 0x38, 0x78, 0x04, 0x10, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0x03,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF9, 0xFC, 0xFC,
  0xFC, 0x7E, 0x7E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x7E,
  0x3F, 0x3F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0x80, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xEF, 0xCE, 0x7E, 0x23, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x01, 0xC0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF9, 0xE0, 0xFC, 0x60, 0x7E, 0x10, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0xFC, 0x1F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xF7, 0xE0, 0x7D, 0xF8,
  0x1E, 0x7E, 0x0F, 0x9F, 0x83, 0xC7, 0xE1, 0xF1, 0xF8, 0x78, 0x7E, 0x3E,
  0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x31, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xE0, 0x00, 0x3C, 0x00, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x9F, 0x87, 0xDF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xF0, 0xFD,
  0xF8, 0x7E, 0xFC, 0x3F, 0x7F, 0x3F, 0x9F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x07, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3, 0xF9, 0xF9, 0xF8, 0x7E, 0xFC, 0x3F,
  0x7E, 0x1F, 0xBF, 0x0F, 0x9F, 0xCF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x9F, 0xCF, 0xCF,
  0xC7, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0xBF, 0xBF, 0xDF, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x01,
  0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF9,
  0xF8, 0xFD, 0xFC, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xF1, 0xFD, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F,
  0xFF, 0xC7, 0xF7, 0xE1, 0xF3, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x01, 0xFE, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x1C, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0,
  0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x00, 0x07, 0xC0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF,
  0xCC, 0x1F, 0x90, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFE, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x3C, 0x7C, 0x1F, 0xC7, 0xCF, 0x07, 0xFE, 0x79, 0xE1, 0xFF, 0xCF, 0x7C,
  0x7E, 0xF9, 0xFF, 0x1F, 0x1E, 0x1F, 0xE3, 0xE3, 0xC3, 0xFC, 0x78, 0x78,
  0x7F, 0x8F, 0x0F, 0x0F, 0xF1, 0xE1, 0xE1, 0xFE, 0x3C, 0x3C, 0x3F, 0xC7,
  0x87, 0x8F, 0xF8, 0xF0, 0xF1, 0xEF, 0x1E, 0x3E, 0x3D, 0xE3, 0xE7, 0xEF,
  0xBC, 0x3F, 0xDF, 0xE7, 0xC7, 0xFB, 0xF8, 0xF8, 0x7E, 0x3E, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x01, 0x80,
  0x3F, 0xF7, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0xF8, 0x01, 0xFB, 0xE0,
  0x07, 0xEF, 0x80, 0x1F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xF8,
  0x07, 0xF7, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFC, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF,
  0xC3, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x0F, 0xEF, 0xC3, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFC, 0x7F,
  0xBF, 0x0F, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xFF, 0x07, 0xEF,
  0xC1, 0xFB, 0xF1, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x83, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF9, 0xFF, 0xF9, 0xFE, 0x0C, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0x7F, 0x83, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF8, 0xFF, 0x3F, 0x0F,
  0xF7, 0xE0, 0xFE, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F,
  0xBF, 0x0F, 0xE7, 0xEF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x1F, 0xFF,
  0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xE0, 0x33, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x81, 0xFB,
  0xF8, 0x3F, 0x7F, 0x87, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x3F, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xCF,
  0xF1, 0xF8, 0x00, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x1F,
  0xCF, 0xC3, 0xF9, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE7, 0xF0, 0xFC, 0xFC,
  0x1F, 0xBF, 0x83, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF3, 0xF8,
  0x7E, 0x7F, 0x0F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xFC,
  0xFC, 0x3F, 0x9F, 0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x07, 0xEF, 0xC0, 0xFE,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0xEF, 0x87,
  0xDF, 0xFD, 0xF0, 0xFB, 0xFF, 0xBE, 0x1F, 0x7F, 0xF3, 0xE3, 0xCF, 0xFE,
  0x7C, 0xF9, 0xFF, 0xCF, 0x9F, 0x3F, 0xF9, 0xF3, 0xE7, 0xFF, 0x1F, 0xF8,
  0xFF, 0xE3, 0xFF, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x8F, 0xFC, 0x7F, 0xF0,
  0xFF, 0x0F, 0xFE, 0x1F, 0xE1, 0xFF, 0xC3, 0xFC, 0x3F, 0xF8, 0x7F, 0x07,
  0xFF, 0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x83, 0xFF, 0x83,
  0xE0, 0x7E, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFE, 0xF8, 0x7F, 0xF7, 0xE3, 0xFF, 0x9F, 0x1F,
  0xFC, 0xFC, 0xFF, 0xE7, 0xE7, 0xFF, 0x1F, 0xBF, 0xF8, 0xFD, 0xFF, 0xC3,
  0xEF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xE0, 0xFE, 0x7F, 0x8F,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFC, 0x7F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0xFE, 0x03, 0xF7,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFD, 0xF8, 0x0F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x8F, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF1, 0xF8, 0xFE, 0x3F, 0x0F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0x9F,
  0x87, 0xF3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF7, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x9F, 0x87, 0xF3, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xC0, 0xFE, 0x01,
  0xC0, 0x0F, 0xFC, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0x1C, 0xFE, 0x04, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF8,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xF8, 0x7F, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9,
  0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x00, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7E, 0x7E, 0x0F,
  0xE0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F,
  0xF0, 0xFE, 0x7E, 0x0F, 0xF0, 0xFC, 0x3F, 0x1F, 0xF0, 0xFC, 0x3F, 0x1F,
  0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1E, 0xF8, 0xFC, 0x3F, 0x1E,
  0xF9, 0xF8, 0x1F, 0x3E, 0x79, 0xF8, 0x1F, 0xBE, 0x79, 0xF8, 0x1F, 0xBE,
  0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF0, 0x0F, 0xBC,
  0x7D, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0xFE, 0x07, 0xE7, 0xF0, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0x9F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xF9, 0xF8, 0x1F, 0x9F, 0x83,
  0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x7F, 0x07, 0xE7, 0xE0, 0x7F,
  0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xF0,
  0x7E, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x1F,
  0x9F, 0x80, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0xF9, 0xF0, 0x1F, 0x9F, 0x81, 0xF0, 0xF8, 0x3F, 0x0F,
  0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x18, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFE, 0x1F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x3F, 0xCF, 0x1F, 0x8F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x78, 0x3F, 0x7F, 0x8F, 0xDF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xCF,
  0xEF, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFE,
  0x1F, 0xBF, 0x87, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0x7F,
  0x8F, 0x8F, 0xC0, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF,
  0xCF, 0xE1, 0x9F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE,
  0x0D, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xC1, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x07, 0x8F, 0xC7, 0xF3, 0xF1, 0xFE, 0xFC,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xCF, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0x87, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFB, 0xF0, 0xFC, 0x7C, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF3, 0xF0, 0xF9, 0xF8, 0x7E,
  0xF8, 0x3F, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x9F,
  0xE7, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC,
  0x3F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xF9, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0x87, 0xC7, 0xFB, 0xF1, 0xFE, 0xFC,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xCF, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0xC7, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFB, 0xF0, 0xFC, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE4, 0x01, 0xF9, 0xF1, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x78, 0x7E, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xF9, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7E, 0x7F, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xF7, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xDF, 0x83,
  0xFB, 0xF0, 0x7E, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xFF, 0xC0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xF3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x1F,
  0xBF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x1F, 0x1F, 0x3F, 0xC7, 0xF3, 0xEF, 0xFD,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xDF, 0xFF,
  0x8F, 0xE1, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x1F, 0x87, 0xFF, 0x83, 0xF0,
  0xFF, 0xF0, 0x7E, 0x1F, 0xFE, 0x0F, 0xC3, 0xFF, 0xC1, 0xF8, 0x7F, 0xF8,
  0x3F, 0x0F, 0xFF, 0x07, 0xE1, 0xFF, 0xE0, 0xFC, 0x3F, 0xFC, 0x1F, 0x87,
  0xFF, 0x83, 0xF0, 0xFF, 0xF0, 0x7E, 0x1F, 0xFE, 0x0F, 0xC3, 0xFF, 0xC1,
  0xF8, 0x7F, 0xF8, 0x3F, 0x0F, 0xFF, 0x07, 0xE1, 0xF8, 0xF8, 0x78, 0x7C,
  0xFF, 0x3E, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFB, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7,
  0xE1, 0xF9, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F,
  0xDF, 0xC7, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x7F, 0x80, 0xF8, 0x78, 0x3E, 0x7F, 0x8F, 0xDF, 0xE3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xCF, 0xEF, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07,
  0xEF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFB,
  0xF0, 0x7E, 0xFE, 0x1F, 0xBF, 0x8F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0x7F, 0x8F, 0xCF, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x87, 0xC7, 0xFB, 0xF1, 0xFE, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xCF, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E,
  0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x1F, 0xDF, 0xC7, 0xF7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFB, 0xF0, 0xFC, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x7F, 0x8F, 0xF9,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0xE7, 0xFF,
  0x9F, 0xFE, 0xFF, 0xFB, 0xF0, 0xCF, 0xC0, 0x3F, 0x00, 0xFF, 0x01, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0x80,
  0xFF, 0x03, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x00,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFE, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFE, 0xF9, 0xFE, 0x7C, 0x7E, 0x3E, 0xFC, 0x07, 0xFF,
  0x80, 0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x8F,
  0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x07,
  0xBE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x1F, 0xC1, 0xFF, 0xE0, 0xFE, 0x0F, 0xDF,
  0x07, 0xF0, 0x7C, 0xFC, 0x3F, 0x87, 0xE7, 0xE3, 0xFE, 0x3F, 0x3F, 0x1F,
  0xF1, 0xF9, 0xF8, 0xF7, 0x8F, 0x87, 0xC7, 0xBC, 0xFC, 0x3F, 0x3D, 0xE7,
  0xE1, 0xFB, 0xEF, 0x3F, 0x0F, 0xDF, 0x7D, 0xF8, 0x3E, 0xF3, 0xEF, 0x81,
  0xF7, 0x8F, 0x7C, 0x0F, 0xBC, 0x7B, 0xE0, 0x7D, 0xE3, 0xFF, 0x03, 0xEF,
  0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFC, 0x3F,
  0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xDF, 0x87, 0xF7, 0xF1, 0xF8, 0xFC,
  0xFE, 0x3F, 0x3F, 0x07, 0xEF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC,
  0xFE, 0x7E, 0x1F, 0x9F, 0x87, 0xEF, 0xE0, 0xFC, 0xFC, 0x07, 0xFF, 0xC0,
  0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0xDF,
  0x80, 0xFB, 0xF0, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x17, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x1F, 0xF8, 0xFF, 0x87,
  0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFF,
  0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x3F,
  0xC1, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFF, 0x07, 0xF8,
  0x0F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x1F, 0xF0,
  0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xE0, 0x00, 0x3F, 0x00, 0x5F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xE8, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 29, 11, 2, -29 },
  { 27, 15, 10, 19, 2, -29 },
  { 46, 20, 29, 21, 1, -29 },
  { 119, 16, 33, 20, 2, -31 },
  { 185, 31, 30, 33, 1, -30 },
  { 302, 24, 30, 24, 1, -30 },
  { 392, 6, 10, 10, 2, -29 },
  { 400, 11, 36, 13, 2, -30 },
  { 450, 11, 36, 13, 0, -30 },
  { 500, 17, 17, 19, 1, -31 },
  { 537, 17, 19, 20, 1, -24 },
  { 578, 8, 11, 11, 1, -5 },
  { 589, 11, 6, 13, 1, -14 },
  { 598, 7, 7, 11, 2, -7 },
  { 605, 17, 30, 17, 0, -30 },
  { 669, 17, 30, 20, 1, -30 },
  { 733, 13, 29, 20, 2, -29 },
  { 781, 17, 30, 20, 1, -30 },
  { 845, 17, 30, 20, 1, -30 },
  { 909, 18, 29, 20, 1, -29 },
  { 975, 16, 29, 20, 2, -29 },
  { 1033, 17, 30, 20, 1, -30 },
  { 1097, 17, 29, 20, 1, -29 },
  { 1159, 17, 30, 20, 1, -30 },
  { 1223, 17, 30, 20, 1, -30 },
  { 1287, 7, 23, 11, 2, -23 },
  { 1308, 8, 29, 11, 1, -23 },
  { 1337, 17, 20, 20, 1, -25 },
  { 1380, 17, 13, 20, 1, -21 },
  { 1408, 18, 20, 20, 1, -25 },
  { 1453, 15, 30, 16, 0, -30 },
  { 1510, 27, 33, 30, 2, -30 },
  { 1622, 22, 29, 22, 0, -29 },
  { 1702, 18, 29, 22, 3, -29 },
  { 1768, 17, 30, 20, 2, -30 },
  { 1832, 19, 29, 23, 3, -29 },
  { 1901, 13, 29, 18, 3, -29 },
  { 1949, 13, 29, 18, 3, -29 },
  { 1997, 19, 30, 24, 2, -30 },
  { 2069, 19, 29, 25, 3, -29 },
  { 2138, 12, 29, 14, 1, -29 },
  { 2182, 11, 38, 12, -2, -29 },
  { 2235, 19, 29, 22, 3, -29 },
  { 2304, 13, 29, 17, 3, -29 },
  { 2352, 27, 29, 32, 3, -29 },
  { 2450, 21, 29, 26, 3, -29 },
  { 2527, 21, 30, 25, 2, -30 },
  { 2606, 16, 29, 21, 3, -29 },
  { 2664, 21, 37, 25, 2, -30 },
  { 2762, 19, 29, 22, 3, -29 },
  { 2831, 16, 30, 18, 1, -30 },
  { 2891, 17, 29, 18, 1, -29 },
  { 2953, 19, 29, 24, 2, -29 },
  { 3022, 22, 29, 22, 0, -29 },
  { 3102, 32, 29, 32, 0, -29 },
  { 3218, 20, 29, 20, 0, -29 },
  { 3291, 20, 29, 20, 0, -29 },
  { 3364, 16, 29, 18, 1, -29 },
  { 3422, 10, 37, 13, 2, -30 },
  { 3469, 17, 30, 17, 0, -30 },
  { 3533, 10, 37, 13, 1, -30 },
  { 3580, 20, 18, 22, 1, -29 },
  { 3625, 19, 4, 18, 0, 3 },
  { 3635, 10, 6, 13, 2, -31 },
  { 3643, 16, 23, 20, 1, -23 },
  { 3689, 18, 31, 21, 2, -31 },
  { 3759, 15, 23, 17, 1, -23 },
  { 3803, 18, 31, 21, 1, -31 },
  { 3873, 17, 23, 19, 1, -23 },
  { 3922, 14, 31, 13, 0, -31 },
  { 3977, 18, 33, 21, 1, -23 },
  { 4052, 17, 31, 21, 2, -31 },
  { 4118, 6, 31, 10, 2, -31 },
  { 4142, 9, 41, 10, -1, -31 },
  { 4189, 19, 31, 21, 2, -31 },
  { 4263, 6, 31, 10, 2, -31 },
  { 4287, 27, 23, 31, 2, -23 },
  { 4365, 17, 23, 21, 2, -23 },
  { 4414, 18, 23, 21, 1, -23 },
  { 4466, 18, 33, 21, 2, -23 },
  { 4541, 18, 33, 21, 1, -23 },
  { 4616, 12, 23, 15, 2, -23 },
  { 4651, 14, 23, 16, 1, -23 },
  { 4692, 13, 27, 14, 0, -27 },
  { 4736, 17, 23, 21, 2, -23 },
  { 4785, 19, 23, 19, 0, -23 },
  { 4840, 29, 23, 29, 0, -23 },
  { 4924, 18, 23, 18, 0, -23 },
  { 4976, 19, 33, 19, 0, -23 },
  { 5055, 14, 23, 15, 1, -23 },
  { 5096, 13, 36, 15, 0, -29 },
  { 5155, 5, 40, 18, 6, -31 },
  { 5180, 13, 36, 15, 1, -29 },
  { 5239, 18, 7, 20, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD41PT7B_H_
