#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD45PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFB, 0xF8,
  0xFD, 0xF8, 0x7E, 0x7C, 0x3F, 0x3E, 0x1F, 0x9F, 0x07, 0xC0, 0x01, 0xF3,
  0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC1, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x1F, 0x1E,
  0x00, 0x7C, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x0F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x83, 0xC7, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x01, 0xE3, 0xE0, 0x07,
  0x8F, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x1F,
  0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFC, 0xFE, 0xCF, 0x3F, 0x30,
  0xCF, 0xCC, 0x03, 0xF3, 0x00, 0xFC, 0xC0, 0x3F, 0xB0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x37, 0xE0, 0x0C, 0xF8, 0x03, 0x3F, 0x80, 0xCF, 0xF0, 0x33,
  0xEF, 0x0D, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0xC0,
  0x3F, 0xC0, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x03, 0xFE,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x7F, 0xF8, 0x0F, 0x00, 0x1F,
  0x3E, 0x07, 0xC0, 0x07, 0xCF, 0x81, 0xF0, 0x03, 0xE3, 0xE0, 0xF8, 0x00,
  0xF8, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0xC7, 0xC0,
  0x03, 0xE1, 0xF1, 0xF0, 0x00, 0xF8, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x3E,
  0x1E, 0x07, 0xCF, 0x8F, 0x1F, 0xE1, 0xF3, 0xE7, 0xCF, 0xFC, 0x7F, 0xF9,
  0xF3, 0xFF, 0x0F, 0xFC, 0xF9, 0xFF, 0xE3, 0xFE, 0x3E, 0x7C, 0xF8, 0x7F,
  0x0F, 0x1F, 0x1E, 0x03, 0x07, 0xC7, 0xC7, 0xC0, 0x01, 0xF1, 0xF1, 0xF0,
  0x00, 0xF8, 0xFC, 0x7C, 0x00, 0x3E, 0x3F, 0x1F, 0x00, 0x0F, 0x0F, 0xC7,
  0xC0, 0x07, 0xC1, 0xF1, 0xF0, 0x01, 0xF0, 0x7C, 0x7C, 0x00, 0xF8, 0x1F,
  0x3E, 0x00, 0x3E, 0x07, 0xCF, 0x80, 0x0F, 0x00, 0xFF, 0xE0, 0x07, 0xC0,
  0x3F, 0xF0, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0x8F, 0xFF, 0x0F, 0xE3, 0xFF, 0xE7,
  0xF1, 0xFF, 0xFD, 0xFC, 0x7F, 0x7F, 0xFF, 0x3F, 0x8F, 0xFF, 0x8F, 0xE3,
  0xFF, 0xE3, 0xF8, 0x7F, 0xF8, 0xFE, 0x0F, 0xFC, 0x3F, 0x81, 0xFF, 0x0F,
  0xF0, 0x7F, 0x83, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xFE, 0x0F, 0xFC, 0x3F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0xF9, 0xF0, 0x03, 0xF0, 0x3E,
  0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x06, 0x1F, 0x0C, 0xF3, 0xEF, 0x9F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xCF, 0xE3, 0xF8, 0xFC, 0x1E,
  0x1F, 0x01, 0xC1, 0x80, 0x08, 0x20, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x10, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x80,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xF7, 0xF1, 0xF8, 0xFE, 0xFE, 0x1F, 0xBF, 0x87, 0xEF, 0xC1, 0xFB, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0x7E, 0xFE, 0x1F, 0xBF, 0x87, 0xE7, 0xE3, 0xF9, 0xFD,
  0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0xFF, 0xFD, 0xFD, 0xF3, 0xF9, 0xE7, 0xF1,
  0x8F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0x40, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF,
  0xBF, 0xFF, 0xE7, 0xE3, 0xFC, 0xE0, 0x7F, 0x10, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x0F, 0xF0, 0x80, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0x7C, 0x3F, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0xFB, 0xF8, 0x0F, 0xBF, 0x81, 0xF3, 0xF8, 0x1F, 0x3F,
  0x83, 0xE3, 0xF8, 0x3E, 0x3F, 0x87, 0xC3, 0xF8, 0x7C, 0x3F, 0x8F, 0x83,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x88, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xB0, 0x0F, 0xEF, 0x9F, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x1F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xF8, 0x11,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0xFD, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xDF,
  0x83, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0x9F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xC7, 0xF3, 0xF8,
  0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xFC, 0x3F, 0x1F, 0x8F, 0xE3, 0xFB,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xF1, 0xFC, 0xFE, 0x1F, 0xDF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xBF, 0x87,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xEF, 0xF3, 0xF8, 0xFE, 0x7E, 0x0F, 0xDF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFB, 0xF8, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xDF, 0x9F, 0xFB,
  0xF1, 0xFE, 0x7E, 0x0F, 0x9F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x10, 0x7F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x08, 0x1E, 0x1F,
  0x8F, 0xEF, 0xF7, 0xF9, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF3, 0xF9, 0xFC, 0xFC,
  0x7E, 0x3F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF0, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0xFC, 0x1F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF9, 0xF1, 0xFC, 0x60, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFE, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x3F, 0xE3, 0xE7, 0xC1, 0xFF,
  0xCF, 0x9F, 0x0F, 0xFF, 0x3E, 0x78, 0x7F, 0xFC, 0x7B, 0xE3, 0xF1, 0xF1,
  0xFF, 0x8F, 0x87, 0xC7, 0xFE, 0x3E, 0x1F, 0x1F, 0xF8, 0xF8, 0x78, 0x7F,
  0xC7, 0xC1, 0xE1, 0xFF, 0x1F, 0x07, 0x87, 0xFC, 0x7C, 0x3E, 0x1F, 0xF1,
  0xF0, 0xF8, 0x7B, 0xC3, 0xE3, 0xE1, 0xEF, 0x8F, 0x8F, 0x8F, 0xBE, 0x3E,
  0x7F, 0x3C, 0xF8, 0xFF, 0xFF, 0xF3, 0xE1, 0xFF, 0x7F, 0x87, 0xC3, 0xF9,
  0xFC, 0x1F, 0x03, 0x81, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x10, 0x07, 0xF0, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x03, 0xFB, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFD,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xE7, 0xFE, 0xFE, 0x1F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x3F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFE, 0x1F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xF8, 0xF1, 0xFC, 0x04, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x03, 0x1F, 0xFB, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xF8, 0x7F,
  0x9F, 0xC1, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xE7,
  0xF1, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xC7,
  0xC7, 0xF8, 0x06, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFB,
  0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x7F, 0xEF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFD, 0x1F, 0xEF,
  0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0xFF, 0x83, 0xF0, 0x00, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFC, 0x1F, 0xCF, 0xE1, 0xFE, 0x7F,
  0x0F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xF8,
  0x3F, 0xBF, 0xC1, 0xFD, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFF, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0xFD, 0xF0, 0x7D, 0xFF, 0xF7,
  0xE1, 0xF7, 0xFF, 0xDF, 0x8F, 0xDF, 0xFF, 0x3E, 0x3E, 0x7F, 0xFC, 0xF8,
  0xF9, 0xFF, 0xF3, 0xF3, 0xE7, 0xFF, 0xCF, 0xDF, 0x9F, 0xFF, 0x1F, 0x7C,
  0x7F, 0xFC, 0x7F, 0xF1, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFF, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xE1, 0xFF, 0xF0, 0xFF, 0x87, 0xFF,
  0xC3, 0xFE, 0x1F, 0xFF, 0x07, 0xF0, 0x7F, 0xFC, 0x1F, 0xC1, 0xFF, 0xF0,
  0x7F, 0x07, 0xFF, 0xC0, 0xF8, 0x1F, 0xFF, 0x03, 0xE0, 0x7F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xDF, 0x87, 0xFF,
  0xBF, 0x8F, 0xFF, 0x3F, 0x1F, 0xFE, 0x7F, 0x3F, 0xFC, 0x7E, 0x7F, 0xF8,
  0xFC, 0xFF, 0xF1, 0xFD, 0xFF, 0xE1, 0xFB, 0xFF, 0xC3, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0xF9, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x7F, 0x7F, 0x01, 0xFE, 0xFF, 0x03, 0xF9, 0xFE, 0x0F, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF9,
  0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xBF,
  0x80, 0x7F, 0x7F, 0x01, 0xFE, 0xFF, 0x03, 0xF9, 0xFE, 0x0F, 0xF1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0x7F, 0x1F, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F,
  0x83, 0xF9, 0xFC, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xFB, 0xF8, 0x1F,
  0xDF, 0xC0, 0xFF, 0x00, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFE, 0x0E, 0x7E, 0x01, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81,
  0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7,
  0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF,
  0x01, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x80, 0xFC, 0xFC, 0x07, 0xF0, 0x3F,
  0x9F, 0xC1, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0xE0, 0xFE, 0x7F, 0x07, 0xFC,
  0x1F, 0xC7, 0xE0, 0xFF, 0x83, 0xF0, 0xFC, 0x3E, 0xF0, 0xFE, 0x1F, 0x87,
  0xDE, 0x1F, 0xC3, 0xF8, 0xFB, 0xE3, 0xF8, 0x7F, 0x1F, 0x7C, 0x7F, 0x07,
  0xE3, 0xEF, 0x8F, 0xC0, 0xFC, 0xFD, 0xF1, 0xF8, 0x1F, 0x9F, 0xBE, 0x7F,
  0x03, 0xF3, 0xE7, 0xEF, 0xE0, 0x7F, 0x7C, 0x7D, 0xFC, 0x07, 0xEF, 0x8F,
  0xBF, 0x00, 0xFD, 0xF1, 0xF7, 0xE0, 0x1F, 0xBE, 0x3E, 0xFC, 0x03, 0xFF,
  0xC7, 0xDF, 0x80, 0x7F, 0xF0, 0x7B, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x7F, 0x3F, 0x81, 0xFC,
  0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFB, 0xF0,
  0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01,
  0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8,
  0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0xCF, 0xE0, 0x3F,
  0x3F, 0x80, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x03, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC7, 0x87, 0xF0, 0x81, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0x7C, 0xFF, 0x9F, 0x1F, 0xC7, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC7, 0xC3, 0xFB, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFC, 0xFC, 0xFF, 0x9F, 0x8F, 0xC0, 0x07, 0xFC, 0x0F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xBC, 0xFF, 0x04, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x02, 0xFF, 0x0E, 0x7F,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE1, 0xF1, 0xFC, 0x7F, 0xBF, 0x9F,
  0xF7, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xE7, 0xE1, 0xF8, 0xFC, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x8F, 0xEF, 0xE1, 0xFB, 0xF0, 0x7E,
  0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x09, 0xFC, 0x0E, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE1, 0xFF,
  0xC3, 0xF8, 0x87, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xF9, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xC7, 0xE3, 0xFC, 0xFC,
  0xFF, 0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0x7F, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE8, 0x01, 0xFC, 0xC0, 0x7F, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xCF, 0xC3, 0xFB, 0xFC, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFC, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0x08, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x02, 0x03, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x08, 0x00,
  0x00, 0x01, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0xFF, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE, 0x3E, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0xFE,
  0xFC, 0x0F, 0xEF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x7F,
  0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xDF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xE7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F,
  0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x7F, 0x07, 0xE3, 0xF3, 0xFE,
  0x7F, 0xCF, 0xDF, 0xF9, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xC3, 0xF8, 0x7F,
  0xFE, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF,
  0x83, 0xF8, 0x3F, 0xFE, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xE0,
  0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x3F, 0xFE, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F,
  0x83, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x3F, 0xFE, 0x0F, 0xE0,
  0xFF, 0xF8, 0x3F, 0x83, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x3F,
  0xFE, 0x0F, 0xE0, 0xFC, 0xFC, 0x7E, 0x1F, 0x9F, 0xF3, 0xF7, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0,
  0x7F, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0x7F, 0xBF, 0x87, 0xF7, 0xF0, 0x7E, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFB, 0xF8,
  0x7F, 0x3F, 0x8F, 0xE7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0xFC, 0x7E, 0x1F, 0x9F, 0xE3, 0xF7, 0xFE, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC,
  0x3F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xF7,
  0xFC, 0xFE, 0x7E, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC7, 0xE3, 0xFC, 0xFC, 0xFF,
  0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0x7F, 0x0F, 0xCF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0xF8, 0x3F, 0xF3, 0xFF,
  0xCF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xE0, 0xFF, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFB, 0xFF, 0xE7,
  0xFF, 0xDF, 0xC3, 0xBF, 0x02, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0x83, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x7F,
  0xFC, 0x7F, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC4, 0x7F,
  0xF1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xBF, 0xDF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFD, 0xF9, 0xFF, 0xBF, 0x0F, 0xC7, 0xE0, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xDF, 0x80, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x1F, 0x83, 0xF0,
  0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x81, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F,
  0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0xFE, 0x7F, 0x1F, 0xF0, 0xFE, 0x7F, 0x1F,
  0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0x1E,
  0xF9, 0xFC, 0x3F, 0x1E, 0xF9, 0xFC, 0x3F, 0xBE, 0x79, 0xF8, 0x1F, 0xBE,
  0x79, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBE, 0x7D, 0xF8, 0x1F, 0xBC,
  0x7D, 0xF0, 0x1F, 0xBC, 0x7F, 0xF0, 0x0F, 0xBC, 0x3F, 0xF0, 0x0F, 0xBC,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xF9, 0xF8, 0x3F, 0x9F, 0xC3, 0xF0,
  0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xDF, 0x80, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x1F, 0x83,
  0xF0, 0xFC, 0x1F, 0x87, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x9F, 0x80, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E,
  0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0, 0x3F, 0xE1, 0xFF,
  0xC3, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x2F,
  0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 33, 12, 2, -32 },
  { 34, 17, 11, 21, 2, -32 },
  { 58, 22, 32, 23, 1, -32 },
  { 146, 18, 37, 22, 2, -34 },
  { 230, 34, 33, 36, 1, -33 },
  { 371, 26, 33, 27, 1, -33 },
  { 479, 7, 11, 11, 2, -32 },
  { 489, 12, 40, 14, 2, -33 },
  { 549, 12, 40, 14, 0, -33 },
  { 609, 19, 19, 21, 1, -34 },
  { 655, 19, 22, 22, 1, -27 },
  { 708, 9, 12, 12, 1, -6 },
  { 722, 12, 6, 14, 1, -15 },
  { 731, 8, 8, 12, 2, -7 },
  { 739, 18, 33, 19, 0, -33 },
  { 814, 18, 33, 21, 2, -33 },
  { 889, 15, 32, 21, 2, -32 },
  { 949, 18, 33, 21, 1, -33 },
  { 1024, 19, 33, 21, 1, -33 },
  { 1103, 20, 32, 21, 1, -32 },
  { 1183, 18, 32, 21, 2, -32 },
  { 1255, 19, 33, 21, 1, -33 },
  { 1334, 19, 32, 21, 1, -32 },
  { 1410, 19, 33, 21, 1, -33 },
  { 1489, 19, 33, 21, 1, -33 },
  { 1568, 8, 26, 12, 2, -25 },
  { 1594, 9, 31, 12, 1, -25 },
  { 1629, 19, 22, 22, 1, -27 },
  { 1682, 19, 15, 22, 1, -23 },
  { 1718, 19, 22, 22, 1, -27 },
  { 1771, 17, 34, 17, 0, -33 },
  { 1844, 30, 36, 33, 2, -33 },
  { 1979, 25, 32, 25, 0, -32 },
  { 2079, 20, 32, 24, 3, -32 },
  { 2159, 19, 33, 22, 2, -33 },
  { 2238, 21, 32, 26, 3, -32 },
  { 2322, 15, 32, 20, 3, -32 },
  { 2382, 15, 32, 20, 3, -32 },
  { 2442, 21, 33, 26, 2, -33 },
  { 2529, 21, 32, 27, 3, -32 },
  { 2613, 13, 32, 15, 1, -32 },
  { 2665, 13, 42, 13, -3, -32 },
  { 2734, 21, 32, 24, 3, -32 },
  { 2818, 15, 32, 19, 3, -32 },
  { 2878, 30, 32, 35, 3, -32 },
  { 2998, 23, 32, 29, 3, -32 },
  { 3090, 23, 33, 27, 2, -33 },
  { 3185, 18, 32, 23, 3, -32 },
  { 3257, 23, 41, 27, 2, -33 },
  { 3375, 21, 32, 24, 3, -32 },
  { 3459, 17, 33, 20, 1, -33 },
  { 3530, 18, 32, 20, 1, -32 },
  { 3602, 20, 32, 26, 3, -32 },
  { 3682, 24, 32, 24, 0, -32 },
  { 3778, 35, 32, 35, 0, -32 },
  { 3918, 22, 32, 22, 0, -32 },
  { 4006, 22, 32, 22, 0, -32 },
  { 4094, 18, 32, 20, 1, -32 },
  { 4166, 11, 40, 14, 2, -33 },
  { 4221, 18, 33, 19, 0, -33 },
  { 4296, 11, 40, 14, 1, -33 },
  { 4351, 22, 20, 24, 1, -32 },
  { 4406, 20, 5, 20, 0, 3 },
  { 4419, 11, 7, 15, 2, -34 },
  { 4429, 18, 25, 22, 1, -25 },
  { 4486, 19, 34, 23, 2, -34 },
  { 4567, 16, 25, 19, 2, -25 },
  { 4617, 19, 34, 23, 2, -34 },
  { 4698, 18, 25, 21, 2, -25 },
  { 4755, 15, 34, 14, 0, -34 },
  { 4819, 19, 36, 23, 2, -25 },
  { 4905, 19, 34, 23, 2, -34 },
  { 4986, 7, 35, 11, 2, -35 },
  { 5017, 10, 46, 11, -1, -35 },
  { 5075, 20, 34, 23, 3, -34 },
  { 5160, 7, 34, 11, 2, -34 },
  { 5190, 30, 25, 35, 2, -25 },
  { 5284, 19, 25, 23, 2, -25 },
  { 5344, 19, 25, 23, 2, -25 },
  { 5404, 19, 36, 23, 2, -25 },
  { 5490, 19, 36, 23, 2, -25 },
  { 5576, 14, 25, 16, 2, -25 },
  { 5620, 15, 25, 17, 1, -25 },
  { 5667, 14, 30, 15, 0, -30 },
  { 5720, 19, 25, 23, 2, -25 },
  { 5780, 21, 25, 21, 0, -25 },
  { 5846, 32, 25, 32, 0, -25 },
  { 5946, 20, 25, 20, 0, -25 },
  { 6009, 21, 36, 21, 0, -25 },
  { 6104, 15, 25, 17, 1, -25 },
  { 6151, 15, 39, 16, 0, -32 },
  { 6225, 6, 45, 19, 7, -35 },
  { 6259, 15, 39, 16, 1, -32 },
  { 6333, 19, 8, 22, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD45PT7B_H_
