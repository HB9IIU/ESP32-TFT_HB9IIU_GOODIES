#ifndef _NOTOSANS_EXTRACONDENSED_EXTRABOLD31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRABOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x80, 0x01, 0xE7, 0xFF, 0x7D, 0xE0, 0xF9, 0xFF, 0x9F, 0x79, 0xF7, 0x9F,
  0x79, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x0F, 0x38, 0x1C, 0xF0, 0x39, 0xE0,
  0x73, 0x80, 0xE7, 0x01, 0xCE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x39,
  0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x38, 0x00,
  0x03, 0x00, 0x30, 0x03, 0x01, 0xFE, 0x3F, 0xF7, 0xFF, 0x7B, 0xEF, 0x30,
  0xF3, 0x07, 0xB0, 0x7F, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x3F,
  0x03, 0x78, 0x37, 0xE3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x0F, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x3E, 0x03, 0x80, 0xFE, 0x0F, 0x03, 0xFC, 0x1C, 0x07,
  0xBC, 0x38, 0x0E, 0x38, 0xF0, 0x1C, 0x71, 0xC0, 0x38, 0xE7, 0x80, 0x71,
  0xCE, 0x00, 0xE3, 0x9C, 0x21, 0xEF, 0x7B, 0xF3, 0xFC, 0xE7, 0xF3, 0xFB,
  0xDF, 0xE3, 0xE7, 0x3D, 0xE0, 0x0E, 0x73, 0xC0, 0x3C, 0xE3, 0x80, 0x71,
  0xC7, 0x00, 0xE3, 0x9E, 0x03, 0x87, 0x3C, 0x07, 0x0F, 0x78, 0x1E, 0x0F,
  0xE0, 0x38, 0x1F, 0xC0, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03,
  0xFF, 0x00, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0xF9, 0xFF, 0x3E, 0xFF, 0xCF,
  0x3E, 0xFF, 0xCF, 0x1F, 0xF3, 0xC7, 0xF8, 0xF0, 0xFE, 0x3E, 0x1F, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xF3, 0xF0, 0xFF, 0xDE, 0xF7,
  0xBD, 0xEF, 0x0F, 0x8F, 0x07, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8,
  0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF8, 0x78,
  0x3C, 0x3C, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC1, 0x1E, 0x2F, 0x77,
  0x7F, 0xFB, 0xFF, 0xE7, 0xF8, 0x1F, 0x81, 0xFE, 0x1F, 0x78, 0xF3, 0xE3,
  0x0C, 0x08, 0x40, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x7D, 0xF7, 0x9E, 0x7B, 0xEF, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x00, 0x1F, 0x81, 0xFF, 0x1F, 0xF8, 0xFF,
  0xE7, 0x9F, 0x7C, 0x7B, 0xE3, 0xDF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1E, 0x78, 0xF3, 0xCF, 0x9F,
  0xFC, 0x7F, 0xC3, 0xFE, 0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3,
  0xFE, 0xFF, 0xFE, 0xFB, 0xDF, 0x33, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0x3F, 0x87, 0xFE, 0xFF, 0xEF, 0xFF, 0x61, 0xF2, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xC7,
  0xFF, 0x3F, 0xFC, 0xFF, 0xE4, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0xFC, 0x0F, 0xBF, 0xFD, 0xFF, 0xCF, 0xFE, 0x3F, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xBC,
  0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0E, 0x3C, 0x78, 0xF1, 0xC3, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7F, 0xC3, 0xFF, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x1E, 0x00, 0xF6, 0x0F, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x3F,
  0xC0, 0x07, 0xF0, 0xFF, 0x8F, 0xFC, 0x7F, 0x67, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0x30, 0xF7, 0xE7, 0xBF, 0xBF, 0xFD, 0xFB, 0xEF, 0x8F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x1F, 0xF8, 0xFB, 0xC7, 0x9F, 0xFC, 0x7F, 0xE3, 0xFE, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x1F, 0xC1, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0x7C, 0x79, 0xE3,
  0xCF, 0xBE, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x7F, 0xC7, 0xFF, 0x7C, 0xFB,
  0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0x7C, 0xFF, 0xE7, 0xFE, 0x0F,
  0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0xF9, 0xFF, 0xEF, 0x9F, 0x7C, 0x7B, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x9F, 0x78,
  0x23, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x1F, 0xF8, 0xFF, 0x87, 0xF8, 0x3F,
  0x80, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x7F, 0xFF, 0xF0,
  0x79, 0xF7, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xDE,
  0x79, 0xEF, 0xBC, 0xF0, 0x00, 0x08, 0x00, 0xC0, 0x3E, 0x07, 0xF0, 0xFF,
  0x9F, 0xE3, 0xFC, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0x80, 0x3C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x06,
  0x00, 0x3C, 0x01, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0x03,
  0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x0F, 0xC0, 0x78, 0x03, 0x00, 0x00, 0x3F,
  0x9F, 0xFB, 0xFF, 0xBF, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xE0,
  0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xE3, 0xF0, 0x3C, 0x03, 0xC3, 0xC0, 0x0E, 0x1C, 0x1C, 0x39, 0xE3, 0xF9,
  0xCE, 0x3F, 0xCF, 0x73, 0xCE, 0x3F, 0x9C, 0x71, 0xFC, 0xE3, 0x8F, 0xCF,
  0x1C, 0x7E, 0x78, 0xE3, 0xF1, 0xC7, 0x3F, 0x8E, 0x79, 0xDE, 0x7B, 0xCE,
  0xF3, 0xFF, 0xE3, 0x8F, 0x9F, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x08, 0x0F, 0xC7, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x1F, 0x7C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0xFF, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xEF, 0x80, 0xFF, 0xC0, 0x7C, 0xFF, 0xC3, 0xFF, 0xCF,
  0xFF, 0x3F, 0xFE, 0xF8, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF9, 0xF3,
  0xFF, 0xCF, 0xFC, 0x3F, 0xFC, 0xF9, 0xFB, 0xE3, 0xEF, 0x87, 0xBE, 0x1F,
  0xF8, 0xFB, 0xE3, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xE3, 0xFF, 0x00, 0x07,
  0xF8, 0x7F, 0xF1, 0xFF, 0x8F, 0xFE, 0x7E, 0x09, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x23, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8,
  0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xF8, 0xFB, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFB, 0xE7, 0xEF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x00, 0x07, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE3, 0xE0, 0x4F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF,
  0x8F, 0xFF, 0x07, 0xDE, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xFC, 0x7C, 0xFF,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0xFF, 0x80, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x9F, 0xFF,
  0xFF, 0xFC, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xBF, 0x7F, 0xBF, 0xDF, 0xC7, 0x80, 0xF8,
  0x7F, 0xF0, 0xFB, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0xF8,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFC, 0x3E, 0xF8, 0x7C, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xE3, 0xE7, 0xC3,
  0xEF, 0x87, 0xDF, 0x0F, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0x70, 0xFF, 0xF7, 0x8E, 0xFF, 0x79, 0xEF, 0xF7, 0x9E,
  0xFF, 0x39, 0xEF, 0xF3, 0xDC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x1F,
  0xCF, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0xF7, 0x8F, 0xF7, 0xCF,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xEF, 0xF1, 0xEF, 0xF1, 0xFF, 0xF0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F,
  0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x07, 0xBE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xF7, 0xC0, 0xF9, 0xE0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3F, 0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x80, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x9F, 0x7C, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF8, 0xFF, 0xCF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x0F,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xE3, 0xF3, 0xE0, 0xF9,
  0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x07, 0xBE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xF7, 0xC0, 0xF9, 0xE0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F,
  0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x3F, 0xFC, 0xF9, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8,
  0xFB, 0xE7, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC3, 0xEF, 0x0F, 0xBE, 0x3E,
  0xF8, 0xF9, 0xF3, 0xE7, 0xCF, 0x8F, 0xBE, 0x3E, 0xF8, 0x7F, 0xE1, 0xF0,
  0x1F, 0xC3, 0xFF, 0x7F, 0xEF, 0xFE, 0xF8, 0x6F, 0x80, 0xF8, 0x0F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0x81, 0xFE, 0x3E, 0xFF, 0xEF, 0xFE, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x80,
  0xF8, 0x0F, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x7C, 0x1E, 0x7C, 0x1E,
  0x3C, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C,
  0x1E, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0xF8, 0x3C, 0x1F, 0xF8,
  0x3C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8, 0x7E, 0x1F, 0x78, 0x7E, 0x1E, 0x78,
  0x7E, 0x1E, 0x7C, 0x7E, 0x3E, 0x7C, 0x7E, 0x3E, 0x7C, 0xFF, 0x3E, 0x3C,
  0xFF, 0x3C, 0x3C, 0xFF, 0x3C, 0x3C, 0xE7, 0x7C, 0x3E, 0xE7, 0x7C, 0x3F,
  0xE7, 0x7C, 0x1F, 0xE7, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE3, 0xF8, 0x1F,
  0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xC3, 0xF0, 0xF8, 0x3E, 0xF8, 0xF9, 0xF1, 0xF1, 0xF3, 0xC3, 0xEF, 0x83,
  0xDE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0x78, 0x3E, 0xF8, 0x7C, 0xF0,
  0xF1, 0xF3, 0xE3, 0xE7, 0xC3, 0xFF, 0x07, 0xC0, 0xF8, 0x3E, 0xF0, 0x7D,
  0xF0, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0xCF, 0x07, 0xBE, 0x0F, 0x78, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xF8, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0xFF,
  0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x1F, 0x78, 0x1E, 0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x78,
  0x1E, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x3C,
  0x1E, 0x0F, 0x3F, 0xC7, 0xFE, 0x3F, 0xF3, 0x9F, 0x00, 0xF0, 0x0F, 0x07,
  0xF3, 0xFF, 0x7F, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0xF1, 0xFF, 0x9F, 0xFF,
  0xF7, 0xFF, 0x7E, 0x70, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0xF8, 0xF7, 0xE7, 0xFF, 0xBF, 0xFD, 0xF1, 0xEF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF1,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9C, 0xF8, 0x1F, 0xE7, 0xFD, 0xFF, 0xBF,
  0xE7, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x82, 0xFF, 0xDF, 0xF9, 0xFF, 0x1F, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE3, 0xCF, 0x3F, 0x7B, 0xFF, 0xDF,
  0xFF, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x3F, 0xF1, 0xF7, 0xDF, 0xBF, 0xFC, 0xFF, 0xE3, 0xEF, 0x1F, 0xC1,
  0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0x7C, 0x7B, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x81, 0x3E, 0x39, 0xFF, 0xC7, 0xFE,
  0x1F, 0xE0, 0x07, 0x83, 0xFC, 0x7F, 0x1F, 0xE3, 0xE0, 0x7C, 0x0F, 0x83,
  0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F,
  0x79, 0xFB, 0xDF, 0xFE, 0xFF, 0xFF, 0x8F, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF, 0x8F, 0xBF, 0xFD, 0xFF, 0xE7,
  0xEF, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x81, 0xF7, 0xBF, 0x3F, 0xF9, 0xFF,
  0x8F, 0xF8, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x7C, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0x6F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0C, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x7F, 0xFF, 0xFF, 0xBE, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x3E, 0xF0, 0xF3, 0xC7, 0xCF,
  0x3E, 0x3C, 0xF0, 0xF7, 0xC3, 0xDE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x0F, 0x3E, 0x3C, 0x78, 0xF1, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xE7, 0xCF, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF9,
  0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F,
  0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xE7, 0xCF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x1F, 0xC1, 0xFF,
  0x1F, 0xFC, 0xFF, 0xF7, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0xF7, 0x8F, 0xBF, 0xFC, 0xFF, 0xC7, 0xFC, 0x0F,
  0xC0, 0xE7, 0xC7, 0xBF, 0x3F, 0xFD, 0xFB, 0xEF, 0x8F, 0x78, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x8F, 0x7F, 0xFB,
  0xFF, 0xDE, 0xFC, 0xF7, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x79, 0xFB, 0xDF, 0xFE, 0xFF, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF1, 0xFF,
  0x8F, 0xBF, 0xFD, 0xFF, 0xE7, 0xEF, 0x1E, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xE7, 0xF3, 0xFF, 0xFF, 0xFF,
  0xEF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x00, 0x3F, 0x9F, 0xFF, 0xFB, 0xE6, 0xF0, 0x3E, 0x0F, 0xC1,
  0xFC, 0x7F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x00, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0xF3,
  0xFC, 0x7F, 0x0F, 0xC0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0x3E, 0x70, 0xF8, 0x3F, 0xE1, 0xF7, 0x87, 0xDE,
  0x1E, 0x7C, 0x78, 0xF3, 0xE3, 0xCF, 0x8F, 0x3C, 0x3E, 0xF0, 0x7B, 0xC1,
  0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0xF8, 0xFC, 0x7F, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F, 0x1E, 0x78,
  0xFC, 0xF9, 0xF7, 0xF3, 0xE3, 0xDD, 0xEF, 0x0F, 0x73, 0xBC, 0x3D, 0xCE,
  0xF0, 0xF7, 0x3B, 0xC3, 0xDC, 0xFE, 0x07, 0x73, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7E, 0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0xF8,
  0x7D, 0xF3, 0xE7, 0xCF, 0x0F, 0x7C, 0x3F, 0xF0, 0x7F, 0x81, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xF0, 0xF7, 0xC7,
  0xCF, 0x9E, 0x3E, 0xF8, 0x78, 0xF8, 0x3D, 0xE1, 0xF7, 0x87, 0xDF, 0x1E,
  0x7C, 0x78, 0xF3, 0xE3, 0xCF, 0x8F, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC3, 0xF0,
  0xFC, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0xF8,
  0xFE, 0x3E, 0x0F, 0xE0, 0xFC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3F, 0x0F, 0xC3, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x3F, 0x0F, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83,
  0xE0, 0x7E, 0x1F, 0xC1, 0xF1, 0xFC, 0xFC, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x00, 0x10, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x70,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 22, 8, 1, -22 },
  { 18, 12, 8, 14, 1, -22 },
  { 30, 15, 22, 16, 1, -22 },
  { 72, 12, 26, 15, 1, -24 },
  { 111, 23, 22, 25, 1, -22 },
  { 175, 18, 22, 18, 1, -22 },
  { 225, 5, 8, 8, 1, -22 },
  { 230, 9, 27, 10, 1, -22 },
  { 261, 9, 27, 10, 0, -22 },
  { 292, 13, 14, 14, 1, -24 },
  { 315, 13, 15, 15, 1, -18 },
  { 340, 6, 8, 8, 1, -4 },
  { 346, 8, 4, 10, 1, -10 },
  { 350, 6, 5, 8, 1, -5 },
  { 354, 13, 22, 13, 0, -22 },
  { 390, 13, 22, 15, 1, -22 },
  { 426, 11, 22, 15, 1, -22 },
  { 457, 12, 22, 15, 1, -22 },
  { 490, 13, 22, 15, 1, -22 },
  { 526, 14, 22, 15, 0, -22 },
  { 565, 13, 22, 15, 1, -22 },
  { 601, 13, 22, 15, 1, -22 },
  { 637, 13, 22, 15, 1, -22 },
  { 673, 13, 22, 15, 1, -22 },
  { 709, 13, 22, 15, 1, -22 },
  { 745, 5, 17, 8, 2, -17 },
  { 756, 6, 21, 8, 1, -17 },
  { 772, 13, 15, 15, 1, -19 },
  { 797, 13, 10, 15, 1, -16 },
  { 814, 13, 15, 15, 1, -19 },
  { 839, 11, 22, 12, 0, -22 },
  { 870, 21, 24, 23, 1, -22 },
  { 933, 17, 22, 17, 0, -22 },
  { 980, 14, 22, 17, 2, -22 },
  { 1019, 14, 22, 15, 1, -22 },
  { 1058, 14, 22, 18, 2, -22 },
  { 1097, 10, 22, 14, 2, -22 },
  { 1125, 10, 22, 13, 2, -22 },
  { 1153, 15, 22, 18, 1, -22 },
  { 1195, 15, 22, 19, 2, -22 },
  { 1237, 9, 22, 10, 1, -22 },
  { 1262, 9, 29, 9, -2, -22 },
  { 1295, 15, 22, 16, 2, -22 },
  { 1337, 10, 22, 13, 2, -22 },
  { 1365, 20, 22, 24, 2, -22 },
  { 1420, 16, 22, 20, 2, -22 },
  { 1464, 17, 22, 19, 1, -22 },
  { 1511, 13, 22, 16, 2, -22 },
  { 1547, 17, 27, 19, 1, -22 },
  { 1605, 14, 22, 16, 2, -22 },
  { 1644, 12, 22, 14, 1, -22 },
  { 1677, 13, 22, 14, 0, -22 },
  { 1713, 14, 22, 18, 2, -22 },
  { 1752, 16, 22, 16, 0, -22 },
  { 1796, 24, 22, 24, 0, -22 },
  { 1862, 15, 22, 15, 0, -22 },
  { 1904, 15, 22, 15, 0, -22 },
  { 1946, 12, 22, 14, 1, -22 },
  { 1979, 7, 27, 10, 2, -22 },
  { 2003, 13, 22, 13, 0, -22 },
  { 2039, 7, 27, 10, 1, -22 },
  { 2063, 16, 14, 17, 0, -22 },
  { 2091, 14, 3, 14, 0, 2 },
  { 2097, 8, 5, 10, 1, -24 },
  { 2102, 12, 17, 15, 1, -17 },
  { 2128, 13, 24, 16, 2, -24 },
  { 2167, 11, 17, 13, 1, -17 },
  { 2191, 13, 24, 16, 1, -24 },
  { 2230, 13, 17, 15, 1, -17 },
  { 2258, 11, 24, 10, 0, -24 },
  { 2291, 13, 24, 16, 1, -17 },
  { 2330, 12, 24, 16, 2, -24 },
  { 2366, 4, 24, 8, 2, -24 },
  { 2378, 7, 31, 8, -1, -24 },
  { 2406, 14, 24, 16, 2, -24 },
  { 2448, 4, 24, 8, 2, -24 },
  { 2460, 20, 17, 24, 2, -17 },
  { 2503, 12, 17, 16, 2, -17 },
  { 2529, 13, 17, 16, 1, -17 },
  { 2557, 13, 24, 16, 2, -17 },
  { 2596, 13, 24, 16, 1, -17 },
  { 2635, 9, 17, 11, 2, -17 },
  { 2655, 10, 17, 12, 1, -17 },
  { 2677, 10, 21, 11, 0, -21 },
  { 2704, 12, 17, 16, 2, -17 },
  { 2730, 14, 17, 14, 0, -17 },
  { 2760, 22, 17, 22, 0, -17 },
  { 2807, 14, 17, 14, 0, -17 },
  { 2837, 14, 24, 14, 0, -17 },
  { 2879, 10, 17, 12, 1, -17 },
  { 2901, 10, 27, 11, 0, -22 },
  { 2935, 4, 31, 13, 5, -24 },
  { 2951, 10, 27, 11, 1, -22 },
  { 2985, 13, 6, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraBold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraBold31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraBold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRABOLD31PT7B_H_
