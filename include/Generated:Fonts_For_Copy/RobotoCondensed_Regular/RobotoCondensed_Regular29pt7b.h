#ifndef _ROBOTOCONDENSED_REGULAR29PT7B_H_
#define _ROBOTOCONDENSED_REGULAR29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF6, 0xCF, 0x3C, 0xF3,
  0xCF, 0x2C, 0x80, 0x06, 0x30, 0x31, 0x81, 0x98, 0x18, 0xC0, 0xC6, 0x06,
  0x31, 0xFF, 0xEF, 0xFF, 0x0C, 0x40, 0x46, 0x06, 0x30, 0x31, 0x81, 0x8C,
  0x7F, 0xFB, 0xFF, 0xC2, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0x63, 0x03,
  0x10, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x0F, 0x83, 0xF8, 0xF7, 0x98, 0x77,
  0x06, 0xE0, 0xFC, 0x1F, 0x80, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0E,
  0x00, 0xE0, 0x1F, 0x03, 0xE0, 0x7E, 0x0D, 0xE7, 0x9F, 0xE0, 0xF8, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0x78, 0x01, 0xF8, 0x03, 0x30, 0x04, 0x31, 0x88,
  0x62, 0x10, 0xCC, 0x21, 0xB0, 0x66, 0x60, 0xFD, 0x80, 0xF3, 0x00, 0x0C,
  0x00, 0x19, 0xC0, 0x67, 0xC0, 0xD8, 0xC3, 0x31, 0x86, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x43, 0x18, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3F, 0x80,
  0xE7, 0x01, 0xC6, 0x03, 0x0E, 0x06, 0x18, 0x0E, 0x70, 0x1D, 0xC0, 0x1F,
  0x80, 0x1C, 0x00, 0x78, 0x01, 0xF8, 0xC7, 0x39, 0x8C, 0x73, 0x38, 0x76,
  0x70, 0x7C, 0x60, 0xF0, 0xE0, 0xE1, 0xE7, 0xE1, 0xFE, 0xC0, 0xF1, 0xC0,
  0xFF, 0xFD, 0xB0, 0x04, 0x31, 0xC6, 0x30, 0xC7, 0x18, 0x63, 0x8E, 0x38,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x38, 0xE1, 0x86, 0x1C, 0x30, 0xC1, 0x87,
  0x0C, 0x10, 0x83, 0x0E, 0x18, 0x30, 0xC3, 0x86, 0x18, 0x71, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x30, 0xC6, 0x18, 0xC2,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x04, 0x60, 0x76, 0xF7, 0xFF, 0x0F, 0x80,
  0xF0, 0x1D, 0x81, 0x9C, 0x38, 0xC1, 0x08, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x33, 0x33, 0x76, 0x40, 0xFF, 0xF0,
  0xFF, 0x80, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x00, 0x1F, 0x0F, 0xF1, 0xCF, 0x70,
  0xEE, 0x0D, 0x81, 0xB0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xE0, 0xDC, 0x39, 0xCE, 0x1F, 0xC1, 0xF0,
  0x02, 0x3D, 0xFF, 0xBC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x0F, 0x83, 0xFC, 0x79, 0xE6,
  0x0E, 0xE0, 0x6E, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x07,
  0xFF, 0x7F, 0xF0, 0x0F, 0x07, 0xF9, 0xE7, 0x38, 0x76, 0x07, 0xC0, 0xC0,
  0x18, 0x07, 0x01, 0xC1, 0xF0, 0x3F, 0x00, 0xF0, 0x0E, 0x00, 0xC0, 0x1F,
  0x03, 0x60, 0x6C, 0x1D, 0xE7, 0x1F, 0xE0, 0xF0, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0xC3, 0x8C, 0x30,
  0xC7, 0x0C, 0x60, 0xCE, 0x0C, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x3F, 0xEF, 0xFD, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x18, 0x03, 0x78, 0x7F, 0x8F, 0x78, 0x83, 0x80, 0x70, 0x0E, 0x00, 0xC0,
  0x1E, 0x07, 0xE0, 0xEC, 0x1D, 0xC7, 0x1F, 0xC1, 0xF0, 0x07, 0x03, 0xE0,
  0xF0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x78, 0xDF, 0x9E, 0x3B, 0x83,
  0x70, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0xEC, 0x19, 0xC7, 0x1F,
  0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x0F,
  0xF1, 0xCF, 0x70, 0xEE, 0x0D, 0xC1, 0xB8, 0x37, 0x0E, 0x73, 0x87, 0xE0,
  0xFE, 0x38, 0xEE, 0x0D, 0x81, 0xB0, 0x3E, 0x07, 0xC0, 0xFC, 0x1B, 0xCF,
  0x3F, 0xC1, 0xF0, 0x0F, 0x07, 0xF0, 0xE7, 0x38, 0x76, 0x0E, 0xC0, 0xF8,
  0x1F, 0x03, 0x60, 0x6C, 0x0D, 0xC3, 0xBC, 0xF3, 0xFE, 0x3C, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x1E, 0x0F, 0x81, 0xC0, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x77, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x77, 0x6E, 0xCC,
  0x00, 0x40, 0x70, 0x7C, 0x3C, 0x3E, 0x3E, 0x0E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0x00, 0x40, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x0F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0C,
  0x1F, 0x1F, 0x1F, 0x8F, 0x83, 0x80, 0x80, 0x00, 0x1E, 0x1F, 0xE7, 0x3B,
  0x87, 0xE1, 0xC0, 0x30, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x0C, 0x00, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x38, 0x1C, 0x0C, 0x01, 0xC3, 0x00, 0x18, 0xE0,
  0x01, 0x98, 0x3C, 0x33, 0x0F, 0xC2, 0xC3, 0x98, 0x78, 0x63, 0x0F, 0x1C,
  0x61, 0xE3, 0x0C, 0x3C, 0x61, 0x87, 0x8C, 0x30, 0xF1, 0x86, 0x1E, 0x30,
  0xC2, 0xC6, 0x38, 0xD8, 0xE7, 0x1B, 0x1F, 0xFE, 0x61, 0xC7, 0x86, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x40, 0x0F, 0xF8, 0x00, 0x7E,
  0x00, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x6C, 0x01, 0xD8,
  0x03, 0xB8, 0x06, 0x70, 0x0C, 0x60, 0x38, 0xC0, 0x61, 0xC0, 0xC1, 0x83,
  0x83, 0x07, 0xFF, 0x0F, 0xFE, 0x38, 0x0C, 0x70, 0x1C, 0xC0, 0x3B, 0x80,
  0x37, 0x00, 0x7C, 0x00, 0xE0, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE1, 0xEF, 0xFC, 0xFF, 0xCE, 0x0E, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x7E, 0x07, 0xE1, 0xEF, 0xFC, 0xFF,
  0x80, 0x0F, 0xC1, 0xFF, 0x1F, 0x3C, 0xE0, 0x6E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x81, 0x9E, 0x3C, 0x7F, 0xC0, 0xF8, 0x00,
  0xFF, 0x07, 0xFE, 0x38, 0x79, 0xC0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x06, 0xE0, 0x77, 0x03, 0xB8, 0x79, 0xFF, 0x8F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F,
  0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0x7F, 0xEE, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x0F, 0xC1, 0xFF,
  0x1E, 0x3C, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x83, 0xFC, 0x1F, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1B, 0x80, 0xDF, 0x1E, 0x7F, 0xE0, 0xFC, 0x00, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x3E, 0x07, 0xE0, 0xFC, 0x19, 0xCF, 0x3F, 0xC1, 0xF0, 0xE0, 0x3B,
  0x81, 0xCE, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x8E, 0x0E, 0x70, 0x39, 0xC0,
  0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xF3, 0x83, 0x8E, 0x0E, 0x1C,
  0x38, 0x70, 0xE0, 0xE3, 0x81, 0xCE, 0x07, 0x38, 0x0E, 0xE0, 0x38, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x7F, 0xFF, 0xFE, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xB0, 0x37, 0xEC, 0x0D,
  0xFB, 0x87, 0x7E, 0xE1, 0x9F, 0x98, 0x67, 0xE7, 0x39, 0xF9, 0xCC, 0x7E,
  0x33, 0x1F, 0x8D, 0xC7, 0xE3, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87,
  0x07, 0xE0, 0xC1, 0xC0, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x7E, 0xC1, 0xFB, 0x87, 0xE6, 0x1F, 0x9C, 0x7E, 0x31, 0xF8,
  0xE7, 0xE1, 0x9F, 0x87, 0x7E, 0x0D, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1C, 0x0F, 0x80, 0xFF, 0x87, 0xCF, 0x1C, 0x0E,
  0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xB0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xB8, 0x06, 0xE0, 0x39, 0xC0,
  0xE7, 0xCF, 0x0F, 0xF8, 0x0F, 0x80, 0xFF, 0x87, 0xFF, 0x38, 0x3D, 0xC0,
  0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xB8, 0x3D,
  0xFF, 0xCF, 0xFC, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0x87, 0xDF, 0x1C, 0x0C,
  0xE0, 0x3B, 0x80, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x6C, 0x01, 0xB8, 0x06, 0xE0, 0x39, 0xC0,
  0xE7, 0xCF, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0xFF,
  0x87, 0xFF, 0x38, 0x79, 0xC0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xDC, 0x0E,
  0xE0, 0x77, 0x0F, 0x3F, 0xF1, 0xFF, 0x0E, 0x18, 0x70, 0xE3, 0x87, 0x1C,
  0x1C, 0xE0, 0xE7, 0x03, 0xB8, 0x1D, 0xC0, 0x6E, 0x03, 0x80, 0x0F, 0x81,
  0xFF, 0x0F, 0x3C, 0xE0, 0x67, 0x03, 0xB0, 0x1D, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xFC, 0x07,
  0xE0, 0x3B, 0x81, 0xDE, 0x3C, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xE0, 0x37,
  0x03, 0x9E, 0x3C, 0x7F, 0xC1, 0xF8, 0x00, 0xE0, 0x0F, 0xC0, 0x3B, 0x80,
  0x73, 0x00, 0xE7, 0x01, 0x8E, 0x07, 0x0C, 0x0E, 0x1C, 0x18, 0x38, 0x70,
  0x30, 0xE0, 0x61, 0x80, 0xE3, 0x01, 0xCE, 0x01, 0x9C, 0x03, 0x30, 0x07,
  0x60, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x60, 0x3E, 0x07, 0x07, 0xE0, 0x70, 0x76, 0x0F, 0x07, 0x60, 0xF0, 0x67,
  0x0F, 0x86, 0x70, 0xD8, 0x67, 0x1D, 0x8E, 0x31, 0x98, 0xE3, 0x19, 0x8C,
  0x31, 0x8C, 0xC3, 0x98, 0xCC, 0x3B, 0x0C, 0xC1, 0xB0, 0xDC, 0x1B, 0x0D,
  0xC1, 0xB0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x00, 0xE0, 0x1D, 0xC0, 0xE7, 0x03, 0x8E, 0x1C, 0x38,
  0x70, 0x73, 0x81, 0xCE, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xCE, 0x07, 0x38, 0x38, 0x70, 0xE1, 0xC7,
  0x03, 0x9C, 0x0E, 0xE0, 0x1C, 0x70, 0x0E, 0xE0, 0x38, 0xC0, 0x71, 0xC1,
  0xC3, 0x83, 0x83, 0x86, 0x07, 0x1C, 0x06, 0x30, 0x0E, 0xE0, 0x0D, 0xC0,
  0x1F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x3F, 0xF0, 0xC0, 0x70, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38,
  0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0x60, 0x38, 0x1C, 0x06, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xF0, 0x18, 0x0E,
  0x07, 0x07, 0x83, 0x61, 0xB1, 0x9C, 0xC6, 0xE3, 0x61, 0xC0, 0xFF, 0xFF,
  0xFC, 0xE1, 0xC3, 0x86, 0x1F, 0x1F, 0xEF, 0x3F, 0x87, 0xC1, 0xC0, 0x71,
  0xFD, 0xFF, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF9, 0xF7, 0xFC, 0xF3,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x33, 0xC6, 0xFC, 0xF1,
  0xDC, 0x1B, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x83, 0x78, 0xED, 0xF9, 0x9E, 0x00, 0x0F, 0x07, 0xF9, 0xE7, 0xB8,
  0x76, 0x07, 0xC0, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x37,
  0x06, 0xF1, 0xCF, 0xF0, 0x7C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC7, 0xD9, 0xFF, 0x79, 0xEE, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x6C, 0x0D, 0xC1, 0xBC, 0xF3, 0xFE, 0x3E, 0xC0,
  0x0F, 0x87, 0xF9, 0xE7, 0xB8, 0x76, 0x06, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x30, 0x07, 0x00, 0xF1, 0xCF, 0xF8, 0x7C, 0x0F, 0x1F,
  0x3C, 0x38, 0x38, 0x38, 0xFE, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x67, 0xFD, 0xE7,
  0xB8, 0x36, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xB0,
  0x37, 0x06, 0xF3, 0xCF, 0xF8, 0xFB, 0x00, 0x60, 0x0C, 0x03, 0x98, 0xF3,
  0xFC, 0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0xF3,
  0x7E, 0xF3, 0xF8, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0xDF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x31, 0xCC, 0x00, 0x00, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33, 0xBD, 0xC0, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x76, 0x1C, 0xC7, 0x18, 0xE3,
  0x38, 0x6E, 0x0D, 0x81, 0xF8, 0x3F, 0x07, 0x70, 0xC7, 0x18, 0xE3, 0x0E,
  0x61, 0xCC, 0x1D, 0x81, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xCF, 0x1F, 0x3F, 0xEF, 0xEF, 0x3F, 0x3B, 0x87, 0x87, 0xC0,
  0xC1, 0xF0, 0x30, 0x7C, 0x0C, 0x1F, 0x03, 0x07, 0xC0, 0xC1, 0xF0, 0x30,
  0x7C, 0x0C, 0x1F, 0x03, 0x07, 0xC0, 0xC1, 0xF0, 0x30, 0x7C, 0x0C, 0x1F,
  0x03, 0x07, 0xCF, 0x37, 0xEF, 0x3F, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x0F, 0x83,
  0xFC, 0x38, 0xE7, 0x07, 0x60, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x36, 0x07, 0x70, 0x73, 0x8E, 0x3F, 0xC0, 0xF8, 0xCF, 0x1B,
  0xF3, 0xCF, 0x70, 0x6C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x0D, 0xE3, 0xB7, 0xE6, 0x78, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x00, 0x1F, 0x67, 0xFD, 0xE3, 0xB8, 0x36, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xB0, 0x37, 0x06, 0xF1,
  0xCF, 0xF8, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0xCF, 0x7F, 0xF8, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x1F, 0x07, 0xF9, 0xC7, 0x38, 0x76, 0x0E, 0xE0, 0x1E, 0x01, 0xF8, 0x0F,
  0x80, 0x78, 0x03, 0xF0, 0x76, 0x0E, 0xE3, 0x8F, 0xF0, 0xF8, 0x18, 0x30,
  0x67, 0xFF, 0xE3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x1C, 0x3C, 0x38, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xFC, 0xF7, 0xFC, 0xF3, 0xC0,
  0xFC, 0x1B, 0x83, 0x30, 0xE6, 0x18, 0xE3, 0x0C, 0x61, 0x9C, 0x33, 0x07,
  0x60, 0x6C, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0xC1, 0xC1, 0xF0,
  0xE1, 0xF8, 0x70, 0xEC, 0x78, 0x66, 0x3E, 0x33, 0x1B, 0x39, 0xCD, 0x9C,
  0xEE, 0xCC, 0x36, 0x76, 0x1B, 0x1B, 0x0D, 0x8F, 0x87, 0xC7, 0x81, 0xC3,
  0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x30, 0xE0, 0xEC, 0x39, 0xC7, 0x19,
  0xC3, 0xB0, 0x3E, 0x07, 0x80, 0x70, 0x0E, 0x03, 0xE0, 0x6C, 0x1D, 0xC3,
  0x38, 0xE3, 0x98, 0x77, 0x07, 0x60, 0x67, 0x0E, 0x70, 0xE3, 0x0E, 0x30,
  0xC3, 0x9C, 0x39, 0xC1, 0x98, 0x19, 0x81, 0xD8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x78,
  0x07, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x3F, 0xFF, 0xFF,
  0x02, 0x1C, 0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x1E,
  0x3C, 0x38, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x06, 0x0C, 0x18, 0x38, 0x38,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x81,
  0xC1, 0x83, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0x83, 0xC7,
  0x8C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x70, 0xC3, 0x84, 0x00,
  0x38, 0x1B, 0xF0, 0xFB, 0xC7, 0x87, 0x7C, 0x3F, 0x00, 0x70,
};

const GFXglyph RobotoCondensed_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 6, 7, 9, 2, -22 },
  { 15, 13, 21, 16, 2, -21 },
  { 50, 11, 27, 14, 2, -24 },
  { 88, 15, 21, 18, 2, -21 },
  { 128, 15, 21, 16, 1, -21 },
  { 168, 3, 7, 5, 1, -22 },
  { 171, 6, 30, 9, 2, -23 },
  { 194, 6, 30, 9, 1, -23 },
  { 217, 12, 12, 12, 0, -21 },
  { 235, 12, 15, 14, 1, -17 },
  { 258, 4, 7, 6, 0, -3 },
  { 262, 6, 2, 7, 1, -10 },
  { 264, 3, 3, 8, 2, -3 },
  { 266, 10, 23, 11, 0, -21 },
  { 295, 11, 21, 14, 2, -21 },
  { 324, 7, 21, 14, 2, -21 },
  { 343, 12, 21, 14, 1, -21 },
  { 375, 11, 21, 14, 1, -21 },
  { 404, 12, 21, 14, 1, -21 },
  { 436, 11, 21, 14, 2, -21 },
  { 465, 11, 21, 14, 2, -21 },
  { 494, 12, 21, 14, 1, -21 },
  { 526, 11, 21, 14, 2, -21 },
  { 555, 11, 21, 14, 1, -21 },
  { 584, 3, 16, 7, 2, -16 },
  { 590, 4, 20, 6, 1, -16 },
  { 600, 10, 13, 13, 1, -16 },
  { 617, 10, 8, 14, 2, -14 },
  { 627, 10, 13, 13, 2, -16 },
  { 644, 10, 21, 12, 1, -21 },
  { 671, 19, 26, 22, 2, -20 },
  { 733, 15, 21, 17, 1, -21 },
  { 773, 12, 21, 16, 2, -21 },
  { 805, 13, 21, 16, 2, -21 },
  { 840, 13, 21, 17, 2, -21 },
  { 875, 11, 21, 14, 2, -21 },
  { 904, 11, 21, 14, 2, -21 },
  { 933, 13, 21, 17, 2, -21 },
  { 968, 14, 21, 18, 2, -21 },
  { 1005, 3, 21, 7, 2, -21 },
  { 1013, 11, 21, 14, 1, -21 },
  { 1042, 14, 21, 16, 2, -21 },
  { 1079, 11, 21, 14, 2, -21 },
  { 1108, 18, 21, 22, 2, -21 },
  { 1156, 14, 21, 18, 2, -21 },
  { 1193, 14, 21, 17, 2, -21 },
  { 1230, 13, 21, 16, 2, -21 },
  { 1265, 14, 24, 17, 2, -21 },
  { 1307, 13, 21, 15, 2, -21 },
  { 1342, 13, 21, 15, 1, -21 },
  { 1377, 13, 21, 15, 1, -21 },
  { 1412, 13, 21, 16, 2, -21 },
  { 1447, 15, 21, 16, 1, -21 },
  { 1487, 20, 21, 22, 1, -21 },
  { 1540, 14, 21, 16, 1, -21 },
  { 1577, 15, 21, 15, 0, -21 },
  { 1617, 13, 21, 15, 1, -21 },
  { 1652, 5, 28, 7, 2, -24 },
  { 1670, 9, 23, 11, 1, -21 },
  { 1696, 5, 28, 7, 0, -24 },
  { 1714, 9, 10, 11, 1, -21 },
  { 1726, 11, 2, 12, 0, 0 },
  { 1729, 6, 4, 9, 1, -22 },
  { 1732, 10, 16, 14, 2, -16 },
  { 1752, 11, 22, 14, 2, -22 },
  { 1783, 11, 16, 13, 1, -16 },
  { 1805, 11, 22, 14, 1, -22 },
  { 1836, 11, 16, 14, 1, -16 },
  { 1858, 8, 22, 9, 1, -22 },
  { 1880, 11, 22, 14, 1, -16 },
  { 1911, 10, 22, 14, 2, -22 },
  { 1939, 3, 22, 7, 2, -22 },
  { 1948, 5, 28, 7, 0, -22 },
  { 1966, 11, 22, 13, 2, -22 },
  { 1997, 3, 22, 7, 2, -22 },
  { 2006, 18, 16, 22, 2, -16 },
  { 2042, 10, 16, 14, 2, -16 },
  { 2062, 12, 16, 15, 1, -16 },
  { 2086, 11, 22, 14, 2, -16 },
  { 2117, 11, 22, 15, 1, -16 },
  { 2148, 6, 16, 9, 2, -16 },
  { 2160, 11, 16, 13, 1, -16 },
  { 2182, 7, 19, 9, 0, -19 },
  { 2199, 10, 16, 14, 2, -16 },
  { 2219, 11, 16, 12, 1, -16 },
  { 2241, 17, 16, 19, 1, -16 },
  { 2275, 11, 16, 13, 1, -16 },
  { 2297, 12, 22, 12, 0, -16 },
  { 2330, 11, 16, 13, 1, -16 },
  { 2352, 7, 28, 9, 1, -23 },
  { 2377, 3, 25, 7, 2, -21 },
  { 2387, 7, 28, 9, 1, -23 },
  { 2412, 13, 6, 17, 2, -12 },
};

const GFXfont RobotoCondensed_Regular29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_REGULAR29PT7B_H_
