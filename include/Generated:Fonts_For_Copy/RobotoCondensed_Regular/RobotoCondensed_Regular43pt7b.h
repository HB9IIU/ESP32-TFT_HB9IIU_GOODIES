#ifndef _ROBOTOCONDENSED_REGULAR43PT7B_H_
#define _ROBOTOCONDENSED_REGULAR43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x00, 0xEF, 0x79, 0xC0, 0xE3, 0xF1, 0xF8,
  0xFC, 0x6E, 0x37, 0x1B, 0x8D, 0x86, 0xC3, 0x61, 0x80, 0x01, 0xC1, 0x80,
  0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00,
  0xE0, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF0, 0x70, 0x60, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07,
  0x0E, 0x00, 0xC1, 0xC0, 0x38, 0x30, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x83, 0x87, 0x00, 0x60, 0xE0, 0x1C, 0x18, 0x03, 0x87, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x06, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1F, 0x80,
  0x3F, 0xF0, 0x3F, 0xFC, 0x3F, 0x7E, 0x1E, 0x0F, 0x8F, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x78, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7B, 0x80, 0x3D, 0xE0, 0x1E, 0xF8, 0x1E, 0x3F, 0x3F, 0x1F, 0xFF, 0x07,
  0xFF, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0x8E, 0x00, 0x0E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70, 0xC0, 0xE0,
  0xE3, 0x81, 0xC1, 0xC6, 0x01, 0xC7, 0x1C, 0x03, 0xFE, 0x30, 0x03, 0xF8,
  0xE0, 0x03, 0xE3, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE1, 0xE0, 0x01, 0xCF, 0xF0, 0x07, 0x1F, 0xE0, 0x0E, 0x70,
  0xE0, 0x38, 0xE1, 0xC0, 0x61, 0x81, 0x81, 0xC3, 0x03, 0x03, 0x06, 0x06,
  0x0E, 0x0C, 0x0C, 0x18, 0x1C, 0x38, 0x30, 0x38, 0x70, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0x00, 0x3E, 0x7C, 0x01, 0xE1, 0xE0, 0x1E, 0x07, 0x00, 0xF0, 0x38,
  0x07, 0x81, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x8F, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xE0, 0xE1, 0xEF, 0x87, 0x1E, 0x3C, 0x38, 0xF0, 0xF1, 0xCF, 0x07,
  0xCE, 0x78, 0x1F, 0xF3, 0xC0, 0x7F, 0x1E, 0x01, 0xF8, 0xF0, 0x0F, 0xC3,
  0xC0, 0x3C, 0x1E, 0x03, 0xF0, 0x7C, 0x7F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFE,
  0x78, 0x1F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x80, 0xC0, 0xE0,
  0xF0, 0x70, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x07,
  0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x08, 0x40,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80,
  0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x38, 0x1C, 0x0E, 0x03, 0x80, 0x40, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x06, 0x0E, 0x0B, 0xE7, 0x3D, 0xFF,
  0xFF, 0x7F, 0xFF, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF7, 0x00,
  0xF3, 0xC0, 0x70, 0xF0, 0x78, 0x78, 0x38, 0x1C, 0x04, 0x04, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x39, 0xCE, 0x73, 0xBD, 0xEE, 0xF7, 0x10, 0xFF, 0xFF, 0xFF, 0xE0, 0x67,
  0xFF, 0xF7, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xC7, 0xC3,
  0xC1, 0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x0E, 0x70, 0x07, 0xB8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0x7B,
  0x80, 0x3D, 0xC0, 0x1C, 0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x07,
  0x87, 0xC7, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x60, 0x3C,
  0x3F, 0x9F, 0xFF, 0xFF, 0xF3, 0xF8, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF8,
  0xF8, 0x78, 0x1F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1C, 0xF0, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x3E, 0x78, 0x1E,
  0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x7C, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7E, 0x3E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x78, 0x01,
  0xEF, 0x00, 0x39, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0E,
  0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF,
  0x3F, 0xFF, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7B, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE,
  0x78, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1E,
  0x7E, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0xF0, 0x03, 0xF0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF3, 0xE0, 0xF7, 0xF8, 0xFF, 0xFC,
  0xFE, 0x3E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1E,
  0x7C, 0x1E, 0x3E, 0x7C, 0x1F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xC7,
  0xC3, 0xC1, 0xE3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x03, 0xC7, 0x01, 0xE3, 0xC1, 0xE0, 0xF1, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0x0F, 0x1E, 0x03, 0xCF, 0x01, 0xE7, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x70, 0x07, 0xBC, 0x07, 0x9E,
  0x03, 0xC7, 0xC7, 0xE3, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x7C, 0x7C, 0x1E, 0x78, 0x1E, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x70, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3E, 0x7F, 0x3F, 0xF7,
  0x1F, 0xE7, 0x07, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0x00,
  0x67, 0xBF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xCF, 0x7F, 0xEE, 0x18, 0xF7, 0xCF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x3C, 0xF3, 0xCF, 0x39, 0xE7, 0xBC,
  0xF1, 0x80, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x3F, 0x03, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x80, 0xF8, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0xC7, 0xFF, 0x9F, 0xBE, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x60, 0xE0, 0x1E, 0x03, 0x8E, 0x03, 0xFC, 0x1C, 0x70, 0x3F, 0xF0, 0x63,
  0x03, 0xC3, 0x83, 0x38, 0x1C, 0x1C, 0x1D, 0xC1, 0xE0, 0xE0, 0xEE, 0x0E,
  0x07, 0x07, 0x70, 0x70, 0x30, 0x3B, 0x03, 0x83, 0x81, 0xD8, 0x38, 0x1C,
  0x0F, 0xC1, 0xC0, 0xE0, 0x7E, 0x0E, 0x07, 0x03, 0xF0, 0x70, 0x38, 0x1F,
  0x83, 0x81, 0xC0, 0xFC, 0x1C, 0x0E, 0x06, 0xE0, 0xE0, 0xF0, 0x73, 0x07,
  0x87, 0x83, 0x9C, 0x1C, 0x7C, 0x38, 0xE0, 0xFF, 0x7F, 0x87, 0x03, 0xF3,
  0xFC, 0x38, 0x0F, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x01, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3B,
  0x80, 0x00, 0xF7, 0x00, 0x01, 0xEF, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x1C,
  0x00, 0x1E, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xF0,
  0x03, 0x81, 0xE0, 0x0F, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x70, 0x07, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x00, 0xE3, 0xC0,
  0x01, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x80, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0xFC, 0xF0, 0x0F, 0xBC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x00, 0x7B,
  0xC0, 0x3C, 0xF0, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xFC, 0xF0,
  0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x7B,
  0xC0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x87, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0xDE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7C, 0xF0,
  0x0F, 0x1F, 0x87, 0xE1, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x3F, 0x8F, 0x00, 0xF9, 0xE0,
  0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xDE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00,
  0xF3, 0xC0, 0x3E, 0x78, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFE, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x87, 0xE7, 0xC0, 0x3C, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x78, 0x00, 0xEF, 0x00, 0x1C, 0xF0,
  0x07, 0x9F, 0xC7, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0x3C, 0x07, 0x9F, 0x07, 0xC7, 0xC7, 0xC3, 0xFF, 0xC0, 0xFF,
  0xC0, 0x1F, 0x80, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00,
  0xF8, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F,
  0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xEF, 0x00,
  0xFC, 0xF8, 0x0F, 0x87, 0x80, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E,
  0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00,
  0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x77, 0xFF, 0x00, 0x1D, 0xFD, 0xC0, 0x0F, 0x7F, 0x78, 0x03, 0xDF, 0xDE,
  0x00, 0xE7, 0xF3, 0x80, 0x79, 0xFC, 0xF0, 0x1E, 0xFF, 0x3C, 0x07, 0x3F,
  0xC7, 0x03, 0xCF, 0xF1, 0xC0, 0xF3, 0xFC, 0x78, 0x38, 0xFF, 0x0E, 0x1E,
  0x3F, 0xC3, 0x87, 0x8F, 0xF0, 0xF1, 0xC3, 0xFC, 0x1C, 0xF0, 0xFF, 0x07,
  0x3C, 0x3F, 0xC1, 0xEE, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF,
  0x03, 0xF0, 0x3F, 0xC0, 0x7C, 0x0F, 0xF0, 0x1F, 0x03, 0xFC, 0x07, 0x80,
  0xFF, 0x00, 0xE0, 0x3C, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xF7, 0x80, 0xFF, 0x78, 0x0F, 0xF3, 0xC0, 0xFF, 0x3C, 0x0F, 0xF1, 0xE0,
  0xFF, 0x1E, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0x78, 0xFF, 0x07,
  0x8F, 0xF0, 0x3C, 0xFF, 0x01, 0xCF, 0xF0, 0x1E, 0xFF, 0x00, 0xEF, 0xF0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x01, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xF9, 0xFC, 0x3C, 0x07, 0xC7, 0x80,
  0x1E, 0x78, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xF9, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x78,
  0x0F, 0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xF7, 0x80, 0x7E, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF,
  0xF0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xBF, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0xF9, 0xF0, 0x03,
  0xCF, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x00,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E, 0x7C, 0x00, 0xF1,
  0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x3F, 0x9F, 0xC0, 0xFF, 0xFC, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0x40, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x78, 0x1F, 0xCF, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79,
  0xE0, 0x1F, 0x3C, 0x0F, 0xC7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0x78, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF3,
  0xC0, 0x0E, 0x70, 0x01, 0xEF, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xBC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xDF, 0x00, 0x79, 0xF0, 0x1F, 0x1F,
  0x8F, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0E,
  0xF0, 0x03, 0xDE, 0x00, 0x79, 0xE0, 0x1F, 0x3F, 0x0F, 0xC3, 0xFF, 0xF0,
  0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07,
  0x80, 0x78, 0x0F, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xC0,
  0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xF1, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x03, 0x80, 0x1E, 0xF0,
  0x07, 0x80, 0x39, 0xE0, 0x1F, 0x00, 0xF3, 0xC0, 0x3E, 0x01, 0xE7, 0x80,
  0x7C, 0x03, 0xC7, 0x00, 0xF8, 0x07, 0x8F, 0x01, 0xF8, 0x0E, 0x1E, 0x07,
  0xF0, 0x3C, 0x3C, 0x0E, 0xE0, 0x78, 0x78, 0x1D, 0xC0, 0xF0, 0x70, 0x3B,
  0xC1, 0xE0, 0xE0, 0xF3, 0x83, 0x81, 0xE1, 0xC7, 0x07, 0x03, 0xC3, 0x8E,
  0x1E, 0x07, 0x87, 0x1C, 0x3C, 0x07, 0x0E, 0x1C, 0x78, 0x0E, 0x38, 0x38,
  0xE0, 0x1C, 0x70, 0x71, 0xC0, 0x3C, 0xE0, 0xE3, 0x80, 0x79, 0xC1, 0xEF,
  0x00, 0x77, 0x81, 0xDE, 0x00, 0xEE, 0x03, 0xB8, 0x01, 0xDC, 0x07, 0x70,
  0x03, 0xB8, 0x0E, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xFB, 0xE0,
  0x07, 0x8F, 0x00, 0x7C, 0x7C, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x81, 0xE0,
  0x3C, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x78, 0x00, 0xF3,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3C, 0xF0, 0x03, 0xE7, 0x80, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0x78, 0x7C, 0x03, 0xE3, 0xC0, 0x0F,
  0x3E, 0x00, 0x7D, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0x9E,
  0x00, 0x7C, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x0F,
  0x1E, 0x00, 0x79, 0xE0, 0x01, 0xCF, 0x00, 0x0F, 0x70, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xFF, 0xFC, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x7F, 0x83, 0x9C, 0x1C, 0xE1, 0xE7,
  0x8E, 0x1C, 0x70, 0xE7, 0x87, 0xB8, 0x1D, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x07, 0xF0,
  0x0F, 0xFC, 0x3F, 0xFC, 0x3E, 0x3E, 0x78, 0x1E, 0x78, 0x0F, 0x78, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x03, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x0F,
  0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F,
  0x7E, 0x7F, 0x7F, 0xFF, 0x3F, 0xEF, 0x0F, 0x8F, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF3, 0xF0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFE, 0x7E, 0xF8, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1E, 0xFC, 0x7E, 0xEF, 0xFC, 0xE7, 0xF8, 0xE3, 0xF0,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFE, 0x3E, 0x3E, 0x78, 0x0F, 0x78, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0x78, 0x0F,
  0x78, 0x0F, 0x3E, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x07, 0xC7, 0x1F, 0xF7, 0x3F, 0xFF, 0x7F, 0x3F,
  0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x78, 0x0F, 0x78, 0x0F, 0x7E, 0x3F, 0x3F, 0xFF, 0x1F, 0xF7,
  0x07, 0xC7, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x3E, 0x78, 0x1E,
  0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x02, 0x78, 0x06, 0x3E, 0x1F, 0x3F, 0xFF, 0x1F, 0xFC, 0x03, 0xF0,
  0x01, 0xF0, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x07, 0xC7, 0x1F, 0xF7, 0x3F, 0xFF, 0x7F, 0x3F, 0x78, 0x0F, 0x78, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78, 0x0F,
  0x78, 0x0F, 0x7F, 0x3F, 0x3F, 0xFF, 0x1F, 0xF7, 0x07, 0xC7, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x30, 0x1F, 0x3C, 0x3E, 0x3F, 0xFE,
  0x1F, 0xF8, 0x07, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE7, 0xE3, 0xDF,
  0xE7, 0xFF, 0xEF, 0xE7, 0xDF, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xF6, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x3C, 0x78, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xE3, 0xDF, 0xBE, 0x78, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1,
  0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0xFB, 0xC0, 0xFB, 0xC0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0,
  0xF8, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7E, 0x1D, 0xFF, 0x1F, 0xE3, 0xFF, 0xF7,
  0xFE, 0x7E, 0x3F, 0xE7, 0xEF, 0x03, 0xF0, 0x3D, 0xE0, 0x3E, 0x07, 0xBC,
  0x07, 0x80, 0x77, 0x80, 0xF0, 0x0F, 0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xC0,
  0x3F, 0xC0, 0x78, 0x07, 0xF8, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x1F, 0xE0,
  0x3C, 0x03, 0xFC, 0x07, 0x80, 0x7F, 0x80, 0xF0, 0x0F, 0xF0, 0x1E, 0x01,
  0xFE, 0x03, 0xC0, 0x3F, 0xC0, 0x78, 0x07, 0xF8, 0x0F, 0x00, 0xFF, 0x01,
  0xE0, 0x1F, 0xE0, 0x3C, 0x03, 0xFC, 0x07, 0x80, 0x78, 0xE3, 0xF1, 0xCF,
  0xF3, 0xBF, 0xF7, 0xF3, 0xEF, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xF8, 0xFC, 0x7C, 0x0F, 0x1E, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0,
  0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x07, 0x9E, 0x01, 0xE7, 0xC0, 0xF0,
  0xF8, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xE3, 0xF0, 0xEF,
  0xF8, 0xEF, 0xFC, 0xFE, 0x7E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xFC,
  0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xF3, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x07, 0xC7, 0x1F, 0xF7, 0x3F, 0xFF, 0x7E, 0x3F, 0x78, 0x0F, 0x78,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78,
  0x07, 0x78, 0x0F, 0x7E, 0x3F, 0x3F, 0xFF, 0x1F, 0xF7, 0x07, 0xC7, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0xE3, 0xF7, 0xFB, 0xFF, 0xFF, 0x87, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x7C, 0x7C, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x78, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1E, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x7C, 0x3E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x80, 0xFC, 0x1F, 0x81, 0xF0, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFB, 0xE7, 0xF7, 0xFF, 0xE7,
  0xFF, 0xC7, 0xE7, 0x80, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0E,
  0x78, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C,
  0x1C, 0x38, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0x70,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xE7, 0x01, 0xE0, 0x39,
  0xC0, 0x78, 0x1E, 0x78, 0x3F, 0x07, 0x9E, 0x0F, 0xC1, 0xE3, 0x83, 0xF0,
  0x70, 0xE1, 0xFC, 0x1C, 0x3C, 0x77, 0x8F, 0x0F, 0x1C, 0xE3, 0xC1, 0xC7,
  0x38, 0xE0, 0x73, 0xCE, 0x38, 0x1C, 0xE3, 0xCE, 0x07, 0xB8, 0x77, 0x80,
  0xEE, 0x1D, 0xC0, 0x3F, 0x87, 0x70, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x00, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x07, 0x87,
  0x83, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x39, 0xE0, 0x1E, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x83, 0xC7,
  0xC1, 0xE3, 0xC0, 0x7B, 0xE0, 0x3C, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70,
  0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x70, 0x3C, 0x1E, 0x0F,
  0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC1, 0xF0, 0xF8, 0x3C, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x1F, 0x01, 0xC0, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xC0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7E, 0x03, 0xC1, 0xF8, 0x7C, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x18, 0x00, 0x1F,
  0x00, 0x03, 0xF8, 0x07, 0x7F, 0xE0, 0xFF, 0xBF, 0x0E, 0xE0, 0xFF, 0xEE,
  0x07, 0xFC, 0xE0, 0x3F, 0xC0, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 31, 11, 3, -31 },
  { 21, 9, 10, 14, 3, -32 },
  { 33, 19, 31, 24, 3, -31 },
  { 107, 17, 40, 21, 2, -36 },
  { 192, 23, 31, 27, 2, -31 },
  { 282, 21, 31, 23, 2, -31 },
  { 364, 3, 10, 8, 2, -32 },
  { 368, 9, 45, 14, 3, -35 },
  { 419, 10, 45, 14, 1, -35 },
  { 476, 17, 18, 19, 1, -31 },
  { 515, 17, 23, 21, 2, -26 },
  { 564, 5, 11, 8, 1, -5 },
  { 571, 9, 3, 11, 1, -14 },
  { 575, 5, 5, 11, 3, -5 },
  { 579, 14, 34, 16, 1, -31 },
  { 639, 17, 31, 21, 2, -31 },
  { 705, 11, 31, 21, 3, -31 },
  { 748, 18, 31, 21, 2, -31 },
  { 818, 16, 31, 21, 2, -31 },
  { 880, 19, 31, 21, 1, -31 },
  { 954, 16, 31, 21, 3, -31 },
  { 1016, 16, 31, 21, 3, -31 },
  { 1078, 17, 31, 21, 2, -31 },
  { 1144, 17, 31, 21, 2, -31 },
  { 1210, 16, 31, 21, 2, -31 },
  { 1272, 5, 24, 10, 3, -24 },
  { 1287, 6, 30, 9, 1, -24 },
  { 1310, 14, 19, 19, 2, -23 },
  { 1344, 15, 11, 21, 3, -20 },
  { 1365, 15, 19, 20, 3, -23 },
  { 1401, 14, 31, 18, 2, -31 },
  { 1456, 29, 40, 33, 2, -30 },
  { 1601, 23, 31, 25, 1, -31 },
  { 1691, 18, 31, 23, 3, -31 },
  { 1761, 19, 31, 24, 3, -31 },
  { 1835, 19, 31, 25, 3, -31 },
  { 1909, 17, 31, 21, 3, -31 },
  { 1975, 16, 31, 21, 3, -31 },
  { 2037, 19, 31, 25, 3, -31 },
  { 2111, 20, 31, 27, 3, -31 },
  { 2189, 4, 31, 11, 3, -31 },
  { 2205, 17, 31, 21, 1, -31 },
  { 2271, 20, 31, 23, 3, -31 },
  { 2349, 16, 31, 20, 3, -31 },
  { 2411, 26, 31, 32, 3, -31 },
  { 2512, 20, 31, 27, 3, -31 },
  { 2590, 20, 31, 26, 3, -31 },
  { 2668, 19, 31, 24, 3, -31 },
  { 2742, 21, 36, 26, 2, -31 },
  { 2837, 19, 31, 23, 3, -31 },
  { 2911, 19, 31, 22, 2, -31 },
  { 2985, 20, 31, 22, 1, -31 },
  { 3063, 19, 31, 24, 3, -31 },
  { 3137, 22, 31, 24, 1, -31 },
  { 3223, 31, 31, 33, 1, -31 },
  { 3344, 21, 31, 24, 1, -31 },
  { 3426, 21, 31, 23, 1, -31 },
  { 3508, 19, 31, 22, 2, -31 },
  { 3582, 7, 42, 11, 3, -35 },
  { 3619, 14, 34, 16, 1, -31 },
  { 3679, 7, 42, 11, 1, -35 },
  { 3716, 13, 15, 16, 1, -31 },
  { 3741, 16, 3, 17, 1, 0 },
  { 3747, 9, 6, 13, 1, -32 },
  { 3754, 16, 23, 21, 2, -23 },
  { 3800, 16, 32, 21, 3, -32 },
  { 3864, 16, 23, 20, 2, -23 },
  { 3910, 16, 32, 21, 2, -32 },
  { 3974, 16, 23, 20, 2, -23 },
  { 4020, 12, 32, 14, 1, -32 },
  { 4068, 16, 32, 21, 2, -23 },
  { 4132, 15, 32, 21, 3, -32 },
  { 4192, 4, 31, 10, 3, -31 },
  { 4208, 7, 40, 10, 0, -31 },
  { 4243, 16, 32, 19, 3, -32 },
  { 4307, 4, 32, 10, 3, -32 },
  { 4323, 27, 23, 32, 3, -23 },
  { 4401, 15, 23, 21, 3, -23 },
  { 4445, 18, 23, 22, 2, -23 },
  { 4497, 16, 32, 21, 3, -23 },
  { 4561, 16, 32, 22, 2, -23 },
  { 4625, 9, 23, 13, 3, -23 },
  { 4651, 16, 23, 20, 2, -23 },
  { 4697, 11, 28, 13, 0, -28 },
  { 4736, 15, 23, 21, 3, -23 },
  { 4780, 16, 23, 18, 1, -23 },
  { 4826, 26, 23, 28, 1, -23 },
  { 4901, 17, 23, 19, 1, -23 },
  { 4950, 16, 32, 18, 1, -23 },
  { 5014, 15, 23, 19, 2, -23 },
  { 5058, 10, 42, 13, 2, -34 },
  { 5111, 3, 37, 11, 4, -31 },
  { 5125, 11, 42, 13, 1, -34 },
  { 5183, 20, 8, 25, 3, -16 },
};

const GFXfont RobotoCondensed_Regular43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_REGULAR43PT7B_H_
