#ifndef _ROBOTOCONDENSED_REGULAR17PT7B_H_
#define _ROBOTOCONDENSED_REGULAR17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x0F, 0xBB, 0xAA, 0x12, 0x12, 0x12, 0x16, 0x7F, 0x24,
  0x24, 0xFE, 0x24, 0x2C, 0x68, 0x48, 0x10, 0x43, 0x9B, 0xC7, 0x14, 0x1C,
  0x1C, 0x18, 0x71, 0xCD, 0xE1, 0x04, 0x60, 0x49, 0x24, 0x92, 0x89, 0x43,
  0x40, 0x2C, 0x29, 0x14, 0x92, 0x49, 0x20, 0x60, 0x38, 0x6C, 0x4C, 0x4C,
  0x78, 0x30, 0x72, 0xDA, 0x8E, 0x86, 0xCE, 0x7B, 0xF0, 0x12, 0x24, 0x4C,
  0xCC, 0xCC, 0xCC, 0xC4, 0x42, 0x21, 0x84, 0x62, 0x33, 0x11, 0x11, 0x11,
  0x33, 0x22, 0x48, 0x10, 0x23, 0x5B, 0xE3, 0x85, 0x81, 0x00, 0x30, 0x60,
  0xC1, 0x8F, 0xE6, 0x0C, 0x18, 0x30, 0x6D, 0x60, 0xF0, 0xF0, 0x0C, 0x20,
  0x86, 0x10, 0x43, 0x08, 0x21, 0x84, 0x10, 0xC0, 0x79, 0x3C, 0x61, 0x86,
  0x18, 0x61, 0xC7, 0x14, 0xDE, 0x17, 0xD1, 0x11, 0x11, 0x11, 0x11, 0x79,
  0x9A, 0x14, 0x20, 0x41, 0x86, 0x08, 0x20, 0xC3, 0x07, 0xF0, 0x7B, 0x38,
  0x41, 0x0C, 0xE0, 0xC1, 0x06, 0x1C, 0xDE, 0x06, 0x0E, 0x0E, 0x16, 0x36,
  0x26, 0x66, 0x46, 0xFF, 0x06, 0x06, 0x06, 0x7C, 0x81, 0x02, 0x07, 0x8D,
  0x81, 0x83, 0x07, 0x8D, 0x31, 0xC0, 0x18, 0xE1, 0x06, 0x0F, 0x9D, 0xB1,
  0x63, 0xC7, 0x89, 0xB1, 0xC0, 0xFE, 0x08, 0x10, 0x60, 0x83, 0x06, 0x08,
  0x30, 0x40, 0x83, 0x00, 0x79, 0x3C, 0x71, 0x4D, 0xEC, 0xF1, 0x87, 0x1C,
  0xDE, 0x7B, 0x3C, 0xE1, 0x87, 0x1C, 0xDD, 0x04, 0x31, 0x9C, 0xF0, 0x03,
  0xC0, 0x6C, 0x00, 0x03, 0x6B, 0x00, 0x09, 0xD9, 0x06, 0x1C, 0x20, 0xFC,
  0x00, 0x3F, 0x83, 0x83, 0x81, 0x3B, 0x88, 0x00, 0x76, 0xE2, 0x11, 0x88,
  0x84, 0x00, 0x08, 0x40, 0x0F, 0x06, 0x10, 0x81, 0x20, 0x14, 0x73, 0x12,
  0x66, 0x4C, 0x89, 0x91, 0x32, 0x66, 0x6D, 0xC6, 0xE4, 0x00, 0x80, 0x0C,
  0x40, 0xF8, 0x0C, 0x06, 0x07, 0x02, 0xC1, 0x21, 0x90, 0xCC, 0x42, 0x7F,
  0x30, 0xD0, 0x68, 0x10, 0xFD, 0x8F, 0x0E, 0x3C, 0x7F, 0xB1, 0xE1, 0xC3,
  0x87, 0x1F, 0xE0, 0x3C, 0x66, 0xC3, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3,
  0xC3, 0x66, 0x3C, 0xF8, 0xCE, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC2, 0xCE, 0xF8, 0xFF, 0x83, 0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0x83,
  0x07, 0xF0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0x60, 0xC1, 0x83, 0x06,
  0x00, 0x3C, 0x66, 0xC3, 0xC3, 0xC0, 0xC0, 0xCF, 0xC3, 0xC3, 0xC3, 0x67,
  0x3E, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xFF, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xC6,
  0x8D, 0xB9, 0xE0, 0xC3, 0xC6, 0xCC, 0xC8, 0xD8, 0xF0, 0xF8, 0xC8, 0xCC,
  0xC6, 0xC6, 0xC3, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x07, 0xF0, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0xFF, 0x1F, 0xA2, 0xF4, 0xDE,
  0xDB, 0xCA, 0x79, 0x4F, 0x39, 0xE2, 0x30, 0xC1, 0xE1, 0xE1, 0xF1, 0xD1,
  0xD9, 0xC9, 0xCD, 0xC5, 0xC7, 0xC3, 0xC3, 0x3C, 0x66, 0xC3, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0x66, 0x3C, 0xFC, 0xC6, 0xC3, 0xC3, 0xC3,
  0xC6, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x66, 0xC3, 0xC3, 0x81,
  0x81, 0x81, 0x81, 0xC3, 0xC3, 0x66, 0x3E, 0x03, 0x01, 0xFC, 0xC6, 0xC2,
  0xC2, 0xC2, 0xC6, 0xFC, 0xCC, 0xC4, 0xC6, 0xC6, 0xC3, 0x39, 0xDB, 0x1E,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0x87, 0x99, 0xE0, 0xFF, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x66, 0x3C, 0x41, 0xA0, 0xD8, 0x4C,
  0x22, 0x31, 0x90, 0xC8, 0x2C, 0x16, 0x0E, 0x03, 0x01, 0x80, 0x84, 0x28,
  0x62, 0xCE, 0x2C, 0xA6, 0xCA, 0x64, 0xA4, 0x5B, 0x45, 0x14, 0x71, 0xC7,
  0x1C, 0x31, 0x82, 0x08, 0xC2, 0xC6, 0x64, 0x2C, 0x38, 0x18, 0x38, 0x38,
  0x6C, 0x66, 0xC6, 0xC3, 0xC1, 0x31, 0x98, 0xC4, 0xC3, 0x60, 0xA0, 0x70,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFE, 0x0C, 0x10, 0x61, 0x82, 0x0C,
  0x10, 0x60, 0x83, 0x07, 0xF0, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xE0,
  0x41, 0x06, 0x08, 0x20, 0xC1, 0x04, 0x18, 0x20, 0x83, 0x04, 0xE4, 0x92,
  0x49, 0x24, 0x92, 0x49, 0xE0, 0x63, 0x1D, 0xA9, 0x4C, 0xFE, 0x63, 0x7B,
  0x3C, 0xC3, 0x7F, 0x38, 0xF3, 0x74, 0xC1, 0x83, 0x06, 0x0F, 0x99, 0xB1,
  0x63, 0xC7, 0x8F, 0x16, 0x6B, 0x80, 0x7B, 0x38, 0x60, 0x82, 0x08, 0x73,
  0x78, 0x04, 0x10, 0x41, 0x77, 0x38, 0x61, 0x86, 0x18, 0x73, 0x74, 0x7B,
  0x38, 0x61, 0xFE, 0x08, 0x31, 0x78, 0x36, 0x44, 0xF4, 0x44, 0x44, 0x44,
  0x40, 0x77, 0x38, 0x61, 0x86, 0x18, 0x73, 0x74, 0x14, 0xDE, 0xC3, 0x0C,
  0x30, 0xFB, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xC4, 0xF0, 0xFF, 0xFF, 0xC0,
  0x4C, 0x06, 0xDB, 0x6D, 0xB6, 0xD6, 0xC1, 0x83, 0x06, 0x0C, 0xDB, 0x34,
  0x70, 0xF1, 0xA3, 0x66, 0x6C, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0xF9, 0xD9,
  0xCB, 0x11, 0xE2, 0x3C, 0x47, 0x88, 0xF1, 0x1E, 0x23, 0xC4, 0x60, 0xFB,
  0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xC4, 0x79, 0x9B, 0x1C, 0x38, 0x70, 0xF1,
  0xE6, 0x78, 0xB9, 0x9B, 0x16, 0x3C, 0x78, 0xF1, 0x66, 0xF9, 0x83, 0x06,
  0x00, 0x77, 0x38, 0x61, 0x86, 0x18, 0x73, 0x74, 0x10, 0x41, 0xFE, 0xCC,
  0xCC, 0xCC, 0xC0, 0x7B, 0x3C, 0xF0, 0x78, 0x38, 0xF3, 0x78, 0x22, 0xF2,
  0x22, 0x22, 0x22, 0x30, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0x74, 0x46,
  0x89, 0x93, 0x62, 0xC5, 0x0E, 0x0C, 0x10, 0x44, 0x48, 0x89, 0x39, 0x35,
  0x62, 0xAC, 0x77, 0x0C, 0x61, 0x8C, 0x31, 0x80, 0x46, 0xC8, 0xB1, 0xC1,
  0x87, 0x0B, 0x32, 0x46, 0xC6, 0x89, 0x93, 0x62, 0x85, 0x0E, 0x08, 0x10,
  0x20, 0xC3, 0x00, 0xFC, 0x21, 0x84, 0x21, 0x84, 0x30, 0xFC, 0x12, 0x66,
  0x66, 0x4C, 0xC4, 0x46, 0x66, 0x23, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x08,
  0x42, 0x10, 0x86, 0x19, 0x08, 0x42, 0x11, 0x98, 0x71, 0xDB, 0x8E,
};

const GFXglyph RobotoCondensed_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 4, 4, 5, 1, -13 },
  { 6, 8, 12, 9, 1, -12 },
  { 18, 6, 16, 8, 1, -14 },
  { 30, 9, 12, 11, 1, -12 },
  { 44, 8, 12, 9, 1, -12 },
  { 56, 1, 4, 3, 1, -13 },
  { 57, 4, 18, 5, 1, -14 },
  { 66, 4, 18, 5, 0, -14 },
  { 75, 7, 7, 7, 0, -12 },
  { 82, 7, 9, 8, 1, -10 },
  { 90, 3, 4, 3, 0, -2 },
  { 92, 4, 1, 4, 0, -6 },
  { 93, 2, 2, 4, 1, -2 },
  { 94, 6, 13, 6, 0, -12 },
  { 104, 6, 12, 8, 1, -12 },
  { 113, 4, 12, 8, 1, -12 },
  { 119, 7, 12, 8, 1, -12 },
  { 130, 6, 12, 8, 1, -12 },
  { 139, 8, 12, 8, 0, -12 },
  { 151, 7, 12, 8, 1, -12 },
  { 162, 7, 12, 8, 1, -12 },
  { 173, 7, 12, 8, 1, -12 },
  { 184, 6, 12, 8, 1, -12 },
  { 193, 6, 12, 8, 1, -12 },
  { 202, 2, 9, 4, 1, -9 },
  { 205, 3, 11, 3, 0, -9 },
  { 210, 5, 7, 8, 1, -9 },
  { 215, 6, 4, 8, 1, -8 },
  { 218, 6, 7, 8, 1, -9 },
  { 224, 5, 12, 7, 1, -12 },
  { 232, 11, 16, 13, 1, -12 },
  { 254, 9, 12, 10, 0, -12 },
  { 268, 7, 12, 9, 1, -12 },
  { 279, 8, 12, 10, 1, -12 },
  { 291, 8, 12, 10, 1, -12 },
  { 303, 7, 12, 8, 1, -12 },
  { 314, 7, 12, 8, 1, -12 },
  { 325, 8, 12, 10, 1, -12 },
  { 337, 8, 12, 11, 1, -12 },
  { 349, 2, 12, 4, 1, -12 },
  { 352, 7, 12, 8, 0, -12 },
  { 363, 8, 12, 9, 1, -12 },
  { 375, 7, 12, 8, 1, -12 },
  { 386, 11, 12, 13, 1, -12 },
  { 403, 8, 12, 11, 1, -12 },
  { 415, 8, 12, 10, 1, -12 },
  { 427, 8, 12, 9, 1, -12 },
  { 439, 8, 14, 10, 1, -12 },
  { 453, 8, 12, 9, 1, -12 },
  { 465, 7, 12, 9, 1, -12 },
  { 476, 8, 12, 9, 0, -12 },
  { 488, 8, 12, 10, 1, -12 },
  { 500, 9, 12, 10, 0, -12 },
  { 514, 12, 12, 13, 1, -12 },
  { 532, 8, 12, 9, 1, -12 },
  { 544, 9, 12, 9, 0, -12 },
  { 558, 7, 12, 9, 1, -12 },
  { 569, 3, 17, 4, 1, -14 },
  { 576, 6, 13, 6, 0, -12 },
  { 586, 3, 17, 4, 0, -14 },
  { 593, 5, 6, 6, 1, -12 },
  { 597, 7, 1, 7, 0, 0 },
  { 598, 4, 2, 5, 0, -12 },
  { 599, 6, 9, 8, 1, -9 },
  { 606, 7, 13, 8, 1, -13 },
  { 618, 6, 9, 8, 1, -9 },
  { 625, 6, 13, 8, 1, -13 },
  { 635, 6, 9, 8, 1, -9 },
  { 642, 4, 13, 5, 1, -13 },
  { 649, 6, 12, 8, 1, -9 },
  { 658, 6, 13, 8, 1, -13 },
  { 668, 2, 13, 4, 1, -13 },
  { 672, 3, 16, 4, 0, -13 },
  { 678, 7, 13, 8, 1, -13 },
  { 690, 2, 13, 4, 1, -13 },
  { 694, 11, 9, 13, 1, -9 },
  { 707, 6, 9, 8, 1, -9 },
  { 714, 7, 9, 9, 1, -9 },
  { 722, 7, 12, 8, 1, -9 },
  { 733, 6, 12, 9, 1, -9 },
  { 742, 4, 9, 5, 1, -9 },
  { 747, 6, 9, 8, 1, -9 },
  { 754, 4, 11, 5, 0, -11 },
  { 760, 6, 9, 8, 1, -9 },
  { 767, 7, 9, 7, 0, -9 },
  { 775, 11, 9, 11, 0, -9 },
  { 788, 7, 9, 7, 0, -9 },
  { 796, 7, 12, 7, 0, -9 },
  { 807, 6, 9, 7, 1, -9 },
  { 814, 4, 16, 5, 1, -13 },
  { 822, 2, 14, 4, 1, -12 },
  { 826, 5, 16, 5, 0, -13 },
  { 836, 8, 3, 10, 1, -6 },
};

const GFXfont RobotoCondensed_Regular17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_REGULAR17PT7B_H_
