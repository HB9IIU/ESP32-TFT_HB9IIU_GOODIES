#ifndef _ROBOTOCONDENSED_REGULAR27PT7B_H_
#define _ROBOTOCONDENSED_REGULAR27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF6, 0xDB, 0x6C, 0x00, 0xDF, 0x00, 0xDE, 0xF7, 0xB9,
  0xCE, 0x60, 0x0C, 0x60, 0xC6, 0x0C, 0x40, 0xCC, 0x0C, 0xC7, 0xFF, 0x7F,
  0xF1, 0x8C, 0x18, 0x81, 0x98, 0x19, 0x81, 0x18, 0xFF, 0xEF, 0xFE, 0x31,
  0x03, 0x30, 0x33, 0x02, 0x30, 0x63, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x07,
  0x83, 0xF8, 0x73, 0x9C, 0x33, 0x07, 0x60, 0xEE, 0x00, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x70, 0x07, 0xE0, 0x6C, 0x0D, 0x83, 0xB8, 0xE3, 0xFC,
  0x3E, 0x01, 0x80, 0x30, 0x3C, 0x00, 0xF8, 0x01, 0x18, 0x06, 0x31, 0x8C,
  0x62, 0x18, 0xCC, 0x11, 0xB0, 0x3E, 0x60, 0x3D, 0x80, 0x03, 0x00, 0x0C,
  0xE0, 0x13, 0xE0, 0x6C, 0x60, 0x98, 0xC3, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x00, 0xF8, 0x00, 0xE0, 0x0F, 0x01, 0xFC, 0x0E, 0x70, 0x61, 0x83, 0x0C,
  0x18, 0xE0, 0xEE, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0D, 0x8C, 0xEE, 0x6E,
  0x3B, 0x70, 0xFB, 0x83, 0xCC, 0x1C, 0x71, 0xF1, 0xFF, 0x87, 0xCE, 0xFF,
  0xF0, 0x04, 0x31, 0x8C, 0x31, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x38, 0x61, 0x86, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x0E,
  0x18, 0x30, 0xC3, 0x86, 0x18, 0x61, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0x86, 0x18, 0xE3, 0x0C, 0x61, 0x0C, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x23,
  0x17, 0xFE, 0x7F, 0x83, 0x80, 0xF8, 0x19, 0x86, 0x38, 0x42, 0x00, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x3F, 0xFF, 0xFF, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x33, 0x33, 0x76, 0x40, 0xFF,
  0xC0, 0xFF, 0x80, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C,
  0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18,
  0x0C, 0x06, 0x00, 0x3E, 0x1F, 0xCE, 0x3B, 0x06, 0xC1, 0xB0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1B, 0x86, 0x63,
  0x9F, 0xC3, 0xE0, 0x04, 0x7F, 0xFB, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x6E,
  0x0F, 0xC1, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0x07, 0xF1,
  0xC7, 0x30, 0x6E, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x0F, 0x81, 0xF0, 0x07,
  0x00, 0x60, 0x0C, 0x01, 0xF8, 0x37, 0x06, 0x71, 0xC7, 0xF0, 0x7C, 0x00,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0xD8, 0x1D, 0x81, 0x98,
  0x39, 0x83, 0x18, 0x71, 0x86, 0x18, 0xE1, 0x8F, 0xFF, 0xFF, 0xF0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x7F, 0xDF, 0xF6, 0x01, 0x80, 0x60, 0x18,
  0x07, 0xE1, 0xFE, 0x63, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x3C, 0x0F,
  0x87, 0x63, 0x9F, 0xE1, 0xE0, 0x0F, 0x07, 0xC3, 0x81, 0xC0, 0x60, 0x38,
  0x0D, 0xE3, 0xFE, 0xF3, 0xB8, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F,
  0x87, 0x73, 0x8F, 0xC1, 0xE0, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x00, 0x3E, 0x1F, 0xCE, 0x3B,
  0x86, 0xC1, 0xB0, 0x6C, 0x19, 0x8E, 0x7F, 0x1F, 0xCE, 0x3B, 0x06, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xE3, 0x9F, 0xC3, 0xE0, 0x1E, 0x07, 0xF1, 0xC6,
  0x30, 0xE6, 0x0D, 0xC1, 0xB8, 0x3F, 0x07, 0x60, 0xEC, 0x1D, 0xC7, 0x9F,
  0xE1, 0xEC, 0x01, 0x80, 0x70, 0x0C, 0x07, 0x83, 0xE0, 0x70, 0x00, 0xDF,
  0x80, 0x00, 0x00, 0x0D, 0xF8, 0x67, 0x60, 0x00, 0x00, 0x00, 0x00, 0x66,
  0x66, 0xEC, 0x80, 0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x86, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x70, 0x3E, 0x07, 0x80, 0xF0, 0x1C, 0x0E, 0x1E, 0x3C, 0x7C,
  0x38, 0x10, 0x00, 0x1E, 0x3F, 0x9C, 0xFC, 0x3C, 0x18, 0x0C, 0x06, 0x06,
  0x07, 0x07, 0x03, 0x03, 0x81, 0x80, 0x00, 0x00, 0x00, 0x08, 0x0E, 0x06,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x38, 0x1C, 0x0E, 0x00, 0xC1, 0x80,
  0x18, 0x60, 0x01, 0x0C, 0x3C, 0x33, 0x0F, 0xC6, 0x61, 0x98, 0x4C, 0x63,
  0x09, 0x0C, 0x61, 0x21, 0x8C, 0x24, 0x61, 0x85, 0x8C, 0x30, 0x91, 0x86,
  0x12, 0x30, 0xC6, 0x63, 0x38, 0x8C, 0x7F, 0xF1, 0x87, 0x3C, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xF0,
  0x00, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0D, 0x80, 0x37, 0x00,
  0xCC, 0x07, 0x30, 0x18, 0xE0, 0x61, 0x83, 0x86, 0x0C, 0x1C, 0x3F, 0xF1,
  0xFF, 0xC6, 0x03, 0x98, 0x0E, 0xE0, 0x1B, 0x80, 0x7C, 0x01, 0xC0, 0xFF,
  0x1F, 0xFB, 0x87, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xFF, 0x9F,
  0xFB, 0x83, 0x70, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE1, 0xFF, 0xFB,
  0xFC, 0x00, 0x0F, 0x83, 0xFC, 0x70, 0xEE, 0x07, 0xE0, 0x7C, 0x03, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0xE0,
  0x7E, 0x07, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x0F, 0xF8, 0xE1, 0xCE,
  0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE1, 0xCF, 0xF8, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xBF,
  0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0xEF, 0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC3, 0xFC, 0x3F, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03,
  0x70, 0x73, 0xFE, 0x0F, 0x80, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xF0, 0x3C, 0x0F, 0x87, 0x73, 0x9F, 0xE1, 0xE0, 0xE0, 0x77, 0x07, 0x38,
  0x71, 0xC3, 0x8E, 0x38, 0x73, 0x83, 0x98, 0x1D, 0xC0, 0xFC, 0x07, 0xF0,
  0x3D, 0x81, 0xCE, 0x0E, 0x38, 0x71, 0xC3, 0x87, 0x1C, 0x18, 0xE0, 0xE7,
  0x03, 0xB8, 0x1C, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3F, 0xFF, 0xFC, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xD8, 0x1F, 0xD8, 0x1B, 0xDC, 0x1B, 0xCC, 0x3B, 0xCC, 0x33, 0xCE,
  0x33, 0xC6, 0x73, 0xC6, 0x63, 0xC7, 0x63, 0xC3, 0x63, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC1, 0xC3, 0xC1, 0x83, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F,
  0x83, 0xFC, 0x1F, 0xB0, 0xFD, 0x87, 0xE6, 0x3F, 0x39, 0xF8, 0xCF, 0xC7,
  0x7E, 0x1B, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x0E,
  0x1F, 0x81, 0xFE, 0x1C, 0x39, 0xC0, 0xEE, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0x60, 0x1B, 0x80,
  0xDC, 0x0E, 0x70, 0xE1, 0xFE, 0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0xE0, 0xEE,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xFF, 0xCF,
  0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x1F, 0x81, 0xFE, 0x1C, 0x39, 0xC0, 0xEE, 0x03, 0x60, 0x1B, 0x00, 0xD8,
  0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x80,
  0xDC, 0x0E, 0x70, 0xE1, 0xFE, 0x07, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x08,
  0xFF, 0x0F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x0E,
  0xE1, 0xCF, 0xFC, 0xFF, 0x0E, 0x38, 0xE1, 0x8E, 0x1C, 0xE1, 0xCE, 0x0C,
  0xE0, 0xEE, 0x06, 0xE0, 0x70, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60,
  0x76, 0x07, 0x70, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0E, 0x00,
  0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0xE3, 0xFE, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x6E, 0x06, 0xF0, 0xE7, 0xFC, 0x1F, 0x00, 0xC0, 0x1B, 0x80, 0x6E,
  0x03, 0x98, 0x0E, 0x60, 0x31, 0xC1, 0xC3, 0x07, 0x0C, 0x18, 0x38, 0x60,
  0x63, 0x81, 0x8C, 0x06, 0x30, 0x1D, 0xC0, 0x36, 0x00, 0xD8, 0x03, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83,
  0x83, 0x30, 0x70, 0x66, 0x1A, 0x0C, 0xC3, 0x63, 0x9C, 0x6C, 0x73, 0x8D,
  0x8C, 0x33, 0x31, 0x86, 0x63, 0x30, 0xCC, 0x66, 0x19, 0x8D, 0xC3, 0xB1,
  0xB0, 0x3C, 0x16, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x80,
  0xC0, 0x30, 0x18, 0x00, 0xE0, 0x3B, 0x83, 0x9C, 0x1C, 0x71, 0xC3, 0x8E,
  0x0E, 0xE0, 0x76, 0x01, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0x01,
  0xDC, 0x0E, 0xE0, 0xE3, 0x87, 0x1C, 0x70, 0x73, 0x83, 0xB8, 0x0E, 0x60,
  0x1D, 0xC0, 0xE3, 0x03, 0x8E, 0x0C, 0x38, 0x70, 0x61, 0x81, 0xCE, 0x03,
  0x30, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xCC, 0xFF, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60,
  0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0xC0, 0x18, 0x18, 0x3C, 0x3C,
  0x3C, 0x66, 0x66, 0x66, 0xE3, 0xC3, 0xFF, 0xFF, 0xFC, 0xE3, 0x8C, 0x30,
  0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x60, 0x0C, 0x01, 0x87, 0xF1, 0xFE, 0x70,
  0xCC, 0x1B, 0x83, 0x30, 0x67, 0x3C, 0xFF, 0x8F, 0x30, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0D, 0xF3, 0xFE, 0xE3, 0xB0, 0x7C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x3B, 0xFE, 0xDF, 0x00,
  0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0D, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x83, 0x30, 0x67, 0x1C, 0x7F, 0x07, 0xC0, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xB9, 0xFF, 0x71, 0xEC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xEC, 0x1D, 0xC7, 0x9F,
  0xF1, 0xEE, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x66, 0x0D, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x0C, 0x7F, 0x87, 0xC0, 0x0E,
  0x3C, 0xE1, 0x83, 0x06, 0x3F, 0xFF, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x1E, 0xE7, 0xFD, 0xC7, 0xB0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xB0, 0x77, 0x1E,
  0x7F, 0xC7, 0xB8, 0x07, 0x00, 0xC4, 0x39, 0xFE, 0x0F, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x79, 0xFE, 0xE3, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0x33, 0x30, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x7F, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3B, 0x1C, 0xC7, 0x33, 0x8D, 0xC3, 0x60, 0xF8, 0x3F, 0x0E, 0xC3, 0x38,
  0xC6, 0x31, 0xCC, 0x33, 0x0E, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xDE, 0x3E, 0x7F, 0xBF, 0xB8, 0xF9, 0xD8, 0x38, 0x6C, 0x18, 0x3E,
  0x0C, 0x1F, 0x06, 0x0F, 0x83, 0x07, 0xC1, 0x83, 0xE0, 0xC1, 0xF0, 0x60,
  0xF8, 0x30, 0x7C, 0x18, 0x3E, 0x0C, 0x1F, 0x06, 0x0E, 0xDE, 0x7F, 0xB8,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x06, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x7E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xB0, 0x77, 0x1C, 0x7F, 0x87, 0xC0, 0xDF,
  0x3F, 0xEE, 0x3B, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1F, 0x07, 0xE3, 0xBF, 0xED, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x1E, 0xE7, 0xFD, 0xC7, 0xB0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xB0, 0x77, 0x1E, 0x7F, 0xC7, 0xB8, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0xDF, 0xFF, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x87, 0x60, 0x1C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x7E, 0x0F, 0x83, 0x71, 0xDF, 0xE1, 0xF0, 0x38,
  0x70, 0xE7, 0xFF, 0xE7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x0C, 0x1E, 0x1C, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x3B, 0xFC, 0xF6, 0xC1, 0xF0, 0x6E, 0x19,
  0x86, 0x63, 0x98, 0xC7, 0x30, 0xCC, 0x36, 0x0D, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x00, 0xC0, 0xC1, 0x87, 0xC3, 0x87, 0xE3, 0x86, 0xE3, 0xC6, 0x63,
  0xC6, 0x66, 0xCE, 0x66, 0xCC, 0x76, 0x6C, 0x36, 0x6C, 0x3C, 0x6C, 0x3C,
  0x78, 0x3C, 0x38, 0x1C, 0x38, 0x18, 0x38, 0x18, 0x38, 0xE1, 0xD8, 0x67,
  0x38, 0xCC, 0x37, 0x07, 0x81, 0xE0, 0x30, 0x1E, 0x07, 0x83, 0x70, 0xCC,
  0x73, 0xB8, 0x6E, 0x1C, 0x60, 0xEC, 0x19, 0xC3, 0x18, 0xE3, 0x18, 0x63,
  0x0E, 0x60, 0xDC, 0x1B, 0x03, 0x60, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x81, 0xE0, 0x38, 0x00, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x3F, 0xFF, 0xFC, 0x04, 0x1C, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xC3, 0x8E, 0x1C, 0x1C, 0x18, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x06, 0x0C,
  0x0E, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x83, 0x06, 0x1C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0E, 0x1C, 0x73, 0x8C, 0x30, 0xC3, 0x0C, 0x30,
  0xC7, 0x18, 0xC2, 0x00, 0x38, 0x37, 0xC3, 0xCF, 0x3C, 0x7E, 0xC1, 0xC0,
};

const GFXglyph RobotoCondensed_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 5, 7, 9, 2, -20 },
  { 14, 12, 19, 15, 2, -19 },
  { 43, 11, 24, 13, 1, -22 },
  { 76, 15, 19, 17, 1, -19 },
  { 112, 13, 19, 15, 1, -19 },
  { 143, 2, 6, 5, 1, -20 },
  { 145, 6, 28, 8, 2, -22 },
  { 166, 6, 28, 9, 1, -22 },
  { 187, 11, 11, 12, 0, -19 },
  { 203, 11, 14, 13, 1, -16 },
  { 223, 4, 7, 5, 0, -3 },
  { 227, 5, 2, 7, 1, -9 },
  { 229, 3, 3, 7, 2, -3 },
  { 231, 9, 21, 10, 0, -19 },
  { 255, 10, 19, 13, 2, -19 },
  { 279, 6, 19, 13, 2, -19 },
  { 294, 11, 19, 13, 1, -19 },
  { 321, 11, 19, 13, 1, -19 },
  { 348, 12, 19, 13, 1, -19 },
  { 377, 10, 19, 13, 2, -19 },
  { 401, 10, 19, 13, 2, -19 },
  { 425, 11, 19, 13, 1, -19 },
  { 452, 10, 19, 13, 2, -19 },
  { 476, 11, 19, 13, 1, -19 },
  { 503, 3, 15, 6, 2, -15 },
  { 509, 4, 19, 5, 1, -15 },
  { 519, 9, 11, 12, 1, -14 },
  { 532, 9, 8, 13, 2, -13 },
  { 541, 9, 12, 12, 2, -15 },
  { 555, 9, 19, 11, 1, -19 },
  { 577, 19, 25, 21, 1, -19 },
  { 637, 14, 19, 16, 1, -19 },
  { 671, 11, 19, 15, 2, -19 },
  { 698, 12, 19, 15, 2, -19 },
  { 727, 12, 19, 15, 2, -19 },
  { 756, 10, 19, 13, 2, -19 },
  { 780, 10, 19, 13, 2, -19 },
  { 804, 12, 19, 16, 2, -19 },
  { 833, 13, 19, 17, 2, -19 },
  { 864, 3, 19, 7, 2, -19 },
  { 872, 10, 19, 13, 1, -19 },
  { 896, 13, 19, 15, 2, -19 },
  { 927, 10, 19, 13, 2, -19 },
  { 951, 16, 19, 20, 2, -19 },
  { 989, 13, 19, 17, 2, -19 },
  { 1020, 13, 19, 16, 2, -19 },
  { 1051, 12, 19, 15, 2, -19 },
  { 1080, 13, 22, 16, 2, -19 },
  { 1116, 12, 19, 14, 2, -19 },
  { 1145, 12, 19, 14, 1, -19 },
  { 1174, 12, 19, 14, 1, -19 },
  { 1203, 12, 19, 15, 2, -19 },
  { 1232, 14, 19, 15, 1, -19 },
  { 1266, 19, 19, 21, 1, -19 },
  { 1312, 13, 19, 15, 1, -19 },
  { 1343, 14, 19, 14, 0, -19 },
  { 1377, 12, 19, 14, 1, -19 },
  { 1406, 4, 26, 7, 2, -22 },
  { 1419, 9, 21, 10, 1, -19 },
  { 1443, 5, 26, 7, 0, -22 },
  { 1460, 8, 10, 10, 1, -19 },
  { 1470, 11, 2, 11, 0, 0 },
  { 1473, 5, 4, 8, 1, -20 },
  { 1476, 11, 15, 13, 1, -15 },
  { 1497, 10, 21, 13, 2, -21 },
  { 1524, 11, 15, 12, 1, -15 },
  { 1545, 11, 21, 13, 1, -21 },
  { 1574, 11, 15, 13, 1, -15 },
  { 1595, 7, 21, 9, 1, -21 },
  { 1614, 11, 20, 13, 1, -15 },
  { 1642, 9, 21, 13, 2, -21 },
  { 1666, 2, 20, 6, 2, -20 },
  { 1671, 4, 25, 6, 0, -20 },
  { 1684, 10, 21, 12, 2, -21 },
  { 1711, 2, 21, 6, 2, -21 },
  { 1717, 17, 15, 20, 2, -15 },
  { 1749, 9, 15, 13, 2, -15 },
  { 1766, 11, 15, 14, 1, -15 },
  { 1787, 10, 20, 13, 2, -15 },
  { 1812, 11, 20, 14, 1, -15 },
  { 1840, 6, 15, 8, 2, -15 },
  { 1852, 10, 15, 12, 1, -15 },
  { 1871, 7, 18, 8, 0, -18 },
  { 1887, 9, 15, 13, 2, -15 },
  { 1904, 10, 15, 12, 1, -15 },
  { 1923, 16, 15, 18, 1, -15 },
  { 1953, 10, 15, 12, 1, -15 },
  { 1972, 11, 20, 11, 0, -15 },
  { 2000, 10, 15, 12, 1, -15 },
  { 2019, 7, 26, 8, 1, -21 },
  { 2042, 2, 23, 7, 2, -19 },
  { 2048, 6, 26, 8, 1, -21 },
  { 2068, 12, 5, 16, 2, -10 },
};

const GFXfont RobotoCondensed_Regular27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_REGULAR27PT7B_H_
