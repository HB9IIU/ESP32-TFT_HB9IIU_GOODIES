#ifndef _ROBOTOCONDENSED_REGULAR47PT7B_H_
#define _ROBOTOCONDENSED_REGULAR47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0xEF, 0xFF, 0xE0, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE, 0x38, 0x00, 0xF0, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87,
  0x00, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x07,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x0E, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x70,
  0x01, 0xC1, 0xC0, 0x07, 0x07, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F,
  0x07, 0xC7, 0x80, 0xF9, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x1E, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x1E, 0xF8, 0x07, 0x9F, 0x03, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFC, 0x01, 0xFC, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x70, 0x70, 0x30, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0xE0, 0x38, 0x1C, 0x70, 0x07, 0x07,
  0x1C, 0x01, 0xC1, 0xCE, 0x00, 0x78, 0xE3, 0x80, 0x0F, 0xF9, 0xC0, 0x01,
  0xFC, 0x70, 0x00, 0x3E, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x1F,
  0x00, 0x03, 0xCF, 0xF0, 0x00, 0xE7, 0xFC, 0x00, 0x71, 0xC3, 0x80, 0x1C,
  0xE0, 0xE0, 0x0E, 0x38, 0x3C, 0x03, 0x8E, 0x07, 0x01, 0xC3, 0x81, 0xC0,
  0x70, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x03, 0x83,
  0x80, 0x80, 0x70, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF8, 0x01, 0xF0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF9, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x70, 0xFB, 0xE0, 0xE1, 0xE3, 0xE1, 0xC7,
  0x83, 0xC7, 0x8F, 0x07, 0xCF, 0x3E, 0x07, 0xDE, 0x78, 0x07, 0xB8, 0xF0,
  0x0F, 0xF1, 0xF0, 0x0F, 0xE1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0xC0,
  0x7F, 0x07, 0xF7, 0xFF, 0x07, 0xFF, 0xDE, 0x07, 0xFF, 0x3E, 0x03, 0xF8,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xE0, 0x00, 0x40, 0x18, 0x07, 0x01,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x06, 0x00, 0x40, 0x40, 0x0C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x03, 0x00, 0x40, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x81,
  0xC0, 0xBC, 0x38, 0xF7, 0xF7, 0x7E, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF0,
  0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xC0, 0x20, 0x10, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xDE, 0x7B, 0xCF, 0x18, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xEF,
  0xFE, 0x78, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFD, 0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xCF,
  0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x79, 0xE0,
  0x3C, 0x7C, 0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0x60, 0x3C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFC, 0x7C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xDF, 0xC7, 0xC0, 0xF8, 0xF0,
  0x0F, 0x9E, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xF0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x0F,
  0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x07, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0x3C, 0x00,
  0x79, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E,
  0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78,
  0x0F, 0x07, 0x80, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF7, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xF0, 0x7E,
  0x18, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80,
  0x7D, 0xE0, 0x1E, 0x3C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE7, 0xE0, 0xF7, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xF0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xDE,
  0x01, 0xF7, 0x80, 0x79, 0xF0, 0x1E, 0x3E, 0x0F, 0x0F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0x1F,
  0x1E, 0x03, 0xC7, 0x80, 0xFB, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0x79, 0xE0, 0x3E, 0x78, 0x0F, 0x0F, 0x07, 0xC3, 0xF7, 0xE0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x87, 0xC1, 0xF1, 0xE0, 0x3C, 0xF0, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xEF,
  0x00, 0x7B, 0xE0, 0x1E, 0x78, 0x0F, 0x9F, 0xDF, 0xC3, 0xFF, 0xE0, 0x7F,
  0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x3E, 0x1F, 0x1F, 0x03, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x3D, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x0F, 0xF3, 0xC0, 0xF8, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x78, 0x3C,
  0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7,
  0x9F, 0x3C, 0x10, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFE, 0x7C, 0x3E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFC, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x1C, 0x1C, 0x01, 0xF0, 0x0E, 0x1C, 0x03, 0xFC, 0x0E,
  0x38, 0x07, 0xFE, 0x0E, 0x38, 0x0F, 0x0E, 0x06, 0x38, 0x1E, 0x0E, 0x06,
  0x78, 0x1C, 0x0E, 0x07, 0x70, 0x3C, 0x1E, 0x07, 0x70, 0x38, 0x1E, 0x07,
  0x70, 0x38, 0x1E, 0x07, 0x70, 0x78, 0x1C, 0x07, 0x70, 0x78, 0x1C, 0x07,
  0x70, 0x78, 0x1C, 0x07, 0x70, 0x70, 0x1C, 0x07, 0x70, 0x70, 0x1C, 0x07,
  0x70, 0x70, 0x1C, 0x06, 0x70, 0x70, 0x1C, 0x0E, 0x70, 0x70, 0x3C, 0x0E,
  0x70, 0x78, 0x3C, 0x0E, 0x70, 0x78, 0x7C, 0x1C, 0x70, 0x3E, 0xFE, 0x3C,
  0x78, 0x3F, 0xCF, 0xF8, 0x38, 0x1F, 0x8F, 0xF0, 0x38, 0x0F, 0x07, 0xC0,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x0C, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x71, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78,
  0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x1F, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xF3, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0x80,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x00, 0xFD,
  0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xC0, 0x3E, 0x78, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x01, 0xF0, 0xF0, 0x03, 0xC7,
  0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xEF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x00,
  0x1E, 0xF8, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x00, 0x3C,
  0x3E, 0x01, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x7C,
  0xF0, 0x0F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0x9E, 0x00,
  0x1E, 0xF8, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7D,
  0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0xFC, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x1F, 0x7E, 0x0F, 0x8F,
  0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x01, 0xF7,
  0x80, 0x1F, 0xBC, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x00, 0xF8, 0x78, 0x07,
  0xC3, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3C,
  0x3E, 0x01, 0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0x79, 0xF0, 0x03, 0xDF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xBC, 0x01, 0xF9,
  0xF0, 0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0xF0, 0x1F, 0x07, 0x80, 0x7C, 0x3C, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x00,
  0x3E, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x3F, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xEF, 0x00, 0x0F, 0xFE, 0xF0, 0x01, 0xEF, 0xFF, 0x00,
  0x1E, 0xFF, 0x78, 0x01, 0xEF, 0xF7, 0x80, 0x3C, 0xFF, 0x38, 0x03, 0xCF,
  0xF3, 0xC0, 0x3C, 0xFF, 0x3C, 0x07, 0x8F, 0xF1, 0xC0, 0x78, 0xFF, 0x1E,
  0x07, 0x8F, 0xF1, 0xE0, 0xF0, 0xFF, 0x0E, 0x0F, 0x0F, 0xF0, 0xF0, 0xF0,
  0xFF, 0x0F, 0x1E, 0x0F, 0xF0, 0x71, 0xE0, 0xFF, 0x07, 0x9E, 0x0F, 0xF0,
  0x79, 0xC0, 0xFF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xBC, 0x03, 0xFD, 0xE0, 0x1F,
  0xE7, 0x80, 0xFF, 0x3C, 0x07, 0xF8, 0xF0, 0x3F, 0xC7, 0x81, 0xFE, 0x1E,
  0x0F, 0xF0, 0x78, 0x7F, 0x83, 0xC3, 0xFC, 0x0F, 0x1F, 0xE0, 0x78, 0xFF,
  0x01, 0xE7, 0xF8, 0x0F, 0x3F, 0xC0, 0x3D, 0xFE, 0x01, 0xEF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF0,
  0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xF0, 0x07, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x3E,
  0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x1E, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0x83, 0xF0, 0x3F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x0F, 0xCF, 0x00, 0x7C,
  0xF0, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3E,
  0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3E, 0x03, 0xE7, 0xC0, 0x1E, 0x7C,
  0x01, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xF7, 0xC0, 0x1F, 0x3E, 0x03, 0xF3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00,
  0x3C, 0xF0, 0x03, 0xE7, 0xC0, 0x3E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xE0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1F,
  0x00, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC1, 0xE0, 0x03,
  0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x78, 0x01, 0xE0, 0x07, 0xBC, 0x00, 0xF8, 0x03, 0xDE, 0x00, 0x7C, 0x01,
  0xE7, 0x80, 0x7E, 0x00, 0xF3, 0xC0, 0x3F, 0x00, 0xF1, 0xE0, 0x1F, 0x80,
  0x78, 0xF0, 0x0F, 0xE0, 0x3C, 0x78, 0x0F, 0xF0, 0x1E, 0x1E, 0x07, 0xB8,
  0x0F, 0x0F, 0x03, 0xDC, 0x0F, 0x07, 0x81, 0xCF, 0x07, 0x83, 0xC0, 0xE7,
  0x83, 0xC1, 0xE0, 0xF1, 0xC1, 0xE0, 0x78, 0x78, 0xE0, 0xF0, 0x3C, 0x38,
  0x70, 0x70, 0x1E, 0x1C, 0x3C, 0x78, 0x0F, 0x1E, 0x0E, 0x3C, 0x07, 0x8F,
  0x07, 0x1E, 0x01, 0xC7, 0x03, 0x8F, 0x00, 0xF3, 0x81, 0xE7, 0x00, 0x7B,
  0xC0, 0xF7, 0x80, 0x3D, 0xE0, 0x3B, 0xC0, 0x1E, 0xE0, 0x1D, 0xE0, 0x07,
  0x70, 0x0E, 0xF0, 0x03, 0xB8, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x00, 0x3C,
  0x3E, 0x01, 0xF0, 0x78, 0x07, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F,
  0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x7C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0x3C, 0x00, 0x7C, 0xF8, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x3C, 0x0F,
  0x01, 0xF0, 0x3E, 0x07, 0x80, 0x78, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7,
  0xC0, 0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0xC0,
  0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x07,
  0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF3, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0x00, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0x78, 0x3C, 0xE0, 0xF3, 0x83, 0x8F, 0x1E, 0x3C, 0x78, 0x71, 0xC1, 0xEF,
  0x07, 0xBC, 0x0E, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF,
  0xF3, 0xF0, 0x7B, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x03, 0xDE, 0x01, 0xEF, 0x83, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xDF,
  0x0F, 0x87, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x1F, 0x83, 0xDF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xC0,
  0xFB, 0xE0, 0x1E, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xEF, 0xC0,
  0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3D, 0xFF, 0x8F, 0x1F, 0x80, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3C, 0x07, 0x9E, 0x01, 0xE7,
  0x80, 0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x3C, 0x07, 0x8F, 0xEF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x3C, 0x3F, 0xEF, 0x1F, 0xFF,
  0xCF, 0xFF, 0xF7, 0xC0, 0xFD, 0xF0, 0x1F, 0x78, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x03,
  0xDE, 0x01, 0xF7, 0xC0, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFE, 0xF0,
  0x3E, 0x3C, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C,
  0x0F, 0x9F, 0x01, 0xE7, 0x80, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x06, 0x3E,
  0x03, 0x8F, 0xF7, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x03, 0xFC, 0x00, 0x01,
  0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0xFF, 0xEF, 0xFE, 0xFF, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0x03, 0xE3, 0xC3, 0xFE, 0xF1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x7E, 0x0F, 0xDF, 0x01, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xF0,
  0x1F, 0x7C, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xEF, 0x03, 0xE3,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC4, 0x01, 0xF3,
  0x80, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x7E, 0x1E, 0x7F,
  0x8F, 0x7F, 0xE7, 0xFF, 0xFB, 0xF0, 0x7D, 0xF0, 0x1E, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xE0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x07, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80,
  0x06, 0x0F, 0x0F, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFE, 0xFE, 0xF8, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x01, 0xF3, 0xC0, 0x7C, 0xF0,
  0x3E, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C, 0xF8,
  0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0xF9, 0xE0, 0x3E, 0x7C, 0x0F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0,
  0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xE3, 0xC0, 0x7C, 0xF0, 0x0F, 0x3C, 0x03,
  0xEF, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xF8, 0x1F,
  0x87, 0xBF, 0xE1, 0xFF, 0x3F, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xC1, 0xFE, 0x0F, 0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x3E, 0x01, 0xFE, 0x00,
  0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x80, 0x3C, 0x03, 0xFC, 0x01, 0xE0,
  0x1F, 0xE0, 0x0F, 0x00, 0xFF, 0x00, 0x78, 0x07, 0xF8, 0x03, 0xC0, 0x3F,
  0xC0, 0x1E, 0x01, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x80,
  0x3C, 0x03, 0xFC, 0x01, 0xE0, 0x1F, 0xE0, 0x0F, 0x00, 0xFF, 0x00, 0x78,
  0x07, 0xF8, 0x03, 0xC0, 0x3F, 0xC0, 0x1E, 0x01, 0xFE, 0x00, 0xF0, 0x0F,
  0xF0, 0x07, 0x80, 0x78, 0xF1, 0xF8, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF,
  0xEF, 0xC1, 0xF7, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x01, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07,
  0x9E, 0x00, 0xFB, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xE3, 0xE0, 0x7C,
  0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0xF1, 0xF8,
  0x3D, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFC, 0x0F, 0xBE, 0x01, 0xEF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xE0, 0x1E, 0xF8, 0x0F, 0xBF, 0xDF, 0xCF,
  0xFF, 0xF3, 0xDF, 0xF8, 0xF1, 0xF8, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE3, 0xC3, 0xFE, 0xF1, 0xFF, 0xFC,
  0xFF, 0xFF, 0x7C, 0x07, 0xDF, 0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x0F, 0x7C, 0x07, 0xCF, 0xEF, 0xF1, 0xFF, 0xFC, 0x3F, 0xEF, 0x03,
  0xE3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0xF3, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xC0, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0,
  0x0F, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xEF, 0x00, 0xF7, 0xC0, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xF8, 0x03,
  0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xF8, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFF, 0x01, 0xF7, 0x81, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xEF,
  0x0F, 0xC7, 0x80, 0xF0, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1C, 0x0E, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x0E, 0x1C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0xF7, 0x00, 0xF0, 0x0F, 0x78, 0x0F, 0x00, 0xF7, 0x80,
  0xF8, 0x0E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x3C, 0x1F, 0xC1,
  0xE3, 0xC1, 0xFC, 0x1E, 0x3C, 0x3D, 0xC1, 0xC3, 0xC3, 0xDC, 0x3C, 0x1C,
  0x39, 0xE3, 0xC1, 0xE3, 0x9E, 0x3C, 0x1E, 0x78, 0xE3, 0x81, 0xE7, 0x8E,
  0x78, 0x0E, 0x70, 0xF7, 0x80, 0xFF, 0x0F, 0x78, 0x0F, 0xF0, 0x77, 0x00,
  0xFE, 0x07, 0x70, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x01, 0xE0,
  0x03, 0xC0, 0x1C, 0x00, 0x78, 0x07, 0xDF, 0x01, 0xE3, 0xC0, 0xF8, 0xF8,
  0x3C, 0x1E, 0x1F, 0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x78,
  0x78, 0x1E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0, 0x79, 0xF0, 0x1F, 0xF8, 0x07,
  0xC0, 0xF0, 0x07, 0xFE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x0F,
  0x1F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C, 0x3C, 0x1E, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3D,
  0xE0, 0x07, 0x78, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x60, 0x1C, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xE0, 0x3C,
  0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x0F, 0x80, 0x70, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3F, 0x07, 0xC0, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F,
  0x00, 0x40, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x73, 0xFE, 0x03, 0xDF,
  0xFC, 0x0F, 0xF0, 0xF8, 0x7B, 0xC1, 0xFF, 0xEF, 0x03, 0xFF, 0x38, 0x07,
  0xF8, 0x00, 0x07, 0xC0,
};

const GFXglyph RobotoCondensed_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 33, 12, 4, -33 },
  { 18, 10, 11, 15, 3, -35 },
  { 32, 22, 33, 26, 3, -33 },
  { 123, 18, 42, 23, 3, -38 },
  { 218, 26, 33, 30, 2, -33 },
  { 326, 23, 33, 26, 2, -33 },
  { 421, 4, 11, 8, 2, -35 },
  { 427, 11, 49, 15, 3, -38 },
  { 495, 11, 49, 15, 1, -38 },
  { 563, 19, 19, 20, 1, -33 },
  { 609, 19, 25, 23, 2, -28 },
  { 669, 6, 12, 9, 1, -5 },
  { 678, 10, 3, 12, 1, -15 },
  { 682, 6, 5, 12, 3, -5 },
  { 686, 15, 36, 17, 1, -33 },
  { 754, 18, 33, 23, 3, -33 },
  { 829, 11, 33, 23, 4, -33 },
  { 875, 19, 33, 23, 2, -33 },
  { 954, 18, 33, 23, 2, -33 },
  { 1029, 21, 33, 23, 1, -33 },
  { 1116, 18, 33, 23, 3, -33 },
  { 1191, 18, 33, 23, 3, -33 },
  { 1266, 19, 33, 23, 2, -33 },
  { 1345, 18, 33, 23, 3, -33 },
  { 1420, 18, 33, 23, 2, -33 },
  { 1495, 5, 25, 11, 3, -25 },
  { 1511, 7, 32, 10, 1, -25 },
  { 1539, 16, 20, 21, 2, -25 },
  { 1579, 16, 14, 23, 3, -23 },
  { 1607, 17, 20, 22, 3, -25 },
  { 1650, 16, 33, 20, 2, -33 },
  { 1716, 32, 43, 36, 2, -33 },
  { 1888, 25, 33, 27, 1, -33 },
  { 1992, 19, 33, 26, 4, -33 },
  { 2071, 22, 33, 27, 3, -33 },
  { 2162, 20, 33, 27, 4, -33 },
  { 2245, 18, 33, 23, 4, -33 },
  { 2320, 17, 33, 23, 4, -33 },
  { 2391, 22, 33, 28, 3, -33 },
  { 2482, 21, 33, 29, 4, -33 },
  { 2569, 4, 33, 12, 4, -33 },
  { 2586, 18, 33, 23, 1, -33 },
  { 2661, 21, 33, 26, 4, -33 },
  { 2748, 17, 33, 22, 4, -33 },
  { 2819, 28, 33, 36, 4, -33 },
  { 2935, 21, 33, 29, 4, -33 },
  { 3022, 22, 33, 28, 3, -33 },
  { 3113, 20, 33, 26, 4, -33 },
  { 3196, 23, 39, 28, 3, -33 },
  { 3309, 20, 33, 25, 4, -33 },
  { 3392, 20, 33, 24, 2, -33 },
  { 3475, 22, 33, 24, 1, -33 },
  { 3566, 21, 33, 26, 3, -33 },
  { 3653, 24, 33, 26, 1, -33 },
  { 3752, 33, 33, 36, 2, -33 },
  { 3889, 22, 33, 26, 2, -33 },
  { 3980, 23, 33, 25, 1, -33 },
  { 4075, 21, 33, 25, 2, -33 },
  { 4162, 8, 45, 12, 3, -38 },
  { 4207, 16, 36, 17, 1, -33 },
  { 4279, 7, 45, 12, 1, -38 },
  { 4319, 14, 17, 17, 2, -33 },
  { 4349, 17, 3, 19, 1, 0 },
  { 4356, 10, 7, 15, 1, -36 },
  { 4365, 17, 25, 23, 3, -25 },
  { 4419, 18, 35, 23, 3, -35 },
  { 4498, 18, 25, 22, 2, -25 },
  { 4555, 18, 35, 23, 2, -35 },
  { 4634, 18, 25, 22, 2, -25 },
  { 4691, 12, 35, 15, 2, -35 },
  { 4744, 18, 35, 23, 2, -25 },
  { 4823, 17, 35, 23, 3, -35 },
  { 4898, 5, 34, 11, 3, -34 },
  { 4920, 8, 44, 11, -1, -34 },
  { 4964, 18, 35, 21, 3, -35 },
  { 5043, 4, 35, 11, 3, -35 },
  { 5061, 29, 25, 35, 3, -25 },
  { 5152, 17, 25, 23, 3, -25 },
  { 5206, 19, 25, 24, 2, -25 },
  { 5266, 18, 35, 23, 3, -25 },
  { 5345, 18, 35, 24, 2, -25 },
  { 5424, 10, 25, 14, 3, -25 },
  { 5456, 17, 25, 21, 2, -25 },
  { 5510, 11, 31, 14, 1, -31 },
  { 5553, 17, 25, 23, 3, -25 },
  { 5607, 18, 25, 20, 1, -25 },
  { 5664, 28, 25, 31, 1, -25 },
  { 5752, 18, 25, 21, 1, -25 },
  { 5809, 18, 35, 20, 1, -25 },
  { 5888, 17, 25, 21, 2, -25 },
  { 5942, 11, 45, 14, 2, -37 },
  { 6004, 3, 39, 11, 4, -33 },
  { 6019, 12, 45, 14, 1, -37 },
  { 6087, 22, 9, 28, 3, -18 },
};

const GFXfont RobotoCondensed_Regular47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_REGULAR47PT7B_H_
