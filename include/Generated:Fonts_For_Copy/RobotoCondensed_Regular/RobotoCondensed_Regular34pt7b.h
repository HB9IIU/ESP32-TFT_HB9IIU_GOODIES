#ifndef _ROBOTOCONDENSED_REGULAR34PT7B_H_
#define _ROBOTOCONDENSED_REGULAR34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0D, 0xFE, 0xE7, 0xCF,
  0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03,
  0x1C, 0x03, 0x18, 0x07, 0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x06,
  0x38, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0xFF,
  0xFE, 0xFF, 0xFE, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18,
  0xE0, 0x18, 0xC0, 0x38, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0xF8, 0x1F, 0xF0, 0xFF, 0x8F, 0x0E, 0x70, 0x73, 0x81, 0xDC, 0x0E, 0xE0,
  0x77, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x73, 0xFF, 0x8F,
  0xF8, 0x1F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x0E, 0x70, 0x03, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0x0C, 0x31, 0x83,
  0x0C, 0xC0, 0xE7, 0x30, 0x1F, 0x98, 0x03, 0xC6, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x63, 0xC0, 0x39, 0xF8, 0x0C, 0xE7, 0x07, 0x30, 0xC1, 0x8C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x30, 0xC2, 0x0E, 0x70, 0x01, 0xF8,
  0x00, 0x3C, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x38, 0xE0, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x60, 0x38, 0xE0, 0x39, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x8E, 0xF3, 0xCE, 0xE1, 0xCE, 0xE0, 0xEE,
  0xE0, 0xFC, 0xE0, 0x7C, 0xE0, 0x38, 0xF0, 0x7C, 0x7F, 0xFC, 0x3F, 0xEE,
  0x0F, 0x8F, 0xFF, 0xFF, 0x02, 0x03, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x0C,
  0x06, 0x03, 0x02, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x1C,
  0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x06, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0xE0,
  0xC0, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x63, 0x8D, 0xFD,
  0xF7, 0xFF, 0xC3, 0xF8, 0x07, 0x80, 0x3F, 0x01, 0xCE, 0x07, 0x1C, 0x38,
  0x70, 0x00, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x39,
  0xCE, 0x73, 0xB9, 0xCC, 0xFF, 0xFF, 0xF8, 0x6F, 0xF7, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38,
  0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xE0,
  0xE7, 0x07, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1C, 0xE0, 0xE7, 0x07, 0x1F, 0xF0, 0xFF, 0x01, 0xF0, 0x03, 0x0F, 0x7F,
  0xFF, 0xE7, 0x87, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x81, 0xFF,
  0x1F, 0xFD, 0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x80, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xE1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x00, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0x3F, 0x01, 0xF8, 0x1D, 0xC0, 0xEF, 0x07, 0x3F, 0xF0,
  0xFF, 0x03, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xDC, 0x03, 0xB8, 0x0E, 0x70, 0x18, 0xE0, 0x71, 0xC0,
  0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x1C, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x77, 0xC3, 0xFF, 0x1F, 0xFC, 0xE0, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0x77, 0x87, 0x9F, 0xF8,
  0x7F, 0x81, 0xF0, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x78, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x67, 0xC7, 0x7F, 0x3F, 0xFD, 0xF0, 0xEF, 0x07,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x0E, 0xE0, 0x77,
  0x87, 0x1F, 0xF8, 0x7F, 0x81, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x0F, 0x81, 0xFF, 0x1F, 0xF8, 0xE1, 0xE7, 0x07, 0x70, 0x3B, 0x81, 0xDC,
  0x0E, 0x70, 0x73, 0x83, 0x8F, 0xF8, 0x3F, 0x83, 0xFE, 0x3C, 0x79, 0xC1,
  0xDC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x77, 0x07, 0x3F, 0xF8,
  0xFF, 0x81, 0xF0, 0x0F, 0x81, 0xFE, 0x1F, 0xF8, 0xE1, 0xCE, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x06, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xF7, 0x0F,
  0xBF, 0xF8, 0xFE, 0xC3, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1E, 0x0F, 0xE0, 0x7E, 0x03, 0xC0, 0x6F, 0xF7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0xFF, 0x70, 0x33, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x73, 0x9C, 0xE7, 0x71, 0x00, 0x00, 0x10, 0x07, 0x01, 0xF0,
  0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0x01,
  0xF0, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x0F, 0x83,
  0xFC, 0x7F, 0xE7, 0x0F, 0xF0, 0x7E, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x00, 0x1E, 0x0F, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x03,
  0x03, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x18, 0x1E, 0x0C, 0x70, 0x7F, 0x0C,
  0xC1, 0xC6, 0x19, 0x83, 0x0C, 0x37, 0x0E, 0x18, 0x6E, 0x18, 0x70, 0xD8,
  0x70, 0xE1, 0xB0, 0xE1, 0xC3, 0x61, 0xC3, 0x86, 0xC3, 0x06, 0x0D, 0x86,
  0x0C, 0x1B, 0x0C, 0x18, 0x36, 0x1C, 0x30, 0x6C, 0x38, 0xE1, 0x98, 0x7B,
  0xE7, 0x38, 0x7C, 0xFC, 0x30, 0x70, 0xF0, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x60,
  0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xDC, 0x00, 0x77, 0x00, 0x1C, 0xE0,
  0x07, 0x38, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x1C, 0x07,
  0x03, 0x01, 0xC0, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0x80,
  0x71, 0xC0, 0x1C, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x07,
  0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03,
  0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xCF, 0xFF, 0x3F, 0xF0, 0xFF, 0xF3, 0x81,
  0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0E, 0xE0,
  0x7B, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x38, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38,
  0x1E, 0xE0, 0x3B, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0E, 0xE0, 0x7B, 0xFF, 0xCF, 0xFE, 0x3F, 0xC0,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0x70,
  0x0E, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x3C, 0x0F, 0x3F, 0xFE, 0x1F,
  0xFC, 0x07, 0xF0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xF7, 0x07, 0x3F, 0xF8, 0xFF, 0x81, 0xF0,
  0xE0, 0x1D, 0xC0, 0x7B, 0x81, 0xE7, 0x03, 0x8E, 0x0E, 0x1C, 0x3C, 0x38,
  0xF0, 0x71, 0xC0, 0xE7, 0x81, 0xDE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF0, 0x3C, 0xE0, 0x70, 0xE0, 0xE1, 0xE1, 0xC1, 0xC3, 0x83, 0xC7,
  0x03, 0xCE, 0x03, 0x9C, 0x07, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xDC, 0x03, 0xFD, 0xC0, 0x3F, 0xDC, 0x07, 0x7C, 0xE0, 0x77, 0xEE, 0x07,
  0x7E, 0xE0, 0xE7, 0xE7, 0x0E, 0x7E, 0x70, 0xE7, 0xE7, 0x1C, 0x7E, 0x39,
  0xC7, 0xE3, 0x9C, 0x7E, 0x3B, 0x87, 0xE1, 0xB8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0E, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xF7, 0x07,
  0xEE, 0x0F, 0xCE, 0x1F, 0x9C, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x39, 0xF8,
  0x73, 0xF0, 0x77, 0xE0, 0xEF, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x3C, 0x1E, 0x70, 0x0E, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x38, 0x1E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0x01, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3B, 0x80, 0x77, 0x01, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x03, 0xC7,
  0x00, 0xE3, 0x80, 0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0,
  0x0E, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x81, 0xE1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0x40, 0xFF, 0xC1, 0xFF, 0xC3, 0xFF, 0xC7, 0x03, 0xCE, 0x03,
  0x9C, 0x07, 0x38, 0x07, 0x70, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xE7,
  0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x38, 0x70, 0x70, 0x70, 0xE0, 0xE1, 0xC1,
  0xE3, 0x81, 0xC7, 0x03, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x07, 0x70, 0x0E,
  0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xC0, 0xE7, 0x80, 0xEE, 0x01, 0xDC,
  0x03, 0xB8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x1D, 0xC0, 0x3B,
  0x80, 0x77, 0x81, 0xE7, 0xFF, 0x87, 0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3B, 0x80, 0xF7, 0x81,
  0xC7, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01,
  0xEE, 0x00, 0xE7, 0x00, 0x73, 0xC0, 0x78, 0xE0, 0x38, 0x70, 0x1C, 0x38,
  0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x80, 0xE3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x0C, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0xE0, 0x1C, 0x07, 0x70, 0x3C, 0x0F, 0x70, 0x3C, 0x0E, 0x70, 0x3C, 0x0E,
  0x70, 0x3E, 0x0E, 0x70, 0x7E, 0x0E, 0x38, 0x76, 0x0E, 0x38, 0x66, 0x1C,
  0x38, 0x67, 0x1C, 0x38, 0xE7, 0x1C, 0x38, 0xE3, 0x1C, 0x1C, 0xE3, 0x1C,
  0x1C, 0xC3, 0x18, 0x1C, 0xC3, 0xB8, 0x1D, 0xC3, 0xB8, 0x1D, 0xC1, 0xB8,
  0x0D, 0x81, 0xB8, 0x0D, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF0,
  0x07, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x3C,
  0x07, 0x8E, 0x03, 0x87, 0x83, 0xC1, 0xC1, 0xC0, 0xF1, 0xE0, 0x38, 0xE0,
  0x1E, 0xF0, 0x07, 0x70, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x0E, 0xE0, 0x0E, 0x78, 0x07, 0x1C, 0x07,
  0x0F, 0x03, 0x83, 0x83, 0xC1, 0xE3, 0xC0, 0x71, 0xE0, 0x3D, 0xE0, 0x0E,
  0x70, 0x03, 0xBC, 0x03, 0xCE, 0x01, 0xC7, 0x01, 0xE1, 0xC0, 0xE0, 0xE0,
  0x70, 0x78, 0x70, 0x1C, 0x38, 0x0E, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF, 0xFC, 0xE0, 0x1C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0xFF, 0xFE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF, 0xF8, 0x0C, 0x03, 0x81, 0xE0, 0x7C,
  0x1F, 0x0E, 0xC3, 0xB8, 0xCE, 0x71, 0x9C, 0x76, 0x1F, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x0F, 0x81, 0xFF, 0x1F,
  0xF8, 0xE1, 0xEE, 0x07, 0x00, 0x38, 0x01, 0xC1, 0xFE, 0x3F, 0xF3, 0xC3,
  0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0xDF, 0xFE, 0x7F, 0x71,
  0xF3, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE7, 0xC7, 0x7F, 0x3F, 0xFD, 0xE0, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0xC1, 0xDF, 0xFE, 0xEF, 0xE7, 0x3E, 0x00, 0x0F, 0x81, 0xFE,
  0x1F, 0xF9, 0xE0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xDC, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0x70, 0x3B, 0xC1, 0xCF, 0xFC, 0x3F,
  0xC0, 0xFC, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x1F, 0x39, 0xFD, 0xDF, 0xFF, 0xE0, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x3F, 0xC1, 0xEF, 0xFF, 0x3F, 0xB8, 0xF9, 0xC0, 0x0F, 0x81,
  0xFF, 0x1F, 0xF8, 0xE0, 0xEE, 0x07, 0x70, 0x3B, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0xCF, 0xFE,
  0x3F, 0xE0, 0x7E, 0x00, 0x07, 0x87, 0xC7, 0xE3, 0x81, 0xC1, 0xC0, 0xE0,
  0x70, 0xFF, 0xFF, 0xCE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x1F, 0x39,
  0xFD, 0xDF, 0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0xC1, 0xEF, 0xFF,
  0x3F, 0xB8, 0xF9, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x30, 0x39, 0xFF, 0x8F,
  0xFC, 0x1F, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x0E, 0xF6, 0x00, 0x0E, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x01, 0xCE, 0x70, 0x00, 0x07,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0xFF, 0xDC, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0xF7, 0x07, 0x38, 0x71, 0xC7, 0x8E, 0x78,
  0x73, 0x83, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3D, 0xC1, 0xC7, 0x0E,
  0x3C, 0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0x77, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7, 0xC3, 0xE7, 0xFF,
  0x7F, 0xBF, 0xFF, 0xFF, 0xE0, 0xF0, 0x7E, 0x07, 0x83, 0xF0, 0x38, 0x1F,
  0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C,
  0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC,
  0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xC0, 0xE7, 0xCE, 0xFE, 0xFF,
  0xFF, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x0F,
  0x81, 0xFF, 0x1F, 0xFC, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1D, 0xC1, 0xCF,
  0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0xE7, 0xC7, 0x7F, 0x3F, 0xFD, 0xE0, 0xEE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xDF, 0xFE, 0xEF, 0xE7, 0x3E, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x1F, 0x39,
  0xFD, 0xDF, 0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC1, 0xEF, 0xFF,
  0x3F, 0xB8, 0xF9, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0xE7, 0xEF, 0xFF, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x83, 0xFC,
  0x7F, 0xEF, 0x0E, 0xE0, 0x7E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0xFE, 0x7F, 0xC1, 0xF8,
  0x1C, 0x0E, 0x07, 0x03, 0x8F, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xF0, 0xF8,
  0x3C, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0xF7,
  0xFF, 0x3F, 0xF1, 0xF7, 0xE0, 0x3F, 0x03, 0x98, 0x1C, 0xE0, 0xE7, 0x06,
  0x38, 0x70, 0xC3, 0x87, 0x1C, 0x38, 0xC0, 0xCE, 0x06, 0x70, 0x3B, 0x00,
  0xD8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x60,
  0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x77, 0x0F, 0x06, 0x70, 0xF0, 0xE7, 0x1F,
  0x8E, 0x71, 0xF8, 0xE3, 0x19, 0x8C, 0x39, 0x98, 0xC3, 0xB9, 0xDC, 0x3B,
  0x9D, 0xC1, 0xB0, 0xD8, 0x1F, 0x0D, 0x81, 0xF0, 0xF8, 0x1F, 0x07, 0x80,
  0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0xF0, 0x7B, 0x83, 0x9E, 0x3C,
  0x71, 0xC3, 0x9C, 0x0E, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xE0, 0x3B, 0x01, 0xDC, 0x1C, 0x70, 0xE3, 0x8E, 0x1E, 0x70, 0x77, 0x83,
  0xC0, 0xE0, 0x77, 0x03, 0xB8, 0x1C, 0xE1, 0xE7, 0x0E, 0x38, 0x70, 0xC3,
  0x87, 0x38, 0x39, 0xC1, 0xCE, 0x07, 0x60, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E,
  0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x03, 0xC1,
  0xC1, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xE0, 0xF0, 0xF0, 0x78, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x70, 0x70, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x0F,
  0x1E, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x70, 0xE0, 0x80, 0x1E, 0x03, 0x3F, 0x07, 0x7F, 0x87, 0xE3, 0xC6, 0xE1,
  0xFE, 0xE0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 24, 8, 3, -24 },
  { 10, 7, 8, 11, 2, -26 },
  { 17, 16, 24, 19, 2, -24 },
  { 65, 13, 31, 17, 2, -28 },
  { 116, 18, 24, 22, 2, -24 },
  { 170, 16, 24, 19, 2, -24 },
  { 218, 2, 8, 6, 2, -26 },
  { 220, 8, 35, 11, 2, -27 },
  { 255, 8, 35, 11, 1, -27 },
  { 290, 14, 14, 15, 0, -24 },
  { 315, 14, 18, 17, 1, -20 },
  { 347, 5, 8, 7, 0, -4 },
  { 352, 7, 3, 8, 1, -12 },
  { 355, 4, 4, 9, 2, -4 },
  { 357, 10, 26, 13, 1, -24 },
  { 390, 13, 24, 17, 2, -24 },
  { 429, 8, 24, 17, 3, -24 },
  { 453, 13, 24, 17, 2, -24 },
  { 492, 13, 24, 17, 2, -24 },
  { 531, 15, 24, 17, 1, -24 },
  { 576, 13, 24, 17, 2, -24 },
  { 615, 13, 24, 17, 2, -24 },
  { 654, 14, 24, 17, 1, -24 },
  { 696, 13, 24, 17, 2, -24 },
  { 735, 13, 24, 17, 2, -24 },
  { 774, 4, 19, 8, 2, -19 },
  { 784, 5, 23, 7, 1, -19 },
  { 799, 12, 15, 15, 1, -18 },
  { 822, 12, 11, 16, 2, -17 },
  { 839, 12, 15, 16, 2, -18 },
  { 862, 12, 24, 14, 1, -24 },
  { 898, 23, 32, 26, 2, -24 },
  { 990, 18, 24, 20, 1, -24 },
  { 1044, 14, 24, 19, 3, -24 },
  { 1086, 16, 24, 19, 2, -24 },
  { 1134, 14, 24, 19, 3, -24 },
  { 1176, 13, 24, 17, 3, -24 },
  { 1215, 12, 24, 16, 3, -24 },
  { 1251, 16, 24, 20, 2, -24 },
  { 1299, 15, 24, 21, 3, -24 },
  { 1344, 3, 24, 9, 3, -24 },
  { 1353, 13, 24, 16, 1, -24 },
  { 1392, 15, 24, 19, 3, -24 },
  { 1437, 12, 24, 16, 3, -24 },
  { 1473, 20, 24, 26, 3, -24 },
  { 1533, 15, 24, 21, 3, -24 },
  { 1578, 16, 24, 20, 2, -24 },
  { 1626, 15, 24, 19, 3, -24 },
  { 1671, 17, 28, 20, 2, -24 },
  { 1731, 15, 24, 18, 3, -24 },
  { 1776, 15, 24, 18, 1, -24 },
  { 1821, 16, 24, 18, 1, -24 },
  { 1869, 15, 24, 19, 2, -24 },
  { 1914, 17, 24, 19, 1, -24 },
  { 1965, 24, 24, 26, 1, -24 },
  { 2037, 17, 24, 19, 1, -24 },
  { 2088, 17, 24, 18, 0, -24 },
  { 2139, 14, 24, 18, 2, -24 },
  { 2181, 6, 33, 9, 2, -28 },
  { 2206, 11, 26, 13, 1, -24 },
  { 2242, 5, 33, 9, 1, -28 },
  { 2263, 10, 12, 13, 1, -24 },
  { 2278, 13, 3, 14, 0, 0 },
  { 2283, 7, 5, 11, 1, -26 },
  { 2288, 13, 18, 16, 2, -18 },
  { 2318, 13, 26, 17, 2, -26 },
  { 2361, 13, 18, 16, 2, -18 },
  { 2391, 13, 26, 17, 2, -26 },
  { 2434, 13, 18, 16, 2, -18 },
  { 2464, 9, 26, 11, 1, -26 },
  { 2494, 13, 25, 17, 2, -18 },
  { 2535, 12, 26, 16, 2, -26 },
  { 2574, 4, 25, 8, 2, -25 },
  { 2587, 5, 32, 8, 0, -25 },
  { 2607, 13, 26, 15, 2, -26 },
  { 2650, 3, 26, 8, 2, -26 },
  { 2660, 21, 18, 26, 2, -18 },
  { 2708, 12, 18, 16, 2, -18 },
  { 2735, 13, 18, 17, 2, -18 },
  { 2765, 13, 25, 17, 2, -18 },
  { 2806, 13, 25, 17, 2, -18 },
  { 2847, 8, 18, 10, 2, -18 },
  { 2865, 12, 18, 16, 2, -18 },
  { 2892, 9, 22, 10, 0, -22 },
  { 2917, 12, 18, 16, 2, -18 },
  { 2944, 13, 18, 15, 1, -18 },
  { 2974, 20, 18, 22, 1, -18 },
  { 3019, 13, 18, 15, 1, -18 },
  { 3049, 13, 25, 14, 1, -18 },
  { 3090, 12, 18, 15, 2, -18 },
  { 3117, 9, 33, 10, 1, -27 },
  { 3155, 2, 28, 8, 3, -24 },
  { 3162, 8, 33, 10, 1, -27 },
  { 3195, 16, 7, 20, 2, -14 },
};

const GFXfont RobotoCondensed_Regular34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_REGULAR34PT7B_H_
