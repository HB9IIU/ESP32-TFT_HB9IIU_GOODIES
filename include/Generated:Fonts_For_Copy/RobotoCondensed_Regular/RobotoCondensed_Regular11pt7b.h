#ifndef _ROBOTOCONDENSED_REGULAR11PT7B_H_
#define _ROBOTOCONDENSED_REGULAR11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x52, 0xBE, 0xA5, 0x7A, 0x94, 0x4E, 0x99, 0xC2, 0x19,
  0xE4, 0xC6, 0xB5, 0xC3, 0xAD, 0x63, 0x65, 0x28, 0x8E, 0xDA, 0x5F, 0xE0,
  0x5A, 0xAA, 0xA5, 0x89, 0x12, 0x49, 0x29, 0x40, 0x25, 0x1C, 0xC5, 0x00,
  0x21, 0x3E, 0x42, 0x00, 0x58, 0xC0, 0x80, 0x12, 0x22, 0x44, 0x44, 0x80,
  0xE9, 0x99, 0x99, 0x9E, 0x75, 0x55, 0xE9, 0x12, 0x24, 0x8F, 0xE9, 0x16,
  0x31, 0x9E, 0x11, 0x8C, 0xA5, 0x7C, 0x42, 0xF8, 0x8E, 0x11, 0x9E, 0x68,
  0x8E, 0x99, 0x96, 0xF8, 0x44, 0x21, 0x10, 0x88, 0xE9, 0x96, 0x99, 0x9E,
  0xEA, 0x99, 0xF1, 0x2C, 0x84, 0x40, 0x16, 0x16, 0x86, 0x10, 0xF0, 0xF0,
  0x86, 0x16, 0x80, 0x79, 0x11, 0x22, 0x02, 0x38, 0x8A, 0x6D, 0x5A, 0xB9,
  0x72, 0xDE, 0x80, 0xF0, 0x10, 0xC3, 0x0A, 0x49, 0xE4, 0x61, 0xF9, 0x9E,
  0x99, 0x9F, 0x74, 0xA3, 0x08, 0x46, 0x4E, 0xE4, 0xA3, 0x18, 0xC6, 0x5C,
  0xF8, 0x8F, 0x88, 0x8F, 0xF8, 0x8E, 0x88, 0x88, 0x74, 0x61, 0x0B, 0xC6,
  0x2E, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xFF, 0x08, 0x42, 0x10, 0x86, 0x4E,
  0x94, 0xA9, 0x8A, 0x52, 0x53, 0x88, 0x88, 0x88, 0x8F, 0x87, 0x1C, 0xF3,
  0xAE, 0xDB, 0x65, 0x8E, 0x73, 0x5A, 0xCE, 0x71, 0x74, 0x63, 0x18, 0xC6,
  0x2E, 0xF4, 0xE3, 0x3F, 0x42, 0x10, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0x08,
  0xF4, 0xA5, 0x2F, 0x52, 0x52, 0x7A, 0x50, 0xC1, 0x85, 0x2F, 0xF9, 0x08,
  0x42, 0x10, 0x84, 0x8C, 0x63, 0x18, 0xC6, 0x5E, 0x85, 0x24, 0x92, 0x28,
  0xC3, 0x04, 0x89, 0x49, 0x59, 0x56, 0x56, 0x56, 0x26, 0x22, 0x49, 0x23,
  0x0C, 0x30, 0xC4, 0x92, 0x89, 0x25, 0x0C, 0x30, 0x82, 0x08, 0x78, 0x44,
  0x22, 0x21, 0x1F, 0xEA, 0xAA, 0xAC, 0x84, 0x44, 0x22, 0x21, 0x10, 0xD5,
  0x55, 0x5C, 0x26, 0x69, 0xF0, 0x48, 0xE9, 0xF9, 0xBD, 0x88, 0x8E, 0x99,
  0x99, 0xE0, 0xE9, 0x88, 0x9E, 0x11, 0x1F, 0x99, 0x99, 0xF0, 0xE9, 0xF8,
  0x8E, 0x29, 0x74, 0x92, 0x40, 0xF9, 0x99, 0x9F, 0x1E, 0x88, 0x8E, 0x99,
  0x99, 0x90, 0xBF, 0x45, 0x55, 0x60, 0x88, 0x8A, 0xEC, 0xCA, 0xB0, 0xFF,
  0x80, 0xED, 0x26, 0x4C, 0x99, 0x32, 0x40, 0xE9, 0x99, 0x99, 0xE9, 0x99,
  0x9E, 0xE9, 0x99, 0x9E, 0x88, 0xF9, 0x99, 0x9F, 0x11, 0xEA, 0xA0, 0xF7,
  0x1B, 0xC0, 0x5D, 0x24, 0x98, 0x99, 0x99, 0x9F, 0x95, 0x55, 0x22, 0x92,
  0xA5, 0xB3, 0x66, 0xC4, 0x80, 0x52, 0x88, 0x45, 0x28, 0x95, 0x56, 0x22,
  0x2C, 0xE5, 0x29, 0xC0, 0x29, 0x25, 0x92, 0x48, 0x80, 0xFF, 0x80, 0x89,
  0x24, 0x52, 0x4A, 0x00, 0xCD, 0x80,
};

const GFXglyph RobotoCondensed_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 2, 3, 4, 1, -8 },
  { 3, 5, 8, 6, 1, -8 },
  { 8, 4, 10, 5, 1, -9 },
  { 13, 5, 8, 7, 1, -8 },
  { 18, 5, 8, 6, 1, -8 },
  { 23, 1, 3, 2, 0, -8 },
  { 24, 2, 12, 3, 1, -9 },
  { 27, 3, 12, 4, 0, -9 },
  { 32, 5, 5, 5, 0, -8 },
  { 36, 5, 5, 5, 0, -6 },
  { 40, 2, 3, 2, 0, -1 },
  { 41, 2, 1, 3, 0, -4 },
  { 42, 1, 1, 3, 1, -1 },
  { 43, 4, 9, 4, 0, -8 },
  { 48, 4, 8, 5, 1, -8 },
  { 52, 2, 8, 5, 1, -8 },
  { 54, 4, 8, 5, 1, -8 },
  { 58, 4, 8, 5, 1, -8 },
  { 62, 5, 8, 5, 0, -8 },
  { 67, 4, 8, 5, 1, -8 },
  { 71, 4, 8, 5, 1, -8 },
  { 75, 5, 8, 5, 0, -8 },
  { 80, 4, 8, 5, 1, -8 },
  { 84, 4, 8, 5, 1, -8 },
  { 88, 1, 6, 3, 1, -6 },
  { 89, 2, 8, 2, 0, -6 },
  { 91, 4, 5, 5, 0, -6 },
  { 94, 4, 3, 5, 1, -5 },
  { 96, 4, 5, 5, 1, -6 },
  { 99, 4, 8, 5, 0, -8 },
  { 103, 7, 10, 8, 1, -8 },
  { 112, 6, 8, 6, 0, -8 },
  { 118, 4, 8, 6, 1, -8 },
  { 122, 5, 8, 6, 1, -8 },
  { 127, 5, 8, 6, 1, -8 },
  { 132, 4, 8, 5, 1, -8 },
  { 136, 4, 8, 5, 1, -8 },
  { 140, 5, 8, 7, 1, -8 },
  { 145, 5, 8, 7, 1, -8 },
  { 150, 1, 8, 3, 1, -8 },
  { 151, 5, 8, 5, 0, -8 },
  { 156, 5, 8, 6, 1, -8 },
  { 161, 4, 8, 5, 1, -8 },
  { 165, 6, 8, 8, 1, -8 },
  { 171, 5, 8, 7, 1, -8 },
  { 176, 5, 8, 7, 1, -8 },
  { 181, 5, 8, 6, 1, -8 },
  { 186, 5, 9, 7, 1, -8 },
  { 192, 5, 8, 6, 1, -8 },
  { 197, 5, 8, 6, 0, -8 },
  { 202, 5, 8, 6, 0, -8 },
  { 207, 5, 8, 6, 1, -8 },
  { 212, 6, 8, 6, 0, -8 },
  { 218, 8, 8, 8, 0, -8 },
  { 226, 6, 8, 6, 0, -8 },
  { 232, 6, 8, 6, 0, -8 },
  { 238, 5, 8, 6, 0, -8 },
  { 243, 2, 11, 3, 1, -9 },
  { 246, 4, 9, 4, 0, -8 },
  { 251, 2, 11, 3, 0, -9 },
  { 254, 4, 4, 4, 0, -8 },
  { 256, 4, 1, 4, 0, 0 },
  { 257, 3, 2, 3, 0, -9 },
  { 258, 4, 6, 5, 1, -6 },
  { 261, 4, 9, 5, 1, -9 },
  { 266, 4, 6, 5, 1, -6 },
  { 269, 4, 9, 5, 1, -9 },
  { 274, 4, 6, 5, 1, -6 },
  { 277, 3, 9, 3, 0, -9 },
  { 281, 4, 8, 5, 1, -6 },
  { 285, 4, 9, 5, 1, -9 },
  { 290, 1, 8, 3, 1, -8 },
  { 291, 2, 10, 2, 0, -8 },
  { 294, 4, 9, 5, 1, -9 },
  { 299, 1, 9, 3, 1, -9 },
  { 301, 7, 6, 8, 1, -6 },
  { 307, 4, 6, 5, 1, -6 },
  { 310, 4, 6, 6, 1, -6 },
  { 313, 4, 8, 5, 1, -6 },
  { 317, 4, 8, 6, 1, -6 },
  { 321, 2, 6, 3, 1, -6 },
  { 323, 3, 6, 5, 1, -6 },
  { 326, 3, 7, 3, 0, -7 },
  { 329, 4, 6, 5, 1, -6 },
  { 332, 4, 6, 5, 0, -6 },
  { 335, 7, 6, 7, 0, -6 },
  { 341, 5, 6, 5, 0, -6 },
  { 345, 4, 8, 5, 0, -6 },
  { 349, 3, 6, 5, 1, -6 },
  { 352, 3, 11, 3, 0, -9 },
  { 357, 1, 9, 3, 1, -8 },
  { 359, 3, 11, 3, 0, -9 },
  { 364, 5, 2, 6, 1, -4 },
};

const GFXfont RobotoCondensed_Regular11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_REGULAR11PT7B_H_
