#ifndef _ROBOTOCONDENSED_REGULAR52PT7B_H_
#define _ROBOTOCONDENSED_REGULAR52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x90, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3B, 0xC7, 0x70, 0xEE, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70,
  0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0,
  0x70, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC1,
  0xE0, 0x01, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xC0, 0x03, 0xC1,
  0xC0, 0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x83, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07,
  0x80, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3E,
  0x07, 0xC3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xE7,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x7E, 0x07, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x78,
  0x1C, 0x0E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x38, 0x0E, 0x07, 0x87, 0x80,
  0xE0, 0x78, 0x70, 0x0E, 0x07, 0x8F, 0x00, 0xE0, 0x70, 0xE0, 0x0F, 0x0F,
  0x1E, 0x00, 0x7F, 0xF1, 0xC0, 0x03, 0xFE, 0x38, 0x00, 0x1F, 0xC3, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x3F, 0x80, 0x03, 0x87,
  0xFC, 0x00, 0x78, 0xFF, 0xC0, 0x07, 0x1E, 0x1E, 0x00, 0xF1, 0xC0, 0xE0,
  0x0E, 0x1C, 0x0E, 0x01, 0xE1, 0xC0, 0xF0, 0x1C, 0x1C, 0x0F, 0x03, 0xC1,
  0xC0, 0xF0, 0x38, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0E,
  0x03, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x01,
  0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0xF1, 0xF1, 0xF0, 0x78, 0xF8, 0x7C, 0x3C, 0xF8, 0x3E, 0x1E,
  0x7C, 0x0F, 0x9F, 0x3C, 0x03, 0xEF, 0x1E, 0x01, 0xFF, 0x8F, 0x00, 0x7F,
  0xC7, 0x80, 0x1F, 0xC3, 0xC0, 0x0F, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xF8, 0x3E, 0x03, 0xFE, 0x1F, 0xE7, 0xFF, 0x07, 0xFF, 0xF7, 0xC1, 0xFF,
  0xF3, 0xF0, 0x3F, 0xE0, 0xF8, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x20, 0x06, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x02, 0x40, 0x06,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0x60, 0x04, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x01, 0x01,
  0xC0, 0x5F, 0x0E, 0x1E, 0xFE, 0x73, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF3,
  0xC0, 0x0F, 0x9F, 0x00, 0x78, 0x78, 0x07, 0xC1, 0xE0, 0x7C, 0x0F, 0x80,
  0xC0, 0x38, 0x02, 0x01, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C,
  0xF3, 0xE7, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xEF,
  0xBE, 0xF8, 0x80, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x3F, 0x9F, 0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xC7, 0xC0, 0x3E,
  0x78, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1E, 0xF8, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3E,
  0x7C, 0x03, 0xC3, 0xE0, 0x7C, 0x3F, 0x9F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF0, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0x0F, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xCF, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x78, 0x01, 0xF1, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0x3E, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x00,
  0x20, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0x9F, 0xC3,
  0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0x80, 0x1F,
  0x78, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xE3, 0xE0, 0x3E,
  0x3F, 0x9F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3,
  0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC0, 0xF0,
  0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x9F, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x87, 0xE1, 0xFC, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF8, 0x03,
  0xE7, 0x80, 0x7C, 0x7C, 0x07, 0xC3, 0xF1, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x8F, 0xC0, 0x79, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xCF, 0xF0, 0x7C, 0xFE, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x3C, 0x01, 0xE3,
  0xE0, 0x3E, 0x3F, 0x07, 0xE1, 0xFD, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0,
  0x03, 0xFE, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0x9F, 0x83, 0xE0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x01, 0xE7, 0x80,
  0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xC3, 0xC0, 0x7C, 0x3F,
  0x0F, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xF0, 0xFC, 0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xEF, 0x80, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x3F, 0x9F, 0xC3, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFB, 0xF8, 0xFC, 0x1F, 0x1F,
  0x01, 0xF3, 0xC0, 0x3E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0xC0, 0x7E, 0xFC,
  0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xEF, 0x0F, 0xF9, 0xE0, 0x7C, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0x00, 0x79, 0xFF, 0xDF, 0x7C, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xFD, 0xF7,
  0xC4, 0x1E, 0x3F, 0x3F, 0x3F, 0x3E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x70, 0x20, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x03, 0xE7, 0x80, 0xFB, 0xE0, 0x1E, 0xF8,
  0x07, 0xFE, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x7C,
  0x01, 0xC3, 0xC0, 0x3F, 0xE0, 0x38, 0x70, 0x0F, 0xFE, 0x07, 0x9E, 0x01,
  0xF3, 0xE0, 0x73, 0xC0, 0x78, 0x3C, 0x0E, 0x70, 0x1E, 0x07, 0x01, 0xCE,
  0x03, 0xC0, 0xE0, 0x39, 0xC0, 0x70, 0x1C, 0x07, 0x78, 0x1E, 0x03, 0x80,
  0xEF, 0x03, 0xC0, 0x70, 0x1D, 0xE0, 0x70, 0x0E, 0x03, 0xB8, 0x1E, 0x03,
  0xC0, 0x77, 0x03, 0xC0, 0x78, 0x0E, 0xE0, 0x78, 0x0F, 0x01, 0xDC, 0x0F,
  0x01, 0xE0, 0x3B, 0x81, 0xE0, 0x3C, 0x07, 0x70, 0x3C, 0x07, 0x80, 0xEE,
  0x07, 0x80, 0xF0, 0x1D, 0xC0, 0xF0, 0x3C, 0x07, 0x3C, 0x1E, 0x07, 0xC0,
  0xE7, 0x81, 0xE1, 0xF8, 0x3C, 0xF0, 0x3E, 0x7F, 0x0F, 0x0E, 0x07, 0xFE,
  0xFF, 0xC1, 0xC0, 0x7F, 0x9F, 0xF8, 0x3C, 0x07, 0xE1, 0xFC, 0x07, 0x80,
  0x20, 0x04, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x80, 0x00, 0x1F, 0xC1,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xF0, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF,
  0x80, 0x7F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7C,
  0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x3E, 0xF8, 0x03, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x3E,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x7C, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8,
  0x0F, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0x7B, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xEF, 0x80,
  0x1F, 0xBE, 0x00, 0xFC, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x80,
  0xFE, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x1F, 0x80,
  0x3F, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01,
  0xF7, 0xC0, 0x3F, 0x3E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0x02, 0x00, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00,
  0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00,
  0xF9, 0xF8, 0x00, 0xFB, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x7C, 0x00, 0xFE, 0x7C, 0x00,
  0xFC, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xEF, 0x00, 0x07, 0xFF, 0xDE, 0x00, 0x0F, 0x7F, 0xBE, 0x00, 0x1E, 0xFF,
  0x3C, 0x00, 0x7D, 0xFE, 0x78, 0x00, 0xF3, 0xFC, 0xF8, 0x01, 0xE7, 0xF8,
  0xF0, 0x07, 0xCF, 0xF1, 0xE0, 0x0F, 0x1F, 0xE3, 0xE0, 0x1E, 0x3F, 0xE3,
  0xC0, 0x7C, 0x7F, 0xC7, 0x80, 0xF0, 0xFF, 0x8F, 0x81, 0xE1, 0xFF, 0x0F,
  0x07, 0xC3, 0xFE, 0x1E, 0x0F, 0x07, 0xFC, 0x3E, 0x1E, 0x0F, 0xF8, 0x3C,
  0x7C, 0x1F, 0xF0, 0x78, 0xF0, 0x3F, 0xE0, 0xF1, 0xE0, 0x7F, 0xC0, 0xF7,
  0xC0, 0xFF, 0x81, 0xEF, 0x01, 0xFF, 0x03, 0xDE, 0x03, 0xFE, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0,
  0x3F, 0xE0, 0x1F, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0xFF, 0x80, 0x3C, 0x01,
  0xE0, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFB, 0xC0, 0x0F, 0xFB, 0xE0,
  0x0F, 0xF9, 0xE0, 0x0F, 0xF9, 0xF0, 0x0F, 0xF8, 0xF0, 0x0F, 0xF8, 0xF8,
  0x0F, 0xF8, 0x78, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3E,
  0x0F, 0xF8, 0x1E, 0x0F, 0xF8, 0x1F, 0x0F, 0xF8, 0x0F, 0x0F, 0xF8, 0x0F,
  0x8F, 0xF8, 0x07, 0x8F, 0xF8, 0x07, 0xCF, 0xF8, 0x03, 0xCF, 0xF8, 0x01,
  0xEF, 0xF8, 0x01, 0xEF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFC, 0x07, 0xE0, 0xFC,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9E,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x0F,
  0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x80, 0x3F, 0x9F, 0x00, 0x1F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFC, 0x07, 0xE0,
  0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x7E, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x63, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x40, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80,
  0x7F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x07,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1,
  0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x01,
  0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF,
  0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3F, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xDE, 0x00, 0x0F, 0xBE, 0x00, 0x1E, 0x7E, 0x00, 0x7C, 0x7E, 0x01, 0xF8,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0x3E,
  0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x0F, 0x01, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x00,
  0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x80, 0x1F, 0x78, 0x01, 0xF8, 0x01, 0xE7,
  0x80, 0x1F, 0x80, 0x1E, 0x7C, 0x01, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0xC0,
  0x3E, 0x7C, 0x03, 0xFC, 0x03, 0xE3, 0xC0, 0x3F, 0xC0, 0x3C, 0x3C, 0x03,
  0xDC, 0x03, 0xC3, 0xE0, 0x39, 0xE0, 0x3C, 0x3E, 0x07, 0x9E, 0x07, 0xC3,
  0xE0, 0x79, 0xE0, 0x7C, 0x1E, 0x07, 0x8E, 0x07, 0x81, 0xE0, 0x70, 0xF0,
  0x78, 0x1E, 0x0F, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0xF0, 0xF8, 0x1F, 0x0F,
  0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x70, 0xF0, 0x0F, 0x0E, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x78, 0xF0, 0x0F, 0x9E, 0x07, 0x8F, 0x00, 0xF9, 0xE0, 0x39,
  0xF0, 0x07, 0x9C, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x07, 0xBC,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1D, 0xE0, 0x07, 0xB8, 0x01, 0xDE, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03,
  0xF0, 0x3E, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x1F, 0x80,
  0x0F, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C,
  0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xF3, 0xF8, 0xF8, 0x0F, 0x9E, 0x01, 0xF7, 0xC0, 0x1E, 0xF8,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xF1, 0xFE, 0x1E, 0x7C, 0x03, 0xDF, 0x00, 0x7B, 0xE0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xF7, 0xC0,
  0x7E, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xEF, 0x8F, 0xF1, 0xF0, 0x10,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF9, 0xFF, 0x0F, 0xBF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3E, 0xFE, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xBF, 0xF8,
  0xF9, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0x8F, 0xE3, 0xE0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF3, 0xE0, 0x3E, 0x1F, 0x8F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x07, 0xFC, 0xF0, 0xFF, 0xEF, 0x1F, 0xFF, 0xF3, 0xFD, 0xFF, 0x3E, 0x03,
  0xF7, 0xC0, 0x1F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x1F, 0x3E, 0x03, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xEF, 0x07, 0xFC, 0xF0, 0x04, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xF9, 0xFC, 0xF8, 0x0F,
  0x9E, 0x00, 0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x33, 0xF0, 0x0E, 0x3F, 0xCF, 0xE7, 0xFF, 0xF8,
  0x7F, 0xFE, 0x03, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x10, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF8, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0x0F, 0xFE,
  0xF1, 0xFF, 0xFF, 0x3F, 0xDF, 0xF3, 0xE0, 0x3F, 0x7C, 0x01, 0xF7, 0xC0,
  0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x0F,
  0x7C, 0x01, 0xF3, 0xE0, 0x3F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFE,
  0xF0, 0x7F, 0xCF, 0x00, 0x40, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF1, 0x80, 0x3E, 0x1E, 0x07, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x08, 0x0F,
  0x9F, 0xE1, 0xF7, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFE, 0x07, 0xDF,
  0x80, 0x7B, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xF8, 0x79, 0xEF, 0xDE, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x07, 0x87, 0xC3, 0xE1,
  0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xF7, 0xFB,
  0xF9, 0xF8, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xCF, 0x80,
  0xFC, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE0, 0xF8,
  0x7C, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xEF, 0x80,
  0xFC, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x3E, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x7C, 0xFF, 0x03, 0xFC, 0x3E, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFF, 0xF7, 0xFF, 0xCF, 0xFB, 0xFF, 0xEF, 0xF7, 0xF0, 0x3F, 0xC0,
  0xFB, 0xF0, 0x0F, 0xC0, 0x3D, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0,
  0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C,
  0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F,
  0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01,
  0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80,
  0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0,
  0x07, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x10, 0x1F, 0x3F,
  0xC3, 0xEF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFC, 0x0F, 0xBF, 0x00,
  0xF7, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xCF, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x1F, 0x1F, 0x00,
  0x3E, 0x7C, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1E, 0x7C, 0x00,
  0x79, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0xC0, 0x7C, 0x1F, 0xC7, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xBF, 0xEF,
  0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0xC0, 0x7E, 0xFF,
  0x9F, 0xCF, 0xFF, 0xFC, 0xFB, 0xFF, 0x8F, 0x9F, 0xE0, 0xF8, 0x30, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0x0F, 0xFE, 0xF1, 0xFF, 0xFF, 0x3F,
  0x8F, 0xF3, 0xE0, 0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0x0F, 0x7C, 0x00, 0xF7, 0xC0, 0x0F, 0x7C, 0x01, 0xF3, 0xE0,
  0x3F, 0x3F, 0x8F, 0xF1, 0xFF, 0xFF, 0x0F, 0xFE, 0xF0, 0x7F, 0xCF, 0x00,
  0x40, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0x7F, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0x40, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x0F,
  0xDF, 0x03, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xCF,
  0x80, 0xC0, 0x00, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0,
  0x3E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x39, 0xE0,
  0x03, 0xDC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0xF0, 0x07, 0x80, 0x3D, 0xE0, 0x1F, 0x00, 0xFB, 0xE0,
  0x3F, 0x01, 0xF7, 0xC0, 0x7E, 0x03, 0xC7, 0x80, 0xFC, 0x07, 0x8F, 0x03,
  0xF8, 0x0F, 0x1E, 0x07, 0xF8, 0x3E, 0x3E, 0x0F, 0xF0, 0x78, 0x3C, 0x3D,
  0xE0, 0xF0, 0x78, 0x79, 0xC1, 0xE0, 0xF0, 0xF3, 0xC3, 0xC1, 0xF1, 0xE7,
  0x8F, 0x01, 0xE7, 0x8F, 0x1E, 0x03, 0xCF, 0x0F, 0x3C, 0x07, 0x9E, 0x1E,
  0x78, 0x0F, 0x38, 0x3D, 0xE0, 0x0F, 0xF0, 0x3B, 0xC0, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF7, 0xC0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F,
  0x8F, 0x80, 0x79, 0xF0, 0x07, 0xDE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x03, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xDF, 0x00, 0x78, 0xF0, 0x0F, 0x8F,
  0x81, 0xF0, 0x78, 0x1F, 0x07, 0xC3, 0xE0, 0x3C, 0x3E, 0x03, 0xE7, 0xC0,
  0x1F, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x78, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0x78,
  0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF1, 0xF0, 0x0F, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x7B,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x10, 0x03, 0x80,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x70, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0xFE,
  0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x02,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x03, 0xCF, 0xFE, 0x01, 0xC7,
  0xFF, 0x81, 0xE7, 0xC7, 0xE0, 0xF3, 0xC1, 0xF8, 0xFB, 0xC0, 0x7F, 0xF9,
  0xE0, 0x1F, 0xF8, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 38, 13, 4, -37 },
  { 25, 11, 13, 17, 3, -39 },
  { 43, 24, 37, 28, 3, -37 },
  { 154, 20, 49, 26, 3, -43 },
  { 277, 28, 39, 33, 3, -38 },
  { 414, 25, 39, 28, 3, -38 },
  { 536, 3, 12, 9, 3, -39 },
  { 541, 12, 54, 16, 3, -42 },
  { 622, 12, 54, 17, 1, -42 },
  { 703, 21, 22, 22, 1, -37 },
  { 761, 21, 27, 26, 2, -30 },
  { 832, 7, 13, 10, 1, -6 },
  { 844, 11, 4, 13, 1, -18 },
  { 850, 6, 6, 14, 4, -5 },
  { 855, 17, 40, 19, 1, -37 },
  { 940, 20, 39, 26, 3, -38 },
  { 1038, 12, 37, 26, 4, -37 },
  { 1094, 22, 38, 26, 2, -38 },
  { 1199, 20, 39, 26, 2, -38 },
  { 1297, 22, 37, 26, 2, -37 },
  { 1399, 20, 38, 26, 4, -37 },
  { 1494, 20, 38, 26, 3, -37 },
  { 1589, 21, 37, 26, 2, -37 },
  { 1687, 20, 39, 26, 3, -38 },
  { 1785, 19, 38, 26, 3, -38 },
  { 1876, 6, 28, 12, 3, -27 },
  { 1897, 8, 34, 11, 1, -27 },
  { 1931, 17, 23, 23, 2, -28 },
  { 1980, 18, 15, 25, 4, -25 },
  { 2014, 19, 23, 24, 3, -28 },
  { 2069, 18, 39, 22, 2, -38 },
  { 2157, 35, 48, 40, 3, -36 },
  { 2367, 28, 37, 30, 1, -37 },
  { 2497, 21, 37, 28, 4, -37 },
  { 2595, 24, 39, 29, 3, -38 },
  { 2712, 22, 37, 30, 4, -37 },
  { 2814, 20, 37, 26, 4, -37 },
  { 2907, 19, 37, 25, 4, -37 },
  { 2995, 24, 39, 31, 3, -38 },
  { 3112, 24, 37, 32, 4, -37 },
  { 3223, 5, 37, 13, 4, -37 },
  { 3247, 20, 38, 25, 1, -37 },
  { 3342, 24, 37, 28, 4, -37 },
  { 3453, 19, 37, 25, 4, -37 },
  { 3541, 31, 37, 39, 4, -37 },
  { 3685, 24, 37, 32, 4, -37 },
  { 3796, 25, 39, 31, 3, -38 },
  { 3918, 23, 37, 29, 4, -37 },
  { 4025, 25, 44, 31, 3, -38 },
  { 4163, 23, 37, 28, 4, -37 },
  { 4270, 23, 39, 27, 2, -38 },
  { 4383, 24, 37, 27, 2, -37 },
  { 4494, 23, 38, 29, 3, -37 },
  { 4604, 27, 37, 29, 1, -37 },
  { 4729, 36, 37, 40, 2, -37 },
  { 4896, 25, 37, 29, 2, -37 },
  { 5012, 25, 37, 27, 1, -37 },
  { 5128, 23, 37, 27, 2, -37 },
  { 5235, 9, 50, 13, 3, -42 },
  { 5292, 18, 40, 19, 1, -37 },
  { 5382, 8, 50, 13, 1, -42 },
  { 5432, 16, 18, 19, 2, -37 },
  { 5468, 19, 4, 21, 1, 0 },
  { 5478, 11, 7, 16, 1, -39 },
  { 5488, 19, 29, 25, 3, -28 },
  { 5557, 20, 40, 26, 3, -39 },
  { 5657, 20, 29, 24, 2, -28 },
  { 5730, 20, 40, 26, 2, -39 },
  { 5830, 19, 29, 24, 3, -28 },
  { 5899, 14, 40, 16, 2, -40 },
  { 5969, 20, 39, 26, 2, -28 },
  { 6067, 19, 39, 25, 3, -39 },
  { 6160, 6, 37, 12, 3, -37 },
  { 6188, 9, 48, 12, -1, -37 },
  { 6242, 20, 39, 23, 3, -39 },
  { 6340, 4, 39, 12, 4, -39 },
  { 6360, 33, 28, 39, 3, -28 },
  { 6476, 19, 28, 25, 3, -28 },
  { 6543, 22, 29, 26, 2, -28 },
  { 6623, 20, 39, 26, 3, -28 },
  { 6721, 20, 39, 26, 2, -28 },
  { 6819, 12, 28, 16, 3, -28 },
  { 6861, 18, 29, 24, 3, -28 },
  { 6927, 12, 35, 15, 1, -34 },
  { 6980, 19, 28, 25, 3, -27 },
  { 7047, 20, 27, 22, 1, -27 },
  { 7115, 31, 27, 34, 1, -27 },
  { 7220, 20, 27, 23, 1, -27 },
  { 7288, 20, 38, 22, 1, -27 },
  { 7383, 19, 27, 23, 2, -27 },
  { 7448, 13, 50, 16, 2, -41 },
  { 7530, 4, 44, 13, 4, -37 },
  { 7552, 13, 50, 16, 1, -41 },
  { 7634, 25, 10, 31, 3, -20 },
};

const GFXfont RobotoCondensed_Regular52pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular52pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular52pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _ROBOTOCONDENSED_REGULAR52PT7B_H_
