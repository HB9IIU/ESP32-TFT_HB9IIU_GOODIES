#ifndef _ROBOTOCONDENSED_REGULAR39PT7B_H_
#define _ROBOTOCONDENSED_REGULAR39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x00,
  0x00, 0x6F, 0xF6, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x01,
  0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x07, 0x1C, 0x01, 0x87, 0x00, 0x61,
  0xC0, 0x38, 0x70, 0x0E, 0x18, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC,
  0x0C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x70, 0x06,
  0x1C, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x0E, 0x18, 0x03, 0x8E,
  0x00, 0xC3, 0x80, 0x30, 0xE0, 0x1C, 0x38, 0x07, 0x0C, 0x01, 0xC3, 0x00,
  0x71, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7E, 0x03,
  0xFE, 0x0F, 0xFE, 0x1E, 0x3E, 0x78, 0x3C, 0xF0, 0x3D, 0xC0, 0x7B, 0x80,
  0xF7, 0x80, 0xEF, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0, 0xF7, 0xC3, 0xC7, 0xFF, 0x87, 0xFE,
  0x03, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x01, 0xF8, 0x00, 0x1C, 0xE0, 0x01, 0xC3, 0x02, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0x83, 0x87, 0x1C, 0x1C, 0x38, 0xC0, 0xE1, 0xCE, 0x07, 0x0C, 0x60,
  0x1D, 0xE7, 0x00, 0xFE, 0x30, 0x01, 0xE3, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x78, 0x00, 0xC7, 0xE0, 0x0E, 0x73, 0x80, 0x63, 0x0E,
  0x07, 0x38, 0x70, 0x31, 0xC3, 0x83, 0x8E, 0x1C, 0x18, 0x70, 0xE1, 0xC3,
  0x87, 0x0C, 0x0C, 0x38, 0x00, 0x7B, 0x80, 0x01, 0xF8, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x1E, 0x3C, 0x03, 0xC3, 0x80,
  0x70, 0x78, 0x0E, 0x0F, 0x01, 0xC1, 0xC0, 0x3C, 0x38, 0x07, 0x8E, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x1C, 0x79, 0xE3, 0x9E, 0x1E, 0x73, 0xC3, 0xCE, 0x70, 0x3D, 0xCE,
  0x03, 0xF9, 0xC0, 0x7E, 0x3C, 0x07, 0xC3, 0x80, 0xF8, 0x78, 0x3F, 0x07,
  0xFF, 0xF0, 0x7F, 0xCF, 0x03, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x80, 0xC0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C,
  0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x07, 0x03, 0x01, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x08, 0x38, 0x1E, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F, 0x80,
  0x3F, 0x00, 0xF7, 0x01, 0xC7, 0x07, 0x0F, 0x0E, 0x0E, 0x08, 0x10, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x7B, 0xDE, 0xF7, 0xB9, 0xDE, 0xE2, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE1, 0xE7, 0x83, 0xCE, 0x03, 0x9C,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xEE, 0x03, 0xDC, 0x07, 0x3C, 0x1E, 0x3C, 0x3C, 0x7F,
  0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x00, 0x83, 0xC7, 0xEF, 0xFF, 0xFF, 0x1E,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x78, 0x7C, 0x70, 0x3C, 0xF0,
  0x1E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xC3, 0xE7, 0x03, 0xDE, 0x03, 0xBC, 0x07, 0x70, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x7F, 0x00, 0xFC, 0x01,
  0xFE, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x07, 0x78, 0x1E, 0x78, 0x7C, 0x7F, 0xF0, 0x7F, 0xC0,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x01,
  0xC7, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x38,
  0x78, 0x1C, 0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF3, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xDF, 0x03, 0xFF,
  0x87, 0xFF, 0x8F, 0x1F, 0x0C, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xBC, 0x07, 0x38, 0x1E, 0x78,
  0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0x7E, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE,
  0x0F, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x7C, 0x3B, 0xFC, 0xFF, 0xFB, 0xE1, 0xEF, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xDC,
  0x0F, 0x78, 0x78, 0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1, 0xE3, 0xE7,
  0x83, 0xCE, 0x03, 0x9C, 0x07, 0x38, 0x0F, 0x70, 0x1C, 0xE0, 0x39, 0xE0,
  0xF1, 0xE1, 0xC1, 0xFF, 0x81, 0xFC, 0x07, 0xFE, 0x1E, 0x3C, 0x78, 0x1C,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xB8,
  0x0E, 0x78, 0x3C, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x3F,
  0xC0, 0xFF, 0xC3, 0xC3, 0xC7, 0x83, 0xCE, 0x07, 0xBC, 0x07, 0x70, 0x0E,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xDC,
  0x0F, 0xBC, 0x3F, 0x3F, 0xFE, 0x3F, 0xB8, 0x3E, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x01, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x39, 0xF7, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE3, 0x8E, 0x38, 0xE7, 0x9C, 0xF3, 0x84, 0x00, 0x00, 0x04,
  0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x00,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xC0, 0x07, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x07,
  0x00, 0x3C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x38, 0x07, 0xC0, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x03, 0xC0, 0x18, 0x00,
  0x80, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xF1, 0xEF, 0x07, 0x70, 0x3F,
  0x81, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0C, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x0E, 0x38, 0x0F, 0x81, 0x8C, 0x07, 0xF0, 0x67, 0x03, 0xFE, 0x1D,
  0xC1, 0xC3, 0x87, 0x70, 0x60, 0xE0, 0xD8, 0x38, 0x30, 0x36, 0x0E, 0x0C,
  0x0F, 0x83, 0x03, 0x03, 0xE1, 0xC0, 0xC0, 0xF8, 0x70, 0x70, 0x3E, 0x1C,
  0x1C, 0x0F, 0x87, 0x07, 0x07, 0xE1, 0xC1, 0xC1, 0xF8, 0x70, 0x70, 0x6E,
  0x1C, 0x3C, 0x1B, 0x87, 0x8F, 0x0E, 0x60, 0xFE, 0xE7, 0x18, 0x3F, 0x3F,
  0x87, 0x03, 0x87, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x40, 0x01,
  0xF8, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0x70, 0x01,
  0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x83, 0x80, 0x38, 0x1C,
  0x01, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x8F, 0x00, 0x1C,
  0x70, 0x00, 0xF3, 0x80, 0x07, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xF0, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x3C, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0,
  0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0xF0, 0x78, 0x3E, 0x3C, 0x03, 0x9E, 0x00, 0xF7, 0x80, 0x3D, 0xC0,
  0x07, 0x70, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x07, 0x70, 0x01, 0xDE, 0x00, 0xF7, 0x80, 0x3C, 0xF0,
  0x0E, 0x1E, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFF, 0x1E, 0x0F, 0xCF, 0x01, 0xE7, 0x80, 0x7B, 0xC0,
  0x1D, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x77, 0x80, 0x7B, 0xC0, 0x3D, 0xE0,
  0x3C, 0xF0, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0x9F, 0xFF,
  0x3F, 0xFE, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8,
  0x3E, 0x3C, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x3D, 0xC0, 0x07, 0x70, 0x01,
  0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xC0,
  0x07, 0x70, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x1C, 0xF0, 0x07, 0x1F, 0x07,
  0xC7, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xBC, 0x0E, 0x7C, 0x7C, 0x7F,
  0xF0, 0x7F, 0xC0, 0x3F, 0x00, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x01, 0xF3,
  0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xF1,
  0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0xF0,
  0x0F, 0x3C, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xF7, 0x00, 0x3F, 0xEE, 0x00, 0xFF, 0xDC,
  0x01, 0xDF, 0x9C, 0x03, 0xBF, 0x38, 0x0F, 0x7E, 0x70, 0x1C, 0xFC, 0x70,
  0x39, 0xF8, 0xE0, 0xF3, 0xF1, 0xC1, 0xC7, 0xE1, 0xC3, 0x8F, 0xC3, 0x8F,
  0x1F, 0x87, 0x1C, 0x3F, 0x07, 0x38, 0x7E, 0x0E, 0xF0, 0xFC, 0x1D, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x78, 0x1F,
  0x80, 0xF0, 0x3F, 0x01, 0xC0, 0x70, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xF7, 0x01, 0xFD, 0xC0, 0x7F, 0x38, 0x1F, 0xCE, 0x07, 0xF1, 0xC1, 0xFC,
  0x70, 0x7F, 0x0E, 0x1F, 0xC3, 0x87, 0xF0, 0x71, 0xFC, 0x1E, 0x7F, 0x03,
  0x9F, 0xC0, 0xF7, 0xF0, 0x1D, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0x87, 0xC3, 0xC0, 0x7C, 0xF0, 0x07, 0x9E,
  0x00, 0x73, 0x80, 0x0F, 0x70, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xF0,
  0x03, 0x9E, 0x00, 0xF1, 0xE0, 0x1E, 0x1F, 0x0F, 0x83, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x03,
  0xEF, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xF7, 0x80, 0xFB, 0xFF, 0xF9,
  0xFF, 0xF8, 0xFF, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0x87, 0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xF7, 0x00, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0xF1, 0xE0,
  0x3C, 0x3F, 0x0F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0xFF,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x07, 0xCF, 0x01, 0xE7, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x01,
  0xEF, 0x01, 0xE7, 0x81, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x78,
  0x38, 0x3C, 0x1E, 0x1E, 0x07, 0x0F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0x79,
  0xE0, 0x3C, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xDE, 0x00, 0xF0, 0x07,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x3B,
  0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1D,
  0xE0, 0x1E, 0x7C, 0x1F, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xE0, 0x1E, 0x3C, 0x0F, 0x0F, 0xFF,
  0xC1, 0xFF, 0xC0, 0x0F, 0xC0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00,
  0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x03, 0x81, 0xC0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E,
  0x07, 0x00, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x79, 0xE0, 0x07, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0xBC, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF7, 0x00, 0xF0, 0x0E, 0x70, 0x0F,
  0x00, 0xE7, 0x00, 0xF0, 0x0E, 0x78, 0x0F, 0x81, 0xE7, 0x81, 0xF8, 0x1E,
  0x38, 0x1F, 0x81, 0xC3, 0x81, 0xF8, 0x1C, 0x38, 0x1D, 0x81, 0xC3, 0xC3,
  0x9C, 0x3C, 0x3C, 0x39, 0xC3, 0xC1, 0xC3, 0x9C, 0x38, 0x1C, 0x38, 0xC3,
  0x81, 0xC3, 0x0E, 0x38, 0x1C, 0x70, 0xE3, 0x81, 0xE7, 0x0E, 0x78, 0x0E,
  0x70, 0xE7, 0x00, 0xE7, 0x06, 0x70, 0x0E, 0xE0, 0x77, 0x00, 0xEE, 0x07,
  0x70, 0x0E, 0xE0, 0x77, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xEF, 0x00, 0x78, 0xF0, 0x0F,
  0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF0,
  0x07, 0x9E, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x1E, 0xF0, 0x03, 0xCF, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x07, 0x83, 0xC0,
  0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x00, 0xF0,
  0xF0, 0x01, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC3, 0x80, 0x78,
  0x78, 0x0E, 0x0F, 0x03, 0xC0, 0xF0, 0x70, 0x1E, 0x1E, 0x01, 0xC3, 0xC0,
  0x3C, 0x70, 0x03, 0x9E, 0x00, 0x7B, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xFF, 0xF0,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF8,
  0x0F, 0x81, 0xF8, 0x1D, 0xC1, 0x9C, 0x39, 0xC3, 0x8E, 0x78, 0xE7, 0x0E,
  0x70, 0x7F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x78, 0x3C,
  0x1E, 0x0E, 0x07, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x03,
  0xCE, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x07, 0xFC, 0x3F, 0xF8, 0xFE, 0x73,
  0xC0, 0xE7, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x3C, 0xF0,
  0xF9, 0xFF, 0xF1, 0xFE, 0xE1, 0xF1, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE7, 0xC3, 0xBF,
  0xCF, 0xFF, 0xBE, 0x1E, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0xE1, 0xEF, 0xFF, 0xBB, 0xFC, 0xE7, 0xC0, 0x07, 0xE0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0xF0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x07, 0xF8, 0x0E, 0x70, 0x1C, 0xF0, 0x78, 0xFF, 0xE0, 0xFF, 0x80,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x0F, 0x9E, 0x7F, 0xFC, 0xFF, 0xFB, 0xC1,
  0xF7, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x70,
  0x1E, 0xF0, 0x7C, 0xFF, 0xF8, 0xFF, 0x70, 0xF8, 0xE0, 0x07, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x08, 0xF8, 0x38, 0xFF, 0xF0, 0xFF, 0xC0, 0x7E,
  0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0xFF, 0xDF, 0xFB, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x0F, 0x8E, 0x7F, 0xDC, 0xFF, 0xFB, 0xC1,
  0xF7, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x70,
  0x1E, 0xF0, 0x7C, 0xFF, 0xF9, 0xFF, 0xF0, 0xF9, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x20, 0x1C, 0x60, 0x79, 0xFF, 0xE1, 0xFF, 0x80, 0x7C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE7, 0xC7, 0x7F, 0xBF, 0xFD, 0xF0, 0xFF, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x80,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C,
  0xF3, 0xC7, 0x00, 0x00, 0x07, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xCF, 0x3F,
  0xEF, 0xBC, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x7B, 0x83, 0xCE, 0x0F, 0x38, 0x78, 0xE3,
  0xC3, 0x9E, 0x0E, 0x78, 0x3B, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0xF7, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE0, 0xF3, 0x83, 0xCE,
  0x07, 0xB8, 0x1E, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xE7, 0xC1, 0xF8, 0xEF, 0xF3, 0xFC, 0xFF, 0xF7,
  0xFE, 0xF8, 0xFE, 0x1E, 0xE0, 0x7C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x38,
  0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38,
  0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38,
  0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38,
  0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE7, 0xC7, 0x7F, 0xBF, 0xFD,
  0xF0, 0xFF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x80, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xFC,
  0x7C, 0x3C, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x0E, 0x78, 0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0xE7, 0xC3, 0xBF, 0xCF, 0xFF, 0xBE, 0x1E, 0xE0, 0x3F, 0x80, 0xFE, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0xC1, 0xEF, 0xFF, 0xBB, 0xFC, 0xE7,
  0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x0F, 0x8E, 0x7F, 0xFD, 0xFF, 0xFB, 0xC1, 0xF7, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0x70, 0x1E, 0xF0,
  0x7C, 0xFF, 0xF9, 0xFF, 0xF0, 0xF9, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0xE7, 0xFF,
  0xFF, 0xFC, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF,
  0x9E, 0x1E, 0x70, 0x3B, 0xC0, 0xF7, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x3D, 0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3F, 0x07, 0xC0, 0xF0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x70, 0x3D, 0xE1,
  0xF3, 0xFF, 0xCF, 0xF7, 0x0F, 0x9C, 0xE0, 0x1F, 0xE0, 0x39, 0xC0, 0x73,
  0x81, 0xE7, 0x03, 0x87, 0x07, 0x0E, 0x0E, 0x1C, 0x3C, 0x38, 0x70, 0x38,
  0xE0, 0x71, 0xC0, 0xE7, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x38,
  0x0F, 0xE0, 0x70, 0x1D, 0xC0, 0xF0, 0x7B, 0x83, 0xE0, 0xF7, 0x07, 0xC1,
  0xCE, 0x0F, 0x83, 0x8E, 0x1B, 0x87, 0x1C, 0x77, 0x1E, 0x38, 0xEE, 0x38,
  0x71, 0xCC, 0x70, 0xF3, 0x1C, 0xE0, 0xEE, 0x39, 0xC1, 0xDC, 0x77, 0x03,
  0xB8, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0xF0,
  0x1E, 0xF0, 0x79, 0xE0, 0xF1, 0xE3, 0xC1, 0xC7, 0x83, 0xDE, 0x03, 0xB8,
  0x07, 0x70, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xDC, 0x07, 0xBC, 0x0E, 0x38, 0x3C, 0x78, 0x78, 0x71, 0xE0, 0xF3, 0xC1,
  0xEF, 0x01, 0xE0, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xDC, 0x0F, 0x70, 0x39,
  0xE0, 0xE3, 0x87, 0x8E, 0x1C, 0x3C, 0x70, 0xF1, 0xC1, 0xCF, 0x07, 0x38,
  0x1E, 0xE0, 0x3B, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x07, 0xC0, 0x1F, 0x00, 0x70, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x70, 0x3C, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x3C, 0x3F, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x38, 0x0F, 0x00, 0xE0,
  0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0xF0, 0x3C, 0x1F, 0x0F, 0x07, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x0E, 0x0F, 0x03, 0x80, 0xC0, 0x00, 0x0F, 0x00, 0xE7, 0xF0, 0x1C, 0xFF,
  0x03, 0x3C, 0xF0, 0xE7, 0x0F, 0x3D, 0xC0, 0xFF, 0x38, 0x0F, 0xC0, 0x00,
  0xF0,
};

const GFXglyph RobotoCondensed_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 28, 10, 3, -28 },
  { 15, 7, 9, 13, 3, -29 },
  { 23, 18, 28, 21, 2, -28 },
  { 86, 15, 36, 19, 2, -32 },
  { 154, 21, 28, 25, 2, -28 },
  { 228, 19, 28, 21, 2, -28 },
  { 295, 3, 9, 7, 2, -29 },
  { 299, 9, 40, 12, 2, -31 },
  { 344, 9, 40, 12, 1, -31 },
  { 389, 15, 16, 17, 1, -28 },
  { 419, 16, 20, 19, 2, -23 },
  { 459, 5, 10, 8, 1, -4 },
  { 466, 8, 3, 10, 1, -13 },
  { 469, 4, 4, 10, 3, -4 },
  { 471, 12, 30, 14, 1, -28 },
  { 516, 15, 28, 19, 2, -28 },
  { 569, 9, 28, 19, 3, -28 },
  { 601, 16, 28, 19, 2, -28 },
  { 657, 15, 28, 19, 2, -28 },
  { 710, 17, 28, 19, 1, -28 },
  { 770, 15, 28, 19, 3, -28 },
  { 823, 14, 28, 19, 3, -28 },
  { 872, 16, 28, 19, 2, -28 },
  { 928, 15, 28, 19, 2, -28 },
  { 981, 15, 28, 19, 2, -28 },
  { 1034, 4, 21, 9, 3, -21 },
  { 1045, 6, 27, 8, 1, -21 },
  { 1066, 14, 17, 17, 1, -21 },
  { 1096, 13, 11, 19, 3, -19 },
  { 1114, 13, 17, 18, 3, -21 },
  { 1142, 13, 28, 16, 2, -28 },
  { 1188, 26, 36, 30, 2, -27 },
  { 1305, 21, 28, 22, 1, -28 },
  { 1379, 16, 28, 21, 3, -28 },
  { 1435, 18, 28, 22, 2, -28 },
  { 1498, 17, 28, 22, 3, -28 },
  { 1558, 15, 28, 19, 3, -28 },
  { 1611, 14, 28, 19, 3, -28 },
  { 1660, 18, 28, 23, 2, -28 },
  { 1723, 18, 28, 24, 3, -28 },
  { 1786, 4, 28, 10, 3, -28 },
  { 1800, 15, 28, 19, 1, -28 },
  { 1853, 18, 28, 21, 3, -28 },
  { 1916, 14, 28, 19, 3, -28 },
  { 1965, 23, 28, 29, 3, -28 },
  { 2046, 18, 28, 24, 3, -28 },
  { 2109, 19, 28, 23, 2, -28 },
  { 2176, 17, 28, 22, 3, -28 },
  { 2236, 19, 33, 23, 2, -28 },
  { 2315, 17, 28, 21, 3, -28 },
  { 2375, 17, 28, 20, 2, -28 },
  { 2435, 18, 28, 20, 1, -28 },
  { 2498, 18, 28, 22, 2, -28 },
  { 2561, 20, 28, 22, 1, -28 },
  { 2631, 28, 28, 30, 1, -28 },
  { 2729, 19, 28, 22, 1, -28 },
  { 2796, 19, 28, 20, 1, -28 },
  { 2863, 17, 28, 20, 2, -28 },
  { 2923, 6, 38, 10, 3, -32 },
  { 2952, 13, 30, 14, 1, -28 },
  { 3001, 6, 38, 10, 1, -32 },
  { 3030, 12, 14, 14, 1, -28 },
  { 3051, 15, 3, 16, 0, 0 },
  { 3057, 8, 6, 12, 1, -30 },
  { 3063, 15, 21, 19, 2, -21 },
  { 3103, 14, 29, 19, 3, -29 },
  { 3154, 15, 21, 18, 2, -21 },
  { 3194, 15, 29, 19, 2, -29 },
  { 3249, 15, 21, 18, 2, -21 },
  { 3289, 11, 29, 12, 1, -29 },
  { 3329, 15, 29, 19, 2, -21 },
  { 3384, 13, 29, 19, 3, -29 },
  { 3432, 3, 28, 9, 3, -28 },
  { 3443, 6, 36, 9, 0, -28 },
  { 3470, 14, 29, 18, 3, -29 },
  { 3521, 3, 29, 9, 3, -29 },
  { 3532, 24, 21, 29, 3, -21 },
  { 3595, 13, 21, 19, 3, -21 },
  { 3630, 16, 21, 20, 2, -21 },
  { 3672, 14, 29, 19, 3, -21 },
  { 3723, 15, 29, 20, 2, -21 },
  { 3778, 8, 21, 12, 3, -21 },
  { 3799, 14, 21, 18, 2, -21 },
  { 3836, 10, 26, 12, 0, -26 },
  { 3869, 14, 21, 19, 2, -21 },
  { 3906, 15, 21, 17, 1, -21 },
  { 3946, 23, 21, 25, 1, -21 },
  { 4007, 15, 21, 17, 1, -21 },
  { 4047, 14, 29, 16, 1, -21 },
  { 4098, 14, 21, 17, 2, -21 },
  { 4135, 10, 37, 12, 1, -30 },
  { 4182, 3, 33, 10, 3, -28 },
  { 4195, 10, 37, 12, 1, -30 },
  { 4242, 19, 8, 23, 2, -16 },
};

const GFXfont RobotoCondensed_Regular39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_REGULAR39PT7B_H_
