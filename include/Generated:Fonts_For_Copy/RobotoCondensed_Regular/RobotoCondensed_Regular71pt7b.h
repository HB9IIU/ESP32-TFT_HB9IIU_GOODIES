#ifndef _ROBOTOCONDENSED_REGULAR71PT7B_H_
#define _ROBOTOCONDENSED_REGULAR71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular71pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xCF, 0xFF, 0xFF, 0x7E, 0xFC, 0xE0, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07,
  0xBC, 0x1E, 0xF0, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x07,
  0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x07, 0xFC, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x01,
  0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0x3E, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0x83, 0xC0,
  0x03, 0xE0, 0x3E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0xF8, 0x00, 0x1F, 0xFF,
  0xC3, 0xE0, 0x00, 0x3F, 0xFE, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x78, 0x00,
  0x00, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0x07,
  0x83, 0xFF, 0x00, 0x00, 0x3E, 0x1F, 0xFE, 0x00, 0x00, 0xF0, 0xFF, 0xFC,
  0x00, 0x07, 0xC7, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x78, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x7C,
  0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x1F, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x1F, 0x03, 0xE0, 0x04, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x3E, 0x0F, 0xF3, 0xF8, 0x0F, 0x83, 0xF8, 0xFF, 0x03, 0xE1, 0xFC,
  0x1F, 0xC0, 0xF8, 0x7E, 0x03, 0xF8, 0x3E, 0x3F, 0x80, 0x7F, 0x1F, 0x8F,
  0xC0, 0x1F, 0xC7, 0xE3, 0xF0, 0x03, 0xF9, 0xF8, 0xFC, 0x00, 0x7F, 0xFC,
  0x3F, 0x00, 0x1F, 0xFF, 0x0F, 0xC0, 0x03, 0xFF, 0xC3, 0xF0, 0x00, 0x7F,
  0xE0, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x1F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xFE, 0x03, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF,
  0x7B, 0xDE, 0xF0, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x02, 0x40, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x60, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x60, 0x0F, 0x80, 0x23, 0xE0, 0x7C, 0x0F, 0x1F, 0xE3, 0xE1, 0xFD, 0xFF,
  0xDF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x87, 0xE3, 0xF0, 0x78, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3F, 0x01, 0xFF, 0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFE, 0x3F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x00,
  0xFF, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F,
  0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xCF,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x80, 0x7F, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xFC,
  0x3F, 0x00, 0x3F, 0x80, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x03, 0xF1, 0xFF, 0xC0,
  0x7E, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC,
  0x7F, 0xC7, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xF3,
  0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xCF, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE3,
  0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F,
  0x80, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xF7,
  0xF0, 0x07, 0xFC, 0xFE, 0x03, 0xFF, 0x3F, 0xF3, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0x3F, 0x03, 0xFF, 0x8F, 0xC0, 0x3F,
  0x83, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0xFE, 0xFE,
  0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38,
  0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x0F, 0x00, 0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x81,
  0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x3C, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x78, 0x3E, 0x00, 0x3F, 0xFE,
  0x00, 0xF8, 0x78, 0x00, 0xFF, 0xFF, 0x00, 0xF1, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xE3, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xC7, 0x80, 0x1F, 0x80, 0xF8,
  0x07, 0x9F, 0x00, 0x3E, 0x01, 0xE0, 0x0F, 0xBE, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0x3D, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xFF, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0xFF,
  0x80, 0xFC, 0x00, 0xF0, 0x01, 0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xFE,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x3D, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFB, 0xE0,
  0x1F, 0x00, 0xFC, 0x01, 0xE7, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xC7, 0x80,
  0x7E, 0x07, 0xF8, 0x0F, 0x0F, 0x80, 0x7F, 0x3F, 0xF0, 0x3E, 0x1F, 0x00,
  0xFF, 0xFB, 0xFB, 0xF8, 0x3E, 0x00, 0xFF, 0xE3, 0xFF, 0xE0, 0x3C, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x7C, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xF8, 0x07, 0xFF, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xC3, 0xF8, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F,
  0x80, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x3F,
  0x80, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xF8,
  0x3F, 0x80, 0x0F, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7,
  0xF0, 0x01, 0xFF, 0x0F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFD, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x03,
  0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03,
  0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x1F, 0xFF, 0xFB, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0xFD, 0xFF, 0xE7, 0xE0, 0x00,
  0x1F, 0xBF, 0xFC, 0xFC, 0x00, 0x03, 0xF7, 0xFF, 0x9F, 0x80, 0x00, 0xFC,
  0xFF, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0xFE, 0x3F, 0x00, 0x03, 0xF3, 0xFF,
  0xC7, 0xE0, 0x00, 0xFC, 0x7F, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xFF, 0x8F,
  0xC0, 0x03, 0xF1, 0xFF, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0xFE, 0x1F, 0x80,
  0x1F, 0x87, 0xFF, 0xC3, 0xF0, 0x03, 0xF0, 0xFF, 0xF8, 0x7E, 0x00, 0xFC,
  0x1F, 0xFF, 0x07, 0xE0, 0x1F, 0x83, 0xFF, 0xE0, 0xFC, 0x03, 0xF0, 0x7F,
  0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x1F, 0x81, 0xFF, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xC0, 0x7C,
  0x1F, 0x80, 0xFF, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0xFF, 0x01, 0xF8, 0x7C,
  0x03, 0xFF, 0xE0, 0x1F, 0x1F, 0x80, 0x7F, 0xFC, 0x03, 0xF3, 0xE0, 0x0F,
  0xFF, 0x80, 0x7E, 0x7C, 0x01, 0xFF, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x01,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF7,
  0xE0, 0x00, 0xFF, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0xFC, 0x00, 0x3F, 0xFE,
  0x7F, 0x00, 0x1F, 0xFF, 0x1F, 0x80, 0x0F, 0xFF, 0x87, 0xE0, 0x07, 0xFF,
  0xC3, 0xF0, 0x03, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xF0, 0x7E, 0x00, 0xFF,
  0xF8, 0x1F, 0x80, 0x7F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFE, 0x03, 0xF0, 0x1F,
  0xFF, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0x03,
  0xFF, 0xE0, 0x0F, 0xC1, 0xFF, 0xF0, 0x07, 0xE0, 0xFF, 0xF8, 0x01, 0xF8,
  0x7F, 0xFC, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0x3F, 0x1F, 0xFF, 0x00, 0x1F,
  0x8F, 0xFF, 0x80, 0x07, 0xE7, 0xFF, 0xC0, 0x03, 0xF3, 0xFF, 0xE0, 0x00,
  0xFD, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x7F,
  0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xFC, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFB, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0x1F, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xF0, 0xFE, 0x01, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xC3, 0xFE,
  0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x3F,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xEF, 0x80, 0x1F,
  0xC1, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x80, 0xFC, 0x01, 0xF1, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x7E,
  0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0x83,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x1F,
  0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x07,
  0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xF0, 0x00,
  0x7E, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x3D, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x1F, 0x83, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7E,
  0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xF0, 0x07, 0xE7, 0xF8, 0x01, 0xF9,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0xE7,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF, 0xC3, 0xFF, 0xE7,
  0xF0, 0x7F, 0xE0, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE3, 0xFF,
  0x80, 0xFC, 0xFF, 0xFC, 0x1F, 0xBF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xF8, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xE7, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0xC0, 0x0F, 0xE7, 0xFC, 0x03,
  0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xE7, 0xFF, 0xF8, 0x7C,
  0x7F, 0xFC, 0x0F, 0x87, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xF0, 0x0F, 0xF1, 0xFC, 0x00,
  0xFE, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x80,
  0x0F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0x81, 0xF8, 0x0F, 0xFE, 0x3F, 0x03, 0xFF, 0xE7, 0xE0, 0xFF,
  0xFE, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xFE,
  0x7F, 0x00, 0x3F, 0xCF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F,
  0xCF, 0xE0, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x7C, 0x1F, 0xFF, 0xCF, 0x81, 0xFF, 0xF1, 0xF0, 0x1F, 0xFC, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC7, 0xE0,
  0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x0C, 0x3F, 0xC0, 0x03, 0xC3, 0xFC, 0x01, 0xFC, 0x7F,
  0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x0F, 0xFF, 0x8F, 0x83, 0xFF, 0xF9, 0xF0,
  0xFF, 0xFF, 0xBE, 0x3F, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F, 0xF9, 0xFC, 0x00,
  0xFF, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0x7E, 0x07, 0xFF, 0xCF, 0xC0, 0x7F, 0xF1, 0xF8, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x40, 0x00, 0xFE, 0x1C, 0x00, 0x3F, 0x83, 0xC0, 0x0F,
  0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1E, 0x01, 0xF8, 0x7F, 0xE0, 0xFC,
  0xFF, 0xF8, 0x7E, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFC, 0x0F, 0xF7, 0xF8, 0x03, 0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF,
  0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF,
  0x7E, 0xFD, 0xFB, 0xF0, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xED, 0xFE, 0xFF, 0xEF,
  0xFC, 0xFF, 0xCF, 0xF8, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0xFC, 0x00,
  0xFF, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE0, 0xFC,
  0x07, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x7F, 0x00,
  0xFC, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0x03, 0xF3, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F,
  0xC0, 0x1F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x1F,
  0xCF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x87, 0xFF, 0x00,
  0xFF, 0xE0, 0xF9, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x07, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x1F, 0xF8, 0x3E, 0x3F, 0xFE, 0x1F,
  0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0x03, 0xFD,
  0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x0F, 0xFE, 0x03,
  0xE3, 0xFF, 0xF0, 0x7C, 0xFF, 0xFF, 0x0F, 0xBF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F,
  0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xF0, 0x0F, 0xF3,
  0xFF, 0xDF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xE1, 0xF9, 0xFF,
  0xF0, 0x3F, 0x1F, 0xFC, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x7C, 0x0F,
  0xFF, 0xCF, 0x83, 0xFF, 0xFD, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xF8, 0x0F, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xEF, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F,
  0xF7, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xEF,
  0xC0, 0x7F, 0xF1, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x1D, 0xF9, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xFC, 0x00,
  0x7F, 0x7F, 0x00, 0x1F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xF0,
  0x03, 0xFD, 0xFC, 0x01, 0xFF, 0x3F, 0x80, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x0F, 0xFF, 0xCF, 0xC0, 0xFF, 0xE3,
  0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x9F,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x7E, 0x00,
  0x7F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0xFF, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0x7C,
  0x03, 0xFF, 0x00, 0xFC, 0x1F, 0x81, 0xF7, 0xE0, 0x3E, 0x07, 0xE0, 0x7C,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xCF, 0xC1,
  0xF8, 0x0F, 0x83, 0xE3, 0xF0, 0x7C, 0x03, 0xF0, 0xF8, 0x7C, 0x1F, 0x00,
  0xFC, 0x3E, 0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x0F,
  0x8F, 0x80, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x07, 0xDF, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x07, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF9,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x3F,
  0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE7, 0xF0,
  0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0,
  0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60,
  0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0x80, 0x01, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xF0, 0xFF, 0xF0, 0x00, 0xFC, 0x7F, 0xFE, 0x00,
  0x3E, 0x1F, 0xFF, 0xC0, 0x0F, 0x8F, 0xFF, 0xF8, 0x03, 0xE3, 0xF0, 0xFF,
  0x01, 0xF9, 0xF8, 0x0F, 0xE0, 0xFC, 0x7C, 0x01, 0xFF, 0xFF, 0x1F, 0x00,
  0x7F, 0xFF, 0x87, 0xC0, 0x0F, 0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0xF0, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Regular71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 7, 51, 17, 5, -50 },
  { 46, 14, 17, 23, 5, -53 },
  { 76, 32, 50, 39, 5, -50 },
  { 276, 27, 65, 35, 4, -58 },
  { 496, 38, 52, 45, 4, -51 },
  { 743, 34, 52, 39, 4, -51 },
  { 964, 5, 17, 12, 4, -53 },
  { 975, 16, 73, 22, 4, -57 },
  { 1121, 16, 73, 23, 2, -57 },
  { 1267, 29, 29, 31, 1, -50 },
  { 1373, 29, 37, 35, 3, -42 },
  { 1508, 10, 18, 14, 1, -8 },
  { 1531, 14, 5, 18, 2, -24 },
  { 1540, 8, 8, 19, 5, -7 },
  { 1548, 23, 54, 26, 1, -50 },
  { 1704, 27, 52, 35, 4, -51 },
  { 1880, 16, 50, 35, 6, -50 },
  { 1980, 29, 51, 35, 3, -51 },
  { 2165, 27, 52, 35, 3, -51 },
  { 2341, 31, 50, 35, 2, -50 },
  { 2535, 27, 51, 35, 5, -50 },
  { 2708, 27, 51, 35, 5, -50 },
  { 2881, 29, 50, 35, 3, -50 },
  { 3063, 27, 52, 35, 4, -51 },
  { 3239, 26, 51, 35, 4, -51 },
  { 3405, 8, 39, 17, 5, -38 },
  { 3444, 11, 48, 14, 1, -38 },
  { 3510, 23, 31, 32, 3, -38 },
  { 3600, 24, 21, 34, 5, -34 },
  { 3663, 25, 31, 33, 5, -38 },
  { 3760, 24, 52, 30, 3, -51 },
  { 3916, 47, 66, 55, 4, -50 },
  { 4304, 38, 50, 41, 1, -50 },
  { 4542, 30, 50, 39, 5, -50 },
  { 4730, 33, 52, 40, 4, -51 },
  { 4945, 31, 50, 41, 5, -50 },
  { 5139, 28, 50, 35, 5, -50 },
  { 5314, 27, 50, 34, 5, -50 },
  { 5483, 33, 52, 42, 4, -51 },
  { 5698, 33, 50, 44, 5, -50 },
  { 5905, 6, 50, 18, 6, -50 },
  { 5943, 27, 51, 34, 2, -50 },
  { 6116, 33, 50, 39, 5, -50 },
  { 6323, 27, 50, 34, 5, -50 },
  { 6492, 43, 50, 54, 5, -50 },
  { 6761, 33, 50, 44, 5, -50 },
  { 6968, 34, 52, 43, 4, -51 },
  { 7189, 32, 50, 39, 5, -50 },
  { 7389, 35, 60, 43, 4, -51 },
  { 7652, 32, 50, 38, 5, -50 },
  { 7852, 31, 52, 37, 3, -51 },
  { 8054, 33, 50, 37, 2, -50 },
  { 8261, 32, 51, 40, 4, -50 },
  { 8465, 37, 50, 40, 1, -50 },
  { 8697, 50, 50, 54, 2, -50 },
  { 9010, 35, 50, 39, 2, -50 },
  { 9229, 35, 50, 37, 1, -50 },
  { 9448, 31, 50, 37, 3, -50 },
  { 9642, 11, 69, 18, 5, -58 },
  { 9737, 23, 54, 26, 2, -50 },
  { 9893, 12, 69, 18, 1, -58 },
  { 9997, 22, 25, 26, 2, -50 },
  { 10066, 27, 5, 29, 1, 0 },
  { 10083, 14, 10, 22, 2, -53 },
  { 10101, 26, 40, 34, 4, -39 },
  { 10231, 27, 54, 35, 5, -53 },
  { 10414, 27, 40, 33, 3, -39 },
  { 10549, 27, 54, 35, 3, -53 },
  { 10732, 27, 40, 33, 3, -39 },
  { 10867, 20, 54, 22, 2, -54 },
  { 11002, 27, 53, 35, 3, -39 },
  { 11181, 25, 53, 34, 5, -53 },
  { 11347, 7, 51, 16, 5, -51 },
  { 11392, 12, 65, 16, -1, -51 },
  { 11490, 26, 53, 32, 5, -53 },
  { 11663, 6, 53, 16, 5, -53 },
  { 11703, 44, 39, 53, 5, -39 },
  { 11918, 25, 39, 34, 5, -39 },
  { 12040, 29, 40, 36, 3, -39 },
  { 12185, 27, 53, 35, 5, -39 },
  { 12364, 27, 53, 36, 3, -39 },
  { 12543, 15, 39, 22, 5, -39 },
  { 12617, 26, 40, 32, 3, -39 },
  { 12747, 17, 48, 21, 1, -47 },
  { 12849, 26, 39, 34, 4, -38 },
  { 12976, 27, 38, 30, 2, -38 },
  { 13105, 42, 38, 46, 2, -38 },
  { 13305, 27, 38, 31, 2, -38 },
  { 13434, 27, 52, 30, 1, -38 },
  { 13610, 25, 38, 31, 3, -38 },
  { 13729, 18, 68, 22, 2, -55 },
  { 13882, 5, 59, 17, 6, -50 },
  { 13919, 18, 68, 22, 1, -55 },
  { 14072, 34, 14, 42, 4, -28 },
};

const GFXfont RobotoCondensed_Regular71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_REGULAR71PT7B_H_
