#ifndef _ROBOTOCONDENSED_REGULAR45PT7B_H_
#define _ROBOTOCONDENSED_REGULAR45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x00, 0x00, 0xE7, 0xFD, 0xEE, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xC0, 0x00, 0xE1,
  0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C,
  0x1C, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x87, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00,
  0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0x0E, 0x1C,
  0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1,
  0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFF, 0x0F, 0x83, 0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07, 0x9E,
  0x00, 0xE3, 0x80, 0x3C, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE,
  0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x60, 0xE0, 0x60, 0x70, 0xE0, 0x70, 0xE0,
  0xE0, 0x70, 0xE0, 0xE0, 0x71, 0xC0, 0xE0, 0x61, 0x80, 0x70, 0xE3, 0x80,
  0x70, 0xE7, 0x00, 0x7F, 0xC7, 0x00, 0x3F, 0xCE, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x39, 0xFE,
  0x00, 0x73, 0xFE, 0x00, 0x63, 0x87, 0x00, 0xE7, 0x87, 0x01, 0xC7, 0x03,
  0x01, 0xC7, 0x03, 0x03, 0x87, 0x03, 0x03, 0x87, 0x03, 0x07, 0x07, 0x03,
  0x07, 0x07, 0x87, 0x02, 0x03, 0x87, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07,
  0xCF, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xE1, 0xE0, 0x07, 0xDF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7B, 0xC1, 0xC3, 0xCF, 0x87, 0x1E, 0x1E, 0x1C, 0x78, 0x3C,
  0x73, 0xC0, 0xFB, 0xCF, 0x01, 0xEF, 0x3C, 0x03, 0xF8, 0xF0, 0x0F, 0xE1,
  0xE0, 0x1F, 0x07, 0x80, 0x3C, 0x1F, 0x03, 0xF8, 0x3F, 0x3F, 0xF0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xCF, 0x80, 0xFC, 0x1F, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE,
  0xE0, 0x00, 0x80, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x20, 0x40,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x70, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0,
  0x70, 0x3C, 0x0E, 0x07, 0x03, 0xC0, 0x60, 0x10, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x2F, 0x1C,
  0x3B, 0xFF, 0x7E, 0xFF, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xDE, 0x01, 0xE3, 0xC0, 0x78, 0xF0, 0x3C, 0x1E, 0x06,
  0x03, 0x80, 0x80, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0xF3, 0xCF, 0x3C,
  0xE7, 0x9E, 0xF3, 0x86, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xCF, 0xC7,
  0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x03,
  0xB8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x9E, 0x03,
  0xCF, 0x03, 0xC3, 0xE7, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x00,
  0xC0, 0xF0, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC,
  0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xE7, 0xE7,
  0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xDE, 0x01,
  0xEF, 0x81, 0xE3, 0xF3, 0xF1, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x0F,
  0x00, 0xF0, 0xF0, 0x0E, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE3, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x3E, 0x07, 0xFF, 0xC3, 0xFF,
  0xF1, 0xFF, 0xFC, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xB8, 0x03, 0xDE, 0x03, 0xEF, 0x81, 0xE3, 0xF7, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x07, 0xE0, 0x00, 0x78, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x3E, 0x0F, 0x7F, 0xC7, 0xFF, 0xF3, 0xFC, 0xF9, 0xF8,
  0x3E, 0xF8, 0x0F, 0x78, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x03, 0x9E, 0x03,
  0xC7, 0x83, 0xE3, 0xF3, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xCF, 0xC7, 0x81, 0xE3, 0xC0, 0xFB,
  0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xCF, 0x01,
  0xC7, 0x81, 0xE1, 0xF3, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x3F, 0xFC, 0x3E,
  0x1F, 0x1E, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xBC, 0x03, 0xDF, 0x03, 0xE7, 0xE7,
  0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xEF, 0xC3, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7B, 0x80,
  0x3D, 0xE0, 0x1E, 0xF0, 0x1F, 0x7C, 0x1F, 0x9F, 0x9F, 0xC7, 0xFF, 0xE1,
  0xFE, 0xF0, 0x7C, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F,
  0x80, 0x1F, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xEF, 0xFF, 0xEE, 0x1C, 0x78, 0xF9, 0xE3, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0x8F, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xFF, 0xEF, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x0F,
  0x80, 0x61, 0xC0, 0x3F, 0xC0, 0xE3, 0x80, 0xFF, 0xC1, 0xC7, 0x03, 0xC3,
  0x83, 0x9C, 0x0F, 0x07, 0x03, 0x38, 0x1C, 0x0E, 0x06, 0x70, 0x38, 0x1C,
  0x0C, 0xE0, 0xF0, 0x78, 0x19, 0xC1, 0xC0, 0xE0, 0x33, 0x83, 0x81, 0xC0,
  0x67, 0x07, 0x03, 0x80, 0xDE, 0x0E, 0x07, 0x01, 0xB8, 0x3C, 0x0E, 0x07,
  0x38, 0x78, 0x1C, 0x0E, 0x70, 0xF0, 0x38, 0x1C, 0xE0, 0xE0, 0xF0, 0x31,
  0xC1, 0xC1, 0xE0, 0xE3, 0x83, 0xC7, 0xC3, 0x87, 0x07, 0xFD, 0xFF, 0x0E,
  0x07, 0xF3, 0xFC, 0x0E, 0x07, 0x83, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7,
  0x00, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x81,
  0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7C, 0x1F, 0xCF, 0x80, 0x7D, 0xF0, 0x07,
  0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x0F,
  0x7C, 0x01, 0xEF, 0x80, 0x79, 0xF0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFF, 0x9F, 0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0x7C, 0x03, 0xEF, 0x83, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0x87,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xBF,
  0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x7B,
  0xC0, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9F, 0x00,
  0x78, 0x7C, 0x07, 0xC1, 0xFD, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0x8F, 0xF8,
  0xF8, 0x0F, 0xCF, 0x80, 0x3C, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01,
  0xEF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0xFC,
  0xF8, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x03, 0xE7, 0xC0, 0x1F, 0x78, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x7C,
  0x00, 0xF3, 0xE0, 0x1F, 0x1F, 0xDF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x1F, 0xE0, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x1E,
  0xF0, 0x07, 0xBE, 0x01, 0xE7, 0x80, 0xF9, 0xF0, 0x3C, 0x3F, 0xFF, 0x0F,
  0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x3E,
  0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x01, 0xF3,
  0xE0, 0x0F, 0x9E, 0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xF7, 0x80, 0x3F, 0xBE, 0x01, 0xF8, 0xF8, 0x0F, 0x83,
  0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x87,
  0xC0, 0x3C, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00,
  0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0x00, 0x0E, 0xFF, 0x78, 0x01,
  0xEF, 0xF7, 0x80, 0x1E, 0xFF, 0x38, 0x01, 0xCF, 0xF3, 0xC0, 0x3C, 0xFF,
  0x3C, 0x03, 0xCF, 0xF1, 0xC0, 0x38, 0xFF, 0x1E, 0x07, 0x8F, 0xF1, 0xE0,
  0x78, 0xFF, 0x0E, 0x07, 0x0F, 0xF0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0x1F,
  0xF0, 0x70, 0xE1, 0xFF, 0x07, 0x9E, 0x1F, 0xF0, 0x79, 0xE1, 0xFF, 0x03,
  0x9C, 0x1F, 0xF0, 0x3B, 0xC1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0x81,
  0xFF, 0x01, 0xF8, 0x1F, 0xF0, 0x1F, 0x81, 0xFF, 0x00, 0xF0, 0x1F, 0xF0,
  0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xDC, 0x03, 0xFE, 0xF0, 0x1F, 0xF3,
  0x80, 0xFF, 0x9E, 0x07, 0xFC, 0x78, 0x3F, 0xE3, 0xC1, 0xFF, 0x0F, 0x0F,
  0xF8, 0x78, 0x7F, 0xC1, 0xE3, 0xFE, 0x0F, 0x1F, 0xF0, 0x3C, 0xFF, 0x81,
  0xE7, 0xFC, 0x07, 0xBF, 0xE0, 0x3D, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x03,
  0xCF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xFB,
  0xC0, 0x07, 0x9F, 0x00, 0x7C, 0x7C, 0x07, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xCF, 0x81, 0xFC, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x81, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0x3E, 0x00, 0x3C,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B,
  0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x00, 0xF1, 0xE0,
  0x03, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8F, 0x87, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3C, 0xF8,
  0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x83, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0x83, 0xE0, 0xF8, 0x1E,
  0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0x8F, 0x80,
  0x78, 0xF8, 0x07, 0xCF, 0x80, 0x3C, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xC0, 0x7C, 0xF8, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xF3, 0xFD,
  0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF8, 0x03, 0xE7, 0xC0, 0x3C, 0x3F, 0xBF, 0xC3, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0x80, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x00,
  0xFB, 0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0x79, 0xC0, 0x00, 0xF7,
  0x80, 0x00, 0xEF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x03, 0x80, 0x1F, 0xE0, 0x0F, 0x00, 0x3F, 0xC0, 0x1F, 0x00, 0x7F,
  0x80, 0x3E, 0x01, 0xEF, 0x00, 0x7C, 0x03, 0xCF, 0x01, 0xF8, 0x07, 0x9E,
  0x03, 0xF8, 0x0F, 0x3C, 0x07, 0x70, 0x1E, 0x78, 0x0E, 0xE0, 0x38, 0xF0,
  0x1D, 0xC0, 0xF0, 0xE0, 0x7B, 0x81, 0xE1, 0xE0, 0xE7, 0x83, 0xC3, 0xC1,
  0xC7, 0x07, 0x87, 0x83, 0x8E, 0x0E, 0x0F, 0x0F, 0x1C, 0x3C, 0x0E, 0x1E,
  0x3C, 0x78, 0x1E, 0x38, 0x38, 0xF0, 0x3C, 0x70, 0x71, 0xE0, 0x79, 0xE0,
  0xE3, 0x80, 0xF3, 0xC1, 0xC7, 0x00, 0xE7, 0x03, 0xDE, 0x01, 0xEE, 0x03,
  0xBC, 0x03, 0xDC, 0x07, 0x78, 0x07, 0xF8, 0x0E, 0xE0, 0x0F, 0xE0, 0x1D,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9F, 0x00, 0x7C,
  0x78, 0x03, 0xC3, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0x01, 0xE0,
  0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xF7, 0xC0, 0x07, 0xBC, 0x00,
  0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03,
  0xCF, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3E,
  0x0F, 0x80, 0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xE7, 0x80, 0x0F,
  0x9F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x07,
  0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0x78, 0x01, 0xE1,
  0xE0, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0xE0, 0x77, 0x07, 0xB8, 0x39, 0xE1, 0xC7, 0x1E, 0x38, 0xE1, 0xE7,
  0x07, 0x78, 0x3B, 0xC1, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xE7, 0xE7, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xF1,
  0xF0, 0x39, 0xE0, 0x1C, 0xF0, 0x0E, 0x70, 0x07, 0x78, 0x03, 0x9E, 0x03,
  0xCF, 0x03, 0xE7, 0xFF, 0xF9, 0xFF, 0xBC, 0x7F, 0x9E, 0x1F, 0x8F, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x7C, 0x1E, 0xFF,
  0x8F, 0xFF, 0xE7, 0xFB, 0xFB, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xF7, 0xC0, 0xFB, 0xFD, 0xFD, 0xFF, 0xFC, 0xF7, 0xFC, 0x78, 0xF8, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xE7, 0xE7, 0xC0, 0xF3, 0xC0,
  0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x07,
  0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x81, 0xE3, 0xF3, 0xF0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x07, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC1, 0xF9, 0xE3, 0xFE, 0xF3, 0xFF, 0xF9, 0xFF, 0xFD, 0xF0, 0x3E, 0xF0,
  0x0F, 0x78, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0x7B, 0xE0, 0x7C, 0xFF, 0xFE, 0x7F, 0xF7, 0x1F,
  0xF3, 0x83, 0xF1, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xE7,
  0xE7, 0xC0, 0xF3, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x4F, 0x80, 0x63, 0xF9,
  0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x7F, 0x0F, 0xF1,
  0xFF, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0xE3,
  0x8F, 0xF9, 0xCF, 0xFE, 0xE7, 0xFF, 0xF7, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x03,
  0xDE, 0x01, 0xEF, 0x81, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xDE, 0x0F,
  0xCF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF3, 0x80, 0xF1,
  0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7, 0xFC, 0xFF, 0xFE, 0xFF,
  0x7E, 0xFC, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x6F, 0xFF, 0x70, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06, 0x0F,
  0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0xBE, 0xFE, 0xFC, 0xF8, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x07, 0xDE, 0x07, 0xCF, 0x07, 0xC7, 0x83, 0xC3, 0xC3, 0xE1,
  0xE3, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xF7, 0x80, 0xF9, 0xE0, 0x78, 0xF8, 0x3C,
  0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0xC7, 0x81, 0xE3, 0xC0, 0xF9, 0xE0, 0x3C,
  0xF0, 0x1F, 0x78, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0,
  0x3F, 0x0F, 0x7F, 0xC7, 0xFC, 0xFF, 0xFC, 0xFF, 0xEF, 0xEF, 0xFF, 0xFE,
  0xF8, 0x1F, 0x81, 0xEF, 0x01, 0xF8, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF1, 0xF0,
  0xF7, 0xFC, 0xFF, 0xFE, 0xFF, 0x7E, 0xFC, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x03, 0xF0,
  0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xDF, 0x83, 0xC0, 0xF8, 0xF0, 0x0F,
  0x9E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x07,
  0x78, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x1E,
  0xF0, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F, 0x1E, 0x03, 0xC3, 0xF3, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0xF1, 0xF0, 0x7B, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xEF, 0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xDF,
  0x03, 0xEF, 0xE7, 0xF7, 0xFF, 0xF3, 0xDF, 0xF1, 0xE7, 0xE0, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0x8F, 0xF9, 0xCF, 0xFF,
  0xE7, 0xE7, 0xF7, 0xC0, 0xFB, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x03, 0xDE, 0x01, 0xEF, 0x81,
  0xF3, 0xF1, 0xF9, 0xFF, 0xFC, 0x7F, 0xDE, 0x0F, 0xCF, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0xF3, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x07,
  0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0x3E, 0x78, 0x1F, 0x78, 0x0F, 0x78,
  0x0F, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0x78, 0x0F, 0x7F, 0x7F, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xEF, 0x0F, 0x8F, 0xF0, 0x07, 0xF8, 0x03,
  0xDE, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0xF1, 0xC0, 0x78, 0xF0, 0x38, 0x78,
  0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x07, 0x87, 0x03, 0xC7, 0x80, 0xE3, 0x80,
  0x71, 0xC0, 0x3C, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0x80, 0xF0,
  0x0E, 0x01, 0xFE, 0x01, 0xE0, 0x3D, 0xC0, 0x7C, 0x07, 0x3C, 0x0F, 0x80,
  0xE7, 0x81, 0xF0, 0x3C, 0xF0, 0x3F, 0x07, 0x8E, 0x0F, 0xE0, 0xF1, 0xE1,
  0xDC, 0x1C, 0x3C, 0x3B, 0x87, 0x87, 0x87, 0x78, 0xF0, 0x71, 0xE7, 0x1E,
  0x0E, 0x38, 0xE3, 0x81, 0xE7, 0x1C, 0x70, 0x3D, 0xE3, 0xDE, 0x03, 0xBC,
  0x3B, 0xC0, 0x77, 0x07, 0x70, 0x0F, 0xE0, 0xEE, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80,
  0x78, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x78, 0x07, 0x9E, 0x03,
  0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x00, 0xF3, 0xC0,
  0x3D, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0x38, 0x03, 0xCF,
  0x01, 0xE3, 0xE0, 0x78, 0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xC7, 0x80, 0xFB,
  0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80,
  0xF3, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x0E, 0x1E, 0x07,
  0x8F, 0x03, 0xC7, 0x80, 0xE3, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xE0,
  0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x40, 0x3C, 0x0F, 0x83, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xE0, 0x3C, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xC1, 0xF8,
  0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8,
  0x1E, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x01, 0xDF, 0xF8, 0x1E,
  0xFF, 0xE0, 0xFF, 0x0F, 0x87, 0x78, 0x3F, 0xFB, 0x80, 0xFF, 0x9C, 0x03,
  0xF8, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 32, 11, 3, -32 },
  { 21, 9, 11, 14, 3, -34 },
  { 34, 20, 32, 25, 3, -32 },
  { 114, 18, 41, 22, 2, -37 },
  { 207, 24, 32, 28, 2, -32 },
  { 303, 22, 32, 24, 2, -32 },
  { 391, 4, 11, 8, 2, -34 },
  { 397, 10, 46, 14, 3, -36 },
  { 455, 10, 46, 14, 1, -36 },
  { 513, 18, 19, 19, 1, -32 },
  { 556, 18, 23, 22, 2, -26 },
  { 608, 6, 11, 9, 1, -5 },
  { 617, 9, 3, 11, 1, -15 },
  { 621, 5, 5, 12, 3, -5 },
  { 625, 14, 35, 17, 1, -32 },
  { 687, 17, 32, 22, 3, -32 },
  { 755, 10, 32, 22, 4, -32 },
  { 795, 18, 32, 22, 2, -32 },
  { 867, 17, 32, 22, 2, -32 },
  { 935, 20, 32, 22, 1, -32 },
  { 1015, 17, 32, 22, 3, -32 },
  { 1083, 17, 32, 22, 3, -32 },
  { 1151, 18, 32, 22, 2, -32 },
  { 1223, 17, 32, 22, 3, -32 },
  { 1291, 17, 32, 22, 2, -32 },
  { 1359, 5, 24, 11, 3, -24 },
  { 1374, 7, 30, 9, 1, -24 },
  { 1401, 15, 20, 20, 2, -24 },
  { 1439, 16, 14, 22, 3, -22 },
  { 1467, 16, 20, 21, 3, -24 },
  { 1507, 15, 32, 19, 2, -32 },
  { 1567, 31, 41, 35, 2, -31 },
  { 1726, 24, 32, 26, 1, -32 },
  { 1822, 19, 32, 25, 3, -32 },
  { 1898, 21, 32, 26, 3, -32 },
  { 1982, 20, 32, 26, 3, -32 },
  { 2062, 18, 32, 22, 3, -32 },
  { 2134, 17, 32, 22, 3, -32 },
  { 2202, 20, 32, 27, 3, -32 },
  { 2282, 21, 32, 28, 3, -32 },
  { 2366, 4, 32, 11, 4, -32 },
  { 2382, 18, 32, 22, 1, -32 },
  { 2454, 21, 32, 25, 3, -32 },
  { 2538, 17, 32, 21, 3, -32 },
  { 2606, 28, 32, 34, 3, -32 },
  { 2718, 21, 32, 28, 3, -32 },
  { 2802, 21, 32, 27, 3, -32 },
  { 2886, 20, 32, 25, 3, -32 },
  { 2966, 22, 37, 27, 3, -32 },
  { 3068, 20, 32, 24, 3, -32 },
  { 3148, 19, 32, 23, 2, -32 },
  { 3224, 21, 32, 23, 1, -32 },
  { 3308, 20, 32, 25, 3, -32 },
  { 3388, 23, 32, 25, 1, -32 },
  { 3480, 31, 32, 34, 2, -32 },
  { 3604, 21, 32, 25, 2, -32 },
  { 3688, 22, 32, 24, 1, -32 },
  { 3776, 20, 32, 24, 2, -32 },
  { 3856, 7, 44, 11, 3, -37 },
  { 3895, 15, 35, 17, 1, -32 },
  { 3961, 7, 44, 11, 1, -37 },
  { 4000, 13, 16, 17, 2, -32 },
  { 4026, 17, 3, 18, 1, 0 },
  { 4033, 9, 6, 14, 1, -33 },
  { 4040, 17, 24, 22, 2, -24 },
  { 4091, 17, 34, 22, 3, -34 },
  { 4164, 17, 24, 21, 2, -24 },
  { 4215, 17, 34, 22, 2, -34 },
  { 4288, 17, 24, 21, 2, -24 },
  { 4339, 12, 34, 14, 2, -34 },
  { 4390, 17, 33, 22, 2, -24 },
  { 4461, 16, 34, 22, 3, -34 },
  { 4529, 4, 33, 10, 3, -33 },
  { 4546, 8, 42, 10, -1, -33 },
  { 4588, 17, 34, 20, 3, -34 },
  { 4661, 4, 34, 10, 3, -34 },
  { 4678, 28, 24, 34, 3, -24 },
  { 4762, 16, 24, 22, 3, -24 },
  { 4810, 19, 24, 23, 2, -24 },
  { 4867, 17, 33, 22, 3, -24 },
  { 4938, 17, 33, 23, 2, -24 },
  { 5009, 10, 24, 14, 3, -24 },
  { 5039, 16, 24, 21, 2, -24 },
  { 5087, 12, 30, 13, 0, -30 },
  { 5132, 16, 24, 22, 3, -24 },
  { 5180, 17, 24, 19, 1, -24 },
  { 5231, 27, 24, 29, 1, -24 },
  { 5312, 18, 24, 20, 1, -24 },
  { 5366, 17, 33, 19, 1, -24 },
  { 5437, 16, 24, 20, 2, -24 },
  { 5485, 11, 43, 14, 2, -35 },
  { 5545, 3, 38, 11, 4, -32 },
  { 5560, 11, 43, 14, 1, -35 },
  { 5620, 21, 9, 27, 3, -18 },
};

const GFXfont RobotoCondensed_Regular45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_REGULAR45PT7B_H_
