#ifndef _ROBOTOCONDENSED_REGULAR72PT7B_H_
#define _ROBOTOCONDENSED_REGULAR72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x3F, 0x7F, 0xFF, 0xFB, 0xF3, 0xC0, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF,
  0x07, 0xBC, 0x1E, 0xF0, 0x78, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC3,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0x00,
  0xF8, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x7C,
  0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x01, 0xF0,
  0x78, 0x00, 0xF8, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0x07,
  0xC0, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC3, 0xE0, 0x00, 0x3F, 0xFF, 0x0F,
  0x80, 0x00, 0xFF, 0xF8, 0x7C, 0x00, 0x00, 0xFF, 0xC1, 0xF0, 0x00, 0x01,
  0xFC, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x00, 0x1E, 0x0F,
  0xFE, 0x00, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0x03, 0xC3, 0xFF, 0xF0, 0x00,
  0x1F, 0x0F, 0x87, 0xE0, 0x00, 0x78, 0x7C, 0x0F, 0x80, 0x03, 0xE1, 0xF0,
  0x1F, 0x00, 0x0F, 0x07, 0x80, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0xF0, 0x03,
  0xE0, 0xF8, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x0F, 0x00, 0x7C, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x1F, 0x01,
  0xF0, 0x0E, 0x00, 0x7C, 0x07, 0xC0, 0x10, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x3F, 0x9F, 0xC0, 0x7E, 0x0F, 0xE3, 0xFC,
  0x0F, 0xC3, 0xF8, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x1F, 0xC0,
  0x7F, 0x87, 0xC3, 0xF8, 0x07, 0xF0, 0xF8, 0x7E, 0x00, 0x7F, 0x3F, 0x0F,
  0xC0, 0x0F, 0xF7, 0xE1, 0xF8, 0x00, 0xFE, 0xFC, 0x3F, 0x00, 0x0F, 0xFF,
  0x07, 0xE0, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0x80, 0x01,
  0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x7F, 0x01, 0xFF, 0xFF, 0xCF,
  0xF0, 0x0F, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE,
  0xF0, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x02, 0x40, 0x00, 0x60, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x7C,
  0x03, 0x9F, 0xC3, 0xE0, 0xFC, 0xFF, 0x9F, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0xFC,
  0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0x38, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x07, 0xF0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF8, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0x1F,
  0xFE, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01,
  0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0xFE, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x0F, 0x8F, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7C, 0x3F, 0x80, 0x01,
  0xF8, 0x7F, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07,
  0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xF0,
  0x03, 0xFC, 0x0E, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00,
  0x0F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x07, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x7E, 0x3F, 0xF8, 0x0F, 0xCF, 0xFF, 0xC1, 0xFB, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xCF, 0xF8, 0xFF, 0xC0, 0x7F, 0x9F, 0xF0, 0x07,
  0xF3, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F,
  0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x03,
  0xFD, 0xFC, 0x00, 0xFF, 0xBF, 0xC0, 0x1F, 0xF3, 0xFC, 0x0F, 0xFE, 0x7F,
  0xE7, 0xFF, 0xC7, 0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0x3E, 0x07, 0xFF, 0xCF,
  0xC0, 0x7F, 0xF1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x0F, 0x07, 0xE3, 0xFC,
  0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F,
  0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x7F, 0xC1, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xFE, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0xFF, 0x80, 0x3C, 0x1F, 0x00, 0x1F,
  0xFF, 0xC0, 0x3E, 0x3E, 0x00, 0x3F, 0xFF, 0xC0, 0x1E, 0x3E, 0x00, 0x7E,
  0x07, 0xC0, 0x1E, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x3C, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x78, 0x03, 0xF0,
  0x07, 0xC0, 0x1F, 0x78, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x0F, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0xF8, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0xF8, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x3C, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x7C, 0x78, 0x07, 0xE0, 0x3F, 0x80, 0x78, 0x7C, 0x03, 0xF0,
  0x7F, 0x80, 0xF8, 0x7C, 0x03, 0xF9, 0xFF, 0xC1, 0xF0, 0x7C, 0x03, 0xFF,
  0xE7, 0xF7, 0xF0, 0x7C, 0x01, 0xFF, 0xE7, 0xFF, 0xE0, 0x3E, 0x00, 0xFF,
  0xC3, 0xFF, 0xC0, 0x3E, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x3E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xF0, 0x00,
  0x7F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F,
  0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x3F,
  0xCF, 0xC0, 0x03, 0xFC, 0x7E, 0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF1, 0xF8, 0x00, 0x7F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x1F, 0xEF, 0xC0, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0xFC, 0x00,
  0x0F, 0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x3F, 0xC7, 0xE0, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x07,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x00, 0xFF, 0x1F, 0x80,
  0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x83, 0xF0,
  0x00, 0x7F, 0x81, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x03, 0xF0, 0x1F, 0xE0, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x00, 0x7E, 0x0F, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC7, 0xF8, 0x00,
  0x07, 0xE7, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFB, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x07, 0xFC, 0x7F,
  0x80, 0x03, 0xFE, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xFC, 0x03, 0xF0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F,
  0xBF, 0x00, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x1F,
  0xFF, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xFE, 0xFC, 0x00, 0x00, 0xFD, 0xFF,
  0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xFF, 0xBF,
  0x00, 0x00, 0xFC, 0xFF, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0xFE, 0x7E, 0x00,
  0x07, 0xE3, 0xFF, 0xCF, 0xC0, 0x00, 0xFC, 0x7F, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0xFF, 0x1F, 0x80, 0x07, 0xE1, 0xFF, 0xE3, 0xF0, 0x00, 0xFC, 0x3F,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xFF, 0x87, 0xE0, 0x07, 0xE0, 0xFF, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0x1F, 0x87, 0xFF, 0xC1, 0xF8,
  0x07, 0xE0, 0xFF, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0x03, 0xF0, 0x1F,
  0x83, 0xFF, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xFF, 0x80, 0xFC, 0x1F, 0x81, 0xFF, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0xFE,
  0x01, 0xF0, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0x1F, 0x80, 0xFF, 0xF8, 0x07,
  0xE3, 0xE0, 0x1F, 0xFF, 0x00, 0x7C, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xDF,
  0x80, 0x7F, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xEF, 0xC0, 0x00, 0xFF,
  0xF7, 0xF0, 0x00, 0x7F, 0xF9, 0xF8, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x1F,
  0xFE, 0x3F, 0x00, 0x0F, 0xFF, 0x0F, 0xC0, 0x07, 0xFF, 0x87, 0xE0, 0x03,
  0xFF, 0xC1, 0xF8, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0x00,
  0x7F, 0xF8, 0x1F, 0x80, 0x3F, 0xFC, 0x07, 0xE0, 0x1F, 0xFE, 0x03, 0xF0,
  0x0F, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0x7E, 0x03, 0xFF, 0xC0, 0x1F,
  0x81, 0xFF, 0xE0, 0x0F, 0xC0, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0xF8, 0x01,
  0xF8, 0x3F, 0xFC, 0x00, 0x7E, 0x1F, 0xFE, 0x00, 0x3F, 0x8F, 0xFF, 0x00,
  0x0F, 0xC7, 0xFF, 0x80, 0x07, 0xF3, 0xFF, 0xC0, 0x01, 0xF9, 0xFF, 0xE0,
  0x00, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0x00, 0x03, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFE, 0xFC, 0x00,
  0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x07,
  0xF8, 0x7E, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x3F,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01,
  0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07,
  0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x3F,
  0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0x87, 0xFC, 0x01, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x7E,
  0x07, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x9F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF3, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0x87,
  0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0x00, 0x3F, 0x01,
  0xF0, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x1F, 0x03, 0xF0, 0x01,
  0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x3E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7E,
  0x00, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x07,
  0xCF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x00,
  0x0F, 0xBF, 0x00, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xFB, 0xE0, 0x07,
  0xCF, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0x83,
  0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0,
  0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x9F, 0x80, 0x3E, 0x7E, 0x00, 0xFD, 0xF0,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x7F, 0xC0, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7E,
  0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F,
  0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xF0,
  0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0x1F, 0x81, 0xFF,
  0xC3, 0xF8, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x3F, 0xF0, 0x1F, 0x9F, 0xFF, 0x83, 0xF7, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xF7, 0xF8, 0x01, 0xFE, 0xFF,
  0xC0, 0x7F, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7E, 0xFF, 0xFF,
  0x0F, 0x8F, 0xFF, 0xC1, 0xF0, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC1, 0xFE, 0x01, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xE0, 0x3F, 0x00, 0xFF, 0xC3, 0xF0, 0x3F, 0xFF, 0x3F, 0x07, 0xFF,
  0xFB, 0xF0, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xFF,
  0x3F, 0xC0, 0x1F, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xF1, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0xBF, 0x03, 0xFF, 0xF3,
  0xF0, 0x0F, 0xFC, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x83, 0xF8, 0x00, 0x1C,
  0x3F, 0xC0, 0x03, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xFC, 0x3F, 0x03, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0xBF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F, 0xF3, 0xFC,
  0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x03, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0x3F, 0x00,
  0xFF, 0xC3, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x40, 0x00, 0xFE, 0x0E, 0x00, 0x0F, 0xE0, 0xF8, 0x03, 0xFC, 0x1F, 0xF1,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0xFC, 0x3F, 0xF0,
  0x7E, 0x7F, 0xFE, 0x3F, 0x7F, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF7, 0xFE, 0x07, 0xFB, 0xFE, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF0, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0xFF,
  0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x87, 0xE0, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0x9F, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF8,
  0x7E, 0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x03,
  0xF0, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x01, 0xF9, 0xFC,
  0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0,
  0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x01, 0xFE,
  0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0xE3, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFB, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0x9F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF7, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xEF,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x7E,
  0x1F, 0xF8, 0x3F, 0x3F, 0xFF, 0x1F, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFB, 0xFF, 0x03, 0xFD, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x0F, 0xFE, 0x03, 0xE3,
  0xFF, 0xF0, 0x7E, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x3F, 0xE0, 0x3F, 0xE7, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0x80,
  0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0xF0, 0x0F, 0xF3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xE1, 0xF9, 0xFF, 0xF8,
  0x3F, 0x1F, 0xFC, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xFC, 0x3F, 0x03, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F,
  0x80, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x3F,
  0x80, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0x3F, 0x01, 0xFF, 0xC3, 0xF0,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xBF, 0x00,
  0x1F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xBF, 0xC0, 0x3F, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFB, 0xF1, 0xFF, 0xF9, 0xF8, 0x3F, 0xF8, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3,
  0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xF0, 0x07, 0xE1,
  0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xC0, 0x1F, 0x87, 0xE0,
  0x1F, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0x80, 0x7C, 0x0F, 0x80, 0x7F,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0x3F, 0x03, 0xF7, 0xC0,
  0x7E, 0x07, 0xE0, 0x7C, 0xFC, 0x0F, 0x80, 0x7C, 0x0F, 0x8F, 0x81, 0xF0,
  0x0F, 0xC3, 0xF1, 0xF0, 0x7E, 0x01, 0xF8, 0x7C, 0x3E, 0x0F, 0xC0, 0x3F,
  0x0F, 0x87, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x7C, 0x3E, 0x00, 0x7C, 0x7E,
  0x0F, 0x8F, 0xC0, 0x0F, 0xCF, 0x81, 0xF9, 0xF8, 0x01, 0xF9, 0xF0, 0x3F,
  0x3E, 0x00, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x7C, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x00,
  0xFE, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF1,
  0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F,
  0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00,
  0x7F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x60, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0xFF, 0xF8,
  0x00, 0x7C, 0x7F, 0xFF, 0x00, 0x1F, 0x1F, 0xFF, 0xE0, 0x07, 0xCF, 0xFF,
  0xFC, 0x03, 0xF3, 0xF0, 0x7F, 0x80, 0xF9, 0xF8, 0x0F, 0xF0, 0x7E, 0x7E,
  0x01, 0xFF, 0xFF, 0x1F, 0x00, 0x3F, 0xFF, 0xC7, 0xC0, 0x07, 0xFF, 0xE3,
  0xF0, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00,
};

const GFXglyph RobotoCondensed_Regular72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 52, 18, 6, -51 },
  { 47, 14, 17, 23, 5, -54 },
  { 77, 33, 51, 39, 5, -51 },
  { 288, 28, 68, 36, 4, -60 },
  { 526, 38, 53, 46, 4, -52 },
  { 778, 35, 53, 39, 4, -52 },
  { 1010, 5, 17, 13, 4, -54 },
  { 1021, 16, 75, 23, 5, -58 },
  { 1171, 16, 75, 23, 2, -58 },
  { 1321, 29, 30, 31, 1, -51 },
  { 1430, 30, 37, 36, 3, -42 },
  { 1569, 10, 18, 14, 1, -8 },
  { 1592, 14, 5, 18, 2, -24 },
  { 1601, 8, 8, 19, 5, -7 },
  { 1609, 23, 55, 27, 1, -51 },
  { 1768, 27, 53, 36, 4, -52 },
  { 1947, 17, 51, 36, 6, -51 },
  { 2056, 30, 52, 36, 3, -52 },
  { 2251, 28, 53, 36, 3, -52 },
  { 2437, 31, 51, 36, 2, -51 },
  { 2635, 28, 52, 36, 5, -51 },
  { 2817, 27, 52, 36, 5, -51 },
  { 2993, 29, 51, 36, 3, -51 },
  { 3178, 27, 53, 36, 4, -52 },
  { 3357, 27, 52, 36, 4, -52 },
  { 3533, 8, 39, 17, 5, -38 },
  { 3572, 10, 48, 15, 2, -38 },
  { 3632, 24, 32, 32, 3, -39 },
  { 3728, 25, 21, 34, 5, -35 },
  { 3794, 25, 32, 33, 5, -39 },
  { 3894, 24, 53, 30, 3, -52 },
  { 4053, 48, 66, 55, 4, -50 },
  { 4449, 38, 51, 42, 2, -51 },
  { 4692, 29, 51, 39, 6, -51 },
  { 4877, 34, 53, 41, 4, -52 },
  { 5103, 31, 51, 41, 6, -51 },
  { 5301, 27, 51, 36, 6, -51 },
  { 5474, 26, 51, 35, 6, -51 },
  { 5640, 34, 53, 43, 4, -52 },
  { 5866, 33, 51, 45, 6, -51 },
  { 6077, 6, 51, 18, 6, -51 },
  { 6116, 28, 52, 35, 2, -51 },
  { 6298, 33, 51, 39, 6, -51 },
  { 6509, 26, 51, 34, 6, -51 },
  { 6675, 43, 51, 54, 6, -51 },
  { 6950, 33, 51, 45, 6, -51 },
  { 7161, 35, 53, 43, 4, -52 },
  { 7393, 31, 51, 40, 6, -51 },
  { 7591, 35, 61, 43, 4, -52 },
  { 7858, 31, 51, 38, 6, -51 },
  { 8056, 31, 53, 37, 3, -52 },
  { 8262, 33, 51, 37, 2, -51 },
  { 8473, 31, 52, 40, 5, -51 },
  { 8675, 37, 51, 40, 2, -51 },
  { 8911, 51, 51, 55, 2, -51 },
  { 9237, 35, 51, 40, 2, -51 },
  { 9461, 36, 51, 38, 1, -51 },
  { 9691, 32, 51, 38, 3, -51 },
  { 9895, 11, 70, 18, 5, -59 },
  { 9992, 24, 55, 27, 2, -51 },
  { 10157, 12, 70, 18, 1, -59 },
  { 10262, 22, 26, 27, 2, -51 },
  { 10334, 27, 5, 29, 1, 0 },
  { 10351, 15, 10, 22, 2, -54 },
  { 10370, 27, 40, 34, 4, -39 },
  { 10505, 27, 55, 36, 5, -54 },
  { 10691, 28, 40, 33, 3, -39 },
  { 10831, 28, 55, 36, 3, -54 },
  { 11024, 28, 40, 34, 3, -39 },
  { 11164, 20, 55, 23, 2, -55 },
  { 11302, 28, 54, 36, 3, -39 },
  { 11491, 25, 54, 35, 5, -54 },
  { 11660, 7, 51, 17, 5, -51 },
  { 11705, 12, 66, 16, -1, -51 },
  { 11804, 27, 54, 32, 5, -54 },
  { 11987, 6, 54, 17, 5, -54 },
  { 12028, 45, 39, 54, 5, -39 },
  { 12248, 25, 39, 35, 5, -39 },
  { 12370, 30, 40, 36, 3, -39 },
  { 12520, 27, 54, 36, 5, -39 },
  { 12703, 28, 54, 36, 3, -39 },
  { 12892, 15, 39, 22, 5, -39 },
  { 12966, 25, 40, 33, 4, -39 },
  { 13091, 18, 48, 21, 1, -47 },
  { 13199, 25, 39, 35, 5, -38 },
  { 13321, 27, 38, 31, 2, -38 },
  { 13450, 43, 38, 47, 2, -38 },
  { 13655, 28, 38, 32, 2, -38 },
  { 13788, 28, 53, 30, 1, -38 },
  { 13974, 26, 38, 32, 3, -38 },
  { 14098, 18, 69, 22, 3, -56 },
  { 14254, 5, 61, 18, 6, -51 },
  { 14293, 18, 69, 22, 1, -56 },
  { 14449, 34, 14, 42, 4, -28 },
};

const GFXfont RobotoCondensed_Regular72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_REGULAR72PT7B_H_
