#ifndef _ROBOTOCONDENSED_REGULAR66PT7B_H_
#define _ROBOTOCONDENSED_REGULAR66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFC, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF3, 0xF7, 0xEF, 0xFF, 0x9F, 0x1C, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xBE, 0x1E, 0xF8, 0x7B, 0xE1,
  0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x3E, 0x03,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0xF8, 0x07, 0x81, 0xF0, 0x0F,
  0x80, 0x78, 0x1E, 0x00, 0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x80, 0x78, 0x3C,
  0x00, 0x78, 0x0F, 0x87, 0xC0, 0x07, 0x80, 0xF8, 0x78, 0x00, 0x7C, 0x0F,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0xF0, 0x00, 0x3F, 0xFE, 0x1E, 0x00, 0x01,
  0xFF, 0xE1, 0xE0, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0x00, 0x7F, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x03, 0xC1, 0xFF, 0x80, 0x00, 0x7C, 0x3F,
  0xFC, 0x00, 0x07, 0x87, 0xFF, 0xC0, 0x00, 0xF8, 0xF8, 0x3E, 0x00, 0x0F,
  0x0F, 0x81, 0xE0, 0x01, 0xF0, 0xF0, 0x1E, 0x00, 0x1E, 0x0F, 0x01, 0xF0,
  0x03, 0xE1, 0xF0, 0x0F, 0x00, 0x3C, 0x1F, 0x00, 0xF0, 0x07, 0xC1, 0xF0,
  0x0F, 0x00, 0x78, 0x1F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0xF0,
  0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x0F, 0x01, 0xE0,
  0x0C, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x7C, 0x1F, 0xDF, 0xC0, 0x7C, 0x3F, 0x8F, 0xE0, 0x7C, 0x3F,
  0x07, 0xF0, 0x7C, 0x7E, 0x03, 0xF0, 0xFC, 0x7E, 0x03, 0xF8, 0xF8, 0x7C,
  0x01, 0xFC, 0xF8, 0xFC, 0x00, 0xFC, 0xF8, 0xFC, 0x00, 0xFF, 0xF8, 0xFC,
  0x00, 0x7F, 0xF8, 0xFC, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x3F, 0xF0, 0x7C,
  0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xF8, 0x1F, 0xE0, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xF8, 0xFE, 0x01,
  0xFF, 0xE0, 0x7F, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x18, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x30, 0x00,
  0x20, 0x40, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x02, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x02, 0x00, 0xF8, 0x00,
  0x70, 0x1F, 0x01, 0x8F, 0xC3, 0xE1, 0xFB, 0xFF, 0x79, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x1F, 0x8F, 0xCF, 0xC7, 0xC7, 0xE1, 0xE0, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x1F, 0xE0, 0xFE,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF3,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x7F, 0x81, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x1F, 0xC1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F,
  0xF0, 0xFE, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x87, 0xF8, 0x3F, 0xC1,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC3, 0xFE, 0x3F, 0xE1, 0xFC, 0x07, 0xF8, 0x7C, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x3E, 0x3F, 0xF0, 0x1F, 0x7F, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0x0F, 0xF3, 0xFE, 0x01,
  0xFD, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFC,
  0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F,
  0x03, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0x80, 0x07, 0xE7,
  0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F,
  0x81, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0x07, 0xE0,
  0x1F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x3F,
  0x87, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7F,
  0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x3F,
  0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0xC7, 0xF0, 0x7F, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFE, 0xF8, 0x3F, 0xFE, 0xFC, 0x0F, 0xFE, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x7E, 0xFF, 0xFF, 0x7F, 0x7E, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7E, 0xFF, 0xFF, 0x7F, 0x7E,
  0x1C, 0x0F, 0x87, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7C, 0x0E, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC7, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xC1, 0xE0, 0x01,
  0xFF, 0x80, 0x3C, 0x3E, 0x00, 0x3F, 0xFC, 0x03, 0xC3, 0xC0, 0x07, 0xFF,
  0xE0, 0x1C, 0x3C, 0x00, 0xFC, 0x3E, 0x01, 0xE7, 0xC0, 0x1F, 0x03, 0xE0,
  0x1E, 0x78, 0x01, 0xF0, 0x3E, 0x01, 0xE7, 0x80, 0x3E, 0x03, 0xE0, 0x1E,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xEF, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0xEF, 0x80, 0x78, 0x03, 0xC0, 0x0E, 0xF0, 0x0F,
  0x80, 0x3C, 0x00, 0xEF, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0x0F, 0x80,
  0x3C, 0x00, 0xFF, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0xF0, 0x0F, 0x00, 0x3C,
  0x00, 0xEF, 0x01, 0xF0, 0x03, 0xC0, 0x1E, 0xF0, 0x1F, 0x00, 0x7C, 0x01,
  0xEF, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xEF,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x1F, 0x00, 0x7C, 0x01, 0xEF, 0x01,
  0xF0, 0x07, 0xC0, 0x3C, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xCF, 0x00, 0xF8,
  0x0F, 0xC0, 0x7C, 0xF8, 0x0F, 0x81, 0xFC, 0x07, 0x8F, 0x80, 0xFC, 0x3F,
  0xC0, 0xF8, 0x78, 0x07, 0xFF, 0xBE, 0x1F, 0x07, 0x80, 0x7F, 0xF3, 0xFF,
  0xE0, 0x7C, 0x03, 0xFE, 0x1F, 0xFC, 0x07, 0xC0, 0x1F, 0xC0, 0xFF, 0x80,
  0x3C, 0x00, 0x70, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x7C, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1,
  0xF8, 0x01, 0xFF, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFE, 0x7E,
  0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x0F, 0xF3, 0xF0,
  0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x0F, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF1, 0xFF, 0x80, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x7F, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0x83,
  0xF0, 0x01, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x87, 0xE0, 0x0F, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3F,
  0x80, 0x00, 0x7C, 0x7F, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFF,
  0x87, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x3F, 0xC0, 0x7F, 0x0F,
  0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x01,
  0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0x00, 0x03, 0xFF,
  0x7F, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFB, 0xE0, 0x00, 0x07, 0xFF, 0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0xFB,
  0xF0, 0x00, 0x0F, 0xBF, 0xFD, 0xF0, 0x00, 0x0F, 0xBF, 0xFD, 0xF8, 0x00,
  0x1F, 0xBF, 0xFD, 0xF8, 0x00, 0x1F, 0x3F, 0xFC, 0xF8, 0x00, 0x1F, 0x3F,
  0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0xFC, 0x7C,
  0x00, 0x3E, 0x3F, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0xFC, 0x7E, 0x00, 0x7C,
  0x3F, 0xFC, 0x3E, 0x00, 0x7C, 0x3F, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0xFC,
  0x3F, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x01,
  0xF8, 0x3F, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0xFC, 0x0F, 0x81, 0xF0, 0x3F,
  0xFC, 0x0F, 0x83, 0xF0, 0x3F, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0xFC, 0x07,
  0xC3, 0xE0, 0x3F, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0xFC, 0x07, 0xE7, 0xC0,
  0x3F, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xDF, 0x00, 0x07, 0xFF, 0xBF, 0x00, 0x0F, 0xFF, 0x3F, 0x00, 0x1F, 0xFE,
  0x7E, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x7F, 0xF8, 0xFC, 0x00, 0xFF, 0xF0,
  0xFC, 0x01, 0xFF, 0xE0, 0xF8, 0x03, 0xFF, 0xC1, 0xF8, 0x07, 0xFF, 0x81,
  0xF0, 0x0F, 0xFF, 0x03, 0xF0, 0x1F, 0xFE, 0x03, 0xE0, 0x3F, 0xFC, 0x07,
  0xE0, 0x7F, 0xF8, 0x07, 0xC0, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF, 0xE0, 0x0F,
  0x83, 0xFF, 0xC0, 0x1F, 0x87, 0xFF, 0x80, 0x1F, 0x0F, 0xFF, 0x00, 0x3F,
  0x1F, 0xFE, 0x00, 0x3E, 0x3F, 0xFC, 0x00, 0x7E, 0x7F, 0xF8, 0x00, 0x7C,
  0xFF, 0xF0, 0x00, 0xFD, 0xFF, 0xE0, 0x00, 0xFB, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x7E, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0xFE, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7E, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0xFF, 0x1F, 0x80, 0x03, 0xF8,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0xC3, 0xF0, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x1F,
  0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0x7E,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xF0,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x7F, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0xEF, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xDF, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xBE, 0x00, 0xFC, 0x0F, 0xC0, 0x1E, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC0, 0x3F,
  0x01, 0xF1, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xE1, 0xE0, 0x3F, 0x00, 0xFC,
  0x0F, 0x83, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0x07, 0xE0, 0x07, 0xE1,
  0xF0, 0x1E, 0x0F, 0xC0, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x00, 0x3E, 0x1E,
  0x00, 0xF0, 0xF8, 0x00, 0x7E, 0x7C, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0xF8,
  0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xC0,
  0x07, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x0F, 0x3E, 0x00, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xF8,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0x9F, 0x00,
  0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x7C,
  0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x1F, 0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xF0,
  0x7E, 0x7F, 0x80, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0x7F, 0xDF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0x3F, 0x0F, 0xFC,
  0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0xF8, 0x03, 0xF1, 0xFF, 0x80, 0xFC, 0xFF, 0xF8, 0x3F,
  0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0x87, 0xF8, 0xFF, 0x80, 0x7F,
  0x3F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC,
  0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xE0, 0x03, 0xFB,
  0xFC, 0x00, 0xFC, 0xFF, 0x80, 0x7F, 0x3F, 0xF8, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xF7, 0xFF, 0xF0, 0xFC, 0xFF, 0xF8, 0x3F, 0x1F, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xDF, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x01, 0xF8,
  0xFE, 0x00, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x07, 0xFF, 0x1F,
  0x07, 0xFF, 0xCF, 0x87, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0xE7, 0xFC, 0x3F,
  0xF3, 0xF8, 0x07, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xE7, 0xE0, 0x07, 0xF3, 0xF8, 0x07, 0xF8, 0xFF, 0x0F, 0xFC, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xDF, 0x07, 0xFF, 0xCF, 0x81, 0xFF, 0xC7, 0xC0, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0xFE, 0x01, 0xFC,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x21, 0xF8, 0x00, 0x30,
  0xFE, 0x00, 0x7C, 0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x10,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC7, 0xC1,
  0xFF, 0xF3, 0xE1, 0xFF, 0xFD, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0x0F, 0xFC,
  0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF9,
  0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x3F, 0xC3, 0xFF, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xF7, 0xC1, 0xFF, 0xF3, 0xE0, 0x7F, 0xF1, 0xF0, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x84, 0x00, 0x1F, 0x87, 0x80, 0x1F, 0xC3, 0xF0, 0x1F, 0xE3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80,
  0xFC, 0x7F, 0xE0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xE3, 0xFC, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x38, 0xF9, 0xFF,
  0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x01, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0xFF, 0xDF, 0xFB, 0xFE,
  0x7F, 0x8F, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x3F,
  0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x7F, 0x03,
  0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80,
  0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xE7, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xC7,
  0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x7E, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0x7F,
  0xFC, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFE, 0x1F, 0xFF, 0x87, 0xFB, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x7F, 0xE0, 0xFC,
  0xFF, 0xF8, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xE3, 0xFC, 0xFF,
  0x80, 0xFE, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xCF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x7E, 0x3F, 0xF0, 0x3F, 0x3F, 0xFE, 0x1F, 0xBF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE7, 0xFF, 0x1F, 0xF3, 0xFC, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xFC, 0x01, 0xFD, 0xFF,
  0x83, 0xFC, 0xFF, 0xFF, 0xFE, 0x7E, 0xFF, 0xFE, 0x3F, 0x3F, 0xFE, 0x1F,
  0x8F, 0xFC, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFF, 0xC7, 0xC1, 0xFF, 0xF3, 0xE1, 0xFF, 0xFD, 0xF1, 0xFF, 0xFF, 0xF9,
  0xFF, 0x0F, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7,
  0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0xC1, 0xFF,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xF7, 0xC1, 0xFF, 0xF3, 0xE0, 0x7F, 0xF1,
  0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3D, 0xF9, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x00, 0xFE, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7E, 0x3F,
  0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF9, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0xFF,
  0x7F, 0x01, 0xFF, 0x3F, 0xCF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xBF, 0x07, 0xFE, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x0F,
  0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00,
  0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F,
  0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x7C, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xCF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x80,
  0x3F, 0x3F, 0x00, 0xFF, 0x80, 0x7C, 0x3E, 0x01, 0xFF, 0x00, 0xF8, 0x7C,
  0x03, 0xFE, 0x01, 0xF0, 0xFC, 0x0F, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0xF8, 0x1F, 0x03, 0xE0, 0x79, 0xF0, 0x3E, 0x07,
  0xC1, 0xF1, 0xF0, 0xFC, 0x0F, 0xC3, 0xE3, 0xE1, 0xF0, 0x0F, 0x87, 0xC7,
  0xC3, 0xE0, 0x1F, 0x1F, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x0F, 0x8F, 0x80,
  0x7E, 0x7C, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x3E, 0x7C, 0x00, 0xFB, 0xE0,
  0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0xFB, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0x9F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x07, 0xE3, 0xE0,
  0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0x7F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xE1,
  0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x7F,
  0xF8, 0x00, 0xF8, 0xFF, 0xF8, 0x01, 0xF3, 0xFF, 0xF8, 0x03, 0xEF, 0xE7,
  0xF8, 0x0F, 0x9F, 0x03, 0xF8, 0x1F, 0x3E, 0x03, 0xF8, 0xFE, 0xF8, 0x03,
  0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0xE3, 0xE0, 0x03, 0xFF, 0x87, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_Regular66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 48, 16, 5, -47 },
  { 43, 14, 16, 21, 4, -50 },
  { 71, 30, 47, 36, 4, -47 },
  { 248, 25, 62, 33, 4, -55 },
  { 442, 36, 49, 42, 3, -48 },
  { 663, 32, 49, 36, 3, -48 },
  { 859, 5, 15, 12, 3, -50 },
  { 869, 15, 68, 21, 4, -53 },
  { 997, 15, 68, 21, 2, -53 },
  { 1125, 27, 27, 28, 1, -47 },
  { 1217, 27, 35, 33, 3, -40 },
  { 1336, 9, 16, 13, 1, -7 },
  { 1354, 13, 5, 16, 2, -23 },
  { 1363, 7, 7, 17, 5, -6 },
  { 1370, 21, 51, 25, 1, -47 },
  { 1504, 25, 49, 33, 4, -48 },
  { 1658, 16, 47, 33, 5, -47 },
  { 1752, 27, 48, 33, 3, -48 },
  { 1914, 25, 49, 33, 3, -48 },
  { 2068, 29, 47, 33, 2, -47 },
  { 2239, 25, 48, 33, 5, -47 },
  { 2389, 25, 48, 33, 4, -47 },
  { 2539, 27, 47, 33, 3, -47 },
  { 2698, 25, 49, 33, 4, -48 },
  { 2852, 25, 48, 33, 3, -48 },
  { 3002, 8, 35, 15, 4, -34 },
  { 3037, 10, 43, 13, 1, -34 },
  { 3091, 22, 29, 29, 3, -35 },
  { 3171, 22, 18, 32, 5, -31 },
  { 3221, 24, 29, 30, 4, -35 },
  { 3308, 22, 49, 28, 3, -48 },
  { 3443, 44, 61, 51, 4, -46 },
  { 3779, 36, 47, 38, 1, -47 },
  { 3991, 27, 47, 36, 5, -47 },
  { 4150, 30, 49, 37, 4, -48 },
  { 4334, 29, 47, 38, 5, -47 },
  { 4505, 25, 47, 33, 5, -47 },
  { 4652, 24, 47, 32, 5, -47 },
  { 4793, 30, 49, 39, 4, -48 },
  { 4977, 31, 47, 41, 5, -47 },
  { 5160, 6, 47, 17, 5, -47 },
  { 5196, 25, 48, 32, 2, -47 },
  { 5346, 31, 47, 36, 5, -47 },
  { 5529, 24, 47, 31, 5, -47 },
  { 5670, 40, 47, 50, 5, -47 },
  { 5905, 31, 47, 41, 5, -47 },
  { 6088, 32, 49, 40, 4, -48 },
  { 6284, 29, 47, 37, 5, -47 },
  { 6455, 32, 56, 40, 4, -48 },
  { 6679, 29, 47, 35, 5, -47 },
  { 6850, 29, 49, 34, 3, -48 },
  { 7028, 30, 47, 34, 2, -47 },
  { 7205, 29, 48, 37, 4, -47 },
  { 7379, 35, 47, 37, 1, -47 },
  { 7585, 47, 47, 50, 2, -47 },
  { 7862, 32, 47, 36, 2, -47 },
  { 8050, 33, 47, 35, 1, -47 },
  { 8244, 29, 47, 35, 3, -47 },
  { 8415, 11, 64, 17, 4, -54 },
  { 8503, 22, 51, 24, 2, -47 },
  { 8644, 11, 64, 17, 1, -54 },
  { 8732, 20, 23, 25, 2, -47 },
  { 8790, 25, 5, 27, 1, 0 },
  { 8806, 13, 9, 20, 2, -49 },
  { 8821, 24, 37, 32, 4, -36 },
  { 8932, 26, 51, 33, 4, -50 },
  { 9098, 25, 37, 30, 3, -36 },
  { 9214, 25, 51, 33, 3, -50 },
  { 9374, 25, 37, 31, 3, -36 },
  { 9490, 18, 51, 21, 2, -51 },
  { 9605, 25, 49, 33, 3, -36 },
  { 9759, 24, 50, 32, 4, -50 },
  { 9909, 7, 48, 15, 4, -48 },
  { 9951, 11, 61, 15, -1, -48 },
  { 10035, 25, 50, 30, 4, -50 },
  { 10192, 5, 50, 15, 5, -50 },
  { 10224, 41, 36, 50, 4, -36 },
  { 10409, 24, 36, 32, 4, -36 },
  { 10517, 27, 37, 33, 3, -36 },
  { 10642, 25, 49, 33, 4, -36 },
  { 10796, 25, 49, 33, 3, -36 },
  { 10950, 15, 36, 20, 4, -36 },
  { 11018, 24, 37, 30, 3, -36 },
  { 11129, 16, 44, 20, 1, -43 },
  { 11217, 24, 36, 32, 4, -35 },
  { 11325, 26, 35, 28, 1, -35 },
  { 11439, 39, 35, 43, 2, -35 },
  { 11610, 25, 35, 29, 2, -35 },
  { 11720, 25, 48, 27, 1, -35 },
  { 11870, 23, 35, 29, 3, -35 },
  { 11971, 17, 63, 20, 2, -51 },
  { 12105, 4, 56, 16, 6, -47 },
  { 12133, 17, 63, 20, 1, -51 },
  { 12267, 31, 13, 39, 4, -26 },
};

const GFXfont RobotoCondensed_Regular66pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular66pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular66pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOCONDENSED_REGULAR66PT7B_H_
