#ifndef _ROBOTOCONDENSED_REGULAR18PT7B_H_
#define _ROBOTOCONDENSED_REGULAR18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0x43, 0xC0, 0x99, 0x99, 0x12, 0x12, 0x12, 0x12, 0x7F,
  0x36, 0x36, 0x24, 0xFF, 0x24, 0x24, 0x24, 0x6C, 0x10, 0x20, 0xE3, 0x6C,
  0x78, 0xD0, 0x30, 0x38, 0x18, 0x1E, 0x3C, 0x6D, 0x8E, 0x08, 0x10, 0x70,
  0x24, 0x09, 0x22, 0x48, 0x94, 0x1D, 0x00, 0x80, 0x2E, 0x16, 0x85, 0x32,
  0x4C, 0x9A, 0x03, 0x80, 0x38, 0x36, 0x11, 0x08, 0x86, 0xC1, 0xC1, 0xC0,
  0xB2, 0xCF, 0x47, 0xB1, 0x9D, 0xE7, 0xB0, 0xF0, 0x13, 0x26, 0x44, 0xCC,
  0xCC, 0xCC, 0x44, 0x62, 0x31, 0x42, 0x08, 0x43, 0x08, 0x42, 0x18, 0xC4,
  0x21, 0x18, 0x84, 0x42, 0x00, 0x18, 0x18, 0xD2, 0x7E, 0x38, 0x2C, 0x24,
  0x10, 0x20, 0x40, 0x8F, 0xFF, 0xC4, 0x08, 0x10, 0x20, 0x6D, 0x60, 0xF0,
  0xF0, 0x04, 0x30, 0x82, 0x18, 0x41, 0x0C, 0x20, 0x86, 0x10, 0x43, 0x00,
  0x38, 0xDB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1B, 0x63, 0x80,
  0x1B, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x80, 0x79, 0xDB, 0x1C,
  0x30, 0x60, 0x83, 0x0C, 0x10, 0x61, 0x86, 0x0F, 0xE0, 0x38, 0xDB, 0x16,
  0x30, 0x41, 0x8E, 0x02, 0x07, 0x0F, 0x1F, 0x67, 0x80, 0x0C, 0x38, 0x71,
  0xE2, 0xCD, 0x93, 0x66, 0x8D, 0xFC, 0x30, 0x60, 0xC0, 0x7E, 0xFD, 0x02,
  0x07, 0xCD, 0x81, 0x83, 0x03, 0x85, 0x1B, 0x63, 0x80, 0x18, 0x61, 0x82,
  0x0F, 0x9D, 0xB1, 0xE3, 0xC7, 0x8D, 0x1B, 0x63, 0x80, 0xFE, 0x0C, 0x18,
  0x20, 0xC1, 0x02, 0x0C, 0x10, 0x60, 0xC1, 0x06, 0x00, 0x38, 0xDB, 0x1E,
  0x3C, 0x4D, 0x9E, 0x22, 0xC7, 0x8F, 0x1B, 0x63, 0x80, 0x38, 0xDB, 0x16,
  0x38, 0x78, 0xF1, 0xB7, 0x76, 0x08, 0x30, 0xC7, 0x00, 0xF0, 0x00, 0xF0,
  0x6C, 0x00, 0x00, 0x6D, 0xE0, 0x04, 0x77, 0x30, 0xC1, 0xC1, 0xC1, 0xFC,
  0x00, 0x3F, 0x81, 0xC0, 0xE0, 0x70, 0xE7, 0x38, 0x40, 0x7B, 0x68, 0xC3,
  0x0C, 0x63, 0x0C, 0x20, 0x00, 0x08, 0x20, 0x0F, 0x81, 0x8C, 0x20, 0x64,
  0x02, 0x47, 0x1C, 0xD9, 0x89, 0x19, 0x91, 0x99, 0x19, 0x11, 0x99, 0x19,
  0xB2, 0xCC, 0xC4, 0x00, 0x60, 0x03, 0x00, 0x1F, 0x00, 0x0C, 0x03, 0x00,
  0xE0, 0x68, 0x1A, 0x04, 0xC3, 0x30, 0xC4, 0x21, 0x9F, 0xE6, 0x09, 0x03,
  0x40, 0xC0, 0xFC, 0xC6, 0xC2, 0xC3, 0xC2, 0xC6, 0xFC, 0xC2, 0xC3, 0xC3,
  0xC3, 0xC6, 0xFC, 0x3E, 0x77, 0x43, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC1, 0x43, 0x67, 0x3E, 0xFC, 0xCE, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC3, 0xC3, 0xCE, 0xFC, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0,
  0xC1, 0x83, 0x06, 0x0F, 0xE0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x00, 0x3E, 0x77, 0x43, 0xC1, 0xC0, 0xC0, 0xC0,
  0xCF, 0xC1, 0xC1, 0x41, 0x73, 0x3E, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0xFF, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xFF, 0xFF, 0xFF,
  0xC0, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x06, 0x18, 0x73, 0x78, 0xC3,
  0x63, 0x31, 0x99, 0x8D, 0x86, 0x83, 0xE1, 0xD0, 0xCC, 0x63, 0x31, 0x98,
  0x6C, 0x10, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0F, 0xE0, 0xE0, 0x7C, 0x0F, 0x83, 0xF8, 0x7F, 0x0B, 0xA3, 0x76, 0x6E,
  0xC9, 0xCB, 0x39, 0x67, 0x38, 0xE3, 0x1C, 0x62, 0xC1, 0xF0, 0xF8, 0x7E,
  0x3D, 0x1E, 0xCF, 0x27, 0x9B, 0xC5, 0xE3, 0xF0, 0xF8, 0x7C, 0x18, 0x3E,
  0x3B, 0x90, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xD0, 0x4E,
  0xE3, 0xE0, 0xFE, 0xC7, 0xC3, 0xC1, 0xC1, 0xC3, 0xC7, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x3C, 0x3B, 0x90, 0xD8, 0x2C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0x90, 0xCE, 0xE3, 0xE0, 0x18, 0x04, 0xFC, 0xC6, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC6, 0xFC, 0xCC, 0xC6, 0xC6, 0xC3, 0xC3, 0x3C, 0x66, 0xC2,
  0xC3, 0xC0, 0x60, 0x3C, 0x0E, 0x02, 0x83, 0xC2, 0x66, 0x3C, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C,
  0x40, 0xD8, 0x26, 0x19, 0x86, 0x21, 0x0C, 0xC3, 0x30, 0x48, 0x12, 0x07,
  0x80, 0xE0, 0x30, 0x0C, 0x00, 0x86, 0x1C, 0x63, 0xC6, 0x3C, 0x63, 0x4F,
  0x24, 0x92, 0x49, 0x66, 0x96, 0x79, 0x67, 0x1C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0xC3, 0xC2, 0x66, 0x64, 0x3C, 0x18, 0x18, 0x38, 0x3C, 0x66, 0x66,
  0xC3, 0xC3, 0xC1, 0xB0, 0x98, 0xC6, 0x63, 0x20, 0xB0, 0x70, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xFE, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0xFF, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDC, 0x41, 0x06, 0x08, 0x20, 0xC1, 0x04, 0x18, 0x60, 0x83, 0x0C, 0x10,
  0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0x3C, 0x23, 0x1C, 0xAD, 0xCC, 0xFE,
  0x62, 0x30, 0x38, 0xDB, 0x10, 0x23, 0xD8, 0xB1, 0x62, 0xCC, 0xEC, 0xC1,
  0x83, 0x06, 0x0F, 0xDD, 0xB1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0xDF, 0x80,
  0x78, 0xDB, 0x1C, 0x08, 0x10, 0x20, 0x63, 0x6C, 0xF0, 0x06, 0x0C, 0x18,
  0x37, 0xFD, 0xF1, 0xC3, 0x87, 0x0E, 0x1E, 0x3E, 0xEF, 0xC0, 0x38, 0xDB,
  0x1C, 0x3F, 0xF0, 0x20, 0x60, 0x66, 0x78, 0x33, 0x10, 0x8F, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x20, 0x7F, 0xDF, 0x1C, 0x38, 0x70, 0xE1, 0xE3, 0xEE,
  0xFC, 0x18, 0x34, 0xCF, 0x00, 0xC1, 0x83, 0x06, 0x0F, 0xDD, 0xB1, 0x63,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xC0, 0xF0, 0xFF, 0xFF, 0xF0, 0x6C, 0x06,
  0xDB, 0x6D, 0xB6, 0xDB, 0x78, 0xC1, 0x83, 0x06, 0x0C, 0xD9, 0x36, 0x78,
  0xF1, 0xA3, 0x66, 0x4C, 0xD8, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF9, 0xDD,
  0xEF, 0x18, 0xE3, 0x1C, 0x63, 0x8C, 0x71, 0x8E, 0x31, 0xC6, 0x38, 0xC4,
  0xFD, 0xDB, 0x16, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8C, 0x38, 0xDB, 0x1C,
  0x18, 0x30, 0x60, 0xE3, 0x6C, 0x70, 0xFD, 0xDB, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xED, 0xFB, 0x06, 0x0C, 0x18, 0x00, 0x7F, 0xDF, 0x1C, 0x38, 0x70,
  0xE1, 0xE3, 0xEE, 0xFC, 0x18, 0x30, 0x60, 0xC0, 0xFF, 0xCC, 0xCC, 0xCC,
  0xCC, 0x7B, 0x3C, 0x70, 0x70, 0x70, 0xF1, 0xCD, 0xE0, 0x21, 0x3E, 0x42,
  0x10, 0x84, 0x21, 0x0C, 0x70, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xEE, 0xFC, 0x42, 0x8D, 0x9B, 0x22, 0x45, 0x8E, 0x0C, 0x18, 0x30, 0x46,
  0x28, 0xCD, 0x99, 0xB7, 0x26, 0xB4, 0x52, 0x8A, 0x71, 0xCC, 0x31, 0x82,
  0x10, 0x66, 0xCC, 0xB1, 0xE1, 0x83, 0x0F, 0x12, 0x66, 0x8C, 0xC6, 0x8D,
  0x93, 0x22, 0xC5, 0x8E, 0x1C, 0x18, 0x30, 0x40, 0x83, 0x0C, 0x00, 0xFC,
  0x30, 0x86, 0x30, 0x86, 0x10, 0xC3, 0xF0, 0x12, 0x66, 0x66, 0x6C, 0xC4,
  0x66, 0x66, 0x62, 0x10, 0xFF, 0xFE, 0x43, 0x08, 0x42, 0x10, 0x86, 0x19,
  0x88, 0x42, 0x10, 0x8C, 0x40, 0x71, 0xAC, 0xB3, 0xD0, 0xC0,
};

const GFXglyph RobotoCondensed_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 4, 4, 6, 1, -14 },
  { 7, 8, 13, 10, 1, -13 },
  { 20, 7, 17, 9, 1, -15 },
  { 35, 10, 13, 11, 1, -13 },
  { 52, 9, 13, 10, 1, -13 },
  { 67, 1, 4, 3, 1, -14 },
  { 68, 4, 18, 6, 1, -14 },
  { 77, 5, 18, 6, 0, -14 },
  { 89, 8, 7, 8, 0, -13 },
  { 96, 7, 10, 9, 1, -11 },
  { 105, 3, 4, 4, 0, -2 },
  { 107, 4, 1, 4, 0, -6 },
  { 108, 2, 2, 5, 1, -2 },
  { 109, 6, 14, 7, 0, -13 },
  { 120, 7, 13, 9, 1, -13 },
  { 132, 5, 13, 9, 1, -13 },
  { 141, 7, 13, 9, 1, -13 },
  { 153, 7, 13, 9, 1, -13 },
  { 165, 7, 13, 9, 1, -13 },
  { 177, 7, 13, 9, 1, -13 },
  { 189, 7, 13, 9, 1, -13 },
  { 201, 7, 13, 9, 1, -13 },
  { 213, 7, 13, 9, 1, -13 },
  { 225, 7, 13, 9, 1, -13 },
  { 237, 2, 10, 4, 1, -10 },
  { 240, 3, 12, 4, 0, -10 },
  { 245, 6, 8, 8, 1, -10 },
  { 251, 6, 4, 9, 1, -8 },
  { 254, 7, 8, 8, 1, -10 },
  { 261, 6, 13, 8, 1, -13 },
  { 271, 12, 17, 14, 1, -13 },
  { 297, 10, 13, 10, 0, -13 },
  { 314, 8, 13, 10, 1, -13 },
  { 327, 8, 13, 10, 1, -13 },
  { 340, 8, 13, 10, 1, -13 },
  { 353, 7, 13, 9, 1, -13 },
  { 365, 7, 13, 9, 1, -13 },
  { 377, 8, 13, 11, 1, -13 },
  { 390, 9, 13, 11, 1, -13 },
  { 405, 2, 13, 5, 1, -13 },
  { 409, 6, 13, 9, 1, -13 },
  { 419, 9, 13, 10, 1, -13 },
  { 434, 7, 13, 9, 1, -13 },
  { 446, 11, 13, 14, 1, -13 },
  { 464, 9, 13, 11, 1, -13 },
  { 479, 9, 13, 11, 1, -13 },
  { 494, 8, 13, 10, 1, -13 },
  { 507, 9, 15, 11, 1, -13 },
  { 524, 8, 13, 10, 1, -13 },
  { 537, 8, 13, 9, 1, -13 },
  { 550, 8, 13, 9, 1, -13 },
  { 563, 8, 13, 10, 1, -13 },
  { 576, 10, 13, 10, 0, -13 },
  { 593, 12, 13, 14, 1, -13 },
  { 613, 8, 13, 10, 1, -13 },
  { 626, 9, 13, 9, 0, -13 },
  { 641, 8, 13, 9, 1, -13 },
  { 654, 3, 18, 5, 1, -15 },
  { 661, 6, 14, 7, 0, -13 },
  { 672, 3, 18, 5, 0, -15 },
  { 679, 5, 6, 7, 1, -13 },
  { 683, 7, 1, 7, 0, 0 },
  { 684, 4, 3, 6, 0, -14 },
  { 686, 7, 10, 9, 1, -10 },
  { 695, 7, 14, 9, 1, -14 },
  { 708, 7, 10, 8, 1, -10 },
  { 717, 7, 14, 9, 1, -14 },
  { 730, 7, 10, 8, 1, -10 },
  { 739, 5, 14, 6, 1, -14 },
  { 748, 7, 14, 9, 1, -10 },
  { 761, 7, 14, 9, 1, -14 },
  { 774, 2, 14, 4, 1, -14 },
  { 778, 3, 18, 4, 0, -14 },
  { 785, 7, 14, 8, 1, -14 },
  { 798, 2, 14, 4, 1, -14 },
  { 802, 11, 10, 14, 1, -10 },
  { 816, 7, 10, 9, 1, -10 },
  { 825, 7, 10, 9, 1, -10 },
  { 834, 7, 14, 9, 1, -10 },
  { 847, 7, 14, 9, 1, -10 },
  { 860, 4, 10, 5, 1, -10 },
  { 865, 6, 10, 8, 1, -10 },
  { 873, 5, 12, 5, 0, -12 },
  { 881, 7, 10, 9, 1, -10 },
  { 890, 7, 10, 8, 0, -10 },
  { 899, 11, 10, 12, 0, -10 },
  { 913, 7, 10, 8, 0, -10 },
  { 922, 7, 14, 8, 0, -10 },
  { 935, 6, 10, 8, 1, -10 },
  { 943, 4, 17, 6, 1, -14 },
  { 952, 1, 15, 4, 2, -13 },
  { 954, 5, 17, 6, 0, -14 },
  { 965, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_Regular18pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular18pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular18pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOCONDENSED_REGULAR18PT7B_H_
