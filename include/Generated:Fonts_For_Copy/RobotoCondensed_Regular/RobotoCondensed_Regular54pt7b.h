#ifndef _ROBOTOCONDENSED_REGULAR54PT7B_H_
#define _ROBOTOCONDENSED_REGULAR54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xBC, 0x80, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x78,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x7E,
  0x0F, 0xC3, 0xE0, 0x3E, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x00, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7E, 0x07, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x87,
  0x00, 0x00, 0x78, 0x3C, 0x06, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC1, 0xE0, 0x38, 0x0E, 0x0E, 0x01,
  0xC0, 0x70, 0xF0, 0x0E, 0x03, 0x87, 0x00, 0x78, 0x3C, 0x78, 0x01, 0xE1,
  0xC3, 0x80, 0x0F, 0xFE, 0x38, 0x00, 0x3F, 0xE3, 0xC0, 0x00, 0xFE, 0x1C,
  0x00, 0x00, 0x81, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x7F, 0x00, 0x03, 0x8F, 0xFC, 0x00,
  0x3C, 0x7F, 0xE0, 0x01, 0xC7, 0x87, 0x80, 0x1E, 0x38, 0x1C, 0x00, 0xE3,
  0xC0, 0xF0, 0x0F, 0x1E, 0x07, 0x80, 0x70, 0xF0, 0x3C, 0x07, 0x87, 0x81,
  0xE0, 0x78, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC1,
  0xC0, 0x38, 0x1C, 0x02, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x00,
  0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x03, 0xC3, 0xE7, 0xC0, 0xF1,
  0xF0, 0xF8, 0x3C, 0x7C, 0x3F, 0x1F, 0x3E, 0x07, 0xC7, 0xCF, 0x80, 0xF9,
  0xE3, 0xE0, 0x3F, 0x78, 0xF0, 0x07, 0xFE, 0x3C, 0x00, 0xFF, 0x8F, 0x80,
  0x3F, 0xC3, 0xE0, 0x07, 0xF0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x7F, 0x07,
  0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0x03, 0xFF, 0xE7,
  0xE0, 0x7F, 0xE0, 0xFC, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE,
  0xEE, 0xE0, 0x00, 0x10, 0x01, 0x80, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x40, 0x40, 0x03, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x01,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x07, 0x81, 0x3E, 0x1E, 0x1E,
  0xFF, 0x73, 0xFB, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0x8F,
  0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xF8, 0x0E, 0x03, 0x80,
  0x10, 0x04, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9E, 0x7C, 0xFB, 0xE7, 0x82, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x3C, 0x7C, 0x01, 0xF3, 0xC0,
  0x0F, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7B,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3D, 0xF0, 0x01,
  0xEF, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x18, 0x03, 0xC0,
  0xFE, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x1F, 0xE0, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x10,
  0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC7, 0xE0, 0x7C, 0x7C, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3E, 0x7E, 0x07, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0,
  0x03, 0xCF, 0x80, 0x07, 0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3C,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xCF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xF1, 0xFC, 0x7C, 0x07, 0xE1, 0x80, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x3F, 0x01,
  0xE7, 0xFE, 0x0F, 0x7F, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x3F, 0x1F, 0xC0,
  0xFC, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF0, 0xF8, 0x1F, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x3C,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0xC0,
  0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x0F, 0xC0,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x83,
  0xE0, 0xF8, 0x0F, 0x8F, 0x80, 0x3C, 0x78, 0x01, 0xF7, 0xC0, 0x07, 0xBE,
  0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xDF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0xF8, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xE0, 0xFC, 0x7C, 0x07, 0xC7, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80,
  0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7,
  0xC0, 0x3F, 0x7E, 0x07, 0xF3, 0xF1, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF,
  0x0F, 0xF9, 0xF0, 0x3F, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0xFB, 0xEF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFE, 0x20,
  0x1E, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x78, 0x70, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x00, 0x40,
  0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFC, 0x1F,
  0x9F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xDF, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFD, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0x1C, 0x1C, 0x00, 0x7C, 0x01, 0xC3, 0xC0, 0x1F, 0xF0, 0x0E,
  0x38, 0x03, 0xFF, 0x80, 0xE3, 0x80, 0x7E, 0xFC, 0x0E, 0x78, 0x07, 0x83,
  0xC0, 0xE7, 0x80, 0xF0, 0x3C, 0x0F, 0x70, 0x0F, 0x03, 0x80, 0xF7, 0x01,
  0xE0, 0x38, 0x07, 0xF0, 0x1E, 0x03, 0x80, 0x7F, 0x01, 0xC0, 0x38, 0x07,
  0xF0, 0x3C, 0x07, 0x80, 0x7F, 0x03, 0xC0, 0x78, 0x07, 0xF0, 0x3C, 0x07,
  0x80, 0x7F, 0x03, 0xC0, 0x78, 0x07, 0xF0, 0x3C, 0x07, 0x80, 0x7F, 0x03,
  0xC0, 0x78, 0x0F, 0xF0, 0x38, 0x07, 0x80, 0xEF, 0x03, 0xC0, 0x78, 0x0E,
  0xF0, 0x3C, 0x07, 0x80, 0xEF, 0x03, 0xC0, 0xF8, 0x1E, 0xF0, 0x3C, 0x0F,
  0x81, 0xC7, 0x03, 0xE1, 0xF8, 0x3C, 0x70, 0x3F, 0x7F, 0x87, 0x87, 0x81,
  0xFF, 0x3F, 0xF8, 0x78, 0x1F, 0xF3, 0xFF, 0x07, 0x80, 0x7E, 0x1F, 0xC0,
  0x3C, 0x01, 0x00, 0x20, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x18, 0x00,
  0x01, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7C,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF8,
  0x07, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x01, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0xF8, 0x03, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFB, 0xE0, 0x0F, 0xEF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFE, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xEF, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x81, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0x80, 0xFF, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x01,
  0xF9, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFC,
  0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xF0, 0x0F, 0xE1, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x0C, 0x00,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xE7, 0xE0, 0x7E,
  0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x40,
  0x00, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x1F, 0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0x81, 0xF0,
  0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F,
  0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01,
  0xF3, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFB, 0xF0, 0x03, 0xF8, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x07, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x9F, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x78, 0x00, 0x3D,
  0xFF, 0xBC, 0x00, 0x3E, 0xFF, 0xDF, 0x00, 0x1F, 0x7F, 0xE7, 0x80, 0x0F,
  0x3F, 0xF3, 0xC0, 0x0F, 0x9F, 0xF9, 0xF0, 0x07, 0xCF, 0xFC, 0x78, 0x03,
  0xC7, 0xFE, 0x3C, 0x03, 0xE3, 0xFF, 0x1F, 0x01, 0xF1, 0xFF, 0x87, 0x80,
  0xF0, 0xFF, 0xC3, 0xC0, 0xF8, 0x7F, 0xE1, 0xF0, 0x7C, 0x3F, 0xF0, 0x78,
  0x3C, 0x1F, 0xF8, 0x3C, 0x3E, 0x0F, 0xFC, 0x1F, 0x1E, 0x07, 0xFE, 0x07,
  0x8F, 0x03, 0xFF, 0x03, 0xC7, 0x81, 0xFF, 0x81, 0xF7, 0x80, 0xFF, 0xC0,
  0x7B, 0xC0, 0x7F, 0xE0, 0x3D, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8,
  0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x03, 0xFF,
  0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1E, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0xF8, 0x03, 0xFF, 0x7C,
  0x01, 0xFF, 0x9F, 0x00, 0xFF, 0xC7, 0x80, 0x7F, 0xE3, 0xE0, 0x3F, 0xF0,
  0xF0, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x1E, 0x07, 0xFE, 0x0F, 0x83, 0xFF,
  0x03, 0xC1, 0xFF, 0x81, 0xF0, 0xFF, 0xC0, 0x78, 0x7F, 0xE0, 0x3E, 0x3F,
  0xF0, 0x0F, 0x1F, 0xF8, 0x07, 0xCF, 0xFC, 0x01, 0xE7, 0xFE, 0x00, 0xFB,
  0xFF, 0x00, 0x3D, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x00,
  0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0x81, 0xF0, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x79, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFC,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7E, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0,
  0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x21,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7E,
  0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFC, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xE0, 0x03,
  0xE0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1F, 0x07,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7F, 0xE0, 0x01, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0x80, 0x0F, 0x9E,
  0x00, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0x00, 0xF9, 0xF0, 0x03, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0xC0, 0x0F, 0x1F, 0x00, 0x7F, 0x80, 0x3C, 0x3C,
  0x01, 0xFE, 0x01, 0xF0, 0xF0, 0x07, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0xE0,
  0x1F, 0x0F, 0x80, 0xF3, 0x80, 0x78, 0x3E, 0x03, 0xCF, 0x01, 0xE0, 0x78,
  0x0F, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0xF0, 0x3E, 0x07, 0xC1, 0xE1, 0xC0,
  0xF8, 0x1F, 0x07, 0x87, 0x83, 0xC0, 0x7C, 0x1E, 0x1E, 0x0F, 0x00, 0xF0,
  0x78, 0x78, 0x3C, 0x03, 0xC3, 0xC1, 0xE1, 0xF0, 0x0F, 0x0F, 0x03, 0xC7,
  0xC0, 0x3E, 0x3C, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x3C, 0x78, 0x01, 0xE7,
  0x80, 0xF1, 0xE0, 0x07, 0x9E, 0x01, 0xCF, 0x80, 0x1E, 0x78, 0x07, 0xBE,
  0x00, 0x7D, 0xE0, 0x1E, 0xF0, 0x01, 0xF7, 0x00, 0x7B, 0xC0, 0x03, 0xFC,
  0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x03, 0xBC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0xDF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F,
  0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F,
  0xC3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xF9,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x03,
  0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xE3, 0xFE, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x07, 0xE7, 0xC0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xDE, 0x3F, 0xF9,
  0xF0, 0xFF, 0x1F, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x8F, 0xF0, 0x7D, 0xFF, 0xE3, 0xEF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0x03, 0xF7, 0xE0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xF0, 0x3F, 0x7F, 0xFF, 0xF3, 0xEF, 0xFF,
  0x1F, 0x7F, 0xF8, 0xF8, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0x7E,
  0x7C, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xE7,
  0xE0, 0x3E, 0x3F, 0xDF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x3F,
  0xCF, 0x87, 0xFF, 0x7C, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x03, 0xF9,
  0xF0, 0x0F, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBC, 0x00,
  0x7D, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x03,
  0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x7C,
  0x03, 0xF3, 0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFD, 0xE1, 0xFF, 0xCF,
  0x03, 0xFC, 0x78, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xE0, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7,
  0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x04, 0x7C, 0x00, 0xE7, 0xE0, 0x1E, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F,
  0x1F, 0xFC, 0xF3, 0xFF, 0xEF, 0x3F, 0xFF, 0xF7, 0xE0, 0x7F, 0x7C, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x7F,
  0x3F, 0xFF, 0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0x7F, 0x8F, 0x00, 0xC1,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x10, 0x01, 0xF3, 0x80,
  0x3E, 0x3E, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0xFF, 0x0F, 0x9F,
  0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x07, 0xEF, 0xE0, 0x3E, 0xFC,
  0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x27, 0xBF, 0xFF,
  0xB8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x03,
  0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0xF8, 0x7C, 0x7F, 0xFF, 0xFF, 0x7F, 0x3F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x07, 0xCF, 0x00, 0xFC, 0xF0, 0x1F, 0x8F, 0x01, 0xF0,
  0xF0, 0x3E, 0x0F, 0x07, 0xE0, 0xF0, 0xFC, 0x0F, 0x0F, 0x80, 0xF1, 0xF0,
  0x0F, 0x3F, 0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF0, 0x0F, 0x8F, 0x80, 0xF0,
  0xF8, 0x0F, 0x07, 0xC0, 0xF0, 0x7E, 0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F,
  0x01, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x3E,
  0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFF, 0x03,
  0xFC, 0x3D, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0xFB,
  0xFF, 0xF7, 0xE0, 0x7F, 0xC0, 0xFB, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x07, 0xFC, 0x00,
  0xF8, 0x03, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0xFF, 0x80,
  0x1F, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x3F, 0xE0, 0x07, 0xC0, 0x1F, 0xF0,
  0x03, 0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x03, 0xFE,
  0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x7F,
  0xC0, 0x0F, 0x80, 0x3F, 0xE0, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xE0, 0x0F,
  0xF8, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x7C, 0x01,
  0xFF, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x8F, 0xF0, 0xF9, 0xFF, 0x8F, 0xBF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0, 0x7E,
  0xFE, 0x03, 0xEF, 0xC0, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x3C, 0x7C, 0x01, 0xF0, 0xF8, 0x0F, 0xC3,
  0xFD, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF8, 0x3E, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x7F, 0x03, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x3E, 0xFC, 0x01, 0xF7, 0xF0, 0x1F, 0xBF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x8F, 0xBF, 0xF8, 0x7C, 0x7F, 0x83, 0xE0, 0x40, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFE,
  0xF1, 0xFF, 0xFF, 0x9F, 0x81, 0xFC, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xEF, 0x81, 0xFE, 0x7C, 0x01, 0x83, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x2F, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x00,
  0x40, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8,
  0x1F, 0x9F, 0x01, 0xF3, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80,
  0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x10,
  0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x00, 0x80,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F,
  0x7E, 0x07, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xDF, 0x0F, 0xF9,
  0xF0, 0x08, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9F, 0x00, 0x7C, 0xF8,
  0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x00, 0xF0,
  0x78, 0x07, 0x83, 0xC0, 0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x01, 0xC0, 0x0F,
  0xBC, 0x01, 0xF0, 0x07, 0x9E, 0x00, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0x03,
  0xE7, 0xC0, 0x7F, 0x01, 0xF1, 0xE0, 0x3F, 0x80, 0xF0, 0xF0, 0x1F, 0xC0,
  0x78, 0x7C, 0x0F, 0xE0, 0x3C, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x07, 0xBC,
  0x1E, 0x07, 0x83, 0xDE, 0x0F, 0x03, 0xC1, 0xEF, 0x07, 0x81, 0xF1, 0xE3,
  0xC7, 0xC0, 0x78, 0xF1, 0xE3, 0xC0, 0x3C, 0x78, 0xF1, 0xE0, 0x1E, 0x3C,
  0x78, 0xF0, 0x0F, 0xBC, 0x1E, 0x78, 0x03, 0xDE, 0x0F, 0x7C, 0x01, 0xEF,
  0x07, 0xBC, 0x00, 0xFF, 0x83, 0xDE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xFB, 0xF0,
  0x0F, 0x8F, 0x80, 0xFC, 0x7E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x83, 0xE0,
  0x3E, 0x1F, 0x00, 0xF1, 0xF0, 0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xBE,
  0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x0F,
  0x80, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1E, 0x7C,
  0x03, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC1,
  0xE0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF8,
  0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xDE,
  0x00, 0x3D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x01, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x07, 0x00, 0x10,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xF1, 0xFF, 0x80, 0x38, 0xFF,
  0xF0, 0x1E, 0x7E, 0x7E, 0x07, 0x9E, 0x0F, 0xC3, 0xE7, 0x81, 0xF9, 0xF1,
  0xE0, 0x3F, 0xFC, 0xF0, 0x07, 0xFE, 0x3C, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x80,
};

const GFXglyph RobotoCondensed_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 39, 13, 4, -38 },
  { 26, 10, 13, 17, 4, -41 },
  { 43, 25, 38, 30, 3, -38 },
  { 162, 21, 51, 27, 3, -45 },
  { 296, 29, 40, 34, 3, -39 },
  { 441, 26, 40, 29, 3, -39 },
  { 571, 4, 13, 9, 3, -41 },
  { 578, 13, 55, 17, 3, -43 },
  { 668, 13, 55, 17, 1, -43 },
  { 758, 22, 22, 23, 1, -38 },
  { 819, 22, 28, 27, 2, -32 },
  { 896, 7, 13, 11, 1, -6 },
  { 908, 11, 4, 13, 1, -18 },
  { 914, 6, 6, 14, 4, -5 },
  { 919, 17, 41, 20, 1, -38 },
  { 1007, 21, 40, 27, 3, -39 },
  { 1112, 13, 38, 27, 4, -38 },
  { 1174, 23, 39, 27, 2, -39 },
  { 1287, 20, 40, 27, 3, -39 },
  { 1387, 23, 38, 27, 2, -38 },
  { 1497, 20, 39, 27, 4, -38 },
  { 1595, 21, 39, 27, 3, -38 },
  { 1698, 22, 38, 27, 2, -38 },
  { 1803, 21, 40, 27, 3, -39 },
  { 1908, 20, 39, 27, 3, -39 },
  { 2006, 6, 29, 13, 4, -28 },
  { 2028, 8, 35, 11, 1, -28 },
  { 2063, 18, 24, 24, 2, -29 },
  { 2117, 18, 14, 26, 4, -25 },
  { 2149, 19, 24, 25, 4, -29 },
  { 2206, 19, 40, 23, 2, -39 },
  { 2301, 36, 50, 42, 3, -38 },
  { 2526, 29, 38, 31, 1, -38 },
  { 2664, 22, 38, 29, 4, -38 },
  { 2769, 25, 40, 31, 3, -39 },
  { 2894, 23, 38, 31, 4, -38 },
  { 3004, 21, 38, 27, 4, -38 },
  { 3104, 20, 38, 26, 4, -38 },
  { 3199, 25, 40, 32, 3, -39 },
  { 3324, 25, 38, 33, 4, -38 },
  { 3443, 5, 38, 14, 4, -38 },
  { 3467, 20, 39, 26, 2, -38 },
  { 3565, 25, 38, 29, 4, -38 },
  { 3684, 20, 38, 26, 4, -38 },
  { 3779, 33, 38, 41, 4, -38 },
  { 3936, 25, 38, 33, 4, -38 },
  { 4055, 26, 40, 32, 3, -39 },
  { 4185, 24, 38, 30, 4, -38 },
  { 4299, 26, 45, 32, 3, -39 },
  { 4446, 24, 38, 29, 4, -38 },
  { 4560, 24, 40, 28, 2, -39 },
  { 4680, 25, 38, 28, 2, -38 },
  { 4799, 24, 39, 30, 3, -38 },
  { 4916, 28, 38, 30, 1, -38 },
  { 5049, 38, 38, 41, 2, -38 },
  { 5230, 26, 38, 30, 2, -38 },
  { 5354, 26, 38, 28, 1, -38 },
  { 5478, 24, 38, 28, 2, -38 },
  { 5592, 8, 52, 14, 4, -44 },
  { 5644, 18, 41, 20, 1, -38 },
  { 5737, 9, 52, 14, 1, -44 },
  { 5796, 16, 19, 20, 2, -38 },
  { 5834, 20, 4, 22, 1, 0 },
  { 5844, 12, 8, 17, 1, -41 },
  { 5856, 20, 31, 26, 3, -30 },
  { 5934, 21, 42, 27, 3, -41 },
  { 6045, 20, 31, 25, 3, -30 },
  { 6123, 21, 42, 27, 2, -41 },
  { 6234, 20, 31, 25, 3, -30 },
  { 6312, 15, 42, 17, 2, -42 },
  { 6391, 20, 41, 27, 3, -30 },
  { 6494, 20, 41, 26, 3, -41 },
  { 6597, 5, 40, 12, 4, -40 },
  { 6622, 9, 51, 12, -1, -40 },
  { 6680, 20, 41, 24, 4, -41 },
  { 6783, 5, 41, 12, 4, -41 },
  { 6809, 33, 30, 41, 4, -30 },
  { 6933, 20, 30, 26, 3, -30 },
  { 7008, 22, 31, 27, 3, -30 },
  { 7094, 21, 41, 27, 3, -30 },
  { 7202, 21, 41, 27, 2, -30 },
  { 7310, 12, 30, 16, 3, -30 },
  { 7355, 19, 31, 25, 3, -30 },
  { 7429, 13, 36, 16, 1, -35 },
  { 7488, 20, 30, 26, 3, -29 },
  { 7563, 21, 29, 23, 1, -29 },
  { 7640, 33, 29, 35, 1, -29 },
  { 7760, 21, 29, 24, 1, -29 },
  { 7837, 20, 40, 22, 1, -29 },
  { 7937, 20, 29, 24, 2, -29 },
  { 8010, 13, 52, 17, 2, -42 },
  { 8095, 4, 45, 13, 5, -38 },
  { 8118, 14, 52, 17, 1, -42 },
  { 8209, 26, 11, 32, 3, -22 },
};

const GFXfont RobotoCondensed_Regular54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_REGULAR54PT7B_H_
