#ifndef _ROBOTOCONDENSED_REGULAR32PT7B_H_
#define _ROBOTOCONDENSED_REGULAR32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x6F,
  0x60, 0xCF, 0x9F, 0x3E, 0x6C, 0xD9, 0xB3, 0x66, 0x03, 0x18, 0x06, 0x30,
  0x1C, 0x60, 0x30, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x8C, 0x3F, 0xFF, 0x7F,
  0xFE, 0x18, 0x60, 0x31, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x3F, 0xFF,
  0x7F, 0xFE, 0x18, 0xE0, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x8C, 0x06,
  0x18, 0x0C, 0x70, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0xF8, 0x3F, 0xC7,
  0xFE, 0x70, 0xE6, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x07, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x3C, 0x00, 0x3F, 0x00, 0x31, 0x80, 0x18, 0xC1, 0x8C, 0x31, 0x86, 0x19,
  0xC3, 0x0C, 0xC1, 0x8E, 0xC0, 0xC6, 0x60, 0x3F, 0x60, 0x0F, 0x30, 0x00,
  0x30, 0x00, 0x19, 0xE0, 0x19, 0xF8, 0x0D, 0xCC, 0x0C, 0xC3, 0x06, 0x61,
  0x86, 0x30, 0xC7, 0x18, 0x63, 0x0C, 0x30, 0x07, 0x30, 0x01, 0xF8, 0x00,
  0x78, 0x0F, 0x00, 0x7F, 0x80, 0xF7, 0x03, 0x87, 0x07, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xF1, 0xCE, 0xF3, 0xB8, 0xE7, 0x70, 0xEE, 0xC1, 0xF9, 0x81, 0xF3, 0x81,
  0xC7, 0x03, 0xC7, 0x9F, 0x87, 0xFB, 0x87, 0xC7, 0x80, 0xFF, 0xFC, 0x02,
  0x0C, 0x38, 0x61, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x60, 0xC1, 0xC1,
  0x81, 0x83, 0x83, 0x02, 0x81, 0x83, 0x83, 0x83, 0x07, 0x06, 0x0C, 0x1C,
  0x38, 0x30, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x06, 0x1C, 0x38, 0x61, 0xC3, 0x0E, 0x38, 0x60, 0x80, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x07, 0x33, 0xBF, 0xFC, 0xFF, 0xC0, 0xF0, 0x0F, 0x80,
  0xEE, 0x07, 0x38, 0x70, 0xE1, 0x04, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x39,
  0xCE, 0x73, 0x39, 0x8C, 0xFF, 0xF0, 0xFF, 0x60, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x00, 0x1F, 0x03, 0xFC, 0x79, 0xE7,
  0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x67,
  0x0E, 0x7B, 0xE3, 0xFC, 0x1F, 0x00, 0x06, 0x3D, 0xFF, 0xFC, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x80, 0x0F, 0x80, 0x7F, 0x83, 0xCF, 0x1C, 0x1C, 0x70, 0x39,
  0x80, 0xEE, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0x03, 0xFC, 0x7B,
  0xEE, 0x0E, 0xE0, 0xEC, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x3C, 0x1F,
  0x81, 0xFC, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x7C, 0x07, 0xE0,
  0x6E, 0x0E, 0xFB, 0xE7, 0xFC, 0x1F, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0D, 0x80, 0x76, 0x03, 0x98, 0x0E, 0x60, 0x71,
  0x81, 0xC6, 0x0E, 0x18, 0x38, 0x61, 0xC1, 0x87, 0x06, 0x38, 0x18, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x77, 0x87, 0xFC, 0x7F, 0xE7, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03,
  0x00, 0x3E, 0x07, 0x60, 0x77, 0x07, 0x7D, 0xE3, 0xFC, 0x0F, 0x80, 0x03,
  0x80, 0xF8, 0x1F, 0x83, 0xC0, 0x78, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE7,
  0x8F, 0xFC, 0xFD, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x70, 0x77, 0x0E, 0x3D, 0xE1, 0xFC, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x1F, 0x03, 0xFC, 0x7B, 0xE7, 0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x06,
  0x70, 0xE7, 0xBC, 0x3F, 0x83, 0xFC, 0x70, 0xEE, 0x0E, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0x79, 0xE3, 0xFC, 0x1F, 0x00, 0x1F,
  0x03, 0xF8, 0x7B, 0xCE, 0x0E, 0xE0, 0xEE, 0x06, 0xC0, 0x6C, 0x07, 0xC0,
  0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0x7B, 0xF3, 0xF7, 0x1E, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x1F, 0x83, 0xF0, 0x3C, 0x00, 0xFF, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x60, 0x77, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x77, 0x77, 0x7E, 0xE4, 0x00, 0x20, 0x1C, 0x0F, 0x83, 0xE1,
  0xF0, 0xF8, 0x3C, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0E,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x38, 0x0F, 0x07, 0xE3, 0xF1, 0xF8, 0x7C, 0x0E, 0x01, 0x00, 0x00,
  0x1F, 0x07, 0xF9, 0xFF, 0x38, 0x7E, 0x0F, 0xC1, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0xF8, 0x03, 0xC0, 0xE0, 0x18, 0x01, 0x81, 0x80, 0x06, 0x1C, 0x00, 0x38,
  0xC0, 0x00, 0xCC, 0x0F, 0x06, 0x60, 0xFE, 0x1B, 0x0E, 0x30, 0xF0, 0x61,
  0x87, 0x87, 0x0C, 0x3C, 0x30, 0x61, 0xE1, 0x87, 0x0F, 0x0C, 0x38, 0x78,
  0xE1, 0x83, 0xC7, 0x0C, 0x1E, 0x38, 0x60, 0xB0, 0xC7, 0x0D, 0x87, 0x7C,
  0xEC, 0x3F, 0x7E, 0x30, 0xF1, 0xE1, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x81, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3B, 0x00, 0x1D, 0xC0, 0x0C, 0xE0, 0x0E, 0x30, 0x07, 0x1C, 0x03, 0x0E,
  0x03, 0x87, 0x01, 0xC1, 0x80, 0xC0, 0xE0, 0xE0, 0x70, 0x7F, 0xF8, 0x3F,
  0xFE, 0x38, 0x07, 0x1C, 0x01, 0x8E, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B,
  0x80, 0x0E, 0xFF, 0xC3, 0xFF, 0xCE, 0x1F, 0x38, 0x0E, 0xE0, 0x3B, 0x80,
  0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0x87, 0xCF, 0xFE, 0x3F, 0xFC, 0xE0,
  0x7B, 0x80, 0xEE, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xB8,
  0x0E, 0xE0, 0xF3, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFB,
  0xE3, 0xC1, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x07, 0xE0, 0x0F, 0xC0, 0x39, 0xC0, 0x73, 0xC1, 0xE3, 0xEF, 0x83, 0xFE,
  0x01, 0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x8E, 0x3F, 0x38, 0x1E, 0xE0, 0x3B,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xB8, 0x1E, 0xE3, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3F, 0xF9, 0xFF, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0xE0, 0xFB, 0xE3, 0xC1, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x0F, 0xFC, 0x1F, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x3B, 0xC0, 0xF3, 0xFF,
  0xC3, 0xFF, 0x01, 0xF8, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77,
  0x0F, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0xE0, 0x1D, 0xC0, 0x7B, 0x80, 0xE7,
  0x03, 0x8E, 0x0F, 0x1C, 0x3C, 0x38, 0x70, 0x71, 0xC0, 0xE7, 0x81, 0xDE,
  0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xB8, 0x1F, 0x70, 0x3C, 0x70, 0x70, 0xF0,
  0xE0, 0xE1, 0xC0, 0xE3, 0x81, 0xE7, 0x01, 0xCE, 0x03, 0xDC, 0x03, 0xB8,
  0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xEC, 0x03, 0xFE, 0xE0, 0x37, 0xEE, 0x07, 0x7E,
  0x60, 0x77, 0xE6, 0x06, 0x7E, 0x70, 0xE7, 0xE7, 0x0E, 0x7E, 0x30, 0xC7,
  0xE3, 0x9C, 0x7E, 0x39, 0xC7, 0xE1, 0x98, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0x60, 0x70, 0xF0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFB, 0x83,
  0xF7, 0x07, 0xE7, 0x0F, 0xCE, 0x1F, 0x8E, 0x3F, 0x0C, 0x7E, 0x1C, 0xFC,
  0x19, 0xF8, 0x3B, 0xF0, 0x37, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0x80, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xC0, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x73, 0xC0, 0xE3, 0xFF, 0x83, 0xFE,
  0x01, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xE3, 0x83, 0xE7, 0x01, 0xEE, 0x01,
  0xDC, 0x03, 0xB8, 0x03, 0x70, 0x07, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77,
  0x07, 0xCF, 0xFF, 0x1F, 0xFC, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x07,
  0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x73, 0xC1,
  0xE3, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x10, 0xFF, 0xC3, 0xFF, 0xCE, 0x1F, 0x38, 0x0E, 0xE0, 0x3B, 0x80,
  0x6E, 0x01, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xEE, 0x03, 0xB8, 0x7C, 0xFF,
  0xE3, 0xFF, 0x0E, 0x0E, 0x38, 0x38, 0xE0, 0xF3, 0x81, 0xCE, 0x07, 0x38,
  0x0E, 0xE0, 0x3B, 0x80, 0x7E, 0x01, 0xC0, 0x07, 0xC0, 0x7F, 0xC3, 0xEF,
  0x9E, 0x0E, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0xE0,
  0x1F, 0x80, 0x77, 0x01, 0xDE, 0x07, 0x3E, 0xF8, 0x7F, 0xC0, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x0E, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC,
  0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x18, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x0C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0xE0,
  0x38, 0x0D, 0xC0, 0x70, 0x39, 0x80, 0xE0, 0x73, 0x83, 0xC0, 0xE7, 0x07,
  0xC1, 0xCE, 0x0D, 0x83, 0x1C, 0x1B, 0x0E, 0x18, 0x76, 0x1C, 0x38, 0xEC,
  0x38, 0x71, 0x9C, 0x70, 0xE3, 0x18, 0xC1, 0xC6, 0x31, 0x81, 0x9C, 0x67,
  0x03, 0x30, 0xEE, 0x07, 0x60, 0xDC, 0x0E, 0xC1, 0xB8, 0x1F, 0x83, 0x60,
  0x1F, 0x06, 0xC0, 0x3C, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x38, 0x01, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x70, 0x1E, 0x38, 0x1C,
  0x38, 0x3C, 0x1C, 0x38, 0x1C, 0x78, 0x0E, 0x70, 0x0E, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x38, 0x3C, 0x38, 0x38, 0x1C, 0x78, 0x1C,
  0x70, 0x1E, 0xF0, 0x0E, 0x70, 0x07, 0x70, 0x0F, 0x38, 0x0E, 0x38, 0x0E,
  0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x07, 0x70,
  0x07, 0x70, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x7F, 0xE0, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00,
  0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07,
  0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0xFF,
  0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x0C,
  0x07, 0x01, 0xE0, 0x78, 0x3E, 0x0D, 0xC3, 0x31, 0xCE, 0x63, 0x98, 0x6E,
  0x1C, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x87, 0x0C, 0x1F, 0x83, 0xFC,
  0x7B, 0xEE, 0x0E, 0xE0, 0xE0, 0x0E, 0x00, 0xE1, 0xFE, 0x7F, 0xE7, 0x0E,
  0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xFF, 0xE7, 0xFE, 0x3E, 0x70, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0xFF,
  0xEF, 0xFE, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0xFE, 0xFF, 0xEE, 0x78, 0x1F,
  0x03, 0xFC, 0x7B, 0xEE, 0x0E, 0xE0, 0x6C, 0x07, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x07, 0xE0, 0x6E, 0x0E, 0x79, 0xE3, 0xFC, 0x1F,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE1, 0xE7, 0x3F, 0xF9, 0xFF, 0xDC, 0x1E, 0xE0, 0x76, 0x03, 0xB0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x01, 0xD8, 0x0E, 0xE0, 0x77, 0x07, 0x9F,
  0xFC, 0xFF, 0xE1, 0xE7, 0x1F, 0x83, 0xFC, 0x79, 0xEE, 0x0E, 0xE0, 0x6E,
  0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E,
  0x06, 0x78, 0xF3, 0xFE, 0x1F, 0x80, 0x07, 0x87, 0xC7, 0xA7, 0x83, 0x81,
  0xC0, 0xE1, 0xFE, 0xFF, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1E, 0x77, 0xFF,
  0x7F, 0xFE, 0x0F, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x0F, 0x7F, 0xF7, 0xFF, 0x1E, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x40, 0xE7, 0xBE, 0x7F, 0xC1, 0xF0, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x3C, 0xFF, 0xDF, 0xFF, 0xC3,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFD, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x39, 0xCE, 0x00, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0xFF, 0x70, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0xE1, 0xCE,
  0x3C, 0xE3, 0x8E, 0x70, 0xEE, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xF7, 0x0E,
  0x70, 0xE3, 0x8E, 0x38, 0xE1, 0xCE, 0x1E, 0xE0, 0xEE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x87, 0xCF, 0xFC, 0xFE,
  0xFF, 0xFD, 0xEE, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x06, 0x07, 0xE0, 0x60,
  0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06,
  0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0,
  0x60, 0x70, 0xE7, 0x9F, 0xFB, 0xFF, 0xF8, 0x7E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x60, 0x0F, 0xC0, 0x7F, 0x83, 0xCF, 0x1E, 0x0E, 0x70, 0x39, 0xC0,
  0x66, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x76, 0x01, 0xDC, 0x06, 0x70,
  0x39, 0xE0, 0xE3, 0xCF, 0x07, 0xF8, 0x0F, 0xC0, 0xEF, 0x8F, 0xFE, 0xFF,
  0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF9, 0xEF, 0xFC, 0xEF, 0x8E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x39, 0xFF, 0xCF,
  0x7E, 0xE0, 0xF7, 0x03, 0xB0, 0x1D, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xD8, 0x0E, 0xC0, 0x77, 0x03, 0xB8, 0x3C, 0xF3, 0xE7, 0xFF, 0x0F, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xEF,
  0xFF, 0xFF, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE0, 0x1F, 0x0F, 0xF1, 0xEF, 0x70, 0x7E, 0x0F, 0xC0, 0x3C, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x0F, 0xC1, 0xFE, 0xFB, 0xFE,
  0x1F, 0x00, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0x0F, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xDF, 0xFB, 0xFB, 0x1E, 0x60, 0xE0,
  0x7E, 0x06, 0xE0, 0xE6, 0x0E, 0x70, 0xE7, 0x0C, 0x31, 0xC3, 0x1C, 0x39,
  0x81, 0x98, 0x1B, 0x81, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x06,
  0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0x30, 0xF0, 0xE7, 0x1F,
  0x1C, 0xE3, 0x63, 0x9C, 0x6C, 0x61, 0x9D, 0x8C, 0x33, 0x3B, 0x87, 0x63,
  0x70, 0xFC, 0x6C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0x80, 0x70, 0x70, 0x0C, 0x0E, 0x00, 0xE0, 0x77, 0x0E, 0x70, 0xE3, 0x9C,
  0x39, 0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8,
  0x39, 0xC3, 0x9C, 0x70, 0xE7, 0x0E, 0xE0, 0x70, 0xE0, 0x7E, 0x0E, 0xE0,
  0xE6, 0x0E, 0x70, 0xC7, 0x1C, 0x71, 0xC3, 0x1C, 0x39, 0x83, 0xB8, 0x1B,
  0x81, 0xB0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0x07,
  0x0E, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x38,
  0x78, 0xF0, 0xF0, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x18, 0x1E, 0x0F, 0x0F, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x80, 0x3C, 0x06, 0xFE, 0x1D, 0xFE,
  0x3F, 0x1F, 0xEC, 0x1F, 0x80, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 7, 8, 10, 2, -24 },
  { 20, 15, 23, 18, 2, -23 },
  { 64, 12, 29, 16, 2, -26 },
  { 108, 17, 23, 20, 2, -23 },
  { 157, 15, 23, 17, 2, -23 },
  { 201, 2, 7, 6, 2, -24 },
  { 203, 7, 33, 10, 2, -26 },
  { 232, 7, 33, 10, 1, -26 },
  { 261, 13, 13, 14, 0, -23 },
  { 283, 13, 17, 16, 1, -19 },
  { 311, 5, 8, 6, 0, -3 },
  { 316, 6, 2, 8, 1, -10 },
  { 318, 4, 3, 8, 2, -3 },
  { 320, 11, 25, 12, 0, -23 },
  { 355, 12, 23, 16, 2, -23 },
  { 390, 7, 23, 16, 3, -23 },
  { 411, 14, 23, 16, 1, -23 },
  { 452, 12, 23, 16, 2, -23 },
  { 487, 14, 23, 16, 1, -23 },
  { 528, 12, 23, 16, 2, -23 },
  { 563, 12, 23, 16, 2, -23 },
  { 598, 13, 23, 16, 1, -23 },
  { 636, 12, 23, 16, 2, -23 },
  { 671, 12, 23, 16, 2, -23 },
  { 706, 4, 17, 7, 2, -17 },
  { 715, 4, 22, 6, 1, -17 },
  { 726, 11, 14, 14, 1, -17 },
  { 746, 11, 10, 15, 2, -16 },
  { 760, 11, 14, 15, 2, -17 },
  { 780, 11, 23, 14, 1, -23 },
  { 812, 21, 29, 25, 2, -22 },
  { 889, 17, 23, 18, 1, -23 },
  { 938, 14, 23, 17, 2, -23 },
  { 979, 15, 23, 18, 2, -23 },
  { 1023, 14, 23, 18, 2, -23 },
  { 1064, 13, 23, 16, 2, -23 },
  { 1102, 12, 23, 15, 2, -23 },
  { 1137, 15, 23, 19, 2, -23 },
  { 1181, 15, 23, 20, 2, -23 },
  { 1225, 2, 23, 8, 3, -23 },
  { 1231, 12, 23, 15, 1, -23 },
  { 1266, 15, 23, 17, 2, -23 },
  { 1310, 12, 23, 15, 2, -23 },
  { 1345, 20, 23, 24, 2, -23 },
  { 1403, 15, 23, 20, 2, -23 },
  { 1447, 15, 23, 19, 2, -23 },
  { 1491, 15, 23, 18, 2, -23 },
  { 1535, 15, 27, 19, 2, -23 },
  { 1586, 14, 23, 17, 2, -23 },
  { 1627, 14, 23, 17, 1, -23 },
  { 1668, 15, 23, 17, 1, -23 },
  { 1712, 14, 23, 18, 2, -23 },
  { 1753, 16, 23, 18, 1, -23 },
  { 1799, 23, 23, 24, 1, -23 },
  { 1866, 16, 23, 18, 1, -23 },
  { 1912, 16, 23, 17, 0, -23 },
  { 1958, 14, 23, 17, 1, -23 },
  { 1999, 5, 31, 8, 2, -26 },
  { 2019, 10, 25, 12, 1, -23 },
  { 2051, 6, 31, 8, 0, -26 },
  { 2075, 10, 11, 12, 1, -23 },
  { 2089, 13, 2, 13, 0, 0 },
  { 2093, 6, 5, 10, 1, -24 },
  { 2097, 12, 17, 15, 2, -17 },
  { 2123, 12, 24, 16, 2, -24 },
  { 2159, 12, 17, 15, 2, -17 },
  { 2185, 13, 24, 16, 1, -24 },
  { 2224, 12, 17, 15, 2, -17 },
  { 2250, 9, 24, 10, 1, -24 },
  { 2277, 12, 24, 16, 2, -17 },
  { 2313, 11, 24, 15, 2, -24 },
  { 2346, 3, 23, 7, 2, -23 },
  { 2355, 5, 30, 7, 0, -23 },
  { 2374, 12, 24, 14, 2, -24 },
  { 2410, 3, 24, 7, 2, -24 },
  { 2419, 20, 17, 24, 2, -17 },
  { 2462, 11, 17, 16, 2, -17 },
  { 2486, 14, 17, 16, 1, -17 },
  { 2516, 12, 24, 16, 2, -17 },
  { 2552, 13, 24, 16, 1, -17 },
  { 2591, 7, 17, 10, 2, -17 },
  { 2606, 11, 17, 15, 2, -17 },
  { 2630, 8, 21, 9, 0, -21 },
  { 2651, 11, 17, 15, 2, -17 },
  { 2675, 12, 17, 14, 1, -17 },
  { 2701, 19, 17, 21, 1, -17 },
  { 2742, 12, 17, 14, 1, -17 },
  { 2768, 12, 24, 13, 1, -17 },
  { 2804, 12, 17, 14, 1, -17 },
  { 2830, 8, 31, 10, 1, -25 },
  { 2861, 2, 27, 8, 3, -23 },
  { 2868, 8, 31, 10, 1, -25 },
  { 2899, 15, 6, 19, 2, -12 },
};

const GFXfont RobotoCondensed_Regular32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_REGULAR32PT7B_H_
