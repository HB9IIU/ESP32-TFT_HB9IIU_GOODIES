#ifndef _ROBOTOCONDENSED_REGULAR12PT7B_H_
#define _ROBOTOCONDENSED_REGULAR12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFC, 0x29, 0x7E, 0xA5, 0x2B, 0xEA, 0xA0, 0x26, 0x99,
  0x86, 0x19, 0x97, 0x40, 0xC2, 0xAB, 0x34, 0x20, 0xF5, 0x55, 0x1C, 0x64,
  0xA4, 0xC4, 0x56, 0x72, 0xE8, 0xE0, 0x5A, 0xAA, 0xA9, 0x40, 0x89, 0x12,
  0x49, 0x25, 0x28, 0x25, 0x5C, 0xA5, 0x00, 0x66, 0xF6, 0x66, 0x58, 0xE0,
  0x80, 0x11, 0x22, 0x24, 0x44, 0x48, 0x69, 0x99, 0x99, 0x99, 0x60, 0x3C,
  0x92, 0x49, 0x20, 0x69, 0x91, 0x22, 0x48, 0xF0, 0xE9, 0x11, 0x61, 0x19,
  0xE0, 0x18, 0x62, 0x8A, 0x49, 0x2F, 0xC2, 0x08, 0xF8, 0x8F, 0x11, 0x19,
  0x70, 0x6C, 0x8F, 0x99, 0x99, 0x60, 0xF8, 0x42, 0x21, 0x08, 0x84, 0x20,
  0x69, 0x99, 0x69, 0x99, 0xE0, 0x69, 0x99, 0x9F, 0x13, 0x60, 0x84, 0x40,
  0x16, 0x13, 0xC3, 0x10, 0xF0, 0x0F, 0x86, 0x16, 0x80, 0x72, 0x82, 0x21,
  0x10, 0x80, 0x20, 0x3C, 0x42, 0x82, 0x99, 0xA9, 0xA9, 0xA9, 0xB6, 0x80,
  0x40, 0x38, 0x10, 0x20, 0xA1, 0x42, 0x88, 0x9F, 0x22, 0xC6, 0xF4, 0xE3,
  0x2F, 0x46, 0x31, 0xF0, 0x74, 0x63, 0x08, 0x42, 0x31, 0x70, 0xF4, 0xE3,
  0x18, 0xC6, 0x33, 0xF0, 0xF4, 0x21, 0x0F, 0x42, 0x10, 0xF8, 0xF8, 0x88,
  0xF8, 0x88, 0x80, 0x74, 0x63, 0x09, 0xC6, 0x31, 0x70, 0x8E, 0x38, 0xE3,
  0xFE, 0x38, 0xE3, 0x8C, 0xFF, 0x80, 0x08, 0x42, 0x10, 0x84, 0x39, 0x70,
  0x8A, 0x4B, 0x28, 0xE2, 0x89, 0x26, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0,
  0x83, 0x8F, 0x1E, 0x3A, 0xB5, 0x6A, 0xC9, 0x92, 0x8F, 0x3C, 0xEB, 0xAE,
  0x79, 0xE3, 0x8C, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xF4, 0x63, 0x1F,
  0x42, 0x10, 0x80, 0x72, 0x28, 0xA2, 0x8A, 0x28, 0xA2, 0x70, 0x20, 0xF4,
  0x63, 0x1F, 0x4A, 0x53, 0x88, 0x39, 0x24, 0x50, 0x38, 0x34, 0x53, 0x38,
  0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x70, 0xC5, 0x14, 0x52, 0x28, 0xA2, 0x8C, 0x10, 0x48, 0xA4, 0xD3, 0x4A,
  0xA5, 0x52, 0xA8, 0xCC, 0x44, 0x22, 0x00, 0x45, 0x22, 0x8C, 0x10, 0xC2,
  0x92, 0x44, 0xC5, 0x24, 0x8A, 0x30, 0x41, 0x04, 0x10, 0xF8, 0x84, 0x42,
  0x23, 0x10, 0xF8, 0xEA, 0xAA, 0xAB, 0x84, 0x44, 0x22, 0x21, 0x11, 0xD5,
  0x55, 0x57, 0x26, 0x55, 0xF8, 0x48, 0xE9, 0x1F, 0x99, 0xF0, 0x88, 0xF9,
  0x99, 0x99, 0xF0, 0xE9, 0x88, 0x89, 0xE0, 0x11, 0xF9, 0x99, 0x99, 0xF0,
  0x69, 0x9F, 0x89, 0xF0, 0x34, 0xE4, 0x44, 0x44, 0x40, 0xF9, 0x99, 0x99,
  0xF1, 0xE0, 0x88, 0xF9, 0x99, 0x99, 0x90, 0xBF, 0x80, 0x45, 0x55, 0x5C,
  0x88, 0xBA, 0xCC, 0xAA, 0x90, 0xFF, 0x80, 0xEF, 0x26, 0x4C, 0x99, 0x32,
  0x64, 0x80, 0xF9, 0x99, 0x99, 0x90, 0x69, 0x99, 0x99, 0x60, 0xF9, 0x99,
  0x99, 0xF8, 0x80, 0xF9, 0x99, 0x99, 0xF1, 0x10, 0xEA, 0xA8, 0xE9, 0x86,
  0x19, 0xE0, 0x5D, 0x24, 0x93, 0x99, 0x99, 0x99, 0xF0, 0x8A, 0x94, 0xA5,
  0x10, 0x80, 0x92, 0xB5, 0x6A, 0xD6, 0xA4, 0x89, 0x00, 0x5A, 0x8C, 0x43,
  0x29, 0x20, 0x8A, 0x94, 0xA5, 0x10, 0x84, 0x40, 0xF2, 0x24, 0x48, 0xF0,
  0x25, 0x25, 0x92, 0x44, 0x80, 0xFF, 0xE0, 0x89, 0x24, 0x52, 0x4A, 0x00,
  0xED, 0xC0,
};

const GFXglyph RobotoCondensed_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -9 },
  { 4, 5, 9, 7, 1, -9 },
  { 10, 4, 11, 6, 1, -10 },
  { 16, 6, 9, 8, 1, -9 },
  { 23, 5, 9, 7, 1, -9 },
  { 29, 1, 3, 2, 1, -9 },
  { 30, 2, 13, 4, 1, -10 },
  { 34, 3, 13, 4, 0, -10 },
  { 39, 5, 5, 5, 0, -9 },
  { 43, 4, 6, 6, 1, -7 },
  { 46, 2, 3, 2, 0, -1 },
  { 47, 3, 1, 3, 0, -4 },
  { 48, 1, 1, 3, 1, -1 },
  { 49, 4, 10, 4, 0, -9 },
  { 54, 4, 9, 6, 1, -9 },
  { 59, 3, 9, 6, 1, -9 },
  { 63, 4, 9, 6, 1, -9 },
  { 68, 4, 9, 6, 1, -9 },
  { 73, 6, 9, 6, 0, -9 },
  { 80, 4, 9, 6, 1, -9 },
  { 85, 4, 9, 6, 1, -9 },
  { 90, 5, 9, 6, 0, -9 },
  { 96, 4, 9, 6, 1, -9 },
  { 101, 4, 9, 6, 1, -9 },
  { 106, 1, 6, 3, 1, -6 },
  { 107, 2, 8, 2, 0, -6 },
  { 109, 4, 5, 5, 0, -6 },
  { 112, 4, 4, 6, 1, -6 },
  { 114, 4, 5, 6, 1, -6 },
  { 117, 5, 9, 5, 0, -9 },
  { 123, 8, 11, 9, 1, -8 },
  { 134, 7, 9, 7, 0, -9 },
  { 142, 5, 9, 7, 1, -9 },
  { 148, 5, 9, 7, 1, -9 },
  { 154, 5, 9, 7, 1, -9 },
  { 160, 5, 9, 6, 1, -9 },
  { 166, 4, 9, 6, 1, -9 },
  { 171, 5, 9, 7, 1, -9 },
  { 177, 6, 9, 7, 1, -9 },
  { 184, 1, 9, 3, 1, -9 },
  { 186, 5, 9, 6, 0, -9 },
  { 192, 6, 9, 7, 1, -9 },
  { 199, 4, 9, 6, 1, -9 },
  { 204, 7, 9, 9, 1, -9 },
  { 212, 6, 9, 7, 1, -9 },
  { 219, 5, 9, 7, 1, -9 },
  { 225, 5, 9, 7, 1, -9 },
  { 231, 6, 10, 7, 1, -9 },
  { 239, 5, 9, 6, 1, -9 },
  { 245, 6, 9, 6, 0, -9 },
  { 252, 6, 9, 6, 0, -9 },
  { 259, 5, 9, 7, 1, -9 },
  { 265, 6, 9, 7, 0, -9 },
  { 272, 9, 9, 9, 0, -9 },
  { 283, 6, 9, 7, 0, -9 },
  { 290, 6, 9, 6, 0, -9 },
  { 297, 5, 9, 6, 1, -9 },
  { 303, 2, 12, 3, 1, -10 },
  { 306, 4, 10, 4, 0, -9 },
  { 311, 2, 12, 3, 0, -10 },
  { 314, 4, 4, 4, 0, -9 },
  { 316, 5, 1, 5, 0, 0 },
  { 317, 3, 2, 4, 0, -9 },
  { 318, 4, 7, 6, 1, -7 },
  { 322, 4, 9, 6, 1, -9 },
  { 327, 4, 7, 6, 1, -7 },
  { 331, 4, 9, 6, 1, -9 },
  { 336, 4, 7, 6, 1, -7 },
  { 340, 4, 9, 4, 0, -9 },
  { 345, 4, 9, 6, 1, -7 },
  { 350, 4, 9, 6, 1, -9 },
  { 355, 1, 9, 3, 1, -9 },
  { 357, 2, 11, 3, 0, -9 },
  { 360, 4, 9, 5, 1, -9 },
  { 365, 1, 9, 3, 1, -9 },
  { 367, 7, 7, 9, 1, -7 },
  { 374, 4, 7, 6, 1, -7 },
  { 378, 4, 7, 6, 1, -7 },
  { 382, 4, 9, 6, 1, -7 },
  { 387, 4, 9, 6, 1, -7 },
  { 392, 2, 7, 4, 1, -7 },
  { 394, 4, 7, 5, 1, -7 },
  { 398, 3, 8, 4, 0, -8 },
  { 401, 4, 7, 6, 1, -7 },
  { 405, 5, 7, 5, 0, -7 },
  { 410, 7, 7, 8, 0, -7 },
  { 417, 5, 7, 5, 0, -7 },
  { 422, 5, 9, 5, 0, -7 },
  { 428, 4, 7, 5, 1, -7 },
  { 432, 3, 11, 4, 0, -9 },
  { 437, 1, 11, 3, 1, -9 },
  { 439, 3, 11, 4, 0, -9 },
  { 444, 5, 2, 7, 1, -4 },
};

const GFXfont RobotoCondensed_Regular12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_REGULAR12PT7B_H_
