#ifndef _ROBOTOCONDENSED_REGULAR65PT7B_H_
#define _ROBOTOCONDENSED_REGULAR65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular65pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xF3,
  0x00, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01,
  0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x80, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xE0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x7F,
  0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0,
  0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xF7, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x1F, 0xF3, 0xFF, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x80, 0x1E, 0x03, 0xC0,
  0x18, 0x03, 0xC0, 0x78, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x07, 0xC1, 0xF0, 0x0F,
  0x80, 0xF8, 0x3C, 0x01, 0xF0, 0x1E, 0x0F, 0x00, 0x1E, 0x03, 0xC1, 0xE0,
  0x03, 0xC0, 0x78, 0x78, 0x00, 0x7C, 0x1F, 0x0F, 0x00, 0x07, 0xFF, 0xC3,
  0xC0, 0x00, 0x7F, 0xF0, 0x78, 0x00, 0x07, 0xFC, 0x1E, 0x00, 0x00, 0x7F,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x01, 0xE1, 0xFF, 0x80, 0x00, 0x7C,
  0x7F, 0xF8, 0x00, 0x0F, 0x0F, 0xFF, 0x80, 0x03, 0xE3, 0xE1, 0xF0, 0x00,
  0x78, 0x78, 0x1F, 0x00, 0x1F, 0x1F, 0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x3C,
  0x00, 0xF0, 0x78, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0,
  0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x7C, 0x03,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0x80,
  0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x7E, 0x07, 0xF0,
  0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x7C, 0x03, 0xF8, 0xF8, 0xFC, 0x01, 0xFD,
  0xF8, 0xFC, 0x00, 0xFD, 0xF0, 0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x7F,
  0xF0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0xF0, 0x3F, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFD,
  0xFC, 0x07, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xE0, 0x7E, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xC0, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x10, 0x40, 0x03, 0x80, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x80,
  0x04, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x01, 0x00, 0x78, 0x00, 0x70, 0x1E, 0x03, 0x9F, 0x87, 0x83, 0xEF,
  0xFD, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0x8F, 0xC7,
  0xC7, 0xE1, 0xE0, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0xC3, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x06, 0x00, 0x3C,
  0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE,
  0x3F, 0xF0, 0x7F, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xE0, 0xFC, 0x03, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x1F, 0x80,
  0x3F, 0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0x7E,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0x87, 0xFC, 0x7E, 0x01, 0xFE, 0x1C, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7F, 0x00, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x1F, 0x80, 0x3E, 0x7F, 0xF0, 0x1F, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xF3, 0xFE, 0x01, 0xF9, 0xFE, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0x7F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3,
  0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFE,
  0x1F, 0xE0, 0xFE, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x3E, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xF7,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01,
  0xFB, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x3F, 0x00,
  0x7F, 0x9F, 0xC0, 0x7F, 0xC7, 0xF0, 0x7F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFC, 0xF8, 0x0F, 0xFC, 0x7C, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x7E,
  0xFF, 0xFF, 0x7E, 0x7E, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x7E, 0xFF, 0xFF, 0x7E, 0x7E, 0x3C, 0x0F, 0x87, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0xFC,
  0x1E, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0x3F, 0xC7, 0xF0, 0x3F, 0xBF, 0x80, 0x7E, 0xFC,
  0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xC1,
  0xF0, 0x01, 0xFF, 0x80, 0x3C, 0x1E, 0x00, 0x3F, 0xFE, 0x01, 0xE1, 0xE0,
  0x07, 0xFF, 0xF0, 0x1E, 0x3E, 0x00, 0xFC, 0x3E, 0x01, 0xE3, 0xC0, 0x0F,
  0x81, 0xE0, 0x1E, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0xE3, 0xC0, 0x1E, 0x01,
  0xE0, 0x0E, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF7, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF7, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x78, 0x07, 0xC0, 0x3E, 0x00, 0xF7, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0x78,
  0x07, 0x80, 0x3E, 0x00, 0xF7, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0x78, 0x0F,
  0x80, 0x3E, 0x00, 0xF7, 0x80, 0xF8, 0x03, 0xC0, 0x0F, 0x78, 0x0F, 0x80,
  0x3C, 0x00, 0xE7, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x78, 0x0F, 0x80, 0x3C,
  0x01, 0xE7, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x78, 0x0F, 0x80, 0x7C, 0x01,
  0xE7, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x78, 0x0F, 0xC0, 0xFC, 0x03, 0xC7,
  0xC0, 0x7C, 0x0F, 0xC0, 0x78, 0x7C, 0x07, 0xE1, 0xFE, 0x07, 0x83, 0xC0,
  0x7F, 0xFF, 0xF1, 0xF0, 0x3C, 0x03, 0xFF, 0x9F, 0xFF, 0x03, 0xE0, 0x1F,
  0xF0, 0xFF, 0xE0, 0x3E, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x7F,
  0x80, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01,
  0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0x3F, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xE3, 0xF0, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x7F,
  0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7,
  0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x80,
  0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0, 0xFC, 0x00, 0x7F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF8, 0xFC, 0x01, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x0F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x1F,
  0xE1, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF1, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7E, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xDF,
  0x00, 0x00, 0x7D, 0xFF, 0xBE, 0x00, 0x00, 0xFB, 0xFF, 0x7E, 0x00, 0x03,
  0xF7, 0xFE, 0x7C, 0x00, 0x07, 0xCF, 0xFC, 0xF8, 0x00, 0x0F, 0x9F, 0xF9,
  0xF8, 0x00, 0x3F, 0x3F, 0xF1, 0xF0, 0x00, 0x7C, 0x7F, 0xF3, 0xE0, 0x00,
  0xF8, 0xFF, 0xE7, 0xE0, 0x03, 0xF1, 0xFF, 0xC7, 0xC0, 0x07, 0xC7, 0xFF,
  0x8F, 0x80, 0x0F, 0x8F, 0xFF, 0x1F, 0x80, 0x3F, 0x1F, 0xFE, 0x1F, 0x00,
  0x7C, 0x3F, 0xFC, 0x3E, 0x00, 0xF8, 0x7F, 0xF8, 0x7E, 0x03, 0xF0, 0xFF,
  0xF0, 0x7C, 0x07, 0xC1, 0xFF, 0xE0, 0xF8, 0x0F, 0x83, 0xFF, 0xC1, 0xF8,
  0x3F, 0x07, 0xFF, 0x81, 0xF0, 0x7C, 0x0F, 0xFF, 0x03, 0xE0, 0xF8, 0x1F,
  0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0xFC, 0x07, 0xC7, 0xC0, 0x7F, 0xF8, 0x0F,
  0x8F, 0x80, 0xFF, 0xF0, 0x1F, 0x9F, 0x01, 0xFF, 0xE0, 0x1F, 0x7C, 0x03,
  0xFF, 0xC0, 0x3E, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFD,
  0xF0, 0x00, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0xCF, 0x80, 0x0F, 0xFF, 0x3F,
  0x00, 0x3F, 0xFC, 0x7C, 0x00, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xC3, 0xF0,
  0x0F, 0xFF, 0x07, 0xC0, 0x3F, 0xFC, 0x1F, 0x80, 0xFF, 0xF0, 0x3E, 0x03,
  0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x01, 0xF0, 0x3F, 0xFC, 0x07, 0xE0, 0xFF,
  0xF0, 0x0F, 0x83, 0xFF, 0xC0, 0x3F, 0x0F, 0xFF, 0x00, 0x7C, 0x3F, 0xFC,
  0x01, 0xF8, 0xFF, 0xF0, 0x03, 0xE3, 0xFF, 0xC0, 0x0F, 0xCF, 0xFF, 0x00,
  0x1F, 0x3F, 0xFC, 0x00, 0x7E, 0xFF, 0xF0, 0x00, 0xFB, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x1F, 0xE3, 0xF0,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3E, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0xFC, 0x07,
  0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x07, 0xE3, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x0F,
  0xE1, 0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xE3, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xFC,
  0x1F, 0x00, 0x3E, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xF3, 0xE0, 0x0F, 0x81,
  0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x3E, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x78, 0x07, 0xE0, 0x3E, 0x01, 0xF1, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0x0F, 0xC0,
  0xF8, 0x3C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0, 0xF0, 0x3F, 0x00, 0x7C, 0x0F,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x07, 0xE1, 0xF0,
  0x3E, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x78, 0x7E, 0x00, 0x3E, 0x1E, 0x01,
  0xE1, 0xF8, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x3C, 0x7C, 0x00, 0x3F, 0x3C, 0x00, 0xF1,
  0xF0, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x7B, 0xE0,
  0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7D, 0xE0,
  0x07, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x83, 0xFC, 0x7F, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE0,
  0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFE, 0x03, 0xFE, 0x7F, 0x8F,
  0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0x7E, 0x1F, 0xFE, 0x7E, 0x0F, 0xFC,
  0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x7C, 0x01, 0xF8, 0xFF, 0xC0, 0xFC, 0xFF, 0xF8, 0x7E, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x1F, 0xF8, 0x3F, 0xCF, 0xF0, 0x07, 0xE7, 0xF0, 0x01,
  0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xE0, 0x0F, 0xCF, 0xFE, 0x1F,
  0xE7, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0xF1, 0xF1, 0xFF, 0xF0, 0xF8, 0x7F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xF0, 0x03, 0xF1,
  0xF8, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x7E, 0x07, 0xFE, 0x3F,
  0x07, 0xFF, 0xDF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFC, 0x3F,
  0xF3, 0xF8, 0x07, 0xFB, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0xC0, 0x0F,
  0xE7, 0xF0, 0x0F, 0xF3, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xBE, 0x0F, 0xFF, 0x9F, 0x03, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x87, 0xF0, 0x00, 0xE1, 0xFC, 0x00, 0xF8, 0x7F, 0x81, 0xFE,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x10, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0x87, 0xC1, 0xFF, 0xF3, 0xE1, 0xFF, 0xFD, 0xF1, 0xFF, 0xFE,
  0xF9, 0xFF, 0x0F, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x7E, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0x87, 0xFE, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0xC0, 0xFF, 0xC7, 0xE0, 0x0F,
  0x83, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x08, 0x00, 0x3F, 0x0E, 0x00, 0x3F, 0x87, 0xE0, 0x3F, 0x87,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xC0, 0x7E, 0x3F,
  0xF0, 0xFC, 0xFF, 0xF1, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F,
  0xEF, 0xF8, 0x0F, 0xDF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E,
  0x38, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x01, 0x80, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF7, 0xFE, 0xFF,
  0xDF, 0xF3, 0xFC, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xCF, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0xC7, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x7E, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFE, 0x1F, 0xFF, 0x0F, 0xFB, 0xFC, 0x03, 0xFF, 0x01, 0xFD, 0xFC, 0x01,
  0xFF, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x0F,
  0x01, 0xF8, 0xFF, 0xC3, 0xF3, 0xFF, 0xC7, 0xEF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xDF, 0xF8, 0x7F, 0xBF, 0xE0, 0x3F, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF8,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E,
  0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x07, 0xF8, 0x3F, 0xC0,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x3F, 0xF0, 0x3E,
  0x7F, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F, 0xF3,
  0xFC, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x07, 0xF7,
  0xF8, 0x07, 0xF3, 0xFE, 0x07, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7E, 0xFF, 0xFC, 0x3F, 0x1F, 0xF8, 0x1F, 0x83, 0xE0, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xC7, 0xC1, 0xFF, 0xF3, 0xE1, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF9, 0xFE, 0x07, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x03, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFE,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xEF, 0xC0, 0xFF, 0xE7,
  0xE0, 0x0F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF3, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3,
  0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7F, 0x00,
  0x7E, 0x3F, 0xC1, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF9, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3C, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x1F, 0xEF, 0xF1,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xDF, 0x1F, 0xFF, 0x3E, 0x0F, 0xFC,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xCF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF8, 0x00,
  0xFB, 0xF0, 0x03, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xE0, 0x07, 0xE7, 0xC0,
  0x0F, 0xE0, 0x0F, 0x8F, 0x80, 0x3F, 0xC0, 0x1F, 0x1F, 0x80, 0x7F, 0x80,
  0x3E, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x3E, 0x01, 0xFF, 0x01, 0xF0, 0x7C,
  0x07, 0xFE, 0x03, 0xE0, 0xFC, 0x0F, 0xFC, 0x07, 0xC1, 0xF8, 0x1F, 0xF8,
  0x0F, 0x81, 0xF0, 0x7C, 0xF8, 0x3E, 0x03, 0xE0, 0xF9, 0xF0, 0x7C, 0x07,
  0xC1, 0xF3, 0xE0, 0xF8, 0x0F, 0xC3, 0xC3, 0xC1, 0xF0, 0x0F, 0x8F, 0x87,
  0xC7, 0xE0, 0x1F, 0x1F, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x1F, 0x1F, 0x00,
  0x7E, 0x78, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x3E, 0x7C, 0x00, 0xFB, 0xE0,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x7B, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0x87, 0xE0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F,
  0x87, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF,
  0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F,
  0x83, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xF1, 0xFF, 0xE0, 0x03,
  0xCF, 0xFF, 0xC0, 0x0F, 0x3F, 0xFF, 0x80, 0x7D, 0xF8, 0xFF, 0x01, 0xF7,
  0xC0, 0xFE, 0x0F, 0x9F, 0x01, 0xFC, 0x7E, 0xF8, 0x03, 0xFF, 0xF3, 0xE0,
  0x07, 0xFF, 0xCF, 0x80, 0x0F, 0xFE, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0x00,
};

const GFXglyph RobotoCondensed_Regular65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 47, 16, 5, -46 },
  { 37, 13, 16, 21, 4, -49 },
  { 63, 30, 46, 36, 4, -46 },
  { 236, 25, 61, 32, 4, -54 },
  { 427, 35, 48, 41, 3, -47 },
  { 637, 32, 48, 35, 3, -47 },
  { 829, 5, 15, 11, 3, -49 },
  { 839, 15, 67, 20, 4, -52 },
  { 965, 14, 67, 21, 2, -52 },
  { 1083, 26, 27, 28, 1, -46 },
  { 1171, 26, 34, 32, 3, -38 },
  { 1282, 9, 16, 13, 1, -7 },
  { 1300, 13, 5, 16, 2, -22 },
  { 1309, 7, 7, 17, 5, -6 },
  { 1316, 21, 50, 24, 1, -46 },
  { 1448, 24, 48, 32, 4, -47 },
  { 1592, 15, 46, 32, 5, -46 },
  { 1679, 27, 47, 32, 3, -47 },
  { 1838, 25, 48, 32, 3, -47 },
  { 1988, 28, 46, 32, 2, -46 },
  { 2149, 24, 47, 32, 5, -46 },
  { 2290, 25, 47, 32, 4, -46 },
  { 2437, 26, 46, 32, 3, -46 },
  { 2587, 24, 48, 32, 4, -47 },
  { 2731, 25, 47, 32, 3, -47 },
  { 2878, 8, 35, 15, 4, -34 },
  { 2913, 10, 43, 13, 1, -34 },
  { 2967, 22, 29, 29, 2, -35 },
  { 3047, 22, 18, 31, 5, -31 },
  { 3097, 23, 29, 30, 4, -35 },
  { 3181, 22, 48, 27, 3, -47 },
  { 3313, 44, 59, 50, 3, -45 },
  { 3638, 35, 46, 37, 1, -46 },
  { 3840, 27, 46, 35, 5, -46 },
  { 3996, 30, 48, 37, 4, -47 },
  { 4176, 28, 46, 37, 5, -46 },
  { 4337, 25, 46, 32, 5, -46 },
  { 4481, 24, 46, 31, 5, -46 },
  { 4619, 30, 48, 38, 4, -47 },
  { 4799, 30, 46, 40, 5, -46 },
  { 4972, 6, 46, 16, 5, -46 },
  { 5007, 25, 47, 31, 2, -46 },
  { 5154, 30, 46, 35, 5, -46 },
  { 5327, 24, 46, 31, 5, -46 },
  { 5465, 39, 46, 49, 5, -46 },
  { 5690, 30, 46, 40, 5, -46 },
  { 5863, 31, 48, 39, 4, -47 },
  { 6049, 29, 46, 36, 5, -46 },
  { 6216, 31, 55, 39, 4, -47 },
  { 6430, 28, 46, 35, 5, -46 },
  { 6591, 28, 48, 34, 3, -47 },
  { 6759, 30, 46, 34, 2, -46 },
  { 6932, 29, 47, 37, 4, -46 },
  { 7103, 34, 46, 36, 1, -46 },
  { 7299, 46, 46, 50, 2, -46 },
  { 7564, 32, 46, 36, 2, -46 },
  { 7748, 32, 46, 34, 1, -46 },
  { 7932, 28, 46, 34, 3, -46 },
  { 8093, 11, 63, 16, 4, -53 },
  { 8180, 21, 50, 24, 2, -46 },
  { 8312, 11, 63, 16, 1, -53 },
  { 8399, 20, 23, 24, 2, -46 },
  { 8457, 25, 5, 26, 1, 0 },
  { 8473, 13, 9, 20, 2, -48 },
  { 8488, 24, 36, 31, 4, -35 },
  { 8596, 25, 50, 32, 4, -49 },
  { 8753, 25, 36, 30, 3, -35 },
  { 8866, 25, 50, 32, 3, -49 },
  { 9023, 25, 36, 30, 3, -35 },
  { 9136, 18, 50, 21, 2, -50 },
  { 9249, 25, 48, 32, 3, -35 },
  { 9399, 23, 49, 31, 4, -49 },
  { 9540, 7, 47, 15, 4, -47 },
  { 9582, 11, 60, 15, -1, -47 },
  { 9665, 25, 49, 29, 4, -49 },
  { 9819, 5, 49, 15, 5, -49 },
  { 9850, 41, 35, 49, 4, -35 },
  { 10030, 23, 35, 31, 4, -35 },
  { 10131, 27, 36, 33, 3, -35 },
  { 10253, 25, 48, 32, 4, -35 },
  { 10403, 25, 48, 33, 3, -35 },
  { 10553, 14, 35, 20, 4, -35 },
  { 10615, 24, 36, 30, 3, -35 },
  { 10723, 16, 44, 19, 1, -43 },
  { 10811, 23, 35, 31, 4, -34 },
  { 10912, 25, 34, 28, 1, -34 },
  { 11019, 39, 34, 42, 2, -34 },
  { 11185, 25, 34, 29, 2, -34 },
  { 11292, 25, 47, 27, 1, -34 },
  { 11439, 23, 34, 29, 3, -34 },
  { 11537, 17, 63, 20, 2, -51 },
  { 11671, 4, 55, 16, 6, -46 },
  { 11699, 17, 63, 20, 1, -51 },
  { 11833, 30, 13, 38, 4, -26 },
};

const GFXfont RobotoCondensed_Regular65pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular65pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular65pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _ROBOTOCONDENSED_REGULAR65PT7B_H_
