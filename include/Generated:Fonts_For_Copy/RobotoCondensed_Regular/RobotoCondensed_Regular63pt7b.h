#ifndef _ROBOTOCONDENSED_REGULAR63PT7B_H_
#define _ROBOTOCONDENSED_REGULAR63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular63pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0x00,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xBC, 0x1D, 0xE0, 0xEF, 0x07, 0x78, 0x3B, 0xC1,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0xF8,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x7C, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0,
  0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3,
  0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF,
  0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0xFC,
  0x7F, 0x01, 0xFC, 0x3F, 0xF7, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x07, 0x81, 0xF0, 0x0C, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0x80,
  0x3C, 0x03, 0xC3, 0xE0, 0x0F, 0x80, 0xF0, 0xF0, 0x01, 0xE0, 0x7C, 0x78,
  0x00, 0x7C, 0x1E, 0x1E, 0x00, 0x0F, 0x8F, 0x8F, 0x00, 0x03, 0xFF, 0xC3,
  0xC0, 0x00, 0x7F, 0xE1, 0xE0, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x08, 0x00, 0x00, 0x3C, 0x3F, 0xC0,
  0x00, 0x1E, 0x1F, 0xF8, 0x00, 0x07, 0x8F, 0xFF, 0x00, 0x03, 0xC3, 0xE3,
  0xE0, 0x00, 0xF1, 0xF0, 0x78, 0x00, 0x78, 0x78, 0x1F, 0x00, 0x3E, 0x1E,
  0x03, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x07, 0xC3, 0xC0, 0x3C, 0x01, 0xE0,
  0xF0, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0xC0,
  0x30, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x01,
  0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x03, 0xE0, 0x7E, 0x7E, 0x07, 0xC1, 0xF8, 0x7E,
  0x0F, 0x87, 0xE0, 0xFE, 0x1F, 0x0F, 0xC0, 0xFC, 0x3E, 0x1F, 0x00, 0xFC,
  0x7C, 0x7E, 0x01, 0xFC, 0xF8, 0xFC, 0x01, 0xFB, 0xF1, 0xF8, 0x01, 0xFF,
  0xC3, 0xF0, 0x03, 0xFF, 0x87, 0xE0, 0x03, 0xFF, 0x0F, 0xC0, 0x03, 0xFC,
  0x0F, 0x80, 0x07, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xE0,
  0x3F, 0x00, 0x7F, 0xE0, 0x7F, 0x83, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0x1F, 0xC0, 0x3F, 0xF8, 0x1F, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF,
  0x7B, 0xC0, 0x00, 0x08, 0x00, 0x60, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x08, 0x40, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0x40, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x80, 0x3C, 0x02, 0x78, 0x1E, 0x07, 0x3F, 0x8F, 0x1F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x00, 0x70, 0x01, 0x00, 0x10, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C,
  0x3E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xC7, 0xC1, 0xE0, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x7E, 0xFE, 0xFE, 0x7E,
  0x7E, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7E,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF0,
  0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xC3, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFC,
  0x3F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x3F, 0x80, 0x3E, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x00, 0xFE, 0x0E,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0xFE, 0x1F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0xFF, 0xC0, 0x7D,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFF,
  0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x1F, 0xE3, 0xF8, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x7E, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7C,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7F,
  0x00, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xC7, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F,
  0x83, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x03,
  0xFF, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE7, 0xFF, 0xFF, 0xFF, 0x7C, 0x20, 0x0F, 0x87, 0xE1, 0xFC,
  0x7F, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x87, 0xE3, 0xF0, 0x78, 0x04,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xF0, 0x3F, 0x9F, 0x80, 0x7E, 0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xF7,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xFF, 0x80, 0x3C, 0x1E, 0x00, 0x7F, 0xFC,
  0x03, 0x87, 0xC0, 0x1F, 0xFF, 0x80, 0x70, 0xF0, 0x03, 0xE0, 0xF0, 0x0F,
  0x1E, 0x00, 0xF8, 0x1E, 0x01, 0xE3, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0xF8,
  0x07, 0xC0, 0x78, 0x07, 0x9E, 0x00, 0xF0, 0x0F, 0x00, 0xF3, 0xC0, 0x3E,
  0x01, 0xE0, 0x0E, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xCF, 0x00, 0xF0, 0x07,
  0x80, 0x39, 0xE0, 0x3E, 0x01, 0xF0, 0x07, 0x3C, 0x07, 0xC0, 0x3E, 0x00,
  0xE7, 0x80, 0xF8, 0x07, 0xC0, 0x1C, 0xF0, 0x1E, 0x00, 0xF8, 0x03, 0xBE,
  0x03, 0xC0, 0x1E, 0x00, 0xF7, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0xF8, 0x0F,
  0x00, 0x78, 0x03, 0xCF, 0x01, 0xE0, 0x0F, 0x00, 0x79, 0xE0, 0x3C, 0x01,
  0xE0, 0x0F, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xC7, 0x80, 0xF8, 0x0F, 0x80,
  0x78, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x1E, 0x03, 0xE0, 0x7E, 0x03, 0xC3,
  0xC0, 0x7E, 0x1F, 0xE0, 0xF8, 0x7C, 0x07, 0xFF, 0xBC, 0x3E, 0x07, 0x80,
  0xFF, 0xE7, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0x00, 0xFE,
  0x07, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x80, 0x00, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80,
  0x01, 0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3E, 0x00,
  0x3F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xBE,
  0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xF8, 0x00, 0xFF, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x03,
  0xFB, 0xE0, 0x03, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0x80, 0x3F, 0x83, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x1F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0xC7, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xF0, 0x03, 0xFC, 0x3E, 0x00, 0x1F, 0xC7,
  0xC0, 0x01, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xEF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x7F, 0x3E, 0x00, 0x1F, 0xC7,
  0xC0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x04, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0xF8, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0xF1, 0xF0,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF8, 0x7C, 0x00, 0x3F, 0x83, 0xE0, 0x01,
  0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0xF8, 0x01, 0xFC, 0x07, 0xC0, 0x1F, 0xC0,
  0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0xFE, 0x00, 0x7C,
  0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0xF8, 0x7F,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF3, 0xF8, 0x00,
  0x0F, 0xBF, 0xC0, 0x00, 0x7D, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x3F, 0xC7,
  0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0xF8, 0x01, 0xF8, 0x07,
  0xC0, 0x0F, 0xE0, 0x3E, 0x00, 0x3F, 0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80,
  0x07, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFE, 0x1F, 0x00, 0x03,
  0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x01, 0xFD,
  0xF0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xF7, 0xFF, 0xF8,
  0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x1F, 0x7F, 0xEF, 0x80, 0x00, 0xF9,
  0xFF, 0xBF, 0x00, 0x03, 0xEF, 0xFE, 0x7C, 0x00, 0x0F, 0xBF, 0xF9, 0xF0,
  0x00, 0x7C, 0xFF, 0xE7, 0xE0, 0x01, 0xF3, 0xFF, 0x8F, 0x80, 0x07, 0xCF,
  0xFE, 0x3E, 0x00, 0x3E, 0x3F, 0xF8, 0xFC, 0x00, 0xF8, 0xFF, 0xE1, 0xF0,
  0x03, 0xE3, 0xFF, 0x87, 0xC0, 0x1F, 0x0F, 0xFE, 0x1F, 0x80, 0x7C, 0x3F,
  0xF8, 0x3E, 0x01, 0xF0, 0xFF, 0xE0, 0xF8, 0x0F, 0x83, 0xFF, 0x83, 0xF0,
  0x3E, 0x0F, 0xFE, 0x07, 0xC0, 0xF8, 0x3F, 0xF8, 0x1F, 0x07, 0xC0, 0xFF,
  0xE0, 0x7E, 0x1F, 0x03, 0xFF, 0x80, 0xF8, 0x7C, 0x0F, 0xFE, 0x03, 0xE3,
  0xE0, 0x3F, 0xF8, 0x0F, 0x8F, 0x80, 0xFF, 0xE0, 0x1F, 0x3E, 0x03, 0xFF,
  0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFE, 0xF8, 0x00, 0x3F, 0xF7, 0xC0, 0x01, 0xFF,
  0x9F, 0x00, 0x0F, 0xFC, 0xF8, 0x00, 0x7F, 0xE3, 0xE0, 0x03, 0xFF, 0x1F,
  0x80, 0x1F, 0xF8, 0x7C, 0x00, 0xFF, 0xC3, 0xF0, 0x07, 0xFE, 0x0F, 0x80,
  0x3F, 0xF0, 0x7E, 0x01, 0xFF, 0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0xC0, 0x7F,
  0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xC0,
  0x3F, 0x07, 0xFE, 0x00, 0xF8, 0x3F, 0xF0, 0x07, 0xE1, 0xFF, 0x80, 0x1F,
  0x0F, 0xFC, 0x00, 0xFC, 0x7F, 0xE0, 0x03, 0xE3, 0xFF, 0x00, 0x1F, 0x9F,
  0xF8, 0x00, 0x7C, 0xFF, 0xC0, 0x03, 0xF7, 0xFE, 0x00, 0x0F, 0xBF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x8F, 0x80, 0x07, 0xF8, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x1F, 0xCF, 0x80,
  0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x21, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE1, 0xF8, 0x01, 0xFE, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF1, 0xF8, 0x01, 0xFE,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xE3, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x1F,
  0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x01,
  0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0,
  0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xFC, 0x00,
  0x3E, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xFC, 0x00, 0x7E,
  0x3E, 0x00, 0x3F, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xFE, 0x00, 0x7C, 0x3F,
  0x00, 0x3D, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xDE, 0x00, 0x7C, 0x1F, 0x00,
  0x7D, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xDF, 0x00, 0xFC, 0x1F, 0x00, 0x79,
  0xF0, 0x0F, 0x81, 0xF8, 0x07, 0x8F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0x07, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x78, 0x1F, 0x00,
  0xFC, 0x1F, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x00, 0x7C,
  0x1E, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x3C, 0x3F, 0x00, 0x7C, 0x3E,
  0x03, 0xC3, 0xE0, 0x07, 0xE3, 0xE0, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x03,
  0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x1E, 0x3E, 0x00, 0x3E, 0x7C, 0x01, 0xE7,
  0xE0, 0x03, 0xE7, 0xC0, 0x1E, 0x7C, 0x00, 0x3E, 0x78, 0x01, 0xF7, 0xC0,
  0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x3E,
  0x78, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x1E, 0x07, 0x83, 0xE1, 0xF0,
  0x7C, 0x3E, 0x07, 0x87, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x3F, 0xF0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x08,
  0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xC3, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xE0, 0x7E, 0x3F, 0x80, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x01,
  0xFE, 0x7F, 0xDF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xBE, 0x0F, 0xFE,
  0x3F, 0x07, 0xFC, 0x3F, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x04,
  0x00, 0xFC, 0x7F, 0xC0, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC3, 0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF, 0x00,
  0xFE, 0xFF, 0xE3, 0xFC, 0xFB, 0xFF, 0xF8, 0xFB, 0xFF, 0xF8, 0xF9, 0xFF,
  0xF0, 0xF8, 0x7F, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC1,
  0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0xC1,
  0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xFE,
  0x1F, 0x07, 0xFF, 0x9F, 0x0F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE3,
  0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0xE3,
  0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF, 0x07, 0xFF, 0x9F, 0x03, 0xFE,
  0x1F, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x0C, 0x3F, 0x80, 0x3E, 0x3F, 0xE0, 0xFF, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xFF, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x1F, 0x07, 0xFF, 0x9F, 0x0F, 0xFF, 0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE3,
  0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F, 0xE3,
  0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xDF, 0x07, 0xFF, 0x9F, 0x03, 0xFE,
  0x1F, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x7E, 0x1C, 0x00, 0x7E, 0x1F, 0x01,
  0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x10, 0x0F, 0xC7, 0xFC, 0x3F, 0x3F, 0xF8,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0xBF, 0xC0, 0x7F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xC0, 0x11, 0xFF, 0xFF, 0xFD, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x1F, 0xBF, 0xF7, 0xFE, 0xFF, 0x9F, 0xE3, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0xFC, 0x00, 0xFD, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0x80, 0xFF, 0xC3,
  0xE7, 0xFF, 0x83, 0xFF, 0xC7, 0xDF, 0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xDF, 0xF8, 0xFF, 0xFC, 0x7F, 0xBF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00,
  0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xE0,
  0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xFC,
  0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x3E,
  0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x04, 0x03, 0xE1, 0xFF, 0x0F, 0x8F, 0xFE, 0x3E, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFF, 0x1F, 0xEF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFB, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF8, 0x7F, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0xF9, 0xFF,
  0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xC7, 0xFC, 0xFF, 0x00,
  0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xF0, 0xFC, 0x7F, 0xC0, 0xFC, 0x0C,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x1F, 0x07, 0xFF, 0x9F, 0x1F, 0xFF,
  0xDF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0x00, 0xFF, 0x7E, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xBF, 0x03, 0xFF, 0x3F, 0x00, 0x20, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xE3, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF,
  0x07, 0xF8, 0xFF, 0x0F, 0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x40, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7F,
  0xA0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x20, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF7, 0xC0, 0x0F,
  0xDF, 0x80, 0xFF, 0x7F, 0x9F, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xDF, 0x07, 0xFC, 0x7C, 0x03, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x03,
  0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xE3, 0xC0, 0x01,
  0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0x7F, 0xF8, 0x03, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xC0, 0x1F, 0x3E, 0x00,
  0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0xF0, 0x07, 0xCF, 0xC0, 0x7F, 0xC0, 0x7C,
  0x3E, 0x03, 0xFE, 0x03, 0xE1, 0xF0, 0x1F, 0xF0, 0x1F, 0x0F, 0x81, 0xF7,
  0x80, 0xF8, 0x7E, 0x0F, 0xBE, 0x0F, 0x81, 0xF0, 0x7D, 0xF0, 0x7C, 0x0F,
  0x83, 0xCF, 0x83, 0xE0, 0x7C, 0x3E, 0x3C, 0x1F, 0x03, 0xE1, 0xF1, 0xF0,
  0xF8, 0x0F, 0x8F, 0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x3C, 0x7C, 0x03, 0xE7,
  0xC1, 0xF3, 0xE0, 0x1F, 0x3E, 0x0F, 0x9F, 0x00, 0x7D, 0xE0, 0x7C, 0xF0,
  0x03, 0xFF, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xC7, 0xE0, 0x07,
  0xE7, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F,
  0x83, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xF8, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F,
  0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F,
  0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07,
  0xC3, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x03,
  0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x02, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x60, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x03, 0xC7, 0xFF, 0x00, 0x1E, 0x7F, 0xFE, 0x00,
  0xF7, 0xFF, 0xF8, 0x0F, 0xBF, 0x1F, 0xE0, 0x7D, 0xF0, 0x3F, 0x87, 0xDF,
  0x00, 0xFF, 0xFE, 0xF8, 0x03, 0xFF, 0xE7, 0xC0, 0x0F, 0xFE, 0x3E, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_Regular63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 46, 16, 5, -45 },
  { 36, 13, 15, 20, 4, -47 },
  { 61, 29, 45, 35, 4, -45 },
  { 225, 25, 60, 31, 3, -53 },
  { 413, 34, 47, 40, 3, -46 },
  { 613, 31, 47, 34, 3, -46 },
  { 796, 5, 15, 11, 3, -47 },
  { 806, 14, 65, 20, 4, -51 },
  { 920, 14, 65, 20, 2, -51 },
  { 1034, 25, 26, 27, 1, -45 },
  { 1116, 25, 32, 31, 3, -37 },
  { 1216, 9, 16, 12, 1, -7 },
  { 1234, 13, 5, 16, 1, -22 },
  { 1243, 8, 7, 17, 4, -6 },
  { 1250, 20, 49, 23, 1, -45 },
  { 1373, 24, 47, 31, 4, -46 },
  { 1514, 15, 45, 31, 5, -45 },
  { 1599, 26, 46, 31, 3, -46 },
  { 1749, 24, 47, 31, 3, -46 },
  { 1890, 27, 45, 31, 2, -45 },
  { 2042, 24, 46, 31, 4, -45 },
  { 2180, 24, 46, 31, 4, -45 },
  { 2318, 25, 45, 31, 3, -45 },
  { 2459, 24, 47, 31, 4, -46 },
  { 2600, 24, 46, 31, 3, -46 },
  { 2738, 7, 34, 15, 4, -33 },
  { 2768, 10, 42, 13, 1, -33 },
  { 2821, 21, 28, 28, 2, -34 },
  { 2895, 21, 18, 30, 5, -30 },
  { 2943, 22, 28, 29, 4, -34 },
  { 3020, 22, 47, 27, 2, -46 },
  { 3150, 43, 58, 48, 3, -44 },
  { 3462, 34, 45, 36, 1, -45 },
  { 3654, 26, 45, 34, 5, -45 },
  { 3801, 29, 47, 36, 4, -46 },
  { 3972, 27, 45, 36, 5, -45 },
  { 4124, 24, 45, 31, 5, -45 },
  { 4259, 23, 45, 30, 5, -45 },
  { 4389, 29, 47, 37, 4, -46 },
  { 4560, 29, 45, 39, 5, -45 },
  { 4724, 6, 45, 16, 5, -45 },
  { 4758, 24, 46, 30, 2, -45 },
  { 4896, 29, 45, 34, 5, -45 },
  { 5060, 23, 45, 30, 5, -45 },
  { 5190, 38, 45, 48, 5, -45 },
  { 5404, 29, 45, 39, 5, -45 },
  { 5568, 30, 47, 38, 4, -46 },
  { 5745, 28, 45, 35, 5, -45 },
  { 5903, 30, 54, 38, 4, -46 },
  { 6106, 27, 45, 33, 5, -45 },
  { 6258, 27, 47, 33, 3, -46 },
  { 6417, 29, 45, 33, 2, -45 },
  { 6581, 28, 46, 35, 4, -45 },
  { 6742, 33, 45, 35, 1, -45 },
  { 6928, 44, 45, 48, 2, -45 },
  { 7176, 31, 45, 35, 2, -45 },
  { 7351, 31, 45, 33, 1, -45 },
  { 7526, 27, 45, 33, 3, -45 },
  { 7678, 10, 61, 16, 4, -51 },
  { 7755, 20, 49, 23, 2, -45 },
  { 7878, 10, 61, 16, 1, -51 },
  { 7955, 19, 22, 23, 2, -45 },
  { 8008, 24, 5, 26, 1, 0 },
  { 8023, 13, 9, 19, 2, -47 },
  { 8038, 24, 35, 30, 3, -34 },
  { 8143, 24, 48, 31, 4, -47 },
  { 8287, 24, 35, 29, 3, -34 },
  { 8392, 24, 48, 31, 3, -47 },
  { 8536, 24, 35, 30, 3, -34 },
  { 8641, 17, 48, 20, 2, -48 },
  { 8743, 24, 47, 31, 3, -34 },
  { 8884, 22, 47, 30, 4, -47 },
  { 9014, 6, 46, 14, 4, -46 },
  { 9049, 11, 59, 14, -1, -46 },
  { 9131, 24, 47, 28, 4, -47 },
  { 9272, 5, 47, 14, 5, -47 },
  { 9302, 39, 34, 47, 4, -34 },
  { 9468, 22, 34, 31, 4, -34 },
  { 9562, 26, 35, 32, 3, -34 },
  { 9676, 24, 47, 31, 4, -34 },
  { 9817, 24, 47, 32, 3, -34 },
  { 9958, 14, 34, 19, 4, -34 },
  { 10018, 23, 35, 29, 3, -34 },
  { 10119, 15, 42, 19, 1, -41 },
  { 10198, 22, 34, 30, 4, -33 },
  { 10292, 24, 33, 27, 1, -33 },
  { 10391, 37, 33, 41, 2, -33 },
  { 10544, 24, 33, 28, 2, -33 },
  { 10643, 24, 46, 26, 1, -33 },
  { 10781, 22, 33, 28, 3, -33 },
  { 10872, 16, 60, 19, 2, -49 },
  { 10992, 5, 53, 15, 5, -45 },
  { 11026, 16, 60, 19, 1, -49 },
  { 11146, 29, 12, 37, 4, -24 },
};

const GFXfont RobotoCondensed_Regular63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_REGULAR63PT7B_H_
