#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/RobotoCondensed_Regular
// Headers: 67

#include "RobotoCondensed_Regular6pt7b.h"
#include "RobotoCondensed_Regular7pt7b.h"
#include "RobotoCondensed_Regular8pt7b.h"
#include "RobotoCondensed_Regular9pt7b.h"
#include "RobotoCondensed_Regular10pt7b.h"
#include "RobotoCondensed_Regular11pt7b.h"
#include "RobotoCondensed_Regular12pt7b.h"
#include "RobotoCondensed_Regular13pt7b.h"
#include "RobotoCondensed_Regular14pt7b.h"
#include "RobotoCondensed_Regular15pt7b.h"
#include "RobotoCondensed_Regular16pt7b.h"
#include "RobotoCondensed_Regular17pt7b.h"
#include "RobotoCondensed_Regular18pt7b.h"
#include "RobotoCondensed_Regular19pt7b.h"
#include "RobotoCondensed_Regular20pt7b.h"
#include "RobotoCondensed_Regular21pt7b.h"
#include "RobotoCondensed_Regular22pt7b.h"
#include "RobotoCondensed_Regular23pt7b.h"
#include "RobotoCondensed_Regular24pt7b.h"
#include "RobotoCondensed_Regular25pt7b.h"
#include "RobotoCondensed_Regular26pt7b.h"
#include "RobotoCondensed_Regular27pt7b.h"
#include "RobotoCondensed_Regular28pt7b.h"
#include "RobotoCondensed_Regular29pt7b.h"
#include "RobotoCondensed_Regular30pt7b.h"
#include "RobotoCondensed_Regular31pt7b.h"
#include "RobotoCondensed_Regular32pt7b.h"
#include "RobotoCondensed_Regular33pt7b.h"
#include "RobotoCondensed_Regular34pt7b.h"
#include "RobotoCondensed_Regular35pt7b.h"
#include "RobotoCondensed_Regular36pt7b.h"
#include "RobotoCondensed_Regular37pt7b.h"
#include "RobotoCondensed_Regular38pt7b.h"
#include "RobotoCondensed_Regular39pt7b.h"
#include "RobotoCondensed_Regular40pt7b.h"
#include "RobotoCondensed_Regular41pt7b.h"
#include "RobotoCondensed_Regular42pt7b.h"
#include "RobotoCondensed_Regular43pt7b.h"
#include "RobotoCondensed_Regular44pt7b.h"
#include "RobotoCondensed_Regular45pt7b.h"
#include "RobotoCondensed_Regular46pt7b.h"
#include "RobotoCondensed_Regular47pt7b.h"
#include "RobotoCondensed_Regular48pt7b.h"
#include "RobotoCondensed_Regular49pt7b.h"
#include "RobotoCondensed_Regular50pt7b.h"
#include "RobotoCondensed_Regular51pt7b.h"
#include "RobotoCondensed_Regular52pt7b.h"
#include "RobotoCondensed_Regular53pt7b.h"
#include "RobotoCondensed_Regular54pt7b.h"
#include "RobotoCondensed_Regular55pt7b.h"
#include "RobotoCondensed_Regular56pt7b.h"
#include "RobotoCondensed_Regular57pt7b.h"
#include "RobotoCondensed_Regular58pt7b.h"
#include "RobotoCondensed_Regular59pt7b.h"
#include "RobotoCondensed_Regular60pt7b.h"
#include "RobotoCondensed_Regular61pt7b.h"
#include "RobotoCondensed_Regular62pt7b.h"
#include "RobotoCondensed_Regular63pt7b.h"
#include "RobotoCondensed_Regular64pt7b.h"
#include "RobotoCondensed_Regular65pt7b.h"
#include "RobotoCondensed_Regular66pt7b.h"
#include "RobotoCondensed_Regular67pt7b.h"
#include "RobotoCondensed_Regular68pt7b.h"
#include "RobotoCondensed_Regular69pt7b.h"
#include "RobotoCondensed_Regular70pt7b.h"
#include "RobotoCondensed_Regular71pt7b.h"
#include "RobotoCondensed_Regular72pt7b.h"
