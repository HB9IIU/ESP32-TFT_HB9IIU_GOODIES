#ifndef _ROBOTOCONDENSED_REGULAR19PT7B_H_
#define _ROBOTOCONDENSED_REGULAR19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x55, 0x50, 0x50, 0xDD, 0x99, 0x90, 0x09, 0x0C, 0x84, 0xC2,
  0x47, 0xF8, 0x90, 0x48, 0x64, 0x36, 0x7F, 0x89, 0x04, 0x82, 0x43, 0x20,
  0x18, 0x30, 0xF3, 0xF4, 0x78, 0x50, 0x30, 0x38, 0x38, 0x18, 0x1C, 0x38,
  0xDF, 0x9E, 0x10, 0x20, 0x70, 0x36, 0x08, 0x92, 0x2C, 0xDA, 0x1D, 0x00,
  0x40, 0x20, 0x0B, 0x84, 0x91, 0x64, 0x99, 0x22, 0x40, 0xE0, 0x38, 0x36,
  0x19, 0x8C, 0xC6, 0xC1, 0xC0, 0xC0, 0xF0, 0xC9, 0x66, 0xB1, 0xD8, 0x66,
  0xF1, 0xEC, 0xF0, 0x11, 0x26, 0x64, 0xCC, 0xCC, 0xCC, 0xC4, 0x66, 0x21,
  0x10, 0x42, 0x08, 0x63, 0x08, 0x43, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x22,
  0x10, 0x18, 0x18, 0x19, 0xFF, 0x18, 0x3C, 0x24, 0x24, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x6D, 0xA4, 0xF0, 0xF0, 0x04,
  0x10, 0xC2, 0x08, 0x61, 0x04, 0x30, 0x82, 0x18, 0x41, 0x0C, 0x00, 0x3C,
  0xDB, 0x1E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0A, 0x36, 0xC7, 0x80,
  0x0B, 0xFF, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x3C, 0x6E, 0xC6,
  0xC6, 0x06, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xFF, 0x38,
  0xDB, 0x1E, 0x30, 0x60, 0xC3, 0x1E, 0x06, 0x0F, 0x1E, 0x36, 0xE7, 0x00,
  0x0C, 0x0C, 0x1C, 0x14, 0x34, 0x24, 0x64, 0x44, 0xC4, 0x84, 0xFF, 0x04,
  0x04, 0x04, 0x7E, 0x7E, 0x60, 0x60, 0x40, 0x5C, 0x7E, 0x06, 0x03, 0x03,
  0xC3, 0x42, 0x66, 0x3C, 0x1C, 0x71, 0x82, 0x04, 0x1B, 0xBB, 0xE3, 0xC3,
  0x87, 0x0A, 0x36, 0xE7, 0x80, 0xFF, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x3C, 0xDF, 0x1E, 0x3C, 0x6D,
  0x8F, 0x23, 0xC7, 0x87, 0x0E, 0x36, 0xE7, 0x80, 0x38, 0xDB, 0x1E, 0x3C,
  0x78, 0x71, 0xB7, 0x3E, 0x0C, 0x18, 0x63, 0xC6, 0x00, 0xF0, 0x00, 0xF0,
  0x6C, 0x00, 0x00, 0x6D, 0xA4, 0x04, 0x77, 0x30, 0xC1, 0xC1, 0xC1, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x81, 0xC0, 0xE0, 0x70, 0xE7, 0x38,
  0x40, 0x7B, 0xF8, 0xC1, 0x0C, 0x31, 0x8C, 0x30, 0xC0, 0x00, 0x30, 0xC0,
  0x0F, 0x80, 0xC7, 0x08, 0x08, 0xC0, 0x24, 0x71, 0x22, 0x4B, 0x22, 0x31,
  0x11, 0x88, 0x8C, 0xCC, 0xE6, 0x65, 0x97, 0x2C, 0xEE, 0x20, 0x01, 0x80,
  0x06, 0x10, 0x0F, 0x80, 0x04, 0x01, 0xC0, 0x28, 0x05, 0x01, 0xB0, 0x36,
  0x04, 0x41, 0x8C, 0x31, 0x87, 0xF1, 0x82, 0x30, 0x66, 0x0C, 0x80, 0x80,
  0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0xC3, 0xC3, 0xC1, 0xC1, 0xC3,
  0xC7, 0xFE, 0x1E, 0x3B, 0x98, 0x58, 0x3C, 0x1E, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x6C, 0x37, 0x70, 0xF0, 0xFC, 0x67, 0x30, 0xD8, 0x2C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x58, 0x6C, 0xE7, 0xE0, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x00, 0x3E, 0x3B, 0x98, 0x78, 0x3C, 0x06, 0x03, 0x01, 0x8F, 0xC1, 0xE0,
  0xF0, 0x6C, 0x37, 0x30, 0xF0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x04, 0xFF, 0xFC, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x1E, 0x3E, 0xCF, 0x00,
  0xC1, 0xE1, 0xB1, 0x99, 0x8C, 0xC6, 0xC3, 0xE1, 0xF0, 0xEC, 0x63, 0x31,
  0x98, 0x6C, 0x36, 0x0C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x1F, 0xC0, 0xE0, 0x3E, 0x07, 0xE0, 0x7F, 0x07, 0xF0,
  0xFD, 0x0F, 0xD8, 0xBD, 0x9B, 0xC9, 0xBC, 0xD3, 0xCF, 0x3C, 0x73, 0xC6,
  0x3C, 0x63, 0xC0, 0xF0, 0x78, 0x3E, 0x1D, 0x0E, 0xC7, 0x23, 0x99, 0xC4,
  0xE3, 0x70, 0xB8, 0x7C, 0x1E, 0x0C, 0x1E, 0x3F, 0x98, 0x78, 0x3C, 0x1E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x6C, 0x37, 0xF0, 0xF0, 0xFE, 0x63,
  0xB0, 0x58, 0x3C, 0x1E, 0x0F, 0x07, 0x8E, 0xFE, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x00, 0x1E, 0x3F, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x6C, 0x37, 0xF0, 0xF8, 0x0E, 0x01, 0xFE, 0x63, 0xB0, 0xD8,
  0x2C, 0x16, 0x1B, 0x1D, 0xF8, 0xC6, 0x63, 0x30, 0x98, 0x6C, 0x36, 0x0C,
  0x3C, 0x66, 0xC3, 0xC3, 0xC0, 0x60, 0x78, 0x1E, 0x07, 0x03, 0xC3, 0xC3,
  0x76, 0x3C, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x58, 0x67, 0x71, 0xF0, 0x40, 0xD8, 0x36, 0x0D,
  0x86, 0x21, 0x8C, 0x63, 0x10, 0x4C, 0x1B, 0x06, 0x80, 0xA0, 0x38, 0x0E,
  0x03, 0x00, 0x82, 0x1E, 0x30, 0xF1, 0xC5, 0x8E, 0x24, 0x51, 0x26, 0x99,
  0xB4, 0xCD, 0x36, 0x68, 0xA3, 0x45, 0x0E, 0x28, 0x61, 0xC3, 0x0E, 0x18,
  0x20, 0xC1, 0xE1, 0x98, 0xCC, 0xC3, 0x60, 0xE0, 0x60, 0x38, 0x3C, 0x1B,
  0x19, 0x8C, 0x6C, 0x36, 0x0C, 0x40, 0x98, 0x66, 0x18, 0xCC, 0x33, 0x04,
  0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0, 0xC0,
  0xFF, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDC, 0x40, 0x81, 0x81, 0x02,
  0x06, 0x04, 0x08, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x81, 0x80, 0xE4, 0x92,
  0x49, 0x24, 0x92, 0x49, 0x3C, 0x23, 0x94, 0xAD, 0xEE, 0x20, 0xFE, 0xCC,
  0x80, 0x3C, 0xDF, 0x18, 0x33, 0xEC, 0xF1, 0xE3, 0xFE, 0xEC, 0xC0, 0xC0,
  0xC0, 0xC0, 0xDC, 0xEE, 0xC2, 0xC2, 0xC2, 0xC3, 0xC2, 0xC2, 0xEE, 0xDC,
  0x3C, 0xDB, 0x1E, 0x1C, 0x18, 0x30, 0x63, 0x6E, 0x78, 0x06, 0x0C, 0x18,
  0x37, 0xED, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x36, 0xEF, 0x40, 0x3C, 0xDF,
  0x1E, 0x1F, 0xF8, 0x30, 0x60, 0x66, 0x78, 0x3B, 0x98, 0xCF, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x30, 0x7A, 0xDF, 0x1E, 0x1C, 0x38, 0x70, 0xE3, 0x6E,
  0xF4, 0x08, 0x36, 0xE7, 0x80, 0xC1, 0x83, 0x06, 0x0D, 0xDD, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xC0, 0xF0, 0xFF, 0xFF, 0xF0, 0x6C, 0x06,
  0xDB, 0x6D, 0xB6, 0xDB, 0x78, 0xC1, 0x83, 0x06, 0x0C, 0x79, 0xB6, 0x78,
  0xF1, 0xF3, 0x66, 0x6C, 0x58, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFD, 0xEE,
  0xF7, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C,
  0x63, 0xDD, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8C, 0x3C, 0x6E,
  0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0x6E, 0x3C, 0xFD, 0xDF, 0x1E, 0x1C,
  0x38, 0x70, 0xE1, 0xEF, 0xFB, 0x06, 0x0C, 0x18, 0x00, 0x7A, 0xDF, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0x6E, 0xFC, 0x18, 0x30, 0x60, 0xC0, 0xFF, 0xCC,
  0xCC, 0xCC, 0xCC, 0x78, 0xDB, 0x1E, 0x07, 0x03, 0x81, 0xE3, 0xEC, 0xF0,
  0x21, 0x3E, 0x42, 0x10, 0x84, 0x21, 0x0E, 0x70, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0x6E, 0xFC, 0x43, 0x42, 0x66, 0x66, 0x24, 0x34, 0x3C,
  0x18, 0x18, 0x18, 0x46, 0x34, 0x62, 0x66, 0x26, 0x72, 0x2D, 0x62, 0x96,
  0x39, 0xC3, 0x9C, 0x18, 0xC1, 0x0C, 0x62, 0x66, 0x34, 0x3C, 0x18, 0x18,
  0x3C, 0x34, 0x66, 0x63, 0xC2, 0x46, 0x66, 0x66, 0x24, 0x3C, 0x3C, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x70, 0x60, 0xFC, 0x18, 0x30, 0xC1, 0x06, 0x18,
  0x20, 0xC1, 0xFC, 0x13, 0x26, 0x66, 0x66, 0xCC, 0x66, 0x66, 0x66, 0x31,
  0xFF, 0xFF, 0x80, 0x43, 0x08, 0x43, 0x18, 0xC6, 0x30, 0xCC, 0x63, 0x18,
  0xC4, 0x62, 0x00, 0x70, 0xBC, 0xF3, 0xF8, 0xE0,
};

const GFXglyph RobotoCondensed_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 5, 1, -14 },
  { 5, 4, 5, 6, 1, -14 },
  { 8, 9, 14, 10, 1, -14 },
  { 24, 7, 18, 9, 1, -16 },
  { 40, 10, 14, 12, 1, -14 },
  { 58, 9, 14, 10, 1, -14 },
  { 74, 1, 4, 3, 1, -14 },
  { 75, 4, 19, 6, 1, -15 },
  { 85, 5, 19, 6, 0, -15 },
  { 97, 8, 8, 8, 0, -14 },
  { 105, 8, 10, 9, 1, -12 },
  { 115, 3, 5, 4, 0, -2 },
  { 117, 4, 1, 5, 0, -6 },
  { 118, 2, 2, 5, 1, -2 },
  { 119, 6, 15, 7, 0, -14 },
  { 131, 7, 14, 9, 1, -14 },
  { 144, 5, 14, 9, 1, -14 },
  { 153, 8, 14, 9, 1, -14 },
  { 167, 7, 14, 9, 1, -14 },
  { 180, 8, 14, 9, 1, -14 },
  { 194, 8, 14, 9, 1, -14 },
  { 208, 7, 14, 9, 1, -14 },
  { 221, 8, 14, 9, 1, -14 },
  { 235, 7, 14, 9, 1, -14 },
  { 248, 7, 14, 9, 1, -14 },
  { 261, 2, 10, 4, 1, -10 },
  { 264, 3, 13, 4, 0, -10 },
  { 269, 6, 8, 8, 1, -10 },
  { 275, 7, 7, 9, 1, -10 },
  { 282, 7, 8, 9, 1, -10 },
  { 289, 6, 14, 8, 1, -14 },
  { 300, 13, 17, 15, 1, -13 },
  { 328, 11, 14, 11, 0, -14 },
  { 348, 8, 14, 10, 1, -14 },
  { 362, 9, 14, 11, 1, -14 },
  { 378, 9, 14, 11, 1, -14 },
  { 394, 8, 14, 9, 1, -14 },
  { 408, 7, 14, 9, 1, -14 },
  { 421, 9, 14, 11, 1, -14 },
  { 437, 9, 14, 12, 1, -14 },
  { 453, 1, 14, 5, 2, -14 },
  { 455, 7, 14, 9, 1, -14 },
  { 468, 9, 14, 10, 1, -14 },
  { 484, 7, 14, 9, 1, -14 },
  { 497, 12, 14, 14, 1, -14 },
  { 518, 9, 14, 12, 1, -14 },
  { 534, 9, 14, 11, 1, -14 },
  { 550, 9, 14, 11, 1, -14 },
  { 566, 9, 16, 11, 1, -14 },
  { 584, 9, 14, 10, 1, -14 },
  { 600, 8, 14, 10, 1, -14 },
  { 614, 8, 14, 10, 1, -14 },
  { 628, 9, 14, 11, 1, -14 },
  { 644, 10, 14, 11, 0, -14 },
  { 662, 13, 14, 14, 1, -14 },
  { 685, 9, 14, 10, 1, -14 },
  { 701, 10, 14, 10, 0, -14 },
  { 719, 8, 14, 10, 1, -14 },
  { 733, 3, 18, 5, 1, -15 },
  { 740, 7, 15, 7, 0, -14 },
  { 754, 3, 18, 5, 0, -15 },
  { 761, 5, 7, 7, 1, -14 },
  { 766, 7, 1, 8, 0, 0 },
  { 767, 3, 3, 6, 1, -15 },
  { 769, 7, 10, 9, 1, -10 },
  { 778, 8, 14, 9, 1, -14 },
  { 792, 7, 10, 9, 1, -10 },
  { 801, 7, 14, 9, 1, -14 },
  { 814, 7, 10, 9, 1, -10 },
  { 823, 5, 14, 6, 1, -14 },
  { 832, 7, 14, 9, 1, -10 },
  { 845, 7, 14, 9, 1, -14 },
  { 858, 2, 14, 4, 1, -14 },
  { 862, 3, 18, 4, 0, -14 },
  { 869, 7, 14, 9, 1, -14 },
  { 882, 2, 14, 4, 1, -14 },
  { 886, 12, 10, 14, 1, -10 },
  { 901, 7, 10, 9, 1, -10 },
  { 910, 8, 10, 10, 1, -10 },
  { 920, 7, 14, 9, 1, -10 },
  { 933, 7, 14, 10, 1, -10 },
  { 946, 4, 10, 6, 1, -10 },
  { 951, 7, 10, 9, 1, -10 },
  { 960, 5, 12, 6, 0, -12 },
  { 968, 7, 10, 9, 1, -10 },
  { 977, 8, 10, 8, 0, -10 },
  { 987, 12, 10, 12, 0, -10 },
  { 1002, 8, 10, 8, 0, -10 },
  { 1012, 8, 14, 8, 0, -10 },
  { 1026, 7, 10, 8, 1, -10 },
  { 1035, 4, 18, 6, 1, -15 },
  { 1044, 1, 17, 5, 2, -14 },
  { 1047, 5, 18, 6, 0, -15 },
  { 1059, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_Regular19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_Regular19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_Regular19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_REGULAR19PT7B_H_
