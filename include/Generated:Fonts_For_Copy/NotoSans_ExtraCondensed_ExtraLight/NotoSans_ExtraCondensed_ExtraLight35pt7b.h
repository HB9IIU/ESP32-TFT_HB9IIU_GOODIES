#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT35PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight35pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x00, 0x17, 0x60, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0x62, 0xC4, 0x04, 0x20, 0x61, 0x03, 0x08,
  0x10, 0x40, 0x82, 0x04, 0x30, 0x21, 0x1F, 0xFF, 0x08, 0x40, 0x42, 0x06,
  0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x43, 0x02, 0x18, 0xFF, 0xF8, 0x84,
  0x04, 0x20, 0x61, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x30, 0x21, 0x00,
  0x04, 0x00, 0x40, 0x06, 0x03, 0xFE, 0x64, 0x24, 0x40, 0xC4, 0x08, 0x40,
  0x84, 0x0C, 0x40, 0xC4, 0x06, 0x40, 0x34, 0x01, 0xC0, 0x07, 0x00, 0x58,
  0x04, 0x40, 0x42, 0x04, 0x30, 0x41, 0x04, 0x10, 0x41, 0x04, 0x20, 0x46,
  0xE4, 0xC3, 0xF0, 0x04, 0x00, 0x40, 0x04, 0x00, 0x78, 0x08, 0x66, 0x0C,
  0x21, 0x04, 0x10, 0x82, 0x08, 0x43, 0x04, 0x31, 0x02, 0x18, 0x81, 0x0C,
  0xC0, 0x86, 0x40, 0x43, 0x20, 0x21, 0x33, 0xD0, 0x92, 0x28, 0x49, 0x1A,
  0x6D, 0x85, 0xE4, 0x82, 0x02, 0x41, 0x03, 0x20, 0x81, 0x10, 0x40, 0x88,
  0x20, 0xC4, 0x10, 0x42, 0x08, 0x21, 0x84, 0x30, 0x46, 0x10, 0x22, 0x08,
  0x0E, 0x00, 0x1E, 0x00, 0x88, 0x08, 0x60, 0x43, 0x02, 0x08, 0x10, 0x40,
  0x86, 0x06, 0x20, 0x11, 0x00, 0x98, 0x03, 0x80, 0x18, 0x01, 0x40, 0x13,
  0x01, 0x88, 0x48, 0x62, 0xC1, 0x14, 0x0C, 0xA0, 0x2D, 0x00, 0xC8, 0x06,
  0x60, 0x31, 0x03, 0xCC, 0x32, 0x3F, 0x18, 0xFF, 0xFF, 0xC0, 0x0C, 0x21,
  0x0C, 0x20, 0x86, 0x10, 0x43, 0x0C, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xC3, 0x04, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0x40, 0xC0, 0xC0,
  0x81, 0x81, 0x03, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x20, 0x40, 0xC1, 0x83,
  0x06, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x30, 0x41, 0x82, 0x08,
  0x30, 0x00, 0x04, 0x01, 0x00, 0x42, 0x11, 0x77, 0x83, 0x00, 0xE0, 0x48,
  0x21, 0x08, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x0F, 0xFF, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x32, 0x22, 0x64, 0x44, 0x80, 0xFE, 0x7C, 0x00, 0x40,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0x80, 0x00, 0x1F, 0x08, 0x46, 0x09, 0x02, 0xC0,
  0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0xD0, 0x26, 0x08, 0xC4,
  0x1E, 0x00, 0x0C, 0x73, 0xDB, 0xCE, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0x0C, 0x18,
  0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C,
  0x01, 0x00, 0x60, 0x18, 0x02, 0x00, 0xFF, 0xE0, 0x3F, 0x9C, 0x19, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x40, 0x18, 0x06, 0x0F,
  0x81, 0xF0, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0xC0, 0x16, 0x06, 0x7F, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x2C, 0x03, 0x60, 0x13, 0x00, 0x98, 0x08, 0xC0, 0x46, 0x04,
  0x30, 0x21, 0x82, 0x0C, 0x10, 0x61, 0x03, 0x08, 0x18, 0x80, 0xC4, 0x06,
  0x3F, 0xFE, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x7F, 0x88, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80,
  0x10, 0x03, 0xF8, 0x61, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x0C, 0x01, 0x00, 0x20, 0x04, 0x01, 0x80, 0x24, 0x18, 0xFE, 0x00, 0x0F,
  0x83, 0x00, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x7C, 0x50, 0xCC, 0x0D, 0x80, 0xA0, 0x14, 0x02, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x2C, 0x05, 0x80, 0x90, 0x33, 0x0C, 0x3F, 0x00, 0xFF, 0xE0,
  0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x00, 0x1F, 0x83, 0x0C,
  0x60, 0x64, 0x02, 0x40, 0x24, 0x02, 0x40, 0x26, 0x02, 0x20, 0x43, 0x0C,
  0x19, 0x80, 0x60, 0x0F, 0x01, 0x18, 0x20, 0x46, 0x06, 0x40, 0x2C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x02, 0x60, 0x63, 0x0C, 0x1F, 0x80, 0x1F,
  0x06, 0x11, 0x81, 0x20, 0x24, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x05, 0x00, 0xA0, 0x36, 0x06, 0x41, 0x47, 0xC8, 0x01, 0x00, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x60, 0x18, 0x7E, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x27, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x22,
  0x26, 0x44, 0x48, 0x00, 0x10, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x60, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x80, 0x00, 0xFC, 0x86, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02,
  0x06, 0x04, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20, 0x00, 0x00,
  0x00, 0x20, 0x30, 0x30, 0x03, 0xF0, 0x03, 0x83, 0x01, 0x80, 0x60, 0x40,
  0x0C, 0x20, 0x01, 0x08, 0x00, 0x44, 0x00, 0x09, 0x03, 0xC2, 0x41, 0x10,
  0xB0, 0x84, 0x28, 0x61, 0x0E, 0x10, 0x43, 0x84, 0x10, 0x61, 0x04, 0x38,
  0x41, 0x0E, 0x10, 0xC3, 0x84, 0x30, 0xA1, 0x0C, 0x28, 0x63, 0x0A, 0x09,
  0x64, 0xC1, 0xCF, 0x10, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0xC1, 0x00, 0x1F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x60, 0x04, 0x80, 0x12, 0x00, 0xC8, 0x02, 0x30, 0x08, 0x40, 0x21,
  0x01, 0x84, 0x06, 0x10, 0x10, 0x60, 0x40, 0x81, 0xFE, 0x0F, 0xF8, 0x20,
  0x30, 0x80, 0x42, 0x01, 0x18, 0x04, 0x40, 0x19, 0x00, 0x24, 0x00, 0xB0,
  0x02, 0xC0, 0x0C, 0xFF, 0x10, 0x72, 0x03, 0x40, 0x28, 0x05, 0x00, 0xE0,
  0x1C, 0x02, 0x80, 0x50, 0x1A, 0x06, 0x7F, 0x88, 0x79, 0x01, 0xA0, 0x14,
  0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xA0, 0x34, 0x1C,
  0xFF, 0x00, 0x07, 0xF1, 0x81, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0xC1, 0x07, 0xF0, 0xFE, 0x08, 0x38, 0x80, 0xC8, 0x04, 0x80, 0x68,
  0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x28, 0x02, 0x80, 0x68,
  0x04, 0x80, 0x88, 0x38, 0xFE, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x1F, 0xEF, 0xF4, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x0F, 0xF7, 0xFA, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x00, 0x07, 0xF8, 0x30, 0x31, 0x00, 0x0C, 0x00, 0x60,
  0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x03, 0xF8, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x14,
  0x00, 0x50, 0x01, 0x60, 0x04, 0x80, 0x11, 0x00, 0x47, 0x01, 0x07, 0xFC,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0xFC, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0C, 0x3F, 0x80, 0x80, 0x50, 0x1A,
  0x06, 0x40, 0x88, 0x31, 0x04, 0x21, 0x84, 0x20, 0x88, 0x13, 0x02, 0x40,
  0x58, 0x0B, 0x81, 0x90, 0x33, 0x04, 0x20, 0x86, 0x10, 0x42, 0x0C, 0x40,
  0x88, 0x19, 0x01, 0x20, 0x34, 0x02, 0x80, 0x60, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFF,
  0x80, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xA0, 0x03,
  0xE8, 0x00, 0xBB, 0x00, 0x2E, 0x40, 0x1B, 0x90, 0x04, 0xE4, 0x01, 0x39,
  0x80, 0xCE, 0x20, 0x23, 0x88, 0x08, 0xE3, 0x02, 0x38, 0x41, 0x8E, 0x10,
  0x43, 0x86, 0x10, 0xE0, 0x8C, 0x38, 0x22, 0x0E, 0x08, 0x83, 0x83, 0x60,
  0xE0, 0x50, 0x38, 0x14, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0xC0, 0x80, 0x1C,
  0x01, 0xC0, 0x1E, 0x01, 0xA0, 0x1B, 0x01, 0x90, 0x19, 0x81, 0x88, 0x18,
  0x81, 0x84, 0x18, 0x41, 0x86, 0x18, 0x21, 0x83, 0x18, 0x11, 0x81, 0x98,
  0x09, 0x80, 0x98, 0x0D, 0x80, 0x58, 0x07, 0x80, 0x38, 0x03, 0x80, 0x10,
  0x0F, 0xC0, 0x61, 0x83, 0x01, 0x18, 0x06, 0x40, 0x09, 0x00, 0x2C, 0x00,
  0xF0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xD0, 0x03, 0x40,
  0x09, 0x80, 0x63, 0x01, 0x06, 0x18, 0x0F, 0xC0, 0xFC, 0x21, 0xC8, 0x1A,
  0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x02, 0x81,
  0xBF, 0x8F, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x61, 0x83, 0x01, 0x18, 0x06, 0x40,
  0x09, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C,
  0x00, 0xD0, 0x03, 0x40, 0x09, 0x80, 0x63, 0x01, 0x06, 0x18, 0x0F, 0xC0,
  0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0xFC,
  0x10, 0xE2, 0x06, 0x40, 0x68, 0x0D, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x50,
  0x1A, 0x02, 0x40, 0xC8, 0x71, 0xF8, 0x21, 0x04, 0x30, 0x82, 0x10, 0x42,
  0x0C, 0x40, 0x88, 0x19, 0x01, 0x20, 0x34, 0x02, 0x80, 0x60, 0x1F, 0xE6,
  0x05, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x16, 0x06, 0x7F, 0x00, 0xFF, 0xF0, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xD0, 0x06, 0x80, 0x34, 0x01, 0x20, 0x09, 0x80,
  0xC6, 0x0C, 0x1F, 0xC0, 0x80, 0x0E, 0x00, 0x50, 0x06, 0x80, 0x34, 0x01,
  0x30, 0x08, 0x80, 0xC4, 0x06, 0x20, 0x21, 0x81, 0x0C, 0x08, 0x20, 0xC1,
  0x04, 0x08, 0x20, 0x61, 0x01, 0x18, 0x08, 0x80, 0x44, 0x03, 0x20, 0x0B,
  0x00, 0x58, 0x02, 0x80, 0x14, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x10, 0x07,
  0x80, 0x20, 0x0D, 0x00, 0xE0, 0x12, 0x01, 0x40, 0x24, 0x02, 0x80, 0x4C,
  0x05, 0x01, 0x88, 0x0A, 0x03, 0x10, 0x36, 0x04, 0x20, 0x44, 0x08, 0x60,
  0x88, 0x10, 0xC1, 0x10, 0x60, 0x82, 0x20, 0xC1, 0x0C, 0x61, 0x02, 0x18,
  0x42, 0x06, 0x20, 0x8C, 0x0C, 0x41, 0x18, 0x08, 0x82, 0x20, 0x13, 0x06,
  0x40, 0x26, 0x04, 0x80, 0x68, 0x0B, 0x00, 0xD0, 0x16, 0x00, 0xA0, 0x28,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x60, 0x32, 0x02,
  0x20, 0x63, 0x04, 0x10, 0x41, 0x0C, 0x08, 0x80, 0x98, 0x0D, 0x00, 0x50,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x70, 0x05, 0x00, 0x90, 0x09, 0x81, 0x88,
  0x10, 0x81, 0x0C, 0x20, 0x42, 0x06, 0x60, 0x64, 0x02, 0xC0, 0x30, 0xC0,
  0x3C, 0x02, 0x40, 0x66, 0x04, 0x20, 0x42, 0x0C, 0x30, 0x81, 0x08, 0x11,
  0x81, 0x10, 0x09, 0x00, 0xB0, 0x0A, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04,
  0x00, 0xFF, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xFF, 0xC0, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xFF,
  0x80, 0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0x40, 0x10,
  0x06, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80,
  0x30, 0x04, 0x01, 0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0xFE, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xFF,
  0x80, 0x02, 0x00, 0x38, 0x01, 0x40, 0x12, 0x00, 0x88, 0x08, 0x40, 0x43,
  0x04, 0x08, 0x60, 0x62, 0x01, 0x30, 0x0D, 0x00, 0x30, 0xFF, 0xFC, 0xC1,
  0x82, 0x04, 0x08, 0x10, 0x1E, 0x0C, 0xE0, 0x08, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x03, 0xC7, 0x12, 0x05, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x41, 0x58, 0x53, 0xE4, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xCF, 0x0D, 0x98, 0xE0, 0x4E, 0x06, 0xC0, 0x2C,
  0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C,
  0x02, 0xC0, 0x2C, 0x06, 0xE0, 0x4D, 0x0C, 0xCF, 0x80, 0x0F, 0x9C, 0x98,
  0x08, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x80, 0x40, 0x30, 0x47, 0xC0, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x1E, 0x66, 0x6D, 0x83, 0xA0, 0x7C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1E, 0x03, 0x40, 0xAC, 0x24, 0xF8, 0x80, 0x1E, 0x0C, 0xC6,
  0x19, 0x02, 0xC0, 0xE0, 0x18, 0x06, 0x01, 0xFF, 0xFF, 0xF8, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0x00, 0x40, 0x08, 0x21, 0xF8, 0x07, 0x86, 0x86,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x3E, 0x7F, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x00, 0x1E, 0x26, 0x65, 0x83, 0xA0, 0x7C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1E, 0x03, 0x40, 0xEC, 0x2C, 0xF9, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0xD0, 0x33, 0xFC, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xCF, 0x36, 0x6F, 0x0F, 0x81, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x04, 0xF0, 0x05, 0x55, 0x55, 0x55, 0x55, 0x40, 0x33,
  0x00, 0x00, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x13, 0x33, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xB0, 0x6C, 0x13, 0x08, 0xC6, 0x31, 0x0C, 0xC3, 0x20,
  0xD8, 0x3F, 0x0E, 0x43, 0x18, 0xC2, 0x30, 0x8C, 0x33, 0x04, 0xC1, 0xB0,
  0x2C, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x8E, 0x0E, 0x4D,
  0x8D, 0xB8, 0x28, 0x7C, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03,
  0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C,
  0x0E, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x30, 0x20, 0x8F, 0x26, 0x6E, 0x0F, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x04, 0x1E, 0x06, 0x71, 0x82, 0x60, 0x2C, 0x05, 0x00, 0xA0, 0x1C,
  0x03, 0x80, 0x70, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x16, 0x02,
  0x40, 0xCC, 0x30, 0xFC, 0x00, 0x87, 0x09, 0x98, 0xB0, 0x4E, 0x06, 0xC0,
  0x2C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02, 0xC0,
  0x2C, 0x02, 0xC0, 0x2E, 0x06, 0xE0, 0x4D, 0x0C, 0xCF, 0x8C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x1E, 0x26,
  0x65, 0x83, 0xA0, 0x7C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0x40, 0xEC, 0x2C, 0xFD,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x8F, 0xBF, 0xC7, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x00, 0x1F, 0x39, 0xD0, 0x18, 0x0C, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x04, 0x02, 0x01, 0x01,
  0xC1, 0x9F, 0x80, 0x20, 0x82, 0x18, 0x7F, 0xF6, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x20, 0x83, 0xC0, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0D, 0x03, 0x40, 0xD8, 0x53, 0xE4, 0xC0, 0x78, 0x09,
  0x01, 0x20, 0x24, 0x0C, 0xC1, 0x08, 0x21, 0x04, 0x21, 0x86, 0x20, 0x44,
  0x08, 0x81, 0x30, 0x34, 0x02, 0x80, 0x50, 0x0A, 0x01, 0xC0, 0x30, 0x00,
  0xC0, 0x40, 0x50, 0x30, 0x14, 0x0E, 0x05, 0x02, 0x83, 0x40, 0xA0, 0x98,
  0x28, 0x22, 0x1A, 0x08, 0x84, 0xC6, 0x21, 0x11, 0x0C, 0x44, 0x41, 0x31,
  0x10, 0x4C, 0x44, 0x12, 0x1B, 0x04, 0x82, 0x81, 0xA0, 0xA0, 0x38, 0x28,
  0x0C, 0x0A, 0x03, 0x03, 0x80, 0xC0, 0x40, 0x80, 0xF0, 0x24, 0x19, 0x84,
  0x23, 0x0C, 0x81, 0x20, 0x50, 0x0C, 0x03, 0x01, 0xC0, 0x50, 0x12, 0x08,
  0x82, 0x31, 0x84, 0x41, 0xB0, 0x28, 0x0C, 0x40, 0x28, 0x05, 0x01, 0xB0,
  0x22, 0x04, 0x40, 0x88, 0x31, 0x84, 0x10, 0x82, 0x10, 0x46, 0x0C, 0x80,
  0x90, 0x12, 0x02, 0xC0, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x03, 0xC0, 0x00, 0xFE, 0xFE, 0x02,
  0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60,
  0x40, 0x40, 0xC0, 0xFF, 0x07, 0x86, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x81, 0xC1, 0x80, 0x30, 0x08,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0x80, 0x3C, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x30, 0x18, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x06, 0x03,
  0x0C, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x18,
  0x10, 0xF0, 0x80, 0x78, 0x1C, 0x61, 0x81, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 25, 7, 2, -25 },
  { 11, 7, 9, 11, 2, -25 },
  { 19, 13, 25, 15, 1, -25 },
  { 60, 12, 29, 14, 1, -27 },
  { 104, 17, 25, 21, 2, -25 },
  { 158, 13, 25, 14, 1, -25 },
  { 199, 2, 9, 6, 2, -25 },
  { 202, 6, 31, 9, 2, -25 },
  { 226, 7, 31, 9, 1, -25 },
  { 254, 10, 10, 12, 1, -27 },
  { 267, 12, 16, 14, 1, -20 },
  { 291, 4, 9, 7, 1, -4 },
  { 296, 7, 1, 9, 1, -10 },
  { 297, 2, 3, 7, 2, -3 },
  { 298, 10, 25, 12, 1, -25 },
  { 330, 10, 25, 14, 2, -25 },
  { 362, 6, 25, 14, 3, -25 },
  { 381, 11, 25, 14, 1, -25 },
  { 416, 11, 25, 14, 1, -25 },
  { 451, 13, 25, 14, 1, -25 },
  { 492, 11, 25, 14, 2, -25 },
  { 527, 11, 25, 14, 2, -25 },
  { 562, 11, 25, 14, 1, -25 },
  { 597, 12, 25, 14, 1, -25 },
  { 635, 11, 25, 14, 1, -25 },
  { 670, 2, 19, 7, 2, -19 },
  { 675, 4, 24, 7, 1, -19 },
  { 687, 12, 15, 14, 1, -20 },
  { 710, 12, 9, 14, 1, -17 },
  { 724, 12, 15, 14, 1, -20 },
  { 747, 8, 25, 10, 1, -25 },
  { 772, 18, 28, 21, 2, -25 },
  { 835, 14, 25, 14, 0, -25 },
  { 879, 11, 25, 15, 3, -25 },
  { 914, 12, 25, 15, 2, -25 },
  { 952, 12, 25, 17, 3, -25 },
  { 990, 9, 25, 13, 3, -25 },
  { 1019, 9, 25, 13, 3, -25 },
  { 1048, 14, 25, 18, 2, -25 },
  { 1092, 12, 25, 17, 3, -25 },
  { 1130, 6, 25, 8, 1, -25 },
  { 1149, 6, 31, 7, -2, -25 },
  { 1173, 11, 25, 14, 3, -25 },
  { 1208, 9, 25, 12, 3, -25 },
  { 1237, 18, 25, 23, 3, -25 },
  { 1294, 12, 25, 18, 3, -25 },
  { 1332, 14, 25, 18, 2, -25 },
  { 1376, 10, 25, 14, 3, -25 },
  { 1408, 14, 31, 18, 2, -25 },
  { 1463, 11, 25, 15, 3, -25 },
  { 1498, 11, 25, 14, 1, -25 },
  { 1533, 12, 25, 12, 0, -25 },
  { 1571, 13, 25, 17, 2, -25 },
  { 1612, 13, 25, 13, 0, -25 },
  { 1653, 23, 25, 23, 0, -25 },
  { 1725, 12, 25, 12, 0, -25 },
  { 1763, 12, 25, 12, 0, -25 },
  { 1801, 10, 25, 12, 1, -25 },
  { 1833, 7, 31, 11, 3, -25 },
  { 1861, 10, 25, 12, 1, -25 },
  { 1893, 7, 31, 11, 1, -25 },
  { 1921, 13, 12, 14, 1, -25 },
  { 1941, 14, 1, 14, 0, 3 },
  { 1943, 6, 6, 8, 1, -27 },
  { 1948, 10, 19, 13, 1, -19 },
  { 1972, 12, 27, 15, 2, -27 },
  { 2013, 9, 19, 11, 2, -19 },
  { 2035, 11, 27, 15, 2, -27 },
  { 2073, 10, 19, 14, 2, -19 },
  { 2097, 9, 27, 8, 0, -27 },
  { 2128, 11, 27, 15, 2, -19 },
  { 2166, 10, 27, 15, 2, -27 },
  { 2200, 2, 25, 6, 2, -25 },
  { 2207, 4, 33, 6, 0, -25 },
  { 2224, 10, 27, 12, 2, -27 },
  { 2258, 2, 27, 6, 2, -27 },
  { 2265, 17, 19, 22, 2, -19 },
  { 2306, 10, 19, 15, 2, -19 },
  { 2330, 11, 19, 14, 2, -19 },
  { 2357, 12, 27, 15, 2, -19 },
  { 2398, 11, 27, 15, 2, -19 },
  { 2436, 7, 19, 9, 2, -19 },
  { 2453, 9, 19, 11, 1, -19 },
  { 2475, 6, 23, 8, 1, -23 },
  { 2493, 10, 19, 15, 2, -19 },
  { 2517, 11, 19, 11, 0, -19 },
  { 2544, 18, 19, 19, 0, -19 },
  { 2587, 10, 19, 11, 1, -19 },
  { 2611, 11, 27, 11, 0, -19 },
  { 2649, 8, 19, 9, 1, -19 },
  { 2668, 9, 31, 12, 2, -25 },
  { 2703, 1, 35, 13, 6, -27 },
  { 2708, 8, 31, 12, 2, -25 },
  { 2739, 12, 3, 14, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT35PT7B_H_
