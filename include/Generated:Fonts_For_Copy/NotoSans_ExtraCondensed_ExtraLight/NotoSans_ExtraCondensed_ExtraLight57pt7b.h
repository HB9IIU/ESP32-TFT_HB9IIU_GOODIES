#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight57pt7bBitmaps[] PROGMEM = {
  0x00, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0x10, 0x18, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x40, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x40, 0x03,
  0x01, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xC0, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x02, 0x01,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x02, 0x00,
  0x18, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xF0, 0x39, 0x8F, 0x0E, 0x30, 0x23, 0x86, 0x00, 0x60, 0xC0,
  0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x0E, 0x18, 0x00, 0xC3, 0x00,
  0x0E, 0x60, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0xDE, 0x00, 0x18, 0xE0, 0x03, 0x0E, 0x00, 0x60, 0xE0, 0x0C, 0x0C,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x60, 0x0C, 0x0D, 0x01, 0x83, 0x38, 0x31, 0xC7,
  0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x0C, 0x03, 0xB8, 0x01, 0x80,
  0x61, 0x80, 0x18, 0x06, 0x0C, 0x01, 0x00, 0xC0, 0xC0, 0x30, 0x0C, 0x0C,
  0x03, 0x00, 0xC0, 0x60, 0x20, 0x0C, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x60,
  0x0C, 0x06, 0x04, 0x00, 0x80, 0x60, 0xC0, 0x08, 0x06, 0x0C, 0x00, 0x80,
  0x60, 0xC0, 0x08, 0x06, 0x18, 0x00, 0x80, 0x61, 0x80, 0x0C, 0x06, 0x18,
  0x00, 0xC0, 0x63, 0x0F, 0x0C, 0x06, 0x31, 0xFC, 0xC0, 0x63, 0x18, 0xCC,
  0x0C, 0x63, 0x06, 0xC0, 0xC6, 0x30, 0x66, 0x0C, 0x66, 0x02, 0x61, 0x8C,
  0x60, 0x33, 0xF8, 0xC6, 0x03, 0x1F, 0x0C, 0x60, 0x30, 0x01, 0x86, 0x03,
  0x00, 0x18, 0x60, 0x30, 0x01, 0x86, 0x03, 0x00, 0x30, 0x60, 0x30, 0x03,
  0x06, 0x03, 0x00, 0x30, 0x60, 0x30, 0x06, 0x06, 0x03, 0x00, 0x60, 0x60,
  0x30, 0x06, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0x20, 0x60, 0x18, 0x03, 0x06, 0x01, 0x80, 0x30, 0x60, 0x18, 0x01,
  0x8C, 0x03, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x20, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00,
  0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x30, 0x18, 0x00, 0xC1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x00,
  0xC6, 0x00, 0x06, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x0E, 0x60, 0x00, 0xE3, 0x00, 0x06, 0x0C, 0x06, 0x60,
  0x70, 0x33, 0x01, 0x81, 0xB8, 0x06, 0x0D, 0x80, 0x30, 0xCC, 0x00, 0xC6,
  0x60, 0x06, 0x33, 0x00, 0x19, 0x98, 0x00, 0xF8, 0xC0, 0x03, 0xC6, 0x00,
  0x1C, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x86, 0x00, 0x7E, 0x38, 0x07, 0x30,
  0xE0, 0x71, 0xC3, 0xDF, 0x06, 0x0F, 0xF0, 0x38, 0x18, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01,
  0x80, 0x30, 0x0C, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x81, 0x71, 0x8E, 0xFD, 0xBF, 0x07,
  0xE0, 0x01, 0x80, 0x03, 0xC0, 0x06, 0x60, 0x0C, 0x30, 0x1C, 0x18, 0x18,
  0x1C, 0x30, 0x08, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x73, 0x18,
  0xCC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x07, 0x03, 0x01, 0x83, 0x00, 0x61,
  0x80, 0x31, 0x80, 0x1C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0xB8, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x01, 0x9C, 0x00, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0xC0, 0x60, 0x70, 0x70,
  0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x1F, 0x0E, 0xC7,
  0x33, 0x8F, 0xC3, 0x40, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x0F, 0xF0, 0x0F,
  0xFF, 0x07, 0x80, 0xE0, 0x80, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0x07, 0x00,
  0xE3, 0x80, 0x1C, 0x40, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xCC, 0x00, 0xE3, 0xF9, 0xF0,
  0x3F, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0x6C, 0x00,
  0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0xE1, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x08, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x73, 0x00, 0x71, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0x00, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0x81, 0xE0, 0x41, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC3, 0xF0, 0x63,
  0xFE, 0x33, 0x07, 0x9B, 0x00, 0xCF, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0xEC, 0x00, 0x63, 0x00, 0x31, 0x80, 0x38, 0x60, 0x38, 0x3C, 0x78,
  0x07, 0xF8, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x70, 0x1C, 0x1C, 0x01, 0xC3,
  0x00, 0x18, 0xE0, 0x03, 0x18, 0x00, 0x73, 0x00, 0x06, 0x60, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x03, 0x38, 0x00, 0xE3, 0x00, 0x18, 0x60, 0x03, 0x06,
  0x00, 0xE0, 0xE0, 0x38, 0x0E, 0x0E, 0x00, 0xE3, 0x80, 0x0F, 0xC0, 0x00,
  0x70, 0x00, 0x3F, 0x00, 0x0E, 0x38, 0x03, 0x03, 0x80, 0xC0, 0x38, 0x30,
  0x03, 0x8E, 0x00, 0x31, 0x80, 0x07, 0x30, 0x00, 0x6C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x03, 0x30, 0x00, 0x67, 0x00, 0x1C, 0x60, 0x07, 0x0F, 0x01, 0xC0, 0xF8,
  0xF0, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0,
  0xE0, 0xE0, 0x18, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x39, 0x80, 0x06,
  0x60, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00,
  0x1D, 0x80, 0x07, 0x70, 0x02, 0xCC, 0x01, 0xB1, 0x80, 0xCC, 0x7F, 0xF3,
  0x07, 0xF0, 0xC0, 0x20, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xE7, 0xC0,
  0x3F, 0xE0, 0x01, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x38, 0xE3, 0x8E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0x86, 0x18, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x00, 0x3F, 0x87, 0xFF, 0x30, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x0C,
  0x60, 0x00, 0x00, 0x63, 0x00, 0x7F, 0x03, 0x30, 0x0F, 0x38, 0x19, 0x80,
  0x60, 0xC0, 0x6C, 0x06, 0x06, 0x03, 0x60, 0x30, 0x30, 0x1E, 0x03, 0x01,
  0x80, 0xF0, 0x18, 0x0C, 0x07, 0x80, 0xC0, 0x60, 0x3C, 0x04, 0x03, 0x01,
  0xE0, 0x60, 0x18, 0x0F, 0x03, 0x00, 0xC0, 0x78, 0x18, 0x06, 0x03, 0xC0,
  0xC0, 0x70, 0x1E, 0x06, 0x03, 0x80, 0xF0, 0x30, 0x1C, 0x07, 0x81, 0x80,
  0xE0, 0x3C, 0x06, 0x07, 0x03, 0x60, 0x30, 0x38, 0x1B, 0x01, 0x83, 0xC0,
  0xCC, 0x0E, 0x12, 0x0C, 0x60, 0x39, 0x9C, 0xE3, 0x00, 0xF8, 0x7E, 0x18,
  0x03, 0x00, 0x80, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x02, 0x00, 0x07, 0x80, 0x30, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x03, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x18,
  0x60, 0x00, 0x61, 0x80, 0x01, 0x87, 0x00, 0x06, 0x0C, 0x00, 0x30, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x60, 0x18, 0x01,
  0x80, 0x60, 0x06, 0x01, 0x80, 0x18, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x00,
  0x30, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x60, 0x01, 0xC1, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x60, 0x00,
  0x19, 0x80, 0x00, 0x76, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0C,
  0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0x81, 0xF8, 0x70, 0x03, 0x8E, 0x00, 0x39,
  0xC0, 0x03, 0x38, 0x00, 0x77, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1B,
  0x80, 0x03, 0x70, 0x00, 0x6E, 0x00, 0x0D, 0xC0, 0x03, 0xB8, 0x00, 0x67,
  0x00, 0x0C, 0xE0, 0x03, 0x1C, 0x00, 0xE3, 0x80, 0xF8, 0x7F, 0xF8, 0x0F,
  0xFF, 0xE1, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xDC,
  0x00, 0x1B, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80, 0x03, 0x70,
  0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x38, 0x03, 0xC7, 0xFF, 0xF0, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xC0, 0x60, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x20, 0x1F, 0x9E, 0x00, 0x7F, 0xE0, 0x00, 0x40, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0xE0, 0x7E, 0x0E, 0x00, 0xF0, 0xE0, 0x03, 0x8E,
  0x00, 0x18, 0xE0, 0x01, 0xCE, 0x00, 0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x06,
  0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0C,
  0xE0, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x3E,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xE0,
  0x1E, 0x07, 0x80, 0x06, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x03, 0x70, 0x00,
  0x03, 0x30, 0x00, 0x03, 0x30, 0x00, 0x03, 0x38, 0x00, 0x03, 0x18, 0x00,
  0x03, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x03, 0x07, 0x00, 0x03, 0x03, 0xC0,
  0x07, 0x01, 0xFD, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x02, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x30, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0xBF, 0xCF, 0xE0, 0xE0, 0x01, 0xF8, 0x00,
  0x6E, 0x00, 0x3B, 0x80, 0x0C, 0xE0, 0x06, 0x38, 0x03, 0x8E, 0x00, 0xC3,
  0x80, 0x70, 0xE0, 0x18, 0x38, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xE0,
  0xE0, 0x38, 0x30, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x00, 0x39, 0xC0,
  0x0E, 0x60, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3E, 0x60, 0x0F, 0x18, 0x03,
  0xC3, 0x00, 0xE0, 0xC0, 0x38, 0x18, 0x0E, 0x06, 0x03, 0x80, 0xC0, 0xE0,
  0x30, 0x38, 0x06, 0x0E, 0x01, 0x83, 0x80, 0x70, 0xE0, 0x0C, 0x38, 0x03,
  0x8E, 0x00, 0x63, 0x80, 0x1C, 0xE0, 0x03, 0x38, 0x00, 0xEE, 0x00, 0x1B,
  0x80, 0x07, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xD8, 0x00, 0x00, 0x7F, 0x60, 0x00, 0x01, 0xFD, 0x80, 0x00, 0x0F,
  0xF3, 0x00, 0x00, 0x37, 0xEC, 0x00, 0x00, 0xDF, 0xB0, 0x00, 0x03, 0x7E,
  0x60, 0x00, 0x19, 0xF9, 0x80, 0x00, 0x67, 0xE6, 0x00, 0x01, 0x9F, 0x98,
  0x00, 0x0E, 0x7E, 0x30, 0x00, 0x31, 0xF8, 0xC0, 0x00, 0xC7, 0xE3, 0x00,
  0x07, 0x1F, 0x86, 0x00, 0x18, 0x7E, 0x18, 0x00, 0x61, 0xF8, 0x60, 0x01,
  0x87, 0xE1, 0xC0, 0x0C, 0x1F, 0x83, 0x00, 0x30, 0x7E, 0x0C, 0x00, 0xC1,
  0xF8, 0x30, 0x06, 0x07, 0xE0, 0x60, 0x18, 0x1F, 0x81, 0x80, 0x60, 0x7E,
  0x06, 0x03, 0x81, 0xF8, 0x0C, 0x0C, 0x07, 0xE0, 0x30, 0x30, 0x1F, 0x80,
  0xC0, 0xC0, 0x7E, 0x03, 0x86, 0x01, 0xF8, 0x06, 0x18, 0x07, 0xE0, 0x18,
  0x60, 0x1F, 0x80, 0x63, 0x00, 0x7E, 0x00, 0xCC, 0x01, 0xF8, 0x03, 0x30,
  0x07, 0xE0, 0x0D, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01,
  0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x1C, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3D, 0x80, 0x01, 0xEC, 0x00, 0x0F,
  0x30, 0x00, 0x79, 0x80, 0x03, 0xEE, 0x00, 0x1F, 0x30, 0x00, 0xF9, 0x80,
  0x07, 0xC6, 0x00, 0x3E, 0x30, 0x01, 0xF0, 0xC0, 0x0F, 0x86, 0x00, 0x7C,
  0x38, 0x03, 0xE0, 0xC0, 0x1F, 0x07, 0x00, 0xF8, 0x18, 0x07, 0xC0, 0xC0,
  0x3E, 0x03, 0x01, 0xF0, 0x18, 0x0F, 0x80, 0x60, 0x7C, 0x03, 0x03, 0xE0,
  0x1C, 0x1F, 0x00, 0x60, 0xF8, 0x03, 0x07, 0xC0, 0x0C, 0x3E, 0x00, 0x61,
  0xF0, 0x01, 0x8F, 0x80, 0x0C, 0x7C, 0x00, 0x73, 0xE0, 0x01, 0x9F, 0x00,
  0x0E, 0xF8, 0x00, 0x37, 0xC0, 0x01, 0xBE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x18,
  0x00, 0x38, 0x38, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x60,
  0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x06, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x0E, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x0C, 0x30,
  0x00, 0x0C, 0x38, 0x00, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x38, 0x3F, 0x1C, 0x01, 0xCE, 0x00,
  0x77, 0x00, 0x1B, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0xEE, 0x00, 0xE7, 0x01,
  0xE3, 0xFF, 0xE1, 0xFF, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x18, 0x00, 0x38,
  0x38, 0x00, 0x18, 0x30, 0x00, 0x1C, 0x30, 0x00, 0x0C, 0x70, 0x00, 0x0C,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06,
  0x60, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C,
  0x38, 0x00, 0x18, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x30, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0x83, 0xF0, 0x70, 0x07,
  0x0E, 0x00, 0x71, 0xC0, 0x06, 0x38, 0x00, 0xE7, 0x00, 0x0C, 0xE0, 0x01,
  0x9C, 0x00, 0x33, 0x80, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x19, 0xC0, 0x03,
  0x38, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x03, 0x9C, 0x00, 0x63, 0x80, 0x1C,
  0x70, 0x07, 0x0E, 0x03, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0x07, 0x00,
  0xE0, 0x60, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x01, 0x81,
  0xC0, 0x30, 0x38, 0x07, 0x07, 0x00, 0x60, 0xE0, 0x0E, 0x1C, 0x00, 0xC3,
  0x80, 0x1C, 0x70, 0x01, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0x38, 0x00, 0x67,
  0x00, 0x0E, 0xE0, 0x00, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0xF1, 0xE0, 0x18,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xCC, 0x00, 0xE3, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x06,
  0x70, 0x00, 0xE3, 0x80, 0x1C, 0x1C, 0x03, 0x80, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x07, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x66, 0x00, 0x01, 0x98,
  0x00, 0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x30, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x80, 0x06, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x60, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x60, 0x06, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x60, 0x30, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0x80, 0x01, 0x86, 0x00, 0x06,
  0x18, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x30,
  0x00, 0x0C, 0xC0, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1B, 0x00, 0x03, 0x80, 0x00, 0xD8, 0x00, 0x1C, 0x00, 0x06, 0xC0, 0x00,
  0xE0, 0x00, 0x76, 0x00, 0x07, 0x80, 0x03, 0xB8, 0x00, 0x3C, 0x00, 0x18,
  0xC0, 0x03, 0x60, 0x00, 0xC6, 0x00, 0x1B, 0x00, 0x06, 0x30, 0x00, 0xD8,
  0x00, 0x71, 0x80, 0x06, 0x60, 0x03, 0x0E, 0x00, 0x33, 0x00, 0x18, 0x30,
  0x01, 0x98, 0x00, 0xC1, 0x80, 0x18, 0xC0, 0x06, 0x0C, 0x00, 0xC6, 0x00,
  0x70, 0x70, 0x06, 0x18, 0x03, 0x03, 0x80, 0x30, 0xC0, 0x18, 0x0C, 0x01,
  0x86, 0x00, 0xC0, 0x60, 0x18, 0x30, 0x0E, 0x03, 0x00, 0xC1, 0x80, 0x70,
  0x1C, 0x06, 0x06, 0x03, 0x00, 0x60, 0x30, 0x30, 0x18, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0x18, 0x18, 0x0C, 0x0E, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x07,
  0x06, 0x01, 0x83, 0x00, 0x18, 0x30, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x60,
  0xC0, 0x06, 0x18, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x18, 0x60, 0x01, 0xC6,
  0x00, 0x63, 0x00, 0x06, 0x30, 0x03, 0x18, 0x00, 0x31, 0x80, 0x19, 0xC0,
  0x01, 0x98, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x06, 0x60, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x60, 0x00, 0xDC, 0x00, 0x73, 0x00,
  0x18, 0xC0, 0x06, 0x38, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x70, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x03, 0x80, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x18, 0x00,
  0xC6, 0x00, 0x33, 0x80, 0x0E, 0xC0, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x06, 0xC0,
  0x03, 0x30, 0x00, 0xCE, 0x00, 0x71, 0x80, 0x18, 0x60, 0x06, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x70, 0x18, 0x18, 0x06, 0x06, 0x01, 0x83, 0x00,
  0x30, 0xC0, 0x0C, 0x70, 0x03, 0x98, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x07,
  0xC0, 0x00, 0xC0, 0xC0, 0x00, 0x7C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00,
  0x67, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00, 0x61, 0xC0, 0x18, 0x18, 0x03,
  0x03, 0x00, 0x60, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x1C, 0x18,
  0x01, 0x83, 0x00, 0x30, 0x60, 0x07, 0x18, 0x00, 0x63, 0x00, 0x0C, 0x60,
  0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFC,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0D, 0xC0, 0x00, 0xE6, 0x00, 0x06, 0x38, 0x00, 0x70, 0xC0, 0x03, 0x07,
  0x00, 0x38, 0x18, 0x01, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x0E,
  0x00, 0x60, 0x60, 0x03, 0x07, 0x00, 0x0C, 0x30, 0x00, 0x63, 0x80, 0x01,
  0x98, 0x00, 0x0D, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x01,
  0xE0, 0x1F, 0xF8, 0x3C, 0x3C, 0x10, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x01, 0xFF, 0x0F, 0xC7, 0x1C, 0x07, 0x38, 0x07, 0x70,
  0x07, 0x60, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x60, 0x0B, 0x60, 0x0B, 0x70, 0x13, 0x3C, 0x73, 0x1F,
  0xE3, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0xE0, 0x31, 0xFF, 0x0C, 0xF1,
  0xE3, 0x60, 0x1C, 0xD8, 0x03, 0x3C, 0x00, 0xEE, 0x00, 0x1B, 0x80, 0x06,
  0xE0, 0x01, 0xB8, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x06,
  0xE0, 0x01, 0xB8, 0x00, 0xEF, 0x00, 0x33, 0x60, 0x1C, 0xCC, 0x0E, 0x33,
  0xCF, 0x0C, 0x7F, 0x80, 0x01, 0x00, 0x00, 0xE0, 0x1F, 0xF0, 0xF0, 0xC7,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3E, 0xF0, 0x7F,
  0xC0, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0xC3, 0xFC, 0x31, 0xE3, 0xCC,
  0xE0, 0x33, 0x30, 0x06, 0xDC, 0x00, 0xB6, 0x00, 0x3D, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xD8, 0x00, 0xF7, 0x00, 0x2C, 0xC0, 0x1B, 0x38, 0x0C, 0xC7, 0xCE,
  0x30, 0xFF, 0x0C, 0x02, 0x00, 0x01, 0xC0, 0x07, 0xF8, 0x07, 0x8E, 0x07,
  0x01, 0x83, 0x00, 0x63, 0x80, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x7C, 0xF8, 0x1F, 0xF0, 0x00,
  0x80, 0x00, 0x40, 0x1F, 0xC1, 0xE4, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x03,
  0xFF, 0x1F, 0xF8, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x03, 0xFE, 0x31, 0xE3, 0xCC, 0xE0, 0x33, 0x30, 0x06,
  0xDC, 0x00, 0xB6, 0x00, 0x3D, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03, 0xD8, 0x00, 0xB6,
  0x00, 0x2C, 0xC0, 0x1F, 0x38, 0x0D, 0xC7, 0xDE, 0x70, 0xFF, 0x1C, 0x02,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x10, 0x03, 0x87,
  0x83, 0xC1, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC1, 0xE0, 0xC7, 0xF8, 0xCF,
  0x3C, 0xDC, 0x0E, 0xD8, 0x06, 0xF0, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xC0, 0x0E, 0x1C, 0x38, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xEB, 0x9F,
  0x38, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x01, 0xB0, 0x06, 0x60, 0x1C, 0xC0, 0x31, 0x80, 0xC3,
  0x01, 0x86, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0xC0, 0x63, 0x80, 0xC6,
  0x01, 0x9E, 0x03, 0x3C, 0x06, 0xDC, 0x0D, 0x18, 0x1E, 0x30, 0x38, 0x30,
  0x60, 0x60, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0xC6, 0x01, 0x8C, 0x03, 0x18,
  0x03, 0x30, 0x06, 0x60, 0x0E, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0,
  0x0E, 0x0C, 0x7F, 0x07, 0xF8, 0xCE, 0x38, 0xE3, 0xCD, 0x81, 0xCC, 0x0E,
  0xD0, 0x0D, 0x80, 0x6E, 0x00, 0xD0, 0x06, 0xE0, 0x0F, 0x00, 0x6E, 0x00,
  0x60, 0x07, 0xC0, 0x06, 0x00, 0x7C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00,
  0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0,
  0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xE0, 0xC7, 0xF8, 0xCE, 0x3C, 0xDC, 0x0E, 0xD8, 0x06, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x01, 0xC0, 0x03, 0xFE, 0x01, 0xE3, 0xC0, 0xE0, 0x38, 0x30, 0x07,
  0x18, 0x00, 0xC6, 0x00, 0x3B, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x01, 0x98, 0x00, 0xE7,
  0x00, 0x30, 0xC0, 0x1C, 0x18, 0x0E, 0x07, 0xCF, 0x00, 0x7F, 0x80, 0x06,
  0x00, 0x00, 0xE0, 0x31, 0xFF, 0x0C, 0xF1, 0xE3, 0x30, 0x18, 0xD8, 0x03,
  0x34, 0x00, 0xEF, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xBC, 0x00, 0xED,
  0x00, 0x33, 0x60, 0x1C, 0xCC, 0x0E, 0x33, 0xCF, 0x0C, 0x3F, 0x83, 0x01,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x03, 0xFE, 0x31, 0xE3, 0xCC, 0xE0,
  0x33, 0x30, 0x06, 0xDC, 0x00, 0xB6, 0x00, 0x3D, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x60, 0x01,
  0xD8, 0x00, 0xB7, 0x00, 0x2C, 0xC0, 0x1B, 0x38, 0x0D, 0xC7, 0xDE, 0x70,
  0xFF, 0x1C, 0x02, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x98, 0xFF, 0x3F, 0xE6,
  0x0D, 0x81, 0xA0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x00, 0x03, 0xC0, 0x7F, 0xE3, 0xC3, 0xDC, 0x01, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xE0, 0x06, 0xC0, 0x3B, 0xF7, 0xC7, 0xFE, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x07, 0xFF, 0xFF, 0xE3, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x07, 0x30,
  0x7E, 0x03, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0B, 0x60, 0x1B, 0x70, 0x33, 0x3D,
  0xF3, 0x1F, 0xC3, 0x02, 0x00, 0xE0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xEC,
  0x00, 0x67, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0C, 0x30, 0x06,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x01, 0xC1, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x38, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC7, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x60, 0x01, 0xB0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x07, 0x00,
  0x3E, 0x00, 0x38, 0x01, 0xB0, 0x01, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x66,
  0x00, 0xD0, 0x03, 0x30, 0x06, 0xC0, 0x31, 0x80, 0x36, 0x01, 0x8C, 0x03,
  0x30, 0x0C, 0x70, 0x19, 0x80, 0x61, 0x80, 0xC6, 0x03, 0x0C, 0x06, 0x30,
  0x30, 0x60, 0x31, 0x81, 0x83, 0x03, 0x0C, 0x0C, 0x0C, 0x18, 0x60, 0x60,
  0x60, 0xC1, 0x87, 0x03, 0x06, 0x0C, 0x30, 0x18, 0x70, 0x61, 0x80, 0xE3,
  0x03, 0x0C, 0x03, 0x18, 0x18, 0x60, 0x18, 0xC0, 0x66, 0x00, 0xC6, 0x03,
  0x30, 0x06, 0x60, 0x19, 0x80, 0x1B, 0x00, 0xCC, 0x00, 0xD8, 0x06, 0x60,
  0x06, 0xC0, 0x1E, 0x00, 0x36, 0x00, 0xF0, 0x01, 0xA0, 0x07, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x03,
  0x38, 0x03, 0x8C, 0x01, 0x86, 0x01, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0x30,
  0x60, 0x18, 0x30, 0x0E, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0x6C, 0x00,
  0x3E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xE0, 0x01, 0xB0,
  0x01, 0x98, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x60, 0xC0, 0x70, 0x60, 0x30,
  0x38, 0x38, 0x0C, 0x18, 0x07, 0x0C, 0x01, 0x8C, 0x00, 0xE6, 0x00, 0x36,
  0x00, 0x1C, 0xC0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x31, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x0C, 0x03, 0x06,
  0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x60, 0x18, 0x30,
  0x0C, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x19,
  0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x00, 0xB0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x5E, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x03,
  0xF0, 0x1E, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x07, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFC, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0x7C,
  0x01, 0xF0, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0xFC, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0xF0,
  0x07, 0x87, 0x81, 0xC0, 0x3F, 0xF8, 0x01, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 41, 12, 4, -41 },
  { 22, 10, 15, 18, 4, -41 },
  { 41, 23, 41, 25, 1, -41 },
  { 159, 19, 46, 23, 2, -43 },
  { 269, 28, 42, 34, 3, -41 },
  { 416, 21, 42, 23, 2, -41 },
  { 527, 2, 15, 10, 4, -41 },
  { 531, 10, 50, 15, 3, -41 },
  { 594, 10, 50, 15, 2, -41 },
  { 657, 16, 15, 20, 2, -43 },
  { 687, 19, 26, 23, 2, -33 },
  { 749, 5, 13, 11, 2, -6 },
  { 758, 13, 3, 15, 1, -17 },
  { 763, 3, 4, 11, 4, -4 },
  { 765, 17, 41, 19, 1, -41 },
  { 853, 17, 41, 23, 3, -41 },
  { 941, 10, 41, 23, 4, -41 },
  { 993, 18, 41, 23, 2, -41 },
  { 1086, 18, 42, 23, 2, -41 },
  { 1181, 21, 41, 23, 1, -41 },
  { 1289, 17, 42, 23, 3, -41 },
  { 1379, 17, 42, 23, 3, -41 },
  { 1469, 18, 41, 23, 2, -41 },
  { 1562, 19, 42, 23, 2, -41 },
  { 1662, 18, 42, 23, 2, -41 },
  { 1757, 3, 30, 11, 4, -30 },
  { 1769, 6, 37, 11, 2, -30 },
  { 1797, 19, 24, 23, 2, -32 },
  { 1854, 19, 14, 23, 2, -27 },
  { 1888, 19, 24, 23, 2, -32 },
  { 1945, 13, 41, 16, 1, -41 },
  { 2012, 29, 46, 35, 3, -41 },
  { 2179, 22, 41, 22, 0, -41 },
  { 2292, 19, 41, 25, 4, -41 },
  { 2390, 20, 42, 24, 3, -41 },
  { 2495, 20, 41, 27, 4, -41 },
  { 2598, 15, 41, 22, 4, -41 },
  { 2675, 15, 41, 20, 4, -41 },
  { 2752, 24, 42, 30, 3, -41 },
  { 2878, 20, 41, 28, 4, -41 },
  { 2981, 9, 41, 13, 2, -41 },
  { 3028, 10, 51, 11, -3, -41 },
  { 3092, 18, 41, 22, 4, -41 },
  { 3185, 15, 41, 20, 4, -41 },
  { 3262, 30, 41, 38, 4, -41 },
  { 3416, 21, 41, 29, 4, -41 },
  { 3524, 24, 42, 30, 3, -41 },
  { 3650, 17, 41, 23, 4, -41 },
  { 3738, 24, 51, 30, 3, -41 },
  { 3891, 19, 41, 24, 4, -41 },
  { 3989, 18, 42, 22, 2, -41 },
  { 4084, 19, 41, 20, 0, -41 },
  { 4182, 20, 42, 28, 4, -41 },
  { 4287, 22, 41, 22, 0, -41 },
  { 4400, 37, 41, 38, 0, -41 },
  { 4590, 18, 41, 20, 1, -41 },
  { 4683, 19, 41, 19, 0, -41 },
  { 4781, 16, 41, 19, 2, -41 },
  { 4863, 11, 50, 18, 5, -41 },
  { 4932, 17, 41, 19, 1, -41 },
  { 5020, 11, 50, 18, 2, -41 },
  { 5089, 21, 20, 23, 1, -41 },
  { 5142, 23, 2, 23, 0, 5 },
  { 5148, 9, 9, 13, 2, -44 },
  { 5159, 16, 32, 21, 2, -31 },
  { 5223, 18, 44, 25, 4, -43 },
  { 5322, 14, 32, 18, 3, -31 },
  { 5378, 18, 44, 25, 3, -43 },
  { 5477, 17, 32, 22, 3, -31 },
  { 5545, 13, 44, 13, 1, -44 },
  { 5617, 18, 45, 25, 3, -31 },
  { 5719, 16, 43, 24, 4, -43 },
  { 5805, 3, 41, 10, 4, -41 },
  { 5821, 7, 55, 10, 0, -41 },
  { 5870, 15, 43, 19, 4, -43 },
  { 5951, 2, 43, 10, 4, -43 },
  { 5962, 28, 31, 36, 4, -31 },
  { 6071, 16, 31, 24, 4, -31 },
  { 6133, 18, 32, 23, 3, -31 },
  { 6205, 18, 44, 25, 4, -31 },
  { 6304, 18, 44, 25, 3, -31 },
  { 6403, 11, 31, 15, 4, -31 },
  { 6446, 14, 32, 18, 2, -31 },
  { 6502, 11, 38, 12, 1, -37 },
  { 6555, 16, 31, 24, 4, -30 },
  { 6617, 17, 30, 18, 0, -30 },
  { 6681, 29, 30, 30, 1, -30 },
  { 6790, 17, 30, 19, 1, -30 },
  { 6854, 17, 44, 19, 1, -30 },
  { 6948, 12, 30, 15, 2, -30 },
  { 6993, 14, 50, 20, 3, -41 },
  { 7081, 2, 57, 22, 10, -43 },
  { 7096, 14, 50, 20, 3, -41 },
  { 7184, 19, 5, 23, 2, -23 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT57PT7B_H_
