#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT16PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x24, 0x48, 0xA3, 0xF2, 0x85, 0x0A, 0x6E,
  0x48, 0x91, 0x20, 0x27, 0xA9, 0x4A, 0x70, 0xC5, 0x29, 0x6E, 0xC2, 0x00,
  0x40, 0xA4, 0xA8, 0xA8, 0xA8, 0xB6, 0xB9, 0x59, 0x29, 0x29, 0x29, 0x46,
  0x21, 0x44, 0x92, 0x30, 0x85, 0x15, 0x8E, 0x38, 0xDD, 0xF0, 0x6A, 0x49,
  0x24, 0x92, 0x24, 0x40, 0x95, 0x55, 0x55, 0xA0, 0x4F, 0x4A, 0x10, 0x41,
  0x3F, 0x10, 0x41, 0x00, 0xF0, 0xF0, 0x80, 0x08, 0x44, 0x21, 0x10, 0x88,
  0x42, 0x20, 0x64, 0xA5, 0x18, 0xC6, 0x31, 0x8C, 0x64, 0xE0, 0x74, 0x92,
  0x49, 0x24, 0x80, 0x64, 0x82, 0x11, 0x08, 0x44, 0x22, 0x21, 0xF0, 0x64,
  0x82, 0x11, 0x09, 0xC1, 0x08, 0x43, 0xE0, 0x08, 0x61, 0x8A, 0x29, 0x24,
  0xBF, 0x08, 0x20, 0x80, 0xF4, 0x21, 0x0E, 0x08, 0x21, 0x08, 0xBC, 0x32,
  0x21, 0x08, 0x7A, 0x31, 0x8C, 0x62, 0xE0, 0xF8, 0x84, 0x22, 0x10, 0x84,
  0x42, 0x10, 0x64, 0xA3, 0x19, 0x31, 0x92, 0x8C, 0x63, 0xE0, 0x64, 0xA5,
  0x18, 0xC6, 0x6D, 0x08, 0x85, 0xC0, 0xC0, 0x80, 0xC1, 0xE0, 0x04, 0x66,
  0x30, 0x30, 0x20, 0x40, 0xFC, 0x00, 0x3F, 0xC0, 0xC0, 0x81, 0x19, 0x88,
  0x00, 0x69, 0x11, 0x12, 0x24, 0x40, 0x04, 0x18, 0x26, 0x42, 0x81, 0x9D,
  0xA5, 0xA5, 0xA5, 0xA9, 0xBF, 0x80, 0x80, 0x7C, 0x10, 0xC3, 0x0A, 0x49,
  0x27, 0x91, 0x86, 0x18, 0x40, 0xFC, 0x63, 0x19, 0x76, 0x31, 0x8C, 0x7C,
  0x3A, 0x21, 0x08, 0x42, 0x10, 0x84, 0x10, 0x70, 0xFA, 0x28, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x2F, 0x00, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0xF0, 0xF8,
  0x88, 0x8F, 0x88, 0x88, 0x80, 0x1C, 0xC6, 0x04, 0x08, 0x10, 0x23, 0xC1,
  0x83, 0x05, 0x09, 0xF0, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18,
  0x40, 0xEA, 0xAA, 0xAC, 0x24, 0x92, 0x49, 0x24, 0x93, 0x80, 0x8C, 0xA5,
  0x4C, 0x72, 0x92, 0x94, 0x62, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81,
  0xC1, 0xC3, 0xC3, 0xA3, 0xA3, 0xA5, 0x95, 0x95, 0x99, 0x89, 0x87, 0x1C,
  0x69, 0xA6, 0x59, 0x63, 0x8E, 0x18, 0x40, 0x31, 0x28, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x5E, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x84, 0x20, 0x31,
  0x28, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5E, 0x08, 0x20, 0x40, 0xF4,
  0x63, 0x18, 0xFA, 0x92, 0x94, 0x62, 0x7C, 0x21, 0x08, 0x20, 0x82, 0x08,
  0x43, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x17, 0x80, 0x86, 0x18, 0x52, 0x49, 0x24, 0x8C,
  0x30, 0xC1, 0x00, 0x84, 0x70, 0x89, 0x31, 0x25, 0x24, 0xA4, 0x95, 0x14,
  0xA1, 0x94, 0x31, 0x86, 0x20, 0x84, 0x00, 0x4A, 0x54, 0x62, 0x10, 0xCA,
  0x4A, 0x62, 0x8C, 0x52, 0xA5, 0x10, 0x84, 0x21, 0x08, 0x78, 0x44, 0x22,
  0x10, 0x88, 0x42, 0x3E, 0xF2, 0x49, 0x24, 0x92, 0x49, 0xC0, 0xC2, 0x10,
  0x42, 0x10, 0x42, 0x10, 0x42, 0xE4, 0x92, 0x49, 0x24, 0x93, 0xC0, 0x10,
  0xA4, 0x91, 0x84, 0xFC, 0x90, 0x69, 0x11, 0x79, 0x99, 0xF0, 0x84, 0x21,
  0x6C, 0xC6, 0x31, 0x8C, 0x63, 0xE0, 0x78, 0x88, 0x88, 0x88, 0x70, 0x08,
  0x42, 0xD9, 0xC6, 0x31, 0x8C, 0x62, 0xF0, 0x69, 0x99, 0xF8, 0x88, 0x70,
  0x74, 0x4E, 0x44, 0x44, 0x44, 0x44, 0x64, 0xE3, 0x18, 0xC6, 0x31, 0x78,
  0x42, 0x1F, 0x00, 0x84, 0x21, 0x4D, 0x46, 0x31, 0x8C, 0x63, 0x10, 0xCF,
  0xF0, 0x50, 0x55, 0x55, 0x56, 0x88, 0x88, 0x9A, 0xCC, 0xAA, 0x99, 0xFF,
  0xF0, 0x66, 0x99, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x89, 0x36, 0x63,
  0x18, 0xC6, 0x31, 0x88, 0x64, 0xA3, 0x18, 0xC6, 0x31, 0x70, 0x36, 0x63,
  0x18, 0xC6, 0x31, 0xF4, 0x21, 0x08, 0x00, 0x64, 0xE3, 0x18, 0xC6, 0x31,
  0x78, 0x42, 0x10, 0x80, 0x3A, 0x49, 0x24, 0x80, 0x78, 0x88, 0x42, 0x11,
  0xE0, 0x4B, 0xA4, 0x92, 0x49, 0x80, 0x8C, 0x63, 0x18, 0xC6, 0x2F, 0x8C,
  0x54, 0xA5, 0x28, 0x84, 0x89, 0x99, 0x59, 0x55, 0x56, 0x66, 0x62, 0x22,
  0xCA, 0x8C, 0x42, 0x29, 0x51, 0x8A, 0x52, 0xA5, 0x18, 0x84, 0x21, 0x11,
  0x80, 0x72, 0x22, 0x44, 0x4F, 0x34, 0x44, 0x44, 0x84, 0x44, 0x44, 0x43,
  0xFF, 0xFF, 0xC4, 0x44, 0x44, 0x32, 0x44, 0x44, 0x48, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 7, 11, 7, 0, -11 },
  { 15, 5, 13, 6, 1, -12 },
  { 24, 8, 12, 9, 1, -12 },
  { 36, 6, 12, 6, 0, -12 },
  { 45, 1, 4, 3, 1, -11 },
  { 46, 3, 14, 4, 1, -11 },
  { 52, 2, 14, 4, 1, -11 },
  { 56, 4, 4, 6, 1, -12 },
  { 58, 6, 7, 6, 0, -9 },
  { 64, 1, 4, 3, 1, -2 },
  { 65, 4, 1, 4, 0, -5 },
  { 66, 1, 1, 3, 1, -1 },
  { 67, 5, 11, 5, 0, -11 },
  { 74, 5, 12, 6, 1, -12 },
  { 82, 3, 11, 6, 1, -11 },
  { 87, 5, 12, 6, 1, -12 },
  { 95, 5, 12, 6, 1, -12 },
  { 103, 6, 11, 6, 0, -11 },
  { 112, 5, 11, 6, 1, -11 },
  { 119, 5, 12, 6, 1, -12 },
  { 127, 5, 11, 6, 1, -11 },
  { 134, 5, 12, 6, 1, -12 },
  { 142, 5, 12, 6, 1, -12 },
  { 150, 1, 9, 3, 1, -9 },
  { 152, 1, 11, 3, 1, -9 },
  { 154, 6, 7, 6, 0, -9 },
  { 160, 6, 4, 6, 0, -8 },
  { 163, 6, 7, 6, 0, -9 },
  { 169, 4, 12, 4, 0, -12 },
  { 175, 8, 13, 10, 1, -12 },
  { 188, 6, 11, 6, 0, -11 },
  { 197, 5, 11, 7, 1, -11 },
  { 204, 5, 12, 7, 1, -12 },
  { 212, 6, 11, 8, 1, -11 },
  { 221, 4, 11, 6, 1, -11 },
  { 227, 4, 11, 6, 1, -11 },
  { 233, 7, 12, 8, 1, -12 },
  { 244, 6, 11, 8, 1, -11 },
  { 253, 2, 11, 4, 1, -11 },
  { 256, 3, 14, 3, -1, -11 },
  { 262, 5, 11, 6, 1, -11 },
  { 269, 4, 11, 6, 1, -11 },
  { 275, 8, 11, 11, 1, -11 },
  { 286, 6, 11, 8, 1, -11 },
  { 295, 6, 12, 8, 1, -12 },
  { 304, 5, 11, 6, 1, -11 },
  { 311, 6, 15, 8, 1, -12 },
  { 323, 5, 11, 7, 1, -11 },
  { 330, 5, 12, 6, 1, -12 },
  { 338, 5, 11, 6, 0, -11 },
  { 345, 6, 11, 8, 1, -11 },
  { 354, 6, 11, 6, 0, -11 },
  { 363, 11, 11, 11, 0, -11 },
  { 379, 5, 11, 6, 0, -11 },
  { 386, 5, 11, 5, 0, -11 },
  { 393, 5, 11, 5, 0, -11 },
  { 400, 3, 14, 5, 1, -11 },
  { 406, 5, 11, 5, 0, -11 },
  { 413, 3, 14, 5, 1, -11 },
  { 419, 6, 5, 6, 0, -11 },
  { 423, 6, 1, 6, 0, 1 },
  { 424, 2, 2, 4, 1, -12 },
  { 425, 4, 9, 6, 1, -9 },
  { 430, 5, 12, 7, 1, -12 },
  { 438, 4, 9, 5, 1, -9 },
  { 443, 5, 12, 7, 1, -12 },
  { 451, 4, 9, 6, 1, -9 },
  { 456, 4, 12, 4, 0, -12 },
  { 462, 5, 13, 7, 1, -9 },
  { 471, 5, 12, 7, 1, -12 },
  { 479, 1, 12, 3, 1, -12 },
  { 481, 2, 16, 3, 0, -12 },
  { 485, 4, 12, 5, 1, -12 },
  { 491, 1, 12, 3, 1, -12 },
  { 493, 8, 9, 10, 1, -9 },
  { 502, 5, 9, 7, 1, -9 },
  { 508, 5, 9, 7, 1, -9 },
  { 514, 5, 13, 7, 1, -9 },
  { 523, 5, 13, 7, 1, -9 },
  { 532, 3, 9, 4, 1, -9 },
  { 536, 4, 9, 5, 1, -9 },
  { 541, 3, 11, 4, 0, -11 },
  { 546, 5, 8, 7, 1, -8 },
  { 551, 5, 8, 5, 0, -8 },
  { 556, 8, 8, 9, 0, -8 },
  { 564, 5, 8, 5, 0, -8 },
  { 569, 5, 12, 5, 0, -8 },
  { 577, 4, 8, 4, 0, -8 },
  { 581, 4, 14, 6, 1, -11 },
  { 588, 1, 16, 6, 3, -12 },
  { 590, 4, 14, 6, 1, -11 },
  { 597, 6, 1, 6, 0, -6 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT16PT7B_H_
