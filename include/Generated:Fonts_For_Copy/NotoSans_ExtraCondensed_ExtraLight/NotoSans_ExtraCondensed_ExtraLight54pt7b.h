#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT54PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x6C, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x7F, 0xF8, 0xE0, 0xF8, 0x36, 0x0D, 0x83, 0x60, 0xD8, 0x36,
  0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0xD0, 0x30, 0x00, 0x80,
  0xC0, 0x04, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x00, 0x18, 0x08, 0x00,
  0xC0, 0x40, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x08, 0x0C,
  0x00, 0x40, 0x60, 0x06, 0x03, 0x07, 0xFF, 0xFF, 0x81, 0x80, 0x80, 0x0C,
  0x04, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0x80, 0xC0,
  0x0C, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0,
  0x40, 0x06, 0x06, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x08, 0x0C, 0x00,
  0xC0, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x10, 0x18, 0x00, 0x80, 0xC0, 0x0C,
  0x06, 0x00, 0x60, 0x30, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x0F, 0xC0, 0x0F, 0xFE, 0x0F, 0x23, 0xC3, 0x08, 0x11, 0x82, 0x00, 0xE0,
  0x80, 0x30, 0x20, 0x0C, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x30, 0x20,
  0x0C, 0x08, 0x03, 0x02, 0x00, 0x60, 0x80, 0x1C, 0x20, 0x03, 0x88, 0x00,
  0x7A, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x02, 0x70, 0x00,
  0x8E, 0x00, 0x20, 0xC0, 0x08, 0x18, 0x02, 0x06, 0x00, 0x80, 0xC0, 0x20,
  0x30, 0x08, 0x0C, 0x02, 0x03, 0x00, 0x80, 0xC0, 0x20, 0x60, 0x08, 0x18,
  0x02, 0x0C, 0xC0, 0x87, 0x3F, 0x2F, 0x83, 0xFF, 0x80, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x18, 0x01,
  0xF8, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x02, 0x0C, 0x03, 0x00, 0x60, 0x40,
  0x30, 0x06, 0x06, 0x03, 0x00, 0x60, 0x60, 0x60, 0x04, 0x06, 0x06, 0x00,
  0x40, 0x60, 0x60, 0x0C, 0x06, 0x0C, 0x00, 0xC0, 0x60, 0xC0, 0x0C, 0x06,
  0x0C, 0x00, 0xC0, 0x61, 0x80, 0x0C, 0x06, 0x18, 0x00, 0xC0, 0x61, 0x80,
  0x04, 0x06, 0x30, 0x60, 0x40, 0x63, 0x1F, 0x86, 0x06, 0x33, 0x8C, 0x60,
  0x66, 0x30, 0xC6, 0x04, 0x62, 0x06, 0x20, 0xC6, 0x60, 0x63, 0x0C, 0xC6,
  0x06, 0x1F, 0x8C, 0x60, 0x60, 0xF0, 0xC6, 0x02, 0x00, 0x18, 0x60, 0x20,
  0x01, 0x84, 0x02, 0x00, 0x18, 0x40, 0x30, 0x03, 0x04, 0x03, 0x00, 0x30,
  0x40, 0x30, 0x03, 0x06, 0x02, 0x00, 0x60, 0x60, 0x20, 0x06, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x60, 0x0C, 0x06, 0x06, 0x00, 0xC0, 0x60, 0x60, 0x0C,
  0x02, 0x06, 0x01, 0x80, 0x30, 0xC0, 0x18, 0x01, 0x9C, 0x01, 0x80, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x0C, 0x30, 0x01, 0x81, 0x00, 0x18,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x01, 0x80, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x30, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xF8, 0x00, 0x1D, 0x80, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x66, 0x06,
  0x06, 0x60, 0x70, 0x6C, 0x03, 0x0C, 0xC0, 0x18, 0xCC, 0x01, 0x8C, 0xC0,
  0x0C, 0xCC, 0x00, 0xD8, 0xC0, 0x07, 0x8C, 0x00, 0x78, 0xC0, 0x03, 0x0C,
  0x00, 0x78, 0xE0, 0x07, 0x86, 0x00, 0xCC, 0x70, 0x18, 0xC3, 0xCF, 0x06,
  0x1F, 0xE0, 0x70, 0x10, 0x00, 0xFD, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x01,
  0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x06, 0x03, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x3C, 0x21, 0xDF, 0x5E, 0x03, 0xE0, 0x03, 0x80, 0x0D, 0x80,
  0x31, 0x80, 0x63, 0x01, 0x83, 0x06, 0x03, 0x04, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xCE, 0x73, 0x18, 0xCE,
  0x63, 0x19, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0x6F, 0xF7, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0x87, 0x03, 0x81, 0xC1,
  0x80, 0x61, 0x80, 0x30, 0xC0, 0x0C, 0x60, 0x06, 0x70, 0x03, 0x30, 0x01,
  0x98, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0,
  0x03, 0x60, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00,
  0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x19, 0xC0, 0x0C, 0x60, 0x06, 0x30,
  0x03, 0x18, 0x03, 0x86, 0x01, 0x83, 0x01, 0xC0, 0xC0, 0xC0, 0x3F, 0xC0,
  0x0F, 0xC0, 0x00, 0xC0, 0x70, 0x3C, 0x3F, 0x1D, 0xCE, 0x77, 0x1F, 0x87,
  0x41, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x0F, 0xE0, 0x1F, 0xFC, 0x1C, 0x07, 0x04, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xFC, 0x1C, 0x07, 0x18, 0x01, 0xC4, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xCC, 0x00, 0xE7, 0xC3, 0xE1, 0xFF,
  0xC0, 0x02, 0x00, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0x60, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x01, 0x86, 0x00,
  0x18, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x0C, 0x06, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x06,
  0x03, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xDF, 0xE0, 0xFF, 0xF8, 0x40, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x80, 0x38, 0xF9, 0xF0, 0x7F, 0xE0, 0x00,
  0xFC, 0x03, 0xFE, 0x07, 0x02, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC1, 0xC0, 0xCF, 0xF8, 0xDC, 0x3C, 0xD0,
  0x0C, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0E, 0x38,
  0x0C, 0x1C, 0x38, 0x0F, 0xF0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0,
  0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x19, 0x80, 0x06,
  0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x19, 0x80, 0x0E, 0x30, 0x03, 0x0C,
  0x01, 0xC1, 0x80, 0x60, 0x70, 0x30, 0x0E, 0x38, 0x00, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x0E, 0x38, 0x07, 0x07, 0x03, 0x80, 0xE0, 0xC0, 0x1C,
  0x60, 0x03, 0x18, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xB8, 0x00, 0x66, 0x00,
  0x39, 0xC0, 0x0C, 0x38, 0x07, 0x07, 0x87, 0x80, 0xFF, 0x80, 0x02, 0x00,
  0x07, 0xE0, 0x07, 0xFC, 0x07, 0x07, 0x06, 0x01, 0x83, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x03,
  0xB0, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0xF3, 0x00, 0x59, 0xC0, 0xEC, 0x7F,
  0xE6, 0x1F, 0xC3, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0x01, 0x8F, 0x80, 0xFF, 0x00, 0x18,
  0x00, 0x67, 0xF7, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x70, 0x31, 0xCE, 0x71, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x19, 0xCE, 0x63, 0x19, 0xCC,
  0x63, 0x31, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x00, 0x3F, 0x87, 0xFE, 0x30, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x60,
  0x1C, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x0C, 0x18, 0x00,
  0x01, 0x86, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x03, 0x30, 0x03, 0xC0, 0x66,
  0x01, 0xFE, 0x06, 0xC0, 0x70, 0xC0, 0xD8, 0x0C, 0x18, 0x1E, 0x03, 0x03,
  0x03, 0xC0, 0x60, 0x60, 0x78, 0x18, 0x0C, 0x0F, 0x03, 0x01, 0x80, 0xE0,
  0x60, 0x30, 0x1C, 0x0C, 0x06, 0x03, 0x81, 0x80, 0x80, 0x70, 0x30, 0x30,
  0x1E, 0x06, 0x06, 0x03, 0xC0, 0xC0, 0xC0, 0x78, 0x18, 0x18, 0x0F, 0x03,
  0x03, 0x01, 0xE0, 0x60, 0x60, 0x3C, 0x0C, 0x1E, 0x0D, 0x80, 0xC2, 0xC1,
  0xB0, 0x18, 0xCC, 0x63, 0x01, 0xF1, 0xFC, 0x60, 0x1C, 0x1E, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00,
  0x10, 0x00, 0x78, 0x0C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xB0, 0x00, 0x0D,
  0x80, 0x00, 0x6C, 0x00, 0x03, 0x20, 0x00, 0x11, 0x80, 0x01, 0x8C, 0x00,
  0x0C, 0x60, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01,
  0x80, 0xC0, 0x0C, 0x07, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0xFF, 0xF0, 0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x0C,
  0x30, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x60, 0xFF, 0x80, 0x3F, 0xFE, 0x0C,
  0x07, 0xC3, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x3B, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x03,
  0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x18, 0xC0, 0x0E, 0x30, 0x0F, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0xC0, 0x0E, 0x30, 0x01, 0xCC, 0x00, 0x33, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC,
  0x00, 0x33, 0x00, 0x1C, 0xC0, 0x1E, 0x3F, 0xFF, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0xF0, 0x78, 0x0C, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x40, 0xF8,
  0xF0, 0x0F, 0xFC, 0x00, 0x20, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0x01, 0xF0,
  0x60, 0x0F, 0x0C, 0x00, 0x71, 0x80, 0x06, 0x30, 0x00, 0xE6, 0x00, 0x0C,
  0xC0, 0x01, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x0C, 0xC0, 0x01, 0x98,
  0x00, 0x63, 0x00, 0x1C, 0x60, 0x07, 0x0C, 0x03, 0xC1, 0xFF, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xE0, 0x3C, 0x03, 0xC1, 0xC0, 0x02, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xD8, 0x00,
  0x03, 0x60, 0x00, 0x0D, 0x80, 0x00, 0x37, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0x38, 0x00, 0x0C, 0x60, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x07,
  0x80, 0x0C, 0x0F, 0xC7, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0x00, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x18, 0xFF, 0xFF, 0xC6, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0xF3, 0xFE, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x8E, 0xFC, 0x70, 0xC0, 0x03, 0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00,
  0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x30, 0x60,
  0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x1C, 0x06, 0x0C, 0x03, 0x0C, 0x01,
  0x86, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x80, 0x1B, 0x60, 0x0D, 0xB0,
  0x07, 0x8C, 0x03, 0x86, 0x01, 0x83, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x18, 0x0E, 0x0C, 0x03, 0x06, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x38,
  0xC0, 0x0C, 0x60, 0x07, 0x30, 0x01, 0x98, 0x00, 0xEC, 0x00, 0x36, 0x00,
  0x1F, 0x00, 0x06, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x1B, 0xD8, 0x00, 0x01,
  0xBD, 0x80, 0x00, 0x1B, 0xCC, 0x00, 0x03, 0x3C, 0xC0, 0x00, 0x33, 0xCC,
  0x00, 0x03, 0x3C, 0xC0, 0x00, 0x63, 0xC6, 0x00, 0x06, 0x3C, 0x60, 0x00,
  0x63, 0xC6, 0x00, 0x06, 0x3C, 0x30, 0x00, 0xC3, 0xC3, 0x00, 0x0C, 0x3C,
  0x30, 0x00, 0xC3, 0xC1, 0x80, 0x18, 0x3C, 0x18, 0x01, 0x83, 0xC1, 0x80,
  0x18, 0x3C, 0x18, 0x03, 0x03, 0xC0, 0xC0, 0x30, 0x3C, 0x0C, 0x03, 0x03,
  0xC0, 0xC0, 0x30, 0x3C, 0x06, 0x06, 0x03, 0xC0, 0x60, 0x60, 0x3C, 0x06,
  0x06, 0x03, 0xC0, 0x30, 0xC0, 0x3C, 0x03, 0x0C, 0x03, 0xC0, 0x30, 0xC0,
  0x3C, 0x03, 0x18, 0x03, 0xC0, 0x19, 0x80, 0x3C, 0x01, 0x98, 0x03, 0xC0,
  0x19, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x06, 0x00, 0x30, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3D, 0x80, 0x03, 0xD8, 0x00, 0x3C, 0xC0,
  0x03, 0xCC, 0x00, 0x3C, 0x60, 0x03, 0xC6, 0x00, 0x3C, 0x60, 0x03, 0xC3,
  0x00, 0x3C, 0x30, 0x03, 0xC1, 0x80, 0x3C, 0x18, 0x03, 0xC0, 0xC0, 0x3C,
  0x0C, 0x03, 0xC0, 0xE0, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x03, 0x03,
  0xC0, 0x30, 0x3C, 0x01, 0x83, 0xC0, 0x18, 0x3C, 0x00, 0xC3, 0xC0, 0x0C,
  0x3C, 0x00, 0xC3, 0xC0, 0x06, 0x3C, 0x00, 0x63, 0xC0, 0x03, 0x3C, 0x00,
  0x33, 0xC0, 0x01, 0xBC, 0x00, 0x1B, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x70, 0x3C, 0x03, 0x00, 0x30, 0x18, 0x00, 0x60, 0xE0, 0x01, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00,
  0x01, 0xB8, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30,
  0x00, 0x30, 0xE0, 0x00, 0xC1, 0x80, 0x06, 0x07, 0x00, 0x38, 0x0E, 0x01,
  0xC0, 0x1F, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0xFE, 0x00, 0xFF,
  0xE0, 0xC0, 0xF8, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0,
  0x1C, 0xC0, 0x78, 0xFF, 0xF0, 0xFF, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x3C, 0x03,
  0x00, 0x30, 0x18, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x00, 0x03, 0x0C, 0x00,
  0x0C, 0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0xB8, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x19, 0x80,
  0x00, 0x66, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x30, 0xE0, 0x00,
  0xC1, 0x80, 0x06, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xC0, 0x1F, 0x3E, 0x00,
  0x1F, 0xE0, 0x00, 0x05, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0xFC, 0x00, 0x7F, 0xF0, 0x30, 0x3E, 0x18, 0x03, 0x8C,
  0x00, 0xE6, 0x00, 0x33, 0x00, 0x1D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x0E, 0xC0, 0x06, 0x60, 0x07, 0x30, 0x07, 0x18, 0x0F, 0x0F, 0xFF, 0x07,
  0xFC, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x0C,
  0x18, 0x06, 0x0C, 0x03, 0x86, 0x00, 0xC3, 0x00, 0x71, 0x80, 0x18, 0xC0,
  0x0C, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1F,
  0x00, 0x06, 0x03, 0xFC, 0x07, 0xFF, 0xC7, 0x80, 0xC7, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xCC, 0x00, 0xE7, 0xF7, 0xE1, 0xFF,
  0xC0, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x06, 0xE0,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x07, 0x18, 0x00, 0xC3, 0x80, 0x70, 0x3E,
  0x7C, 0x01, 0xFF, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xB8,
  0x00, 0x0C, 0xC0, 0x00, 0x66, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x61, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x06, 0x03, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x60,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0xC6,
  0x00, 0x06, 0x20, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00,
  0x36, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x0D, 0x80, 0x03,
  0x80, 0x01, 0xB0, 0x00, 0x70, 0x00, 0x36, 0x00, 0x0F, 0x00, 0x0E, 0xC0,
  0x01, 0xE0, 0x01, 0x8C, 0x00, 0x2C, 0x00, 0x31, 0x80, 0x0D, 0x80, 0x06,
  0x30, 0x01, 0xB0, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x38, 0xC0, 0x06, 0x60,
  0x06, 0x0C, 0x00, 0xCC, 0x00, 0xC1, 0x80, 0x31, 0x80, 0x18, 0x30, 0x06,
  0x30, 0x03, 0x06, 0x00, 0xC3, 0x00, 0xC0, 0xE0, 0x18, 0x60, 0x18, 0x0C,
  0x03, 0x0C, 0x03, 0x01, 0x80, 0xC1, 0x80, 0x60, 0x30, 0x18, 0x30, 0x1C,
  0x06, 0x03, 0x03, 0x03, 0x00, 0x60, 0x60, 0x60, 0x60, 0x0C, 0x0C, 0x0C,
  0x0C, 0x01, 0x83, 0x01, 0x81, 0x80, 0x30, 0x60, 0x30, 0x60, 0x06, 0x0C,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x61, 0x80, 0x0C, 0x30, 0x0C, 0x30, 0x01,
  0x8C, 0x01, 0x86, 0x00, 0x31, 0x80, 0x31, 0x80, 0x06, 0x30, 0x03, 0x30,
  0x00, 0x66, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x01, 0x90, 0x01,
  0xB8, 0x00, 0x36, 0x00, 0x36, 0x00, 0x06, 0xC0, 0x02, 0xC0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0xCC, 0x00, 0x73, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x06, 0x06,
  0x01, 0x81, 0x80, 0x70, 0xC0, 0x0C, 0x30, 0x03, 0x18, 0x00, 0x66, 0x00,
  0x19, 0x80, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x03, 0x18,
  0x00, 0xC6, 0x00, 0x30, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0x18, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x38, 0xC0,
  0x06, 0x70, 0x01, 0x98, 0x00, 0x7E, 0x00, 0x0C, 0xC0, 0x00, 0xF0, 0x00,
  0x76, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x1C, 0x18, 0x06, 0x06, 0x01, 0x81, 0x80, 0xE0, 0x30, 0x30, 0x0C,
  0x0C, 0x03, 0x07, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x38, 0x00, 0xCC,
  0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0x98, 0x00, 0x19, 0x80, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x01, 0x81, 0x80,
  0x18, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00, 0x06, 0xE0,
  0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x0F, 0xE0, 0x7F, 0xF0, 0xC0, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x01, 0xE0, 0x7F, 0xC3, 0xC1, 0x9C, 0x03, 0x70, 0x06,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x1E, 0xC0, 0x2D, 0xC0, 0xD9, 0xC3, 0x31, 0xFC, 0x60, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x3F, 0x06, 0x7F, 0xC3, 0x70, 0x71, 0xA0, 0x1C, 0xF0,
  0x06, 0x70, 0x01, 0xB8, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xB8, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x67, 0x80, 0x33, 0x60, 0x31,
  0x9C, 0x78, 0x87, 0xF0, 0x00, 0x60, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xE0,
  0x47, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0xE7, 0x07, 0xFC, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x03, 0xF0, 0xC3, 0xFE, 0x31, 0xC0, 0xCC, 0x60, 0x1B,
  0x38, 0x02, 0xCC, 0x00, 0xF7, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xD8,
  0x00, 0x76, 0x00, 0x0D, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x07,
  0x60, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0xC0, 0x0F, 0x30, 0x02, 0xCE,
  0x01, 0xB1, 0xC0, 0xCC, 0x38, 0xE3, 0x07, 0xF0, 0xC0, 0x70, 0x00, 0x03,
  0xF0, 0x07, 0xFC, 0x07, 0x07, 0x03, 0x01, 0xC3, 0x00, 0x61, 0x80, 0x11,
  0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0x4C, 0x00,
  0x26, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0xC1, 0xE3, 0xE0, 0x3F,
  0xC0, 0x02, 0x00, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3F, 0xCF, 0xFC,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x00, 0x03, 0xF0, 0xC3, 0xFE, 0x31, 0xC0, 0xCC,
  0x60, 0x1B, 0x30, 0x02, 0xCC, 0x00, 0xF7, 0x00, 0x1D, 0x80, 0x07, 0x60,
  0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D,
  0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0xC0, 0x0B, 0x30,
  0x02, 0xCE, 0x01, 0xB1, 0xC0, 0xDC, 0x38, 0xE7, 0x07, 0xF1, 0xC0, 0x30,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC4, 0x00, 0x71, 0xC0, 0x78, 0x3F,
  0xFC, 0x03, 0xFC, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x3E, 0x19, 0xFF, 0x37, 0x06, 0x6C, 0x06, 0xF0, 0x0D,
  0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0x6F, 0x76, 0x00,
  0x00, 0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x60, 0x0C, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1C,
  0x33, 0xE7, 0x80, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x1B, 0x00, 0x6C, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x0C, 0x1C,
  0x30, 0x60, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x33, 0x80, 0xCE, 0x03, 0x6C,
  0x0D, 0x30, 0x3C, 0xC0, 0xE1, 0x83, 0x06, 0x0C, 0x0C, 0x30, 0x30, 0xC0,
  0xE3, 0x01, 0x8C, 0x06, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xEC, 0x01, 0xB0,
  0x06, 0xC0, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x87, 0xE0, 0x7E, 0x23, 0xFC, 0x3F, 0xC9, 0x83, 0x18, 0x3A,
  0x40, 0x6C, 0x06, 0xA0, 0x1A, 0x01, 0xB8, 0x07, 0x80, 0x3C, 0x00, 0xC0,
  0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x00,
  0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C,
  0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00,
  0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0, 0x03,
  0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0xF0,
  0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0F, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00,
  0xC0, 0x83, 0xE1, 0x1F, 0xF2, 0x70, 0x74, 0x80, 0x6B, 0x00, 0xD4, 0x01,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xC0, 0xE0, 0x60, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xE6, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x0D, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xD8, 0x00,
  0x36, 0x00, 0x0D, 0x80, 0x07, 0x60, 0x01, 0x98, 0x00, 0x66, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x03, 0x06, 0x00, 0xC1, 0xC0, 0x60, 0x3C, 0xF0, 0x07,
  0xF8, 0x00, 0x10, 0x00, 0x83, 0xF0, 0x47, 0xFC, 0x27, 0x07, 0x13, 0x01,
  0xCB, 0x00, 0x65, 0x00, 0x1A, 0x80, 0x0D, 0xC0, 0x06, 0xC0, 0x03, 0x60,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x36, 0x00, 0x1B, 0x80, 0x0D, 0xC0, 0x06, 0xF0, 0x06, 0x68, 0x07, 0x36,
  0x03, 0x19, 0xC7, 0x0C, 0x7F, 0x06, 0x06, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF0,
  0xC3, 0xFE, 0x30, 0xC0, 0xCC, 0x60, 0x1B, 0x38, 0x02, 0xCC, 0x00, 0xF7,
  0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x76,
  0x00, 0x1C, 0xC0, 0x0B, 0x30, 0x02, 0xCE, 0x01, 0xB1, 0xC0, 0xCC, 0x3C,
  0xE7, 0x07, 0xF1, 0xC0, 0x20, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x83, 0xE3, 0xF8,
  0xC3, 0x60, 0xD0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0xE1,
  0xFF, 0xDC, 0x06, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0xE0, 0x0D, 0xF3, 0xC7, 0xFC, 0x02, 0x00, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0xFF, 0xFF, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x07, 0x90, 0xFC, 0x04, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x2D, 0x80, 0xDB, 0xEF,
  0x33, 0xFC, 0x60, 0x80, 0x00, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30,
  0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x18, 0x0C,
  0x18, 0x0C, 0x18, 0x0C, 0x30, 0x04, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x60, 0x02, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x40, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x05, 0x00, 0x2C, 0x01, 0xA0, 0x0C, 0xC0, 0x36, 0x01, 0x98,
  0x06, 0xC0, 0x33, 0x00, 0xD8, 0x06, 0x60, 0x1B, 0x01, 0x84, 0x06, 0x30,
  0x30, 0xC0, 0xC6, 0x06, 0x18, 0x18, 0xC0, 0xC3, 0x03, 0x18, 0x18, 0x60,
  0x43, 0x06, 0x06, 0x18, 0x30, 0xC0, 0xC3, 0x06, 0x18, 0x18, 0x60, 0xC3,
  0x03, 0x0C, 0x18, 0xC0, 0x23, 0x01, 0x18, 0x06, 0x60, 0x33, 0x00, 0xCC,
  0x06, 0x60, 0x19, 0x80, 0xCC, 0x03, 0x30, 0x1B, 0x00, 0x3C, 0x01, 0x60,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x01, 0x80,
  0x1C, 0x00, 0x30, 0x01, 0x80, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x0E, 0x30,
  0x0C, 0x30, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x30, 0x0C, 0x30, 0x06,
  0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x06, 0xE0, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x18,
  0x30, 0x18, 0x18, 0x38, 0x18, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x0E, 0x60,
  0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x18,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x02,
  0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x08, 0x07, 0xC0, 0x78,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x1E, 0x00, 0xF0, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0xF8, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0x10, 0x00, 0x0C, 0x00, 0x1F,
  0xC0, 0x1E, 0x3C, 0x0E, 0x03, 0xEF, 0x80, 0x3F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 39, 11, 4, -39 },
  { 16, 10, 14, 17, 3, -39 },
  { 34, 21, 39, 23, 1, -39 },
  { 137, 18, 44, 22, 2, -41 },
  { 236, 28, 39, 32, 2, -39 },
  { 373, 20, 40, 22, 2, -39 },
  { 473, 3, 14, 9, 3, -39 },
  { 479, 9, 48, 15, 3, -39 },
  { 533, 10, 48, 15, 2, -39 },
  { 593, 15, 15, 19, 2, -41 },
  { 622, 18, 25, 22, 2, -32 },
  { 679, 5, 13, 10, 2, -6 },
  { 688, 12, 2, 14, 1, -16 },
  { 691, 4, 4, 10, 3, -4 },
  { 693, 16, 39, 18, 1, -39 },
  { 771, 17, 39, 22, 2, -39 },
  { 854, 10, 39, 22, 4, -39 },
  { 903, 17, 39, 22, 2, -39 },
  { 986, 17, 40, 22, 2, -39 },
  { 1071, 20, 39, 22, 1, -39 },
  { 1169, 16, 39, 22, 3, -39 },
  { 1247, 16, 40, 22, 3, -39 },
  { 1327, 17, 39, 22, 2, -39 },
  { 1410, 18, 40, 22, 2, -39 },
  { 1500, 17, 40, 22, 2, -39 },
  { 1585, 4, 29, 10, 3, -29 },
  { 1600, 5, 36, 10, 2, -29 },
  { 1623, 18, 22, 22, 2, -30 },
  { 1673, 18, 14, 22, 2, -26 },
  { 1705, 18, 22, 22, 2, -30 },
  { 1755, 13, 39, 15, 1, -39 },
  { 1819, 27, 44, 33, 3, -39 },
  { 1968, 21, 39, 21, 0, -39 },
  { 2071, 18, 39, 24, 4, -39 },
  { 2159, 18, 40, 23, 3, -39 },
  { 2249, 19, 39, 26, 4, -39 },
  { 2342, 14, 39, 21, 4, -39 },
  { 2411, 14, 39, 19, 4, -39 },
  { 2480, 22, 40, 28, 3, -39 },
  { 2590, 19, 39, 27, 4, -39 },
  { 2683, 9, 39, 13, 2, -39 },
  { 2727, 8, 49, 10, -2, -39 },
  { 2776, 17, 39, 21, 4, -39 },
  { 2859, 14, 39, 19, 4, -39 },
  { 2928, 28, 39, 36, 4, -39 },
  { 3065, 20, 39, 28, 4, -39 },
  { 3163, 22, 40, 28, 3, -39 },
  { 3273, 16, 39, 22, 4, -39 },
  { 3351, 22, 48, 28, 3, -39 },
  { 3483, 17, 39, 22, 4, -39 },
  { 3566, 17, 40, 21, 2, -39 },
  { 3651, 18, 39, 19, 0, -39 },
  { 3739, 19, 40, 27, 4, -39 },
  { 3834, 21, 39, 21, 0, -39 },
  { 3937, 35, 39, 36, 0, -39 },
  { 4108, 18, 39, 19, 0, -39 },
  { 4196, 18, 39, 18, 0, -39 },
  { 4284, 15, 39, 18, 2, -39 },
  { 4358, 11, 48, 17, 4, -39 },
  { 4424, 16, 39, 18, 1, -39 },
  { 4502, 10, 48, 17, 2, -39 },
  { 4562, 20, 19, 22, 1, -39 },
  { 4610, 22, 2, 22, 0, 5 },
  { 4616, 8, 8, 13, 2, -41 },
  { 4624, 15, 30, 20, 2, -29 },
  { 4681, 17, 42, 23, 4, -41 },
  { 4771, 14, 30, 17, 2, -29 },
  { 4824, 18, 42, 23, 2, -41 },
  { 4919, 17, 30, 21, 2, -29 },
  { 4983, 12, 41, 12, 1, -41 },
  { 5045, 18, 42, 23, 2, -29 },
  { 5140, 15, 41, 23, 4, -41 },
  { 5217, 4, 39, 10, 3, -39 },
  { 5237, 7, 52, 10, 0, -39 },
  { 5283, 14, 41, 18, 4, -41 },
  { 5355, 2, 41, 10, 4, -41 },
  { 5366, 26, 29, 34, 4, -29 },
  { 5461, 15, 29, 23, 4, -29 },
  { 5516, 18, 30, 22, 2, -29 },
  { 5584, 17, 42, 23, 4, -29 },
  { 5674, 18, 42, 23, 2, -29 },
  { 5769, 10, 29, 15, 4, -29 },
  { 5806, 13, 30, 17, 2, -29 },
  { 5855, 10, 36, 12, 1, -35 },
  { 5900, 15, 30, 23, 4, -29 },
  { 5957, 16, 29, 17, 0, -29 },
  { 6015, 27, 29, 29, 1, -29 },
  { 6113, 16, 29, 18, 1, -29 },
  { 6171, 16, 42, 18, 1, -29 },
  { 6255, 11, 29, 14, 2, -29 },
  { 6295, 13, 48, 19, 3, -39 },
  { 6373, 2, 54, 21, 9, -41 },
  { 6387, 13, 48, 19, 3, -39 },
  { 6465, 18, 5, 22, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight54pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT54PT7B_H_
