#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT66PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight66pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0xEF, 0xFF,
  0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36,
  0x03, 0x60, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x06, 0x00,
  0xC0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06,
  0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x0E, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x0C,
  0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00,
  0x60, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80,
  0x60, 0x00, 0xC0, 0x18, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x07, 0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x07,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x06, 0x00, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xF3, 0x1F, 0x87, 0x0C, 0x0C, 0x38, 0x30,
  0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x30, 0x03,
  0x80, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80,
  0xC0, 0x06, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xC0,
  0x01, 0xE3, 0x00, 0x03, 0xCC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x37, 0xC0, 0x00, 0xC7, 0x80, 0x03,
  0x0F, 0x00, 0x0C, 0x0E, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x70, 0x03, 0x00,
  0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x03, 0xA0, 0x0C,
  0x0C, 0xE0, 0x30, 0xF3, 0xF0, 0xCF, 0x87, 0xFF, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xC0, 0x0E, 0x38, 0x00, 0x60, 0x06, 0x0C, 0x00, 0x70, 0x07, 0x07, 0x00,
  0x30, 0x03, 0x01, 0x80, 0x18, 0x01, 0x80, 0xC0, 0x1C, 0x00, 0xC0, 0x70,
  0x0C, 0x00, 0xE0, 0x18, 0x06, 0x00, 0x60, 0x0C, 0x07, 0x00, 0x30, 0x06,
  0x03, 0x00, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x01, 0x81, 0xC0, 0x06, 0x00,
  0xC0, 0xC0, 0x03, 0x00, 0x60, 0x60, 0x01, 0x80, 0x30, 0x70, 0x00, 0xC0,
  0x18, 0x30, 0x00, 0x60, 0x0C, 0x18, 0x00, 0x30, 0x06, 0x1C, 0x00, 0x18,
  0x03, 0x0C, 0x1F, 0x0C, 0x01, 0x86, 0x1F, 0xC7, 0x00, 0xC7, 0x1C, 0x71,
  0x80, 0xE3, 0x0C, 0x18, 0xC0, 0x61, 0x8C, 0x0E, 0x60, 0x31, 0xC6, 0x03,
  0x38, 0x38, 0xC3, 0x01, 0x8C, 0x18, 0x63, 0x80, 0xE7, 0xBC, 0x71, 0x80,
  0x71, 0xFC, 0x30, 0xC0, 0x18, 0x38, 0x18, 0x60, 0x0C, 0x00, 0x1C, 0x30,
  0x06, 0x00, 0x0C, 0x18, 0x03, 0x00, 0x06, 0x0C, 0x01, 0x80, 0x07, 0x06,
  0x00, 0xC0, 0x03, 0x03, 0x00, 0x60, 0x01, 0x81, 0x80, 0x30, 0x01, 0xC0,
  0xC0, 0x18, 0x00, 0xC0, 0x60, 0x0C, 0x00, 0x60, 0x30, 0x06, 0x00, 0x70,
  0x18, 0x03, 0x00, 0x30, 0x0C, 0x03, 0x80, 0x18, 0x07, 0x01, 0x80, 0x1C,
  0x01, 0x80, 0xC0, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x00, 0x70, 0x70, 0x07,
  0x00, 0x18, 0x30, 0x03, 0x00, 0x07, 0x70, 0x01, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x18, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x38, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x38,
  0x00, 0x07, 0x0C, 0x00, 0x07, 0x07, 0x00, 0xC3, 0x81, 0x80, 0x63, 0x80,
  0x60, 0x31, 0xC0, 0x38, 0x18, 0xC0, 0x0C, 0x0C, 0xE0, 0x07, 0x0E, 0x70,
  0x01, 0x87, 0x38, 0x00, 0xE3, 0x1C, 0x00, 0x31, 0x8C, 0x00, 0x1D, 0xC6,
  0x00, 0x07, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x30, 0x00, 0x3C, 0x1C, 0x00, 0x3F, 0x0E, 0x00, 0x39, 0x83, 0x80, 0x38,
  0xE0, 0xE0, 0x38, 0x30, 0x7F, 0xF8, 0x1C, 0x0F, 0xF8, 0x07, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xED, 0xB6, 0xDB, 0x60, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x04, 0x06, 0x07, 0x83, 0x0F, 0xF9, 0x3F, 0x1F,
  0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x6C, 0x00, 0x63, 0x00, 0x70, 0xC0,
  0x30, 0x70, 0x30, 0x1C, 0x30, 0x06, 0x08, 0x02, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x73, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC6, 0x18,
  0xE3, 0x0C, 0x30, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xF0, 0x70,
  0x0C, 0x03, 0x81, 0xC0, 0x1C, 0x18, 0x01, 0xC3, 0x80, 0x0C, 0x30, 0x00,
  0xE3, 0x00, 0x0E, 0x70, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0x76, 0x00,
  0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00,
  0x06, 0x70, 0x00, 0x63, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0C, 0x18,
  0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x03, 0x80, 0xF0, 0x70, 0x07, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0x71, 0xE7, 0x3C,
  0x77, 0x87, 0xE0, 0x74, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0x80, 0x78, 0x60,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0xF0, 0x07, 0x8F,
  0x00, 0x1E, 0x20, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC8, 0x00, 0x1E, 0x38,
  0x01, 0xE1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x6C, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00,
  0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x06, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x70, 0x18, 0x00, 0x30, 0x0C,
  0x00, 0x38, 0x06, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x07, 0x00, 0x18, 0x03, 0x00,
  0x0C, 0x03, 0x80, 0x06, 0x01, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x60, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xDF, 0xF8, 0x07, 0xFF, 0xF0, 0x3C, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x71, 0x00, 0x07, 0x0E, 0x00, 0xF0, 0x7F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0x80, 0x40, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC1, 0xF8, 0x0E,
  0x3F, 0xF0, 0x73, 0xE7, 0xC3, 0xB8, 0x07, 0x1D, 0x80, 0x1C, 0xF8, 0x00,
  0xE7, 0x80, 0x03, 0x3C, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x70,
  0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80,
  0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x71, 0x80, 0x03, 0x8E, 0x00, 0x18,
  0x30, 0x01, 0xC1, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x1F, 0x7E, 0x00, 0x7F,
  0xC0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xC0,
  0x78, 0x1C, 0x00, 0xE0, 0x60, 0x01, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0E,
  0x30, 0x00, 0x38, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30,
  0x00, 0x38, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0C, 0x1C, 0x00,
  0x70, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0xF0, 0x03, 0x87, 0x80,
  0x07, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0E,
  0x1C, 0x00, 0x70, 0x38, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x01,
  0xC3, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x19, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x67, 0x00, 0x03,
  0x8E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x78, 0x07, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE,
  0x01, 0xC0, 0x70, 0x38, 0x03, 0x83, 0x00, 0x1C, 0x70, 0x01, 0xC6, 0x00,
  0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xF6, 0x00, 0x0F, 0x70, 0x01, 0xB3, 0x00, 0x1F, 0x38, 0x03,
  0x71, 0xE1, 0xE7, 0x0F, 0xFC, 0x70, 0x3F, 0x87, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x04, 0x03, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFF, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x70, 0x38, 0xF7, 0xCF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x73, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC6, 0x18, 0xE3, 0x0C, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F,
  0xF0, 0xFF, 0xF8, 0x60, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x06, 0x03,
  0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x30, 0x70, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x3F, 0x00, 0x63, 0x00, 0x3F, 0xF0,
  0x18, 0xC0, 0x1E, 0x1C, 0x06, 0x30, 0x06, 0x07, 0x01, 0xDC, 0x03, 0x81,
  0xC0, 0x77, 0x00, 0xC0, 0x70, 0x0D, 0x80, 0x70, 0x1C, 0x03, 0x60, 0x18,
  0x06, 0x00, 0xD8, 0x06, 0x01, 0x80, 0x36, 0x03, 0x80, 0x60, 0x0D, 0x80,
  0xE0, 0x18, 0x03, 0x60, 0x30, 0x06, 0x00, 0xD8, 0x0C, 0x01, 0x80, 0x3E,
  0x03, 0x00, 0x60, 0x0F, 0x80, 0xC0, 0x18, 0x03, 0xE0, 0x30, 0x06, 0x00,
  0xD8, 0x0C, 0x01, 0x80, 0x36, 0x03, 0x00, 0xE0, 0x1D, 0x80, 0xE0, 0x38,
  0x07, 0x60, 0x38, 0x0E, 0x01, 0x98, 0x06, 0x02, 0x80, 0x66, 0x01, 0x81,
  0xA0, 0x39, 0x80, 0x70, 0x6C, 0x0C, 0x70, 0x0C, 0x33, 0x87, 0x1C, 0x03,
  0xFC, 0x7F, 0x83, 0x00, 0x7E, 0x0F, 0xC0, 0xC0, 0x06, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x40, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x63, 0x80,
  0x00, 0x18, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x86, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x80, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x30, 0x00, 0x30, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x60, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x39, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1C, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x38, 0x03, 0xF1,
  0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6E,
  0x00, 0x03, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x77, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00, 0x78, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x1C, 0x03, 0xF0, 0xE0, 0x03, 0xC7, 0x00, 0x07,
  0x38, 0x00, 0x1D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0xCE,
  0x00, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0x00, 0x30, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x20, 0x1E, 0x00, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x03, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0x80,
  0x7E, 0x07, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x33, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x3C, 0x0E,
  0x07, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x60, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0x60, 0x00, 0x7F, 0xF6, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x00, 0x00, 0x03, 0x38,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x31, 0xC0, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30,
  0x38, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x0F, 0x00, 0x1F, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0xFF,
  0x9F, 0xE1, 0xF0, 0x00, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x38, 0x00, 0x39,
  0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x1C, 0x00,
  0xE0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x18, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x73,
  0xC0, 0x03, 0xBE, 0x00, 0x1D, 0xB8, 0x00, 0xF9, 0xC0, 0x07, 0xC7, 0x00,
  0x3C, 0x38, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x18, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x60, 0x38, 0x03, 0x81,
  0xC0, 0x0C, 0x0E, 0x00, 0x70, 0x70, 0x01, 0x83, 0x80, 0x0E, 0x1C, 0x00,
  0x30, 0xE0, 0x01, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xCE,
  0x00, 0x07, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xD8, 0x00, 0x00, 0x07, 0xF6, 0x00, 0x00,
  0x03, 0xFD, 0xC0, 0x00, 0x00, 0xFF, 0x30, 0x00, 0x00, 0x37, 0xEC, 0x00,
  0x00, 0x0D, 0xFB, 0x80, 0x00, 0x07, 0x7E, 0x60, 0x00, 0x01, 0x9F, 0x98,
  0x00, 0x00, 0x67, 0xE6, 0x00, 0x00, 0x39, 0xF9, 0xC0, 0x00, 0x0E, 0x7E,
  0x30, 0x00, 0x03, 0x1F, 0x8C, 0x00, 0x01, 0xC7, 0xE3, 0x80, 0x00, 0x71,
  0xF8, 0x60, 0x00, 0x18, 0x7E, 0x18, 0x00, 0x06, 0x1F, 0x87, 0x00, 0x03,
  0x87, 0xE1, 0xC0, 0x00, 0xC1, 0xF8, 0x30, 0x00, 0x30, 0x7E, 0x0C, 0x00,
  0x1C, 0x1F, 0x83, 0x80, 0x07, 0x07, 0xE0, 0x60, 0x01, 0x81, 0xF8, 0x18,
  0x00, 0xE0, 0x7E, 0x07, 0x00, 0x38, 0x1F, 0x80, 0xC0, 0x0C, 0x07, 0xE0,
  0x30, 0x03, 0x01, 0xF8, 0x0E, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0x60, 0x1F,
  0x80, 0x60, 0x18, 0x07, 0xE0, 0x18, 0x0E, 0x01, 0xF8, 0x07, 0x03, 0x80,
  0x7E, 0x00, 0xC0, 0xC0, 0x1F, 0x80, 0x30, 0x70, 0x07, 0xE0, 0x0E, 0x1C,
  0x01, 0xF8, 0x01, 0x86, 0x00, 0x7E, 0x00, 0x61, 0x80, 0x1F, 0x80, 0x1C,
  0xE0, 0x07, 0xE0, 0x07, 0x30, 0x01, 0xF8, 0x00, 0xCC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xD8, 0x00, 0x03, 0xDC,
  0x00, 0x03, 0xDC, 0x00, 0x03, 0xEC, 0x00, 0x03, 0xEE, 0x00, 0x03, 0xE6,
  0x00, 0x03, 0xE7, 0x00, 0x03, 0xE3, 0x00, 0x03, 0xE3, 0x80, 0x03, 0xE1,
  0x80, 0x03, 0xE1, 0x80, 0x03, 0xE1, 0xC0, 0x03, 0xE0, 0xC0, 0x03, 0xE0,
  0xE0, 0x03, 0xE0, 0x60, 0x03, 0xE0, 0x70, 0x03, 0xE0, 0x30, 0x03, 0xE0,
  0x38, 0x03, 0xE0, 0x38, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x1C, 0x03, 0xE0,
  0x0C, 0x03, 0xE0, 0x0E, 0x03, 0xE0, 0x06, 0x03, 0xE0, 0x07, 0x03, 0xE0,
  0x03, 0x03, 0xE0, 0x03, 0x83, 0xE0, 0x03, 0x83, 0xE0, 0x01, 0x83, 0xE0,
  0x01, 0xC3, 0xE0, 0x00, 0xC3, 0xE0, 0x00, 0xE3, 0xE0, 0x00, 0x63, 0xE0,
  0x00, 0x73, 0xE0, 0x00, 0x73, 0xE0, 0x00, 0x33, 0xE0, 0x00, 0x3B, 0xE0,
  0x00, 0x1B, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0xF0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x30,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x06, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00,
  0x67, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC1, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0xE0, 0x3F, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x1C,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00,
  0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x3F, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00,
  0x76, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00, 0x06, 0x70,
  0x00, 0x00, 0x67, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xE3, 0x00, 0x00,
  0x0E, 0x30, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x70, 0x07, 0x80, 0x0E, 0x00, 0x3E, 0x03, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x38, 0x0F, 0xC1, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x70,
  0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x67, 0x00, 0x03,
  0x38, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80,
  0x01, 0xDC, 0x00, 0x0C, 0xE0, 0x00, 0x67, 0x00, 0x07, 0x38, 0x00, 0x39,
  0xC0, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x07,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x60, 0x0E,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x01, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x30, 0x70,
  0x01, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x07,
  0x38, 0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1F, 0x80,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xF1, 0xE0, 0x06,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x80, 0x03, 0xCE, 0x00, 0xF8, 0xFF, 0xFF, 0x07,
  0xFF, 0xC0, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x30, 0xE0, 0x00,
  0xE1, 0xE0, 0x03, 0x81, 0xE0, 0x1E, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x67, 0x00, 0x00, 0x33, 0x80, 0x00, 0x38, 0xC0, 0x00,
  0x1C, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x03,
  0x80, 0x0E, 0x00, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x30, 0x00, 0x03,
  0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x38, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x80, 0x00, 0x77, 0x00, 0x00, 0xF0, 0x00, 0x0C, 0x60, 0x00, 0x3E,
  0x00, 0x03, 0x8C, 0x00, 0x06, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0xD8, 0x00,
  0x0E, 0x38, 0x00, 0x1B, 0x80, 0x01, 0x87, 0x00, 0x03, 0x70, 0x00, 0x30,
  0x60, 0x00, 0xE6, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0xC0, 0x01, 0xC1, 0xC0,
  0x03, 0x18, 0x00, 0x38, 0x38, 0x00, 0x63, 0x80, 0x06, 0x07, 0x00, 0x0C,
  0x70, 0x00, 0xC0, 0x60, 0x03, 0x86, 0x00, 0x38, 0x0C, 0x00, 0x70, 0xC0,
  0x07, 0x01, 0xC0, 0x0C, 0x18, 0x00, 0xE0, 0x38, 0x01, 0x83, 0x80, 0x18,
  0x07, 0x00, 0x30, 0x70, 0x03, 0x00, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0xC0, 0x1C, 0x01, 0xC0, 0x30, 0x18, 0x03, 0x00, 0x38, 0x06,
  0x03, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0x60, 0x38, 0x06,
  0x03, 0x80, 0x0C, 0x07, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x18, 0x0C,
  0x00, 0x38, 0x18, 0x03, 0x81, 0x80, 0x03, 0x03, 0x00, 0x70, 0x70, 0x00,
  0x60, 0xE0, 0x06, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0xC1, 0xC0, 0x01, 0xC3,
  0x00, 0x18, 0x30, 0x00, 0x38, 0x60, 0x03, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x71, 0xC0, 0x00, 0x63, 0x80, 0x06, 0x38, 0x00, 0x0E, 0x70, 0x00, 0xC6,
  0x00, 0x01, 0xCC, 0x00, 0x18, 0xC0, 0x00, 0x39, 0x80, 0x03, 0xB8, 0x00,
  0x03, 0x30, 0x00, 0x77, 0x00, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x1B, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x39, 0x80, 0x01,
  0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0x80, 0x06, 0x0E, 0x00, 0x70, 0x30,
  0x03, 0x81, 0x80, 0x18, 0x0E, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0xC0, 0xE0,
  0x0E, 0x07, 0x00, 0x30, 0x30, 0x01, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x30,
  0xC0, 0x01, 0xCE, 0x00, 0x06, 0x60, 0x00, 0x37, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x37, 0x00, 0x03, 0x98, 0x00, 0x18, 0xE0, 0x00,
  0xC7, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x18,
  0x01, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0xE0, 0x70,
  0x03, 0x03, 0x00, 0x18, 0x38, 0x00, 0xE1, 0x80, 0x03, 0x1C, 0x00, 0x1C,
  0xE0, 0x00, 0xE6, 0x00, 0x03, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1D, 0x80, 0x00, 0x66, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x30, 0x00,
  0x30, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0,
  0x70, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x06, 0x00, 0x60, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x07, 0x38, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x06, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x18, 0x00, 0x03, 0x8E,
  0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xE0,
  0x38, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x38,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x63, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00,
  0x70, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x70, 0x1E, 0x10, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x7F, 0xC0, 0xFF, 0xF0, 0x78, 0x0C, 0x78, 0x03, 0x38, 0x00, 0xCE, 0x00,
  0x37, 0x00, 0x0D, 0xC0, 0x03, 0x60, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x3D, 0xC0, 0x0F, 0x30,
  0x06, 0xCE, 0x03, 0xB1, 0xF3, 0xCC, 0x3F, 0xE3, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x01, 0x80, 0x18, 0x7F, 0xC0, 0xC7, 0xFF, 0x06, 0x70, 0x3C, 0x37, 0x00,
  0x71, 0xB0, 0x01, 0x8F, 0x00, 0x0E, 0x78, 0x00, 0x33, 0x80, 0x01, 0x9C,
  0x00, 0x0E, 0xE0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00,
  0x6C, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xB8, 0x00, 0x19, 0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x6C, 0x00, 0xE3,
  0x70, 0x07, 0x19, 0xC0, 0xF0, 0xC7, 0xFF, 0x06, 0x1F, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x30, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xE0, 0x20, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x41, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x01, 0x80, 0x60,
  0x7F, 0x83, 0x07, 0xFF, 0x18, 0x70, 0x1C, 0xC7, 0x00, 0x66, 0x70, 0x01,
  0xB3, 0x80, 0x05, 0x98, 0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x07, 0x60,
  0x00, 0x3B, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xDC, 0x00,
  0x1E, 0xE0, 0x00, 0xF3, 0x00, 0x05, 0x9C, 0x00, 0x6C, 0x70, 0x06, 0x63,
  0xC0, 0x63, 0x0F, 0xFF, 0x18, 0x1F, 0xE0, 0xC0, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x83, 0x80,
  0x1C, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x20, 0xF0, 0x0E, 0x07,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x7F,
  0xF8, 0xFF, 0xF0, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0xC1, 0xFF,
  0xC6, 0x1C, 0x07, 0x31, 0xC0, 0x19, 0x9C, 0x00, 0x6C, 0xE0, 0x01, 0x6E,
  0x00, 0x0F, 0x70, 0x00, 0x7B, 0x00, 0x01, 0xD8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x2C,
  0xC0, 0x03, 0xE7, 0x00, 0x1F, 0x1C, 0x01, 0xB8, 0xF0, 0x19, 0xC3, 0xFF,
  0x8E, 0x07, 0xF8, 0x70, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x88, 0x00, 0x3C, 0x60,
  0x03, 0xC3, 0xF0, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x03, 0x03, 0x0F, 0xF0, 0xC7, 0xFE,
  0x33, 0x81, 0xCD, 0xC0, 0x3B, 0x60, 0x0E, 0xF0, 0x01, 0xBC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x30, 0x6F, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x06, 0x0F, 0x0F, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x0E, 0x0E, 0x0E, 0xBC, 0xF8, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x0E, 0xC0, 0x06, 0x60, 0x07, 0x30, 0x07, 0x18,
  0x03, 0x8C, 0x03, 0x86, 0x01, 0x83, 0x01, 0xC1, 0x81, 0xC0, 0xC0, 0xC0,
  0x60, 0xE0, 0x30, 0x60, 0x18, 0x70, 0x0C, 0x70, 0x06, 0x3C, 0x03, 0x3E,
  0x01, 0xBB, 0x00, 0xD9, 0xC0, 0x78, 0x60, 0x3C, 0x38, 0x1C, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x83, 0x00, 0xC1, 0x80, 0x70, 0xC0, 0x18, 0x60, 0x0E,
  0x30, 0x07, 0x18, 0x01, 0x8C, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x1D, 0x80,
  0x0E, 0xC0, 0x03, 0x60, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x83,
  0xF8, 0x0F, 0xF0, 0xCF, 0xFC, 0x1F, 0xF8, 0xCC, 0x0E, 0x38, 0x3C, 0xD8,
  0x06, 0x30, 0x1C, 0xD0, 0x07, 0x60, 0x0E, 0xF0, 0x03, 0x40, 0x06, 0xE0,
  0x03, 0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x06, 0xE0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x30, 0x30, 0xFF, 0x0C,
  0x7F, 0xF3, 0x38, 0x1C, 0xDC, 0x03, 0xB6, 0x00, 0x6F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xE0,
  0x1C, 0x07, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0x8E, 0x00,
  0x0E, 0x70, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0D, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x67, 0x00, 0x03, 0x18, 0x00, 0x38, 0xE0,
  0x01, 0x87, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x70, 0x1E, 0x01, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x04, 0x1F, 0xF0, 0x31,
  0xFF, 0xC1, 0x9C, 0x0F, 0x0C, 0xC0, 0x1C, 0x6C, 0x00, 0x63, 0x40, 0x03,
  0x9E, 0x00, 0x0C, 0xE0, 0x00, 0x67, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x06, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x06, 0x78, 0x00,
  0x73, 0xC0, 0x03, 0x9B, 0x00, 0x38, 0xDC, 0x01, 0xC6, 0x70, 0x3C, 0x31,
  0xFF, 0xC1, 0x87, 0xFC, 0x0C, 0x07, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0xF0, 0xC1, 0xFF, 0xC6, 0x1E, 0x07, 0x31, 0xC0, 0x19, 0x8C, 0x00, 0x6C,
  0xE0, 0x01, 0x66, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x01, 0xD8, 0x00,
  0x0E, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x77, 0x00, 0x07,
  0xB8, 0x00, 0x2C, 0xE0, 0x03, 0x67, 0x00, 0x17, 0x1C, 0x01, 0xB8, 0x70,
  0x19, 0xC3, 0xFF, 0x8E, 0x07, 0xF8, 0x70, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0xC3, 0xFC,
  0x7F, 0xCE, 0x1C, 0xC0, 0xD8, 0x0D, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x03, 0xFF, 0x07, 0xFF, 0xE7, 0x80, 0x63,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x80,
  0x07, 0x70, 0x0F, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x78, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x3F,
  0xFF, 0xFF, 0xC3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0x81, 0xFC, 0x01, 0x80, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1D,
  0x80, 0x03, 0xB0, 0x00, 0xF6, 0x00, 0x1E, 0xE0, 0x02, 0xDC, 0x00, 0xD9,
  0xC0, 0x33, 0x3C, 0x0E, 0x63, 0xFF, 0x8C, 0x3F, 0xE1, 0x80, 0xE0, 0x00,
  0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x67, 0x00, 0x06, 0x70, 0x00,
  0xE3, 0x00, 0x0E, 0x30, 0x00, 0xE3, 0x80, 0x0C, 0x38, 0x00, 0xC1, 0x80,
  0x1C, 0x18, 0x01, 0xC1, 0x80, 0x18, 0x1C, 0x01, 0x80, 0xC0, 0x38, 0x0C,
  0x03, 0x80, 0xC0, 0x30, 0x0E, 0x03, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00,
  0x60, 0x60, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x03, 0x0E, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x38, 0xC0, 0x01, 0x9C, 0x00, 0x19, 0x80, 0x01, 0x98,
  0x00, 0x1D, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x76, 0x00, 0x3E, 0x00,
  0x33, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x0C, 0xE0, 0x06, 0xE0,
  0x0E, 0x30, 0x03, 0x30, 0x07, 0x18, 0x03, 0x98, 0x03, 0x0C, 0x01, 0x8C,
  0x01, 0x87, 0x00, 0xC6, 0x00, 0xC3, 0x80, 0x63, 0x80, 0xE0, 0xC0, 0x70,
  0xC0, 0x60, 0x60, 0x38, 0x60, 0x30, 0x30, 0x18, 0x30, 0x18, 0x1C, 0x0C,
  0x1C, 0x1C, 0x06, 0x06, 0x0E, 0x0E, 0x03, 0x07, 0x03, 0x06, 0x01, 0x83,
  0x81, 0x83, 0x00, 0xE1, 0x80, 0xC1, 0x80, 0x70, 0xC0, 0x71, 0xC0, 0x18,
  0xE0, 0x38, 0xC0, 0x0C, 0x70, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x30, 0x03,
  0x98, 0x03, 0x18, 0x01, 0xCC, 0x01, 0xDC, 0x00, 0x66, 0x00, 0x6C, 0x00,
  0x37, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x0D, 0x80,
  0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xEE, 0x00, 0x1C, 0xC0, 0x07,
  0x1C, 0x00, 0xE1, 0x80, 0x18, 0x38, 0x07, 0x03, 0x00, 0xC0, 0x70, 0x38,
  0x06, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x01, 0x8E, 0x00, 0x39, 0x80,
  0x03, 0x30, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1B, 0x80, 0x07, 0x30, 0x00, 0xC7, 0x00,
  0x38, 0x60, 0x06, 0x0E, 0x01, 0xC0, 0xC0, 0x38, 0x1C, 0x06, 0x03, 0x81,
  0xC0, 0x38, 0x30, 0x07, 0x0E, 0x00, 0x61, 0x80, 0x0E, 0x70, 0x00, 0xCC,
  0x00, 0x1F, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00,
  0x67, 0x00, 0x06, 0x70, 0x00, 0xE3, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x80,
  0x0C, 0x38, 0x01, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0x81, 0xC0, 0x18, 0x1C,
  0x03, 0x80, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xE0, 0x30, 0x0E, 0x07, 0x00,
  0x60, 0x70, 0x06, 0x06, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x30, 0xE0,
  0x03, 0x0C, 0x00, 0x38, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0x98,
  0x00, 0x19, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x9E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xFC,
  0x01, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x40, 0x00, 0x00,
  0x1F, 0xC0, 0x02, 0xFF, 0xE0, 0x0F, 0xC1, 0xF0, 0x3E, 0x00, 0xFF, 0xE8,
  0x00, 0x7F, 0x80, 0x00, 0x38, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 47, 13, 5, -47 },
  { 25, 12, 17, 20, 4, -47 },
  { 51, 26, 47, 28, 1, -47 },
  { 204, 22, 54, 26, 2, -50 },
  { 353, 33, 49, 39, 3, -48 },
  { 556, 25, 49, 27, 2, -48 },
  { 710, 3, 17, 11, 4, -47 },
  { 717, 12, 57, 18, 3, -47 },
  { 803, 11, 57, 18, 3, -47 },
  { 882, 17, 18, 23, 3, -50 },
  { 921, 23, 31, 27, 2, -39 },
  { 1011, 6, 16, 12, 3, -7 },
  { 1023, 14, 2, 17, 2, -19 },
  { 1027, 4, 5, 12, 4, -5 },
  { 1030, 19, 47, 22, 2, -47 },
  { 1142, 20, 48, 26, 3, -48 },
  { 1262, 12, 47, 26, 5, -47 },
  { 1333, 20, 48, 26, 3, -48 },
  { 1453, 21, 49, 26, 2, -48 },
  { 1582, 25, 47, 26, 1, -47 },
  { 1729, 21, 48, 26, 3, -47 },
  { 1855, 21, 49, 26, 3, -48 },
  { 1984, 20, 47, 26, 3, -47 },
  { 2102, 22, 49, 26, 2, -48 },
  { 2237, 20, 49, 26, 3, -48 },
  { 2360, 4, 35, 13, 4, -35 },
  { 2378, 6, 44, 12, 3, -35 },
  { 2411, 23, 27, 27, 2, -37 },
  { 2489, 23, 16, 27, 2, -31 },
  { 2535, 23, 27, 27, 2, -37 },
  { 2613, 16, 48, 18, 1, -48 },
  { 2709, 34, 53, 40, 3, -47 },
  { 2935, 26, 47, 26, 0, -47 },
  { 3088, 21, 47, 29, 5, -47 },
  { 3212, 23, 49, 28, 3, -48 },
  { 3353, 23, 47, 32, 5, -47 },
  { 3489, 17, 47, 25, 5, -47 },
  { 3589, 17, 47, 24, 5, -47 },
  { 3689, 28, 49, 35, 3, -48 },
  { 3861, 23, 47, 33, 5, -47 },
  { 3997, 11, 47, 15, 2, -47 },
  { 4062, 11, 59, 13, -3, -47 },
  { 4144, 21, 47, 26, 5, -47 },
  { 4268, 17, 47, 23, 5, -47 },
  { 4368, 34, 47, 44, 5, -47 },
  { 4568, 24, 47, 34, 5, -47 },
  { 4709, 28, 49, 34, 3, -48 },
  { 4881, 20, 47, 27, 5, -47 },
  { 4999, 28, 59, 34, 3, -48 },
  { 5206, 21, 47, 27, 5, -47 },
  { 5330, 20, 49, 26, 3, -48 },
  { 5453, 21, 47, 23, 1, -47 },
  { 5577, 23, 48, 33, 5, -47 },
  { 5715, 25, 47, 25, 0, -47 },
  { 5862, 43, 47, 44, 0, -47 },
  { 6115, 21, 47, 23, 1, -47 },
  { 6239, 22, 47, 22, 0, -47 },
  { 6369, 19, 47, 22, 2, -47 },
  { 6481, 13, 58, 20, 5, -47 },
  { 6576, 19, 47, 22, 2, -47 },
  { 6688, 13, 58, 20, 2, -47 },
  { 6783, 25, 23, 27, 1, -47 },
  { 6855, 27, 2, 26, 0, 6 },
  { 6862, 10, 10, 15, 3, -50 },
  { 6875, 18, 37, 25, 2, -36 },
  { 6959, 21, 51, 29, 5, -50 },
  { 7093, 17, 37, 21, 3, -36 },
  { 7172, 21, 51, 29, 3, -50 },
  { 7306, 20, 37, 26, 3, -36 },
  { 7399, 15, 50, 15, 1, -50 },
  { 7493, 21, 52, 28, 3, -36 },
  { 7630, 18, 50, 28, 5, -50 },
  { 7743, 4, 48, 12, 4, -48 },
  { 7767, 8, 64, 12, 0, -48 },
  { 7831, 17, 50, 22, 5, -50 },
  { 7938, 2, 50, 12, 5, -50 },
  { 7951, 32, 36, 41, 5, -36 },
  { 8095, 18, 36, 28, 5, -36 },
  { 8176, 21, 37, 27, 3, -36 },
  { 8274, 21, 51, 28, 5, -36 },
  { 8408, 21, 51, 28, 3, -36 },
  { 8542, 12, 35, 18, 5, -35 },
  { 8595, 17, 37, 21, 2, -36 },
  { 8674, 13, 44, 14, 1, -43 },
  { 8746, 19, 36, 28, 4, -35 },
  { 8832, 20, 35, 20, 0, -35 },
  { 8920, 33, 35, 35, 1, -35 },
  { 9065, 19, 35, 22, 1, -35 },
  { 9149, 20, 51, 22, 1, -35 },
  { 9277, 14, 35, 18, 2, -35 },
  { 9339, 17, 58, 23, 3, -47 },
  { 9463, 3, 66, 25, 11, -50 },
  { 9488, 17, 58, 23, 3, -47 },
  { 9612, 23, 6, 27, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT66PT7B_H_
