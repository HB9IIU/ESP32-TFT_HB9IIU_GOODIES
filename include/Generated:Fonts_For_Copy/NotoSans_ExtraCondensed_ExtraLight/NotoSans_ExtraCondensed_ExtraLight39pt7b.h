#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT39PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0x43, 0x43, 0x43,
  0x43, 0x43, 0x42, 0x42, 0x42, 0x42, 0x06, 0x18, 0x08, 0x20, 0x10, 0x40,
  0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x06, 0x08, 0x7F, 0xFE, 0xFF,
  0xFC, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x0C, 0x10,
  0x18, 0x20, 0x30, 0xC3, 0xFF, 0xF0, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04,
  0x10, 0x08, 0x20, 0x30, 0x40, 0x61, 0x80, 0xC3, 0x01, 0x06, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x3F, 0xC3, 0x23, 0x31, 0x01, 0x08, 0x18, 0x40,
  0xC2, 0x06, 0x10, 0x30, 0x80, 0x84, 0x06, 0x20, 0x19, 0x00, 0x68, 0x01,
  0xC0, 0x03, 0x80, 0x17, 0x00, 0x8C, 0x04, 0x30, 0x20, 0x81, 0x04, 0x08,
  0x20, 0x41, 0x02, 0x08, 0x10, 0xE0, 0x8D, 0xF7, 0xC1, 0xF8, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x3C, 0x06, 0x08, 0x80, 0x83, 0x18, 0x10, 0x41, 0x06,
  0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0xC6, 0x04, 0x18, 0x80, 0x83, 0x10,
  0x10, 0x66, 0x02, 0x0C, 0x80, 0x41, 0x11, 0xC8, 0x26, 0x45, 0x84, 0x98,
  0xD1, 0x92, 0x1B, 0x26, 0x41, 0x3C, 0x88, 0x20, 0x11, 0x04, 0x06, 0x20,
  0x80, 0x8C, 0x10, 0x10, 0x82, 0x06, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41,
  0x06, 0x08, 0x20, 0x81, 0x8C, 0x10, 0x11, 0x06, 0x03, 0xC0, 0x0F, 0x00,
  0x33, 0x00, 0x42, 0x01, 0x86, 0x03, 0x04, 0x06, 0x08, 0x0C, 0x30, 0x08,
  0x60, 0x10, 0x80, 0x31, 0x00, 0x66, 0x00, 0x58, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x80, 0x19, 0x80, 0x61, 0x04, 0x83, 0x1B, 0x02, 0x36, 0x06, 0x4C,
  0x04, 0x98, 0x07, 0x30, 0x0E, 0x60, 0x18, 0x40, 0x38, 0xC0, 0xD0, 0xC3,
  0x30, 0xFC, 0x30, 0xD5, 0x55, 0x50, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x08,
  0x10, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x81, 0x02, 0x06, 0x0C,
  0x18, 0x30, 0x20, 0x40, 0xC1, 0x81, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x0C,
  0xC0, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0xC0, 0x0C, 0x03,
  0x00, 0x80, 0x20, 0xC9, 0xCF, 0xC0, 0xC0, 0x58, 0x32, 0x18, 0x44, 0x18,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x03, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x33, 0x32, 0x26, 0x64,
  0xC0, 0xFF, 0x7D, 0x80, 0x00, 0x20, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x00, 0x1F, 0x03, 0x98, 0x20, 0xC6,
  0x04, 0x40, 0x64, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C,
  0x03, 0xC0, 0x2C, 0x02, 0x40, 0x24, 0x06, 0x60, 0x42, 0x0C, 0x39, 0x81,
  0xF0, 0x06, 0x1C, 0x79, 0xB6, 0x78, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x3F, 0x0E, 0x18, 0x80, 0xC0, 0x06, 0x00, 0x60, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10,
  0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x0F, 0xFF, 0x1F, 0x83, 0x87, 0x30,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x1C, 0x0F, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x98, 0x38, 0xFF, 0x00, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0x60, 0x05, 0x80, 0x26, 0x00, 0x98, 0x06, 0x60, 0x11, 0x80,
  0xC6, 0x02, 0x18, 0x18, 0x60, 0x41, 0x83, 0x06, 0x08, 0x18, 0x60, 0x61,
  0x01, 0x8C, 0x06, 0x20, 0x18, 0xFF, 0xFC, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x7F, 0xC7, 0xFC, 0x40, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0D,
  0xE0, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C, 0xC1, 0x8F,
  0xF0, 0x07, 0xE0, 0xC2, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0xF8, 0x98, 0xCA, 0x06, 0xC0, 0x2C,
  0x02, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34,
  0x03, 0x40, 0x26, 0x06, 0x30, 0xC1, 0xF8, 0x02, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x0F, 0xC0, 0xC3, 0x0C, 0x0C, 0xC0, 0x26, 0x01, 0xB0,
  0x0D, 0x80, 0x6C, 0x03, 0x60, 0x11, 0x81, 0x84, 0x18, 0x31, 0x80, 0x78,
  0x03, 0x80, 0x37, 0x03, 0x0C, 0x30, 0x33, 0x00, 0x90, 0x06, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x28, 0x03, 0x60, 0x1B, 0x01, 0x8E, 0x18, 0x3F,
  0x80, 0x1F, 0x03, 0x18, 0x60, 0xCC, 0x04, 0xC0, 0x68, 0x02, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x07, 0x40, 0x76,
  0x1B, 0x3F, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xE0, 0x7D, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF6, 0x33, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x33, 0x22, 0x66, 0x4C, 0x00, 0x04, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x00, 0x7C, 0x63, 0x80, 0xC0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30,
  0x10, 0x08, 0x0C, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0C,
  0x06, 0x00, 0x01, 0xF8, 0x00, 0x30, 0xE0, 0x0C, 0x03, 0x00, 0x80, 0x18,
  0x10, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x00, 0x66, 0x00, 0x02, 0x60, 0x7C,
  0x24, 0x0C, 0xC3, 0x41, 0x0C, 0x3C, 0x30, 0xC3, 0xC3, 0x0C, 0x1C, 0x20,
  0xC1, 0xC2, 0x0C, 0x18, 0x20, 0xC1, 0x82, 0x08, 0x18, 0x20, 0x83, 0x82,
  0x08, 0x3C, 0x20, 0x82, 0xC3, 0x14, 0x2C, 0x31, 0x46, 0x41, 0xE7, 0xC4,
  0x04, 0x18, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x40, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x07, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x2C, 0x00, 0xC8, 0x01, 0x90, 0x02,
  0x20, 0x04, 0x60, 0x18, 0xC0, 0x30, 0x80, 0x41, 0x00, 0x83, 0x03, 0x06,
  0x06, 0x04, 0x08, 0x08, 0x1F, 0xF8, 0x3F, 0xF0, 0xC0, 0x61, 0x80, 0x42,
  0x00, 0x84, 0x01, 0x98, 0x03, 0x30, 0x02, 0x40, 0x04, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x10, 0xFF, 0x07, 0xFE, 0x20, 0x19, 0x00, 0x68, 0x03, 0x40,
  0x1A, 0x00, 0x50, 0x06, 0x80, 0x34, 0x01, 0xA0, 0x09, 0x00, 0xC8, 0x1C,
  0x7F, 0xC2, 0x03, 0x10, 0x04, 0x80, 0x34, 0x00, 0xA0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x50, 0x02, 0x80, 0x34, 0x03, 0x20, 0xF1, 0xFF,
  0x00, 0x03, 0xF8, 0x70, 0xC6, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x82, 0x07, 0xF0, 0xFE,
  0x03, 0xFF, 0x08, 0x0E, 0x20, 0x08, 0x80, 0x32, 0x00, 0x48, 0x01, 0xA0,
  0x06, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xA0, 0x02, 0x80, 0x1A,
  0x00, 0x68, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x03, 0x88, 0x3C, 0x3F, 0xC0,
  0xFF, 0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x3F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x0F, 0xFE, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x03, 0xFC,
  0x07, 0x07, 0x0C, 0x01, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x3F, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x40, 0x01, 0x40, 0x01, 0x60, 0x01, 0x60, 0x01, 0x30, 0x01, 0x10, 0x01,
  0x18, 0x01, 0x0E, 0x03, 0x03, 0xFE, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x47, 0xF0, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x0D, 0xBB, 0xE0,
  0x80, 0x38, 0x02, 0x80, 0x68, 0x0C, 0x80, 0x88, 0x18, 0x81, 0x08, 0x30,
  0x86, 0x08, 0x40, 0x8C, 0x08, 0x80, 0x98, 0x0B, 0x80, 0xAC, 0x0E, 0x40,
  0xC6, 0x08, 0x20, 0x83, 0x08, 0x10, 0x81, 0x88, 0x08, 0x80, 0xC8, 0x04,
  0x80, 0x68, 0x02, 0x80, 0x38, 0x01, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7A, 0x00, 0x05, 0xA0, 0x00, 0xDB, 0x00, 0x0D, 0x90, 0x00, 0x99, 0x00,
  0x09, 0x98, 0x01, 0x98, 0x80, 0x11, 0x88, 0x01, 0x18, 0xC0, 0x31, 0x8C,
  0x03, 0x18, 0x40, 0x21, 0x84, 0x06, 0x18, 0x60, 0x61, 0x82, 0x04, 0x18,
  0x20, 0x41, 0x83, 0x0C, 0x18, 0x10, 0x81, 0x81, 0x08, 0x18, 0x19, 0x81,
  0x81, 0x98, 0x18, 0x09, 0x01, 0x80, 0xB0, 0x18, 0x0F, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x68, 0x01, 0xB0, 0x06,
  0x40, 0x19, 0x80, 0x62, 0x01, 0x88, 0x06, 0x30, 0x18, 0x40, 0x61, 0x81,
  0x82, 0x06, 0x0C, 0x18, 0x10, 0x60, 0x61, 0x81, 0x86, 0x02, 0x18, 0x0C,
  0x60, 0x11, 0x80, 0x66, 0x00, 0x98, 0x03, 0x60, 0x05, 0x80, 0x16, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x07, 0xE0, 0x0C, 0x38, 0x18, 0x0C, 0x30, 0x0C,
  0x20, 0x06, 0x60, 0x06, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03, 0x40, 0x02,
  0x60, 0x02, 0x20, 0x06, 0x30, 0x04, 0x18, 0x0C, 0x1C, 0x38, 0x07, 0xF0,
  0xFE, 0x0F, 0xF8, 0x80, 0xC8, 0x06, 0x80, 0x68, 0x02, 0x80, 0x28, 0x03,
  0x80, 0x38, 0x02, 0x80, 0x28, 0x06, 0x80, 0x68, 0x0C, 0x81, 0x8F, 0xF0,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x07, 0xE0, 0x0C, 0x38, 0x18, 0x0C,
  0x30, 0x0C, 0x20, 0x06, 0x60, 0x06, 0x40, 0x02, 0x40, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40, 0x03,
  0x40, 0x02, 0x60, 0x02, 0x20, 0x06, 0x30, 0x04, 0x18, 0x0C, 0x1C, 0x38,
  0x07, 0xF0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0xFE, 0x0F, 0xF8, 0x80, 0xC8, 0x06, 0x80, 0x28,
  0x02, 0x80, 0x28, 0x03, 0x80, 0x38, 0x02, 0x80, 0x28, 0x06, 0x80, 0x48,
  0x0C, 0xFF, 0x8F, 0xE0, 0x82, 0x08, 0x30, 0x81, 0x08, 0x18, 0x81, 0x88,
  0x0C, 0x80, 0xC8, 0x04, 0x80, 0x68, 0x02, 0x80, 0x38, 0x01, 0x1F, 0xC3,
  0x86, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0xC1, 0xCF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x03, 0x40, 0x1B, 0x01, 0x8C, 0x18, 0x3F, 0x80,
  0xC0, 0x07, 0x80, 0x0D, 0x00, 0x12, 0x00, 0x24, 0x00, 0xCC, 0x01, 0x98,
  0x02, 0x10, 0x04, 0x20, 0x18, 0x60, 0x30, 0xC0, 0x40, 0x80, 0x81, 0x03,
  0x03, 0x06, 0x06, 0x08, 0x04, 0x10, 0x08, 0x20, 0x10, 0xC0, 0x31, 0x80,
  0x22, 0x00, 0x44, 0x00, 0x98, 0x01, 0xB0, 0x03, 0x40, 0x02, 0x80, 0x05,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x24,
  0x00, 0xC0, 0x09, 0x00, 0x70, 0x06, 0x60, 0x1C, 0x01, 0x98, 0x05, 0x80,
  0x42, 0x01, 0x60, 0x10, 0x80, 0x48, 0x0C, 0x20, 0x32, 0x03, 0x0C, 0x0C,
  0x80, 0xC3, 0x03, 0x30, 0x20, 0x40, 0x8C, 0x08, 0x10, 0x21, 0x06, 0x06,
  0x18, 0x41, 0x81, 0x86, 0x10, 0x60, 0x61, 0x86, 0x10, 0x08, 0x41, 0x84,
  0x02, 0x10, 0x23, 0x00, 0xC4, 0x08, 0xC0, 0x33, 0x02, 0x20, 0x0C, 0xC0,
  0xC8, 0x01, 0x20, 0x36, 0x00, 0x48, 0x05, 0x80, 0x1A, 0x01, 0x60, 0x07,
  0x80, 0x50, 0x00, 0xE0, 0x14, 0x00, 0x30, 0x07, 0x00, 0x0C, 0x00, 0xC0,
  0x60, 0x19, 0x00, 0xCC, 0x04, 0x60, 0x61, 0x02, 0x0C, 0x30, 0x21, 0x81,
  0x08, 0x0C, 0xC0, 0x24, 0x01, 0xA0, 0x0F, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xF0, 0x04, 0x80, 0x24, 0x03, 0x30, 0x10, 0x81, 0x84, 0x08, 0x30,
  0x40, 0x86, 0x06, 0x20, 0x33, 0x00, 0x98, 0x07, 0x80, 0x30, 0xC0, 0x1E,
  0x00, 0x90, 0x04, 0xC0, 0x66, 0x02, 0x10, 0x10, 0xC1, 0x86, 0x08, 0x10,
  0x40, 0xC6, 0x06, 0x20, 0x11, 0x00, 0xD8, 0x02, 0x80, 0x14, 0x00, 0xE0,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0x00, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x7F, 0xF0, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0x80, 0x18, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x10,
  0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0x03, 0x00,
  0x0C, 0x00, 0x78, 0x01, 0x20, 0x0C, 0xC0, 0x21, 0x01, 0x86, 0x04, 0x08,
  0x30, 0x30, 0x80, 0x46, 0x01, 0x90, 0x06, 0xC0, 0x0E, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0x06, 0x0C, 0x10, 0x30, 0x1F, 0x87, 0x38, 0x01,
  0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x20, 0x7C, 0x78, 0x98,
  0x16, 0x02, 0x80, 0x50, 0x1E, 0x03, 0xC0, 0x68, 0x0D, 0x02, 0xB0, 0xD3,
  0xF2, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0xF8, 0x99, 0xCA, 0x06, 0xC0, 0x6C, 0x02, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x2A, 0x06, 0xB0, 0xC9, 0xF8, 0x0F, 0xC7,
  0x23, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC1, 0x1F,
  0xC0, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0xF1, 0x39, 0x96, 0x05, 0x60, 0x34, 0x03, 0xC0, 0x3C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x3C, 0x03, 0x40, 0x36, 0x05, 0x30, 0xD1, 0xF9, 0x0F, 0x07,
  0x31, 0x83, 0x20, 0x24, 0x07, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x3F, 0xFF,
  0xFF, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80,
  0x18, 0x31, 0xFC, 0x07, 0xC3, 0xE0, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x0F, 0xCF, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x00, 0x1F, 0x13, 0x99, 0x60, 0x56, 0x03, 0x40,
  0x3C, 0x03, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x34, 0x05, 0x60, 0x53, 0x09, 0x1F,
  0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0xC0,
  0xC7, 0xF8, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x11, 0xE2, 0x66, 0x50, 0x6C, 0x05, 0x80, 0xB0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x7D, 0x00, 0x02, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20, 0x19, 0xC4, 0x00, 0x00, 0x02,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x6E, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x38, 0x1A, 0x04, 0x83, 0x21,
  0x88, 0x42, 0x30, 0x88, 0x26, 0x0B, 0x82, 0xB0, 0xC4, 0x31, 0x88, 0x62,
  0x08, 0x83, 0x20, 0x48, 0x1A, 0x06, 0x80, 0xA0, 0x30, 0xFF, 0xFF, 0xFF,
  0xFC, 0x9F, 0x0F, 0x16, 0x73, 0x32, 0x82, 0x83, 0x60, 0x50, 0x2C, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30,
  0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x38, 0x0C, 0x06, 0x8F, 0x13, 0x32, 0x83, 0x60, 0x2C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x0F, 0x03, 0x9C, 0x60,
  0x64, 0x02, 0xC0, 0x3C, 0x03, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x03, 0xC0, 0x34, 0x02, 0x60,
  0x63, 0x0C, 0x1F, 0x80, 0x8F, 0x09, 0x9C, 0xA0, 0x6A, 0x06, 0xC0, 0x2C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x3C, 0x03, 0xC0, 0x2C, 0x06, 0xA0, 0x6B, 0x0C, 0x9F, 0x88,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x0F, 0x13, 0x99, 0x20, 0x56, 0x05, 0x40, 0x3C, 0x03, 0xC0, 0x38,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x3C,
  0x03, 0xC0, 0x34, 0x03, 0x60, 0x53, 0x09, 0x1F, 0x90, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x8F, 0x3E,
  0x85, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x00, 0x1F, 0x8E, 0x76, 0x01, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x00, 0x40, 0x30, 0x0F, 0x06, 0x7F, 0x00, 0x20, 0x40, 0x81, 0x02,
  0x0F, 0xFF, 0x90, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x3C, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1F, 0x03, 0xB1, 0xB7, 0xE6,
  0xC0, 0x3C, 0x03, 0x40, 0x24, 0x02, 0x60, 0x66, 0x06, 0x20, 0x42, 0x04,
  0x30, 0xC3, 0x0C, 0x10, 0x81, 0x08, 0x11, 0x81, 0x98, 0x09, 0x00, 0x90,
  0x09, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x20, 0x14, 0x07,
  0x01, 0x40, 0x70, 0x34, 0x05, 0x03, 0x60, 0x50, 0x22, 0x05, 0x02, 0x20,
  0xD8, 0x22, 0x0D, 0x86, 0x30, 0x88, 0x63, 0x08, 0x84, 0x11, 0x88, 0x41,
  0x18, 0xCC, 0x11, 0x0C, 0xC1, 0x90, 0x48, 0x09, 0x04, 0x80, 0xB0, 0x48,
  0x0B, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0x60, 0x30, 0x06, 0x03,
  0x00, 0xC0, 0x68, 0x09, 0x83, 0x30, 0x62, 0x18, 0x63, 0x04, 0x40, 0xD8,
  0x0A, 0x01, 0xC0, 0x30, 0x07, 0x00, 0xA0, 0x36, 0x04, 0x41, 0x8C, 0x20,
  0x8C, 0x19, 0x03, 0x60, 0x28, 0x06, 0x40, 0x14, 0x01, 0x60, 0x32, 0x03,
  0x20, 0x22, 0x02, 0x30, 0x61, 0x06, 0x10, 0x41, 0x04, 0x18, 0xC0, 0x8C,
  0x08, 0x80, 0x88, 0x0D, 0x80, 0x58, 0x05, 0x00, 0x50, 0x07, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x0F, 0x00, 0x7F, 0x3F, 0x80, 0x40, 0x60, 0x20, 0x30, 0x18, 0x08,
  0x0C, 0x04, 0x02, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10,
  0x18, 0x0F, 0xF8, 0x01, 0xC1, 0xE0, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0xF0,
  0x38, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE0, 0x3C, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x03,
  0x80, 0xF0, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x38, 0x3C, 0x00, 0x10, 0x01,
  0xF8, 0x1C, 0x39, 0xA0, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 28, 8, 3, -28 },
  { 8, 8, 10, 12, 2, -28 },
  { 18, 15, 28, 17, 1, -28 },
  { 71, 13, 32, 16, 1, -30 },
  { 123, 19, 28, 23, 2, -28 },
  { 190, 15, 28, 16, 1, -28 },
  { 243, 2, 10, 7, 2, -28 },
  { 246, 7, 34, 10, 2, -28 },
  { 276, 8, 34, 10, 1, -28 },
  { 310, 10, 11, 14, 2, -30 },
  { 324, 14, 18, 16, 1, -23 },
  { 356, 4, 9, 7, 1, -4 },
  { 361, 8, 1, 10, 1, -11 },
  { 362, 3, 3, 7, 2, -3 },
  { 364, 11, 28, 13, 1, -28 },
  { 403, 12, 28, 16, 2, -28 },
  { 445, 7, 28, 16, 3, -28 },
  { 470, 12, 28, 16, 2, -28 },
  { 512, 13, 28, 16, 1, -28 },
  { 558, 14, 28, 16, 1, -28 },
  { 607, 12, 28, 16, 2, -28 },
  { 649, 12, 29, 16, 2, -28 },
  { 693, 12, 28, 16, 2, -28 },
  { 735, 13, 28, 16, 1, -28 },
  { 781, 12, 28, 16, 2, -28 },
  { 823, 3, 21, 7, 2, -21 },
  { 831, 4, 26, 7, 1, -21 },
  { 844, 14, 16, 16, 1, -22 },
  { 872, 14, 10, 16, 1, -19 },
  { 890, 14, 16, 16, 1, -22 },
  { 918, 9, 28, 11, 1, -28 },
  { 950, 20, 32, 24, 2, -28 },
  { 1030, 15, 28, 15, 0, -28 },
  { 1083, 13, 28, 17, 3, -28 },
  { 1129, 13, 28, 16, 2, -28 },
  { 1175, 14, 28, 19, 3, -28 },
  { 1224, 10, 28, 15, 3, -28 },
  { 1259, 10, 28, 14, 3, -28 },
  { 1294, 16, 28, 20, 2, -28 },
  { 1350, 13, 28, 19, 3, -28 },
  { 1396, 7, 28, 9, 1, -28 },
  { 1421, 7, 35, 8, -2, -28 },
  { 1452, 12, 28, 15, 3, -28 },
  { 1494, 10, 28, 14, 3, -28 },
  { 1529, 20, 28, 26, 3, -28 },
  { 1599, 14, 28, 20, 3, -28 },
  { 1648, 16, 28, 20, 2, -28 },
  { 1704, 12, 28, 16, 3, -28 },
  { 1746, 16, 35, 20, 2, -28 },
  { 1816, 12, 28, 16, 3, -28 },
  { 1858, 12, 28, 15, 2, -28 },
  { 1900, 13, 28, 13, 0, -28 },
  { 1946, 13, 28, 19, 3, -28 },
  { 1992, 15, 28, 15, 0, -28 },
  { 2045, 26, 28, 26, 0, -28 },
  { 2136, 13, 28, 13, 0, -28 },
  { 2182, 13, 28, 13, 0, -28 },
  { 2228, 11, 28, 13, 1, -28 },
  { 2267, 8, 34, 12, 3, -28 },
  { 2301, 11, 28, 13, 1, -28 },
  { 2340, 8, 34, 12, 1, -28 },
  { 2374, 14, 14, 16, 1, -28 },
  { 2399, 16, 2, 16, 0, 3 },
  { 2403, 6, 6, 9, 2, -30 },
  { 2408, 11, 21, 15, 1, -21 },
  { 2437, 12, 30, 17, 3, -30 },
  { 2482, 10, 21, 12, 2, -21 },
  { 2509, 12, 30, 17, 2, -30 },
  { 2554, 11, 21, 15, 2, -21 },
  { 2583, 10, 30, 9, 0, -30 },
  { 2621, 12, 30, 17, 2, -21 },
  { 2666, 11, 30, 16, 3, -30 },
  { 2708, 3, 28, 7, 2, -28 },
  { 2719, 5, 37, 7, 0, -28 },
  { 2743, 10, 30, 13, 3, -30 },
  { 2781, 1, 30, 7, 3, -30 },
  { 2785, 19, 21, 24, 3, -21 },
  { 2835, 11, 21, 16, 3, -21 },
  { 2864, 12, 21, 16, 2, -21 },
  { 2896, 12, 30, 17, 3, -21 },
  { 2941, 12, 30, 17, 2, -21 },
  { 2986, 7, 21, 11, 3, -21 },
  { 3005, 10, 21, 12, 1, -21 },
  { 3032, 7, 26, 9, 1, -26 },
  { 3055, 11, 21, 16, 3, -21 },
  { 3084, 12, 21, 12, 0, -21 },
  { 3116, 20, 21, 21, 0, -21 },
  { 3169, 11, 21, 13, 1, -21 },
  { 3198, 12, 30, 13, 0, -21 },
  { 3243, 9, 21, 10, 1, -21 },
  { 3267, 10, 34, 14, 2, -28 },
  { 3310, 1, 39, 15, 7, -30 },
  { 3315, 10, 34, 14, 2, -28 },
  { 3358, 14, 4, 16, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight39pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT39PT7B_H_
