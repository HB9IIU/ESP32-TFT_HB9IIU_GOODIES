#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT69PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x76, 0x03, 0xB0, 0x1D,
  0x80, 0xEC, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x76, 0x03, 0xB0,
  0x1D, 0x80, 0xEC, 0x07, 0x60, 0x3B, 0x01, 0xC0, 0x00, 0x30, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x30,
  0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x06, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x00, 0x01, 0xC0, 0x30, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80,
  0x30, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30,
  0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x30, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x03, 0xEC, 0x3F, 0x0E, 0x18, 0x0C, 0x38,
  0x30, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x0E, 0x03,
  0x00, 0x1C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x30,
  0x01, 0xC0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x03, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x18, 0x00, 0x07, 0xB0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x06, 0x7C, 0x00, 0x0C, 0x3C, 0x00, 0x18, 0x3C, 0x00, 0x30, 0x3C, 0x00,
  0x60, 0x38, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x70, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x60, 0x03, 0x01, 0xD0, 0x06, 0x07,
  0x3C, 0x0C, 0x1C, 0x7F, 0x9B, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x20, 0x03, 0xFC, 0x00,
  0x18, 0x00, 0x73, 0x80, 0x03, 0x00, 0x18, 0x38, 0x00, 0xE0, 0x03, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x70, 0x03, 0x00, 0x18, 0x06, 0x00, 0xE0, 0x03,
  0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x03, 0x00, 0x1C, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0x70, 0x18, 0x00, 0x60, 0x0E, 0x03, 0x00, 0x0C, 0x00, 0xC0,
  0xE0, 0x01, 0x80, 0x18, 0x18, 0x00, 0x30, 0x03, 0x03, 0x00, 0x06, 0x00,
  0x60, 0xE0, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x18, 0x01, 0x83, 0x00, 0x03,
  0x00, 0x30, 0xE0, 0x00, 0x60, 0x0E, 0x18, 0x00, 0x0E, 0x01, 0xC3, 0x07,
  0xE1, 0xC0, 0x38, 0xE1, 0xFE, 0x18, 0x06, 0x18, 0x70, 0xC3, 0x00, 0xC3,
  0x0C, 0x1C, 0x60, 0x18, 0xE3, 0x81, 0x8E, 0x07, 0x1C, 0x60, 0x38, 0xC0,
  0xC3, 0x0C, 0x03, 0x1C, 0x38, 0x63, 0x80, 0x61, 0xCE, 0x1C, 0x70, 0x0C,
  0x3F, 0x83, 0x0C, 0x01, 0x81, 0xE0, 0x61, 0x80, 0x38, 0x00, 0x1C, 0x30,
  0x07, 0x00, 0x03, 0x06, 0x00, 0xE0, 0x00, 0x60, 0xC0, 0x1C, 0x00, 0x1C,
  0x18, 0x03, 0x80, 0x03, 0x03, 0x00, 0x70, 0x00, 0x60, 0x60, 0x0E, 0x00,
  0x1C, 0x0C, 0x01, 0xC0, 0x03, 0x01, 0x80, 0x38, 0x00, 0x60, 0x30, 0x07,
  0x00, 0x1C, 0x06, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x1C,
  0x03, 0x00, 0x1C, 0x01, 0x80, 0x60, 0x03, 0x00, 0x30, 0x1C, 0x00, 0x60,
  0x06, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x60, 0x03, 0x00, 0x0E, 0x1C, 0x00,
  0x60, 0x00, 0xFF, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1C,
  0x1C, 0x00, 0x06, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x18, 0x00,
  0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x18,
  0x00, 0x30, 0x06, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x80, 0x60, 0x00, 0xE0,
  0x38, 0x00, 0x18, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x30, 0x60, 0x00, 0x0E, 0x38, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x1C, 0x03, 0x0E,
  0x03, 0x00, 0xC3, 0x00, 0xE0, 0x31, 0xC0, 0x18, 0x0C, 0x60, 0x07, 0x03,
  0x18, 0x00, 0xC0, 0xCE, 0x00, 0x38, 0x73, 0x80, 0x07, 0x1C, 0xE0, 0x01,
  0xC6, 0x38, 0x00, 0x3B, 0x8E, 0x00, 0x06, 0xE3, 0x80, 0x01, 0xF0, 0xE0,
  0x00, 0x3C, 0x38, 0x00, 0x0E, 0x06, 0x00, 0x03, 0xC1, 0xC0, 0x01, 0xF0,
  0x70, 0x00, 0xEE, 0x0E, 0x00, 0x39, 0x83, 0x80, 0x1C, 0x70, 0x78, 0x1E,
  0x0E, 0x0F, 0xFF, 0x03, 0x81, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xFD,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x20, 0x30, 0x1F, 0x0C, 0x1F, 0xF3, 0x3F,
  0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x06, 0xC0, 0x03, 0x38, 0x01,
  0x86, 0x00, 0xE0, 0xC0, 0x70, 0x38, 0x38, 0x07, 0x04, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x1C,
  0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x18, 0x63, 0x8C, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x73, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xC0, 0xE0, 0x0E,
  0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x18, 0x38, 0x00,
  0x70, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x1C, 0x00, 0x0C, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0xE7, 0x00, 0x03, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x3B, 0x80,
  0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00,
  0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00,
  0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x03,
  0x98, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x06, 0x00,
  0x18, 0x1C, 0x00, 0xE0, 0x78, 0x03, 0x00, 0xE0, 0x1C, 0x01, 0xE1, 0xE0,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3B,
  0x07, 0x30, 0xE3, 0x1C, 0x33, 0x83, 0xF0, 0x36, 0x03, 0x40, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xEF, 0xE0, 0xF0, 0x07, 0x86, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xEF, 0xE1, 0xF0, 0x07, 0x8E, 0x00, 0x1E, 0x20, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x72, 0x00, 0x07, 0x9E,
  0x00, 0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x37, 0x00, 0x00, 0x0D, 0xC0,
  0x00, 0x07, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x31,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x60, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x60,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01,
  0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x1C,
  0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x10, 0x00,
  0x6F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE2, 0x00, 0x0F, 0x0F,
  0x00, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x78, 0x04, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0xFF, 0x01, 0x8F, 0xFE, 0x0E,
  0x78, 0x3C, 0x3B, 0x80, 0x38, 0xEC, 0x00, 0x73, 0xE0, 0x01, 0xCF, 0x00,
  0x03, 0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0x6E, 0x00, 0x01,
  0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xDC, 0x00,
  0x06, 0x70, 0x00, 0x19, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x8E, 0x00, 0x0C,
  0x38, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xE0, 0x0E, 0x03, 0xC0, 0x70, 0x07,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xBF, 0x80, 0x78, 0x07, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00,
  0x06, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x60, 0x00, 0x38, 0xC0, 0x00,
  0x71, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x3B, 0x00, 0x00,
  0x76, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0, 0x00, 0x07,
  0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE3,
  0x80, 0x01, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x1E, 0x07, 0x80, 0x78, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xF0, 0x03, 0xF7, 0xC0, 0x3C, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x61,
  0xC0, 0x03, 0x8E, 0x00, 0x0C, 0x60, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00,
  0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x60, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xEC, 0x00, 0x0F, 0x70,
  0x00, 0x7B, 0x80, 0x07, 0xCE, 0x00, 0x7E, 0x78, 0x07, 0x71, 0xF0, 0xF3,
  0x87, 0xFF, 0x1C, 0x0F, 0xE0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x04,
  0x07, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x73, 0xFF,
  0xF7, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x18, 0xF3,
  0xCF, 0x3C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x1C, 0x73,
  0x8E, 0x38, 0xE3, 0x1C, 0x71, 0x86, 0x38, 0xC3, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0xFE, 0xFC,
  0x60, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x03, 0x0C,
  0x00, 0x08, 0x00, 0x63, 0x80, 0x0F, 0xF8, 0x0E, 0x70, 0x03, 0xFF, 0x00,
  0xCC, 0x00, 0xE0, 0xE0, 0x19, 0x80, 0x38, 0x1C, 0x03, 0x30, 0x06, 0x03,
  0x80, 0x6E, 0x01, 0xC0, 0x70, 0x0F, 0xC0, 0x30, 0x0E, 0x01, 0xF8, 0x0E,
  0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x38, 0x07, 0xC0, 0x30, 0x07, 0x00, 0xF8,
  0x06, 0x00, 0xE0, 0x1F, 0x00, 0xC0, 0x18, 0x03, 0xE0, 0x18, 0x03, 0x00,
  0x7C, 0x03, 0x00, 0x60, 0x0F, 0x80, 0x60, 0x0C, 0x01, 0xF0, 0x0C, 0x01,
  0x80, 0x3E, 0x01, 0x80, 0x30, 0x07, 0xC0, 0x30, 0x0E, 0x00, 0xD8, 0x06,
  0x01, 0xC0, 0x1B, 0x00, 0xC0, 0x38, 0x03, 0x60, 0x1C, 0x07, 0x00, 0xEC,
  0x03, 0x80, 0xB0, 0x1D, 0xC0, 0x30, 0x36, 0x03, 0x38, 0x07, 0x06, 0xC0,
  0xE7, 0x00, 0x71, 0x8C, 0x38, 0x60, 0x0F, 0xF1, 0xFE, 0x0C, 0x00, 0xF8,
  0x1F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x18, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x0E, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0E, 0x38,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x18, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x18,
  0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0x80, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x30, 0x00, 0x06, 0x06,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0x80, 0x1F, 0x87, 0x00, 0x07,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x19, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00,
  0x1E, 0x1C, 0x00, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xE0, 0x0F,
  0xC1, 0xC0, 0x03, 0xC3, 0x80, 0x01, 0xC7, 0x00, 0x01, 0xCE, 0x00, 0x03,
  0x9C, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0D,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x07, 0x1C, 0x00,
  0x3E, 0x38, 0x07, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFB, 0xF8, 0x0F, 0x00, 0x30, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x80, 0xF8, 0x07, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x38, 0x03, 0xF0, 0x1C, 0x00,
  0x7C, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x06, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x67, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xDC, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x37, 0x00, 0x00, 0x1B, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x1E,
  0x03, 0x81, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x60, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x70,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x03, 0x38, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x30,
  0xE0, 0x00, 0x03, 0x07, 0x00, 0x00, 0x30, 0x78, 0x00, 0x03, 0x03, 0xC0,
  0x00, 0x30, 0x1F, 0x00, 0x1F, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x3A, 0x0F, 0x7F, 0xCF, 0xF0, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0E,
  0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80, 0x0E, 0x1C,
  0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x78, 0x00,
  0x3B, 0xF0, 0x00, 0xED, 0xC0, 0x03, 0xF3, 0x80, 0x0F, 0x8E, 0x00, 0x3C,
  0x1C, 0x00, 0xF0, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x00, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xEC, 0x00, 0x00, 0x03, 0x7E, 0xC0,
  0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x07, 0x7E, 0x60, 0x00, 0x00, 0x67,
  0xE6, 0x00, 0x00, 0x06, 0x7E, 0x70, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00,
  0x0C, 0x7E, 0x30, 0x00, 0x00, 0xC7, 0xE3, 0x80, 0x00, 0x1C, 0x7E, 0x38,
  0x00, 0x01, 0xC7, 0xE1, 0x80, 0x00, 0x18, 0x7E, 0x18, 0x00, 0x03, 0x87,
  0xE1, 0xC0, 0x00, 0x38, 0x7E, 0x0C, 0x00, 0x03, 0x07, 0xE0, 0xC0, 0x00,
  0x30, 0x7E, 0x0E, 0x00, 0x07, 0x07, 0xE0, 0xE0, 0x00, 0x60, 0x7E, 0x06,
  0x00, 0x06, 0x07, 0xE0, 0x70, 0x00, 0xE0, 0x7E, 0x07, 0x00, 0x0E, 0x07,
  0xE0, 0x30, 0x00, 0xC0, 0x7E, 0x03, 0x00, 0x1C, 0x07, 0xE0, 0x38, 0x01,
  0xC0, 0x7E, 0x01, 0x80, 0x18, 0x07, 0xE0, 0x18, 0x01, 0x80, 0x7E, 0x01,
  0xC0, 0x38, 0x07, 0xE0, 0x1C, 0x03, 0x00, 0x7E, 0x00, 0xC0, 0x30, 0x07,
  0xE0, 0x0E, 0x07, 0x00, 0x7E, 0x00, 0xE0, 0x70, 0x07, 0xE0, 0x06, 0x06,
  0x00, 0x7E, 0x00, 0x60, 0xE0, 0x07, 0xE0, 0x07, 0x0E, 0x00, 0x7E, 0x00,
  0x70, 0xC0, 0x07, 0xE0, 0x03, 0x1C, 0x00, 0x7E, 0x00, 0x39, 0xC0, 0x07,
  0xE0, 0x03, 0x98, 0x00, 0x7E, 0x00, 0x19, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xB0, 0x00, 0x07, 0xDC, 0x00, 0x03, 0xE6, 0x00, 0x01,
  0xF3, 0x80, 0x00, 0xF8, 0xC0, 0x00, 0x7C, 0x70, 0x00, 0x3E, 0x38, 0x00,
  0x1F, 0x0C, 0x00, 0x0F, 0x87, 0x00, 0x07, 0xC1, 0x80, 0x03, 0xE0, 0xE0,
  0x01, 0xF0, 0x30, 0x00, 0xF8, 0x1C, 0x00, 0x7C, 0x0E, 0x00, 0x3E, 0x03,
  0x80, 0x1F, 0x01, 0xC0, 0x0F, 0x80, 0x60, 0x07, 0xC0, 0x38, 0x03, 0xE0,
  0x0C, 0x01, 0xF0, 0x07, 0x00, 0xF8, 0x01, 0x80, 0x7C, 0x00, 0xE0, 0x3E,
  0x00, 0x70, 0x1F, 0x00, 0x1C, 0x0F, 0x80, 0x0E, 0x07, 0xC0, 0x03, 0x03,
  0xE0, 0x01, 0xC1, 0xF0, 0x00, 0x60, 0xF8, 0x00, 0x38, 0x7C, 0x00, 0x1C,
  0x3E, 0x00, 0x07, 0x1F, 0x00, 0x03, 0x8F, 0x80, 0x00, 0xC7, 0xC0, 0x00,
  0x73, 0xE0, 0x00, 0x19, 0xF0, 0x00, 0x0E, 0xF8, 0x00, 0x03, 0x7C, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x06, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x38, 0x07,
  0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xB8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07,
  0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x7C, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x81, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0E, 0x01, 0xF8, 0x38,
  0x00, 0xF0, 0xE0, 0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x33, 0x80, 0x00, 0xCE, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0,
  0x00, 0x33, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x63, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x01, 0xE0, 0xE0, 0x1F, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80,
  0x60, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x06, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x83,
  0xFF, 0xFE, 0x3E, 0x00, 0x63, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x72, 0x00, 0x07, 0x9E, 0x00, 0xF8,
  0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00,
  0xE3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x03, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x06, 0x00,
  0x18, 0x01, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0xE0, 0x03,
  0x00, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x18, 0x60, 0x00, 0x07, 0x18, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xEC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x77, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x18, 0x00, 0x07, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x36, 0x00, 0x01,
  0xC7, 0x00, 0x01, 0xB8, 0x00, 0x0E, 0x38, 0x00, 0x0D, 0xC0, 0x00, 0x61,
  0xC0, 0x00, 0x6E, 0x00, 0x07, 0x06, 0x00, 0x07, 0x30, 0x00, 0x38, 0x30,
  0x00, 0x39, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0x8E, 0x00, 0x0E, 0x0E, 0x00,
  0x0C, 0x70, 0x00, 0x60, 0x70, 0x00, 0x63, 0x80, 0x07, 0x01, 0x80, 0x07,
  0x0C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC0, 0x70, 0x01, 0x83,
  0x80, 0x0C, 0x03, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0x0C, 0x00, 0x60, 0xE0,
  0x07, 0x00, 0x60, 0x07, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x18, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0xE0, 0x0C, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0xE0,
  0x03, 0x00, 0x60, 0x38, 0x07, 0x00, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x00,
  0xE0, 0x38, 0x06, 0x01, 0xC0, 0x07, 0x01, 0x80, 0x30, 0x0C, 0x00, 0x38,
  0x0C, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x60, 0x0E, 0x07, 0x00, 0x06, 0x07,
  0x00, 0x30, 0x38, 0x00, 0x38, 0x38, 0x01, 0x81, 0x80, 0x01, 0xC1, 0x80,
  0x0C, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x70, 0xE0, 0x00, 0x30, 0x60, 0x03,
  0x87, 0x00, 0x01, 0xC7, 0x00, 0x0C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x61,
  0x80, 0x00, 0x71, 0xC0, 0x03, 0x1C, 0x00, 0x01, 0x8C, 0x00, 0x1C, 0xE0,
  0x00, 0x0C, 0x60, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x03, 0x30, 0x00,
  0x03, 0xB8, 0x00, 0x19, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0xCC, 0x00, 0x00,
  0x6C, 0x00, 0x06, 0xE0, 0x00, 0x03, 0x60, 0x00, 0x3F, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x63, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x70,
  0x01, 0xC0, 0xC0, 0x06, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x70, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x81, 0x80, 0x0E, 0x0E, 0x00,
  0x18, 0x30, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x18, 0x00, 0x0E,
  0xE0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0xCE, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x70, 0x00, 0x61,
  0xC0, 0x03, 0x83, 0x00, 0x0C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x60,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x07, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE3,
  0x00, 0x01, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x1C,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x30, 0x01, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x18, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x01,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x18, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x01, 0xC0, 0x03,
  0x80, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0x70,
  0x0E, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x07,
  0xFC, 0x07, 0xFF, 0x83, 0xE0, 0xF0, 0x40, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x7F, 0xC0, 0xFF, 0xF0, 0xFC, 0x0C, 0x78, 0x03, 0x38, 0x00, 0xDC, 0x00,
  0x36, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x02, 0xDC, 0x01, 0xB7, 0x80, 0xCC, 0xFD, 0xE3, 0x1F, 0xF0, 0xC0, 0xE0,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x3F, 0x80, 0xC3, 0xFF, 0x83,
  0x1E, 0x1F, 0x0C, 0xE0, 0x1C, 0x33, 0x00, 0x38, 0xD8, 0x00, 0x73, 0x40,
  0x01, 0xCF, 0x00, 0x03, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0x6E, 0x00, 0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xF0, 0x00, 0x33, 0xC0, 0x01, 0xCD, 0x80, 0x07, 0x36, 0x00,
  0x38, 0xCC, 0x01, 0xE3, 0x1C, 0x0F, 0x0C, 0x7F, 0xF8, 0x30, 0x7F, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x7E, 0x18, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0C, 0x1F, 0xFF,
  0x01, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x7F,
  0x07, 0x03, 0xFF, 0x1C, 0x3E, 0x1E, 0x70, 0xE0, 0x1C, 0xC7, 0x00, 0x33,
  0x38, 0x00, 0x6C, 0xE0, 0x00, 0xB3, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0x80, 0x00,
  0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x3C, 0xC0, 0x00, 0xB3,
  0x80, 0x06, 0xCE, 0x00, 0x1B, 0x1C, 0x00, 0xCC, 0x3C, 0x0E, 0x30, 0x7F,
  0xF0, 0xC0, 0xFF, 0x83, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8,
  0x01, 0xE1, 0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0x70, 0xE0,
  0x01, 0x86, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x66, 0x00, 0x03, 0x70, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x01,
  0x83, 0xE0, 0x3C, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x0C,
  0x1F, 0xFC, 0x30, 0xF8, 0x78, 0xC3, 0x80, 0x73, 0x1C, 0x00, 0xEC, 0xE0,
  0x01, 0xB3, 0x80, 0x03, 0xCC, 0x00, 0x0F, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8,
  0x00, 0x07, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0x00, 0x03, 0xCE, 0x00,
  0x1F, 0x18, 0x00, 0xDC, 0x70, 0x03, 0x70, 0xF0, 0x39, 0xC1, 0xFF, 0xC7,
  0x03, 0xFE, 0x1C, 0x03, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x71,
  0x00, 0x03, 0x87, 0x80, 0x3C, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F,
  0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x07, 0xE0, 0xC3, 0xFF, 0x18, 0xF1, 0xF3, 0x38, 0x0E, 0x66,
  0x00, 0xED, 0x80, 0x0D, 0xA0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x30, 0x73, 0xBE, 0xE7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x80, 0x07, 0x0F, 0x0F, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0xFC, 0xF8, 0x60, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0E, 0xC0, 0x03, 0xB0,
  0x01, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x1C, 0x30, 0x07, 0x0C, 0x03,
  0x83, 0x01, 0xC0, 0xC0, 0x70, 0x30, 0x38, 0x0C, 0x0C, 0x03, 0x07, 0x00,
  0xC3, 0x80, 0x30, 0xE0, 0x0C, 0x78, 0x03, 0x1F, 0x00, 0xCD, 0xC0, 0x37,
  0x30, 0x0D, 0x8E, 0x03, 0xC1, 0x80, 0xF0, 0x70, 0x38, 0x1C, 0x0C, 0x03,
  0x03, 0x00, 0xE0, 0xC0, 0x18, 0x30, 0x07, 0x0C, 0x01, 0xC3, 0x00, 0x38,
  0xC0, 0x0E, 0x30, 0x01, 0x8C, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x03, 0xB0,
  0x00, 0xEC, 0x00, 0x1B, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x03, 0xF8, 0x63,
  0xFF, 0x03, 0xFE, 0x33, 0xC3, 0xC3, 0x87, 0x99, 0x80, 0xE3, 0x01, 0xED,
  0x80, 0x3B, 0x00, 0x76, 0x80, 0x1D, 0x80, 0x1F, 0xC0, 0x06, 0x80, 0x0F,
  0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x18, 0xC0, 0xFE, 0x18, 0x7F, 0xE3, 0x1E, 0x1E, 0x67,
  0x01, 0xED, 0xC0, 0x1D, 0xB0, 0x01, 0xB4, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x06, 0x01, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0xF8, 0x7C, 0x03, 0x80, 0x78, 0x1C, 0x00, 0xF0, 0xE0, 0x01,
  0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0E, 0x70, 0x00, 0x19, 0xC0, 0x00, 0x66,
  0x00, 0x01, 0xD8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xDC, 0x00,
  0x06, 0x70, 0x00, 0x19, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x8E, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x03, 0x80, 0xF0, 0x1E, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0xFE, 0x03, 0x0F, 0xFE, 0x0C, 0x78,
  0x7C, 0x33, 0x80, 0x70, 0xCC, 0x00, 0xE3, 0x60, 0x01, 0xCD, 0x80, 0x07,
  0x3C, 0x00, 0x0C, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xE0,
  0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x3B, 0xC0, 0x00, 0xCD, 0x00, 0x07, 0x36, 0x00, 0x1C, 0xD8, 0x00, 0xE3,
  0x30, 0x07, 0x8C, 0x70, 0x3C, 0x30, 0xFF, 0xE0, 0xC1, 0xFF, 0x03, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x0C, 0x0F, 0xFC,
  0x30, 0x78, 0x78, 0xC3, 0x80, 0x73, 0x1C, 0x00, 0xCC, 0x60, 0x01, 0xB3,
  0x80, 0x02, 0xCE, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xDC, 0x00, 0x07,
  0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0x80, 0x02, 0xCE, 0x00, 0x1F, 0x1C,
  0x00, 0xDC, 0x78, 0x07, 0x70, 0xF0, 0x39, 0xC1, 0xFF, 0xC7, 0x03, 0xFE,
  0x1C, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0xC1, 0xFE, 0x1F,
  0xF1, 0xFF, 0x9C, 0x0C, 0xC0, 0x6C, 0x03, 0x60, 0x1A, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x03, 0xFE,
  0x03, 0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x02, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0xB0, 0x01, 0xCF, 0x00, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xF0, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xF0,
  0x3F, 0x80, 0x70, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x5F, 0x00, 0x1B, 0x70, 0x03, 0x6E, 0x00, 0xCC,
  0xE0, 0x71, 0x9F, 0xFE, 0x31, 0xFF, 0x06, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3B, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xE0, 0x00, 0x67, 0x00, 0x07, 0x18,
  0x00, 0x38, 0xC0, 0x01, 0xC7, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x06, 0x00, 0x38, 0x38, 0x01, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x30,
  0x07, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x01, 0x80, 0xE0,
  0x0C, 0x06, 0x00, 0x70, 0x30, 0x03, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0x60,
  0xC0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0x63, 0x80, 0x03, 0x18, 0x00,
  0x18, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xD8,
  0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03,
  0x60, 0x03, 0x98, 0x00, 0x6C, 0x00, 0x73, 0x80, 0x0D, 0x80, 0x0C, 0x70,
  0x03, 0xB8, 0x01, 0x86, 0x00, 0x77, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x0E,
  0x1C, 0x01, 0x8C, 0x01, 0xC3, 0x80, 0x71, 0x80, 0x30, 0x30, 0x0E, 0x38,
  0x06, 0x06, 0x01, 0xC3, 0x01, 0xC0, 0xC0, 0x30, 0x60, 0x38, 0x1C, 0x06,
  0x0C, 0x06, 0x03, 0x81, 0xC1, 0xC0, 0xC0, 0x30, 0x38, 0x38, 0x18, 0x06,
  0x06, 0x03, 0x07, 0x00, 0xE0, 0xC0, 0x60, 0xE0, 0x1C, 0x18, 0x0C, 0x18,
  0x01, 0x87, 0x01, 0xC3, 0x00, 0x30, 0xE0, 0x38, 0xE0, 0x06, 0x18, 0x03,
  0x1C, 0x00, 0xE3, 0x00, 0x63, 0x00, 0x1C, 0xE0, 0x0C, 0x60, 0x01, 0x9C,
  0x01, 0xCC, 0x00, 0x33, 0x80, 0x3B, 0x80, 0x07, 0x60, 0x03, 0x70, 0x00,
  0xEC, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x0D, 0x80, 0x01, 0xF0, 0x01, 0xB0,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x77, 0x00, 0x07, 0x30,
  0x00, 0xE3, 0x80, 0x0E, 0x18, 0x01, 0xC1, 0xC0, 0x1C, 0x0C, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x30, 0xE0,
  0x03, 0x8E, 0x00, 0x19, 0xC0, 0x01, 0xDC, 0x00, 0x0D, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1D,
  0x80, 0x01, 0x9C, 0x00, 0x38, 0xC0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07,
  0x07, 0x00, 0x60, 0x70, 0x0E, 0x03, 0x80, 0xC0, 0x38, 0x1C, 0x01, 0x81,
  0x80, 0x1C, 0x38, 0x00, 0xC3, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x07,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0xD8, 0x00, 0x0C, 0xE0,
  0x00, 0x67, 0x00, 0x07, 0x18, 0x00, 0x38, 0xC0, 0x01, 0x87, 0x00, 0x0C,
  0x38, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x30, 0x38, 0x01, 0x81, 0xC0,
  0x1C, 0x06, 0x00, 0xE0, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80,
  0x30, 0x1C, 0x01, 0x80, 0xC0, 0x0E, 0x06, 0x00, 0x70, 0x70, 0x01, 0x83,
  0x80, 0x0C, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x8E, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x00, 0x03, 0x98, 0x00, 0x1D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0x60,
  0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x02,
  0x00, 0x00, 0x1F, 0xE0, 0x01, 0x7F, 0xF8, 0x03, 0xF0, 0x7C, 0x07, 0xC0,
  0x1F, 0xFE, 0x80, 0x07, 0xFC, 0x80, 0x00, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 49, 14, 5, -49 },
  { 26, 13, 18, 21, 4, -49 },
  { 56, 28, 49, 30, 1, -49 },
  { 228, 23, 56, 28, 2, -52 },
  { 389, 35, 51, 41, 3, -50 },
  { 613, 26, 51, 28, 2, -50 },
  { 779, 3, 18, 12, 4, -49 },
  { 786, 12, 60, 19, 4, -49 },
  { 876, 12, 60, 19, 3, -49 },
  { 966, 18, 18, 24, 3, -52 },
  { 1007, 24, 32, 28, 2, -40 },
  { 1103, 6, 16, 13, 3, -7 },
  { 1115, 14, 3, 18, 2, -20 },
  { 1121, 5, 5, 13, 4, -5 },
  { 1125, 20, 49, 23, 2, -49 },
  { 1248, 22, 50, 28, 3, -50 },
  { 1386, 12, 49, 28, 5, -49 },
  { 1460, 21, 50, 28, 3, -50 },
  { 1592, 21, 51, 28, 3, -50 },
  { 1726, 26, 50, 28, 1, -50 },
  { 1889, 22, 50, 28, 3, -49 },
  { 2027, 22, 51, 28, 3, -50 },
  { 2168, 21, 49, 28, 3, -49 },
  { 2297, 23, 51, 28, 2, -50 },
  { 2444, 21, 51, 28, 3, -50 },
  { 2578, 5, 37, 13, 4, -37 },
  { 2602, 6, 46, 13, 3, -37 },
  { 2637, 24, 29, 28, 2, -39 },
  { 2724, 24, 17, 28, 2, -33 },
  { 2775, 24, 29, 28, 2, -39 },
  { 2862, 16, 50, 19, 1, -50 },
  { 2962, 35, 56, 42, 4, -50 },
  { 3207, 27, 49, 27, 0, -49 },
  { 3373, 23, 49, 30, 5, -49 },
  { 3514, 23, 51, 29, 4, -50 },
  { 3661, 25, 49, 33, 5, -49 },
  { 3815, 18, 49, 27, 5, -49 },
  { 3926, 18, 49, 25, 5, -49 },
  { 4037, 28, 51, 36, 4, -50 },
  { 4216, 24, 49, 34, 5, -49 },
  { 4363, 10, 49, 16, 3, -49 },
  { 4425, 11, 61, 13, -3, -49 },
  { 4509, 22, 49, 27, 5, -49 },
  { 4644, 18, 49, 24, 5, -49 },
  { 4755, 36, 49, 46, 5, -49 },
  { 4976, 25, 49, 36, 5, -49 },
  { 5130, 28, 51, 36, 4, -50 },
  { 5309, 21, 49, 28, 5, -49 },
  { 5438, 28, 62, 36, 4, -50 },
  { 5655, 22, 49, 29, 5, -49 },
  { 5790, 21, 51, 27, 3, -50 },
  { 5924, 22, 49, 24, 1, -49 },
  { 6059, 24, 50, 34, 5, -49 },
  { 6209, 26, 49, 26, 0, -49 },
  { 6369, 45, 49, 46, 0, -49 },
  { 6645, 22, 49, 24, 1, -49 },
  { 6780, 23, 49, 23, 0, -49 },
  { 6921, 19, 49, 23, 2, -49 },
  { 7038, 13, 60, 21, 6, -49 },
  { 7136, 20, 49, 23, 2, -49 },
  { 7259, 14, 60, 21, 2, -49 },
  { 7364, 26, 24, 28, 1, -49 },
  { 7442, 28, 2, 28, 0, 6 },
  { 7449, 10, 11, 16, 3, -53 },
  { 7463, 18, 38, 26, 3, -37 },
  { 7549, 22, 53, 30, 5, -52 },
  { 7695, 18, 38, 22, 3, -37 },
  { 7781, 22, 53, 30, 3, -52 },
  { 7927, 21, 38, 27, 3, -37 },
  { 8027, 16, 53, 15, 1, -53 },
  { 8133, 22, 54, 30, 3, -37 },
  { 8282, 19, 52, 29, 5, -52 },
  { 8406, 5, 50, 13, 4, -50 },
  { 8438, 8, 67, 13, 0, -50 },
  { 8505, 18, 52, 23, 5, -52 },
  { 8622, 2, 52, 12, 5, -52 },
  { 8635, 33, 37, 43, 5, -37 },
  { 8788, 19, 37, 29, 5, -37 },
  { 8876, 22, 38, 28, 3, -37 },
  { 8981, 22, 53, 30, 5, -37 },
  { 9127, 22, 53, 30, 3, -37 },
  { 9273, 13, 37, 19, 5, -37 },
  { 9334, 18, 38, 22, 2, -37 },
  { 9420, 13, 46, 15, 1, -45 },
  { 9495, 19, 38, 29, 5, -37 },
  { 9586, 21, 37, 21, 0, -37 },
  { 9684, 35, 37, 37, 1, -37 },
  { 9846, 20, 37, 23, 1, -37 },
  { 9939, 21, 54, 23, 1, -37 },
  { 10081, 15, 37, 18, 2, -37 },
  { 10151, 18, 60, 24, 3, -49 },
  { 10286, 2, 70, 26, 12, -53 },
  { 10304, 18, 60, 24, 3, -49 },
  { 10439, 24, 7, 28, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT69PT7B_H_
