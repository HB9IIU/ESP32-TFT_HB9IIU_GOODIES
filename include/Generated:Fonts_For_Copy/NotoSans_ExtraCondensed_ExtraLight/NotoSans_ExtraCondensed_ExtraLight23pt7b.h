#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0x8C, 0x63, 0x18, 0xC4, 0x11, 0x04, 0x41, 0x10, 0x44,
  0x7F, 0xC4, 0x81, 0x20, 0x48, 0x12, 0x08, 0x8F, 0xF8, 0x88, 0x22, 0x08,
  0x82, 0x40, 0x90, 0x10, 0xFE, 0x44, 0x89, 0x12, 0x24, 0x28, 0x30, 0x38,
  0x48, 0x91, 0x22, 0x44, 0xFE, 0x10, 0x20, 0x20, 0x05, 0x08, 0x91, 0x08,
  0x90, 0x89, 0x08, 0xA0, 0x8A, 0x08, 0xAE, 0x95, 0x25, 0x52, 0x25, 0x10,
  0x91, 0x09, 0x10, 0x91, 0x11, 0x11, 0x12, 0x10, 0xE0, 0x30, 0x48, 0x48,
  0x44, 0x48, 0x48, 0x48, 0x30, 0x20, 0x50, 0x89, 0x89, 0x86, 0x86, 0x82,
  0x86, 0x79, 0xFC, 0x12, 0x24, 0x44, 0x88, 0x88, 0x88, 0x84, 0x44, 0x22,
  0x11, 0x84, 0x22, 0x21, 0x11, 0x11, 0x11, 0x11, 0x22, 0x24, 0x48, 0x12,
  0x57, 0x8C, 0x49, 0x20, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x5A, 0x80, 0xF8, 0x70, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04,
  0x20, 0x84, 0x10, 0x42, 0x08, 0x20, 0x18, 0xC9, 0x12, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x50, 0xA2, 0x38, 0x35, 0x91, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x31, 0x98, 0x10, 0x10, 0x20, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x40, 0xFE, 0x31, 0x98, 0x08, 0x10,
  0x20, 0x41, 0x02, 0x38, 0x08, 0x08, 0x10, 0x20, 0x40, 0x82, 0xF8, 0x02,
  0x01, 0x01, 0x81, 0x40, 0xA0, 0x50, 0x48, 0x24, 0x22, 0x11, 0x10, 0x88,
  0x4F, 0xF8, 0x10, 0x08, 0x04, 0x02, 0x00, 0x7C, 0x82, 0x04, 0x08, 0x10,
  0x3E, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20, 0x41, 0x7C, 0x0C, 0x65, 0x02,
  0x04, 0x10, 0x20, 0x5E, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x50, 0xA1, 0x3C,
  0xFE, 0x04, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x51, 0x14, 0x18, 0xCA, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x7C, 0x38, 0x8A, 0x14, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x8C, 0xE8, 0x10, 0x20, 0x81, 0x04, 0x78, 0xD0, 0x00, 0x07, 0x50,
  0x00, 0x05, 0xA8, 0x01, 0x06, 0x18, 0x60, 0x80, 0x40, 0x30, 0x0C, 0x02,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x40, 0x30, 0x0C, 0x03,
  0x06, 0x18, 0x20, 0xC0, 0x80, 0x72, 0x20, 0x41, 0x04, 0x10, 0x82, 0x10,
  0x82, 0x08, 0x20, 0x00, 0x08, 0x20, 0x07, 0x01, 0x88, 0x20, 0x42, 0x02,
  0x40, 0x24, 0x71, 0x89, 0x18, 0x91, 0x89, 0x19, 0x11, 0x91, 0x19, 0x11,
  0x89, 0x18, 0xAA, 0x44, 0x44, 0x00, 0x40, 0x02, 0x00, 0x1F, 0x80, 0x08,
  0x0A, 0x05, 0x02, 0x81, 0x41, 0x10, 0x88, 0x44, 0x22, 0x1F, 0x10, 0x48,
  0x24, 0x12, 0x0A, 0x03, 0x01, 0xFD, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x7C,
  0x85, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x7C, 0x0E, 0x11, 0x20, 0x40, 0x40,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x1F,
  0xFC, 0x84, 0x82, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x82, 0x84, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x3E, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFE, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x07, 0x06, 0x32, 0x01, 0x00, 0x40, 0x10, 0x08,
  0x02, 0x00, 0x80, 0x20, 0xF8, 0x06, 0x01, 0x40, 0x50, 0x14, 0x04, 0x81,
  0x1F, 0xC0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92, 0x49, 0x24, 0x97,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1E, 0x87, 0x0A,
  0x24, 0x49, 0x14, 0x28, 0x70, 0xA1, 0x22, 0x44, 0x48, 0x90, 0xA1, 0x41,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F,
  0x80, 0x3C, 0x03, 0xC0, 0x5C, 0x05, 0xA0, 0x5A, 0x09, 0xA0, 0x9A, 0x09,
  0x91, 0x19, 0x11, 0x91, 0x18, 0x91, 0x8A, 0x18, 0xA1, 0x86, 0x18, 0x41,
  0x81, 0xC1, 0xC1, 0xA1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85,
  0x83, 0x83, 0x83, 0x81, 0x0C, 0x0C, 0xC4, 0x09, 0x02, 0x40, 0xA0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x90, 0x24, 0x08, 0x84,
  0x1E, 0x00, 0xF9, 0x0A, 0x14, 0x18, 0x30, 0x61, 0x42, 0xF9, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x0C, 0x0C, 0xC4, 0x09, 0x02, 0x40, 0xA0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x40, 0x90, 0x24, 0x08, 0x84,
  0x1E, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0xF9, 0x0A, 0x14, 0x18, 0x30,
  0xA1, 0x44, 0xF1, 0x22, 0x24, 0x48, 0x50, 0xA1, 0x41, 0x1C, 0xC6, 0x04,
  0x08, 0x10, 0x20, 0x30, 0x30, 0x18, 0x08, 0x10, 0x20, 0x40, 0x82, 0xFC,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x82, 0x7C, 0x80, 0xC0, 0x90, 0x48,
  0x24, 0x12, 0x10, 0x88, 0x44, 0x22, 0x12, 0x09, 0x02, 0x81, 0x40, 0xA0,
  0x60, 0x10, 0x81, 0x03, 0x02, 0x05, 0x0A, 0x0A, 0x14, 0x24, 0x28, 0x48,
  0x50, 0x88, 0xA1, 0x11, 0x24, 0x24, 0x48, 0x48, 0x90, 0x91, 0x20, 0xA2,
  0x41, 0x43, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x43, 0x42, 0x22, 0x24,
  0x24, 0x18, 0x18, 0x08, 0x18, 0x18, 0x24, 0x24, 0x22, 0x42, 0x42, 0x81,
  0x83, 0x42, 0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x18, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0xFC, 0x10, 0x82, 0x08, 0x41, 0x08, 0x20, 0x84,
  0x10, 0x42, 0x08, 0x3F, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x8F, 0x82, 0x04, 0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0x02, 0x08,
  0x20, 0x41, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F,
  0x0C, 0x0A, 0x04, 0x84, 0x42, 0x22, 0x09, 0x05, 0x01, 0xFF, 0x80, 0x89,
  0x10, 0x78, 0x10, 0x41, 0x04, 0xF4, 0x61, 0x86, 0x18, 0x5F, 0x81, 0x02,
  0x04, 0x08, 0x1F, 0xA1, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC2,
  0xF8, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x0F, 0x02, 0x04,
  0x08, 0x10, 0x2F, 0xD0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xA3,
  0x3A, 0x3C, 0x8A, 0x0C, 0x18, 0x3F, 0xE0, 0x40, 0x81, 0x01, 0x01, 0xF0,
  0x1C, 0x82, 0x08, 0x20, 0x8F, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x80, 0x7E, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x19,
  0xD0, 0x20, 0x40, 0x81, 0xCC, 0x60, 0x82, 0x08, 0x20, 0x83, 0xE8, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0x70, 0x15, 0x55, 0x55, 0x40,
  0x2C, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0xA0, 0x82, 0x08, 0x20,
  0x82, 0x29, 0x24, 0xA2, 0x8E, 0x28, 0x92, 0x48, 0xA2, 0x8C, 0xFF, 0xFF,
  0x80, 0xFB, 0xD1, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21,
  0x84, 0x30, 0x86, 0x10, 0xC2, 0x10, 0xFA, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x7C, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05,
  0x09, 0xE0, 0xFD, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0B, 0x15,
  0xC8, 0x10, 0x20, 0x40, 0x80, 0x3E, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x05, 0x19, 0xD0, 0x20, 0x40, 0x81, 0x02, 0xF8, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x7A, 0x08, 0x20, 0xC0, 0x81, 0x02, 0x04, 0x10, 0xBE, 0x21,
  0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0xE0, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0xFD, 0x83, 0x05, 0x12, 0x24, 0x48, 0x8A,
  0x14, 0x28, 0x50, 0x40, 0x80, 0x82, 0x14, 0x61, 0x46, 0x24, 0x52, 0x45,
  0x24, 0x92, 0x29, 0x22, 0x94, 0x28, 0xC2, 0x8C, 0x10, 0xC1, 0x08, 0x42,
  0x88, 0x91, 0x41, 0x82, 0x06, 0x14, 0x24, 0x89, 0x16, 0x10, 0xC2, 0x85,
  0x0A, 0x22, 0x44, 0x89, 0x14, 0x18, 0x30, 0x60, 0x81, 0x02, 0x04, 0x10,
  0x21, 0x80, 0xF8, 0x84, 0x42, 0x11, 0x08, 0x44, 0x21, 0xF0, 0x1C, 0x42,
  0x08, 0x20, 0x82, 0x08, 0x23, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x81,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x81, 0x04, 0x10, 0x41, 0x04, 0x10, 0x31,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x42, 0x30, 0xF1, 0x8E,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 5, 6, 7, 1, -16 },
  { 7, 10, 16, 10, 0, -16 },
  { 27, 7, 18, 9, 1, -17 },
  { 43, 12, 17, 14, 1, -17 },
  { 69, 8, 17, 9, 1, -17 },
  { 86, 1, 6, 4, 1, -16 },
  { 87, 4, 20, 6, 1, -16 },
  { 97, 4, 20, 6, 1, -16 },
  { 107, 6, 6, 8, 1, -17 },
  { 112, 8, 10, 9, 1, -13 },
  { 122, 2, 5, 4, 1, -2 },
  { 124, 5, 1, 6, 1, -7 },
  { 125, 2, 2, 4, 1, -2 },
  { 126, 6, 16, 8, 1, -16 },
  { 138, 7, 17, 9, 1, -17 },
  { 153, 4, 16, 9, 2, -16 },
  { 161, 7, 17, 9, 1, -17 },
  { 176, 7, 17, 9, 1, -17 },
  { 191, 9, 17, 9, 0, -17 },
  { 211, 7, 16, 9, 1, -16 },
  { 225, 7, 17, 9, 1, -17 },
  { 240, 7, 16, 9, 1, -16 },
  { 254, 7, 17, 9, 1, -17 },
  { 269, 7, 17, 9, 1, -17 },
  { 284, 2, 12, 4, 1, -12 },
  { 287, 2, 15, 4, 1, -12 },
  { 291, 8, 10, 9, 1, -13 },
  { 301, 8, 6, 9, 1, -11 },
  { 307, 8, 10, 9, 1, -13 },
  { 317, 6, 17, 6, 0, -17 },
  { 330, 12, 19, 14, 1, -17 },
  { 359, 9, 16, 9, 0, -16 },
  { 377, 7, 16, 10, 2, -16 },
  { 391, 8, 17, 10, 1, -17 },
  { 408, 8, 16, 11, 2, -16 },
  { 424, 6, 16, 9, 2, -16 },
  { 436, 6, 16, 8, 2, -16 },
  { 448, 10, 17, 12, 1, -17 },
  { 470, 8, 16, 11, 2, -16 },
  { 486, 3, 16, 5, 1, -16 },
  { 492, 4, 20, 4, -1, -16 },
  { 502, 7, 16, 9, 2, -16 },
  { 516, 6, 16, 8, 2, -16 },
  { 528, 12, 16, 15, 2, -16 },
  { 552, 8, 16, 12, 2, -16 },
  { 568, 10, 17, 12, 1, -17 },
  { 590, 7, 16, 9, 2, -16 },
  { 604, 10, 21, 12, 1, -17 },
  { 631, 7, 16, 10, 2, -16 },
  { 645, 7, 17, 9, 1, -17 },
  { 660, 8, 16, 8, 0, -16 },
  { 676, 8, 16, 11, 2, -16 },
  { 692, 9, 16, 9, 0, -16 },
  { 710, 15, 16, 15, 0, -16 },
  { 740, 8, 16, 8, 0, -16 },
  { 756, 8, 16, 8, 0, -16 },
  { 772, 6, 16, 8, 1, -16 },
  { 784, 4, 20, 7, 2, -16 },
  { 794, 6, 16, 8, 1, -16 },
  { 806, 4, 20, 7, 1, -16 },
  { 816, 9, 8, 9, 0, -16 },
  { 825, 9, 1, 9, 0, 2 },
  { 827, 3, 4, 5, 1, -18 },
  { 829, 6, 12, 9, 1, -12 },
  { 838, 7, 17, 10, 2, -17 },
  { 853, 6, 12, 7, 1, -12 },
  { 862, 7, 17, 10, 1, -17 },
  { 877, 7, 12, 9, 1, -12 },
  { 888, 6, 18, 5, 0, -18 },
  { 902, 7, 18, 10, 1, -12 },
  { 918, 6, 17, 10, 2, -17 },
  { 931, 2, 17, 4, 1, -17 },
  { 936, 3, 23, 4, 0, -17 },
  { 945, 6, 17, 8, 2, -17 },
  { 958, 1, 17, 4, 2, -17 },
  { 961, 11, 12, 14, 2, -12 },
  { 978, 6, 12, 10, 2, -12 },
  { 987, 7, 12, 9, 1, -12 },
  { 998, 7, 17, 10, 2, -12 },
  { 1013, 7, 17, 10, 1, -12 },
  { 1028, 4, 12, 6, 2, -12 },
  { 1034, 6, 12, 7, 1, -12 },
  { 1043, 5, 15, 5, 0, -15 },
  { 1053, 6, 12, 10, 2, -12 },
  { 1062, 7, 12, 7, 0, -12 },
  { 1073, 12, 12, 12, 0, -12 },
  { 1091, 7, 12, 8, 0, -12 },
  { 1102, 7, 18, 8, 0, -12 },
  { 1118, 5, 12, 6, 1, -12 },
  { 1126, 6, 20, 8, 1, -16 },
  { 1141, 1, 24, 9, 4, -18 },
  { 1144, 6, 20, 8, 1, -16 },
  { 1159, 8, 2, 9, 1, -9 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT23PT7B_H_
