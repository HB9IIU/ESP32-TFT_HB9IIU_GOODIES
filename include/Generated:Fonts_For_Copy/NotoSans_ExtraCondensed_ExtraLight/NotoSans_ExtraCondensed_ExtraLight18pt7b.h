#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT18PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xC8, 0xB6, 0xDA, 0x14, 0x28, 0x91, 0x27, 0xE4, 0x89, 0x12,
  0xFE, 0x51, 0x22, 0x44, 0x80, 0x21, 0xCA, 0xA8, 0xA2, 0x8E, 0x0C, 0x28,
  0x92, 0x49, 0xA9, 0xC2, 0x00, 0x62, 0x52, 0x25, 0x12, 0x89, 0x84, 0xDA,
  0xB2, 0xE9, 0x14, 0x8A, 0x49, 0x24, 0x92, 0x30, 0x62, 0x49, 0x24, 0x51,
  0x86, 0x29, 0x96, 0x58, 0xA2, 0xF4, 0xF8, 0x29, 0x49, 0x24, 0x92, 0x48,
  0x91, 0x91, 0x22, 0x49, 0x24, 0x94, 0xA4, 0x21, 0x36, 0xC9, 0x00, 0x20,
  0x82, 0x08, 0xFC, 0x82, 0x08, 0x20, 0xF0, 0xF0, 0x80, 0x04, 0x20, 0x82,
  0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x80, 0x74, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x17, 0x00, 0x35, 0x91, 0x11, 0x11, 0x11, 0x11, 0x10, 0xF0,
  0x42, 0x10, 0x84, 0x42, 0x21, 0x11, 0x0F, 0x80, 0xF4, 0x42, 0x10, 0x89,
  0xC1, 0x08, 0x42, 0x1F, 0x00, 0x08, 0x10, 0x50, 0xA2, 0x44, 0x91, 0x22,
  0x85, 0xFC, 0x10, 0x20, 0x40, 0xFC, 0x21, 0x08, 0x78, 0x21, 0x08, 0x42,
  0x1F, 0x00, 0x3A, 0x21, 0x08, 0x7A, 0x31, 0x8C, 0x63, 0x17, 0x00, 0xF8,
  0x42, 0x11, 0x08, 0x44, 0x21, 0x10, 0x84, 0x00, 0x72, 0x28, 0xA2, 0x89,
  0x47, 0x22, 0x8A, 0x18, 0x62, 0x78, 0x74, 0x63, 0x18, 0xC6, 0x2F, 0x08,
  0x42, 0x2E, 0x00, 0xC0, 0x40, 0xC0, 0xF0, 0x0C, 0xC4, 0x20, 0x40, 0xC0,
  0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0xF0,
  0x82, 0x11, 0x08, 0x84, 0x42, 0x00, 0x04, 0x00, 0x1E, 0x10, 0x90, 0x50,
  0x19, 0xCC, 0xA6, 0x93, 0x49, 0xA4, 0xCA, 0x66, 0xD0, 0x04, 0x01, 0x10,
  0x70, 0x10, 0x20, 0xA1, 0x42, 0x85, 0x11, 0x3E, 0x44, 0x8A, 0x0C, 0x18,
  0x20, 0xFA, 0x18, 0x61, 0x86, 0x2F, 0xA1, 0x86, 0x18, 0x61, 0xF8, 0x3D,
  0x04, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x3C, 0xF1, 0x1A, 0x14,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x14, 0x2F, 0x80, 0xFC, 0x21, 0x08,
  0x43, 0xF0, 0x84, 0x21, 0x0F, 0x80, 0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84,
  0x21, 0x08, 0x00, 0x3E, 0x81, 0x04, 0x08, 0x10, 0x23, 0x41, 0x83, 0x06,
  0x0A, 0x13, 0xE0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x20, 0xE9, 0x24, 0x92, 0x49, 0x2E, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x4F, 0x86, 0x28, 0xA4, 0xA2, 0x8E, 0x24, 0x92, 0x28, 0xA2, 0x84,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80, 0x80, 0xF0, 0x3C,
  0x0E, 0x85, 0xA1, 0x68, 0x5A, 0x16, 0x49, 0x92, 0x64, 0x98, 0xC6, 0x31,
  0x8C, 0x40, 0x83, 0x87, 0x0D, 0x1A, 0x32, 0x64, 0xC5, 0x8B, 0x16, 0x1C,
  0x38, 0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A,
  0x13, 0xC0, 0xF2, 0x28, 0x61, 0x86, 0x18, 0xBC, 0x82, 0x08, 0x20, 0x80,
  0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x13, 0xC1,
  0x01, 0x02, 0xF2, 0x28, 0x61, 0x86, 0x1F, 0xA4, 0x92, 0x28, 0xA1, 0x84,
  0x7C, 0x21, 0x08, 0x20, 0xC1, 0x08, 0x42, 0x1F, 0x00, 0xFC, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0A, 0x27, 0x80, 0x83, 0x06, 0x12, 0x24, 0x48,
  0x91, 0x14, 0x28, 0x50, 0xA1, 0x81, 0x00, 0x84, 0x18, 0x61, 0x86, 0x24,
  0x62, 0x46, 0x24, 0xA2, 0x49, 0x24, 0x94, 0x29, 0x42, 0x94, 0x31, 0x43,
  0x08, 0x10, 0x80, 0x45, 0x14, 0x8A, 0x28, 0x41, 0x0C, 0x29, 0x24, 0x91,
  0x84, 0x86, 0x14, 0x92, 0x48, 0xC3, 0x08, 0x20, 0x82, 0x08, 0x20, 0x78,
  0x20, 0x82, 0x10, 0x41, 0x08, 0x21, 0x04, 0x10, 0xFC, 0xF8, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x8F, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10,
  0x20, 0x82, 0x04, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x4F, 0x10, 0x30, 0xA1,
  0x24, 0x58, 0x40, 0xFE, 0xA4, 0x64, 0x82, 0x13, 0xE6, 0x31, 0x9F, 0x40,
  0x82, 0x08, 0x20, 0xB3, 0x28, 0x61, 0x86, 0x18, 0x61, 0xC6, 0xE0, 0x34,
  0x88, 0x88, 0x88, 0x87, 0x04, 0x10, 0x41, 0x76, 0x38, 0x61, 0x86, 0x18,
  0x61, 0x8D, 0xD0, 0x74, 0x63, 0x1F, 0xC2, 0x10, 0x83, 0xC0, 0x34, 0x44,
  0xF4, 0x44, 0x44, 0x44, 0x44, 0x76, 0x38, 0x61, 0x86, 0x18, 0x61, 0x8D,
  0xD0, 0x41, 0x0B, 0xE0, 0x84, 0x21, 0x0B, 0x66, 0x31, 0x8C, 0x63, 0x18,
  0xC4, 0x9F, 0xF8, 0x41, 0x55, 0x55, 0x55, 0xC0, 0x84, 0x21, 0x08, 0xCA,
  0x54, 0xA7, 0x25, 0x28, 0xC4, 0xFF, 0xFC, 0xB3, 0x66, 0x62, 0x31, 0x18,
  0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x40, 0xB6, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x40, 0x72, 0x28, 0xA1, 0x86, 0x18, 0x61, 0x89, 0xC0, 0xB3, 0x28,
  0x61, 0x86, 0x18, 0x61, 0xC6, 0xE8, 0x20, 0x82, 0x00, 0x35, 0x38, 0x61,
  0x86, 0x18, 0x61, 0x8D, 0xD0, 0x41, 0x04, 0x10, 0xBC, 0x88, 0x88, 0x88,
  0x88, 0x78, 0x88, 0xC2, 0x11, 0x1E, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x47,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8B, 0xC0, 0x8C, 0x62, 0x94, 0xA9, 0x46,
  0x31, 0x00, 0x88, 0xC4, 0x63, 0x29, 0x95, 0x4A, 0xA9, 0x4C, 0x66, 0x23,
  0x11, 0x00, 0x85, 0x24, 0x8C, 0x30, 0xC3, 0x12, 0x4A, 0x30, 0x86, 0x14,
  0x92, 0x49, 0x23, 0x0C, 0x30, 0x42, 0x08, 0x23, 0x00, 0x71, 0x11, 0x22,
  0x44, 0x4F, 0x12, 0x22, 0x22, 0x4C, 0x44, 0x22, 0x22, 0x21, 0xFF, 0xFF,
  0xC0, 0xC2, 0x22, 0x22, 0x23, 0x22, 0x22, 0x22, 0x2C, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 13, 4, 1, -13 },
  { 3, 3, 5, 6, 1, -13 },
  { 5, 7, 13, 8, 0, -13 },
  { 17, 6, 15, 7, 1, -14 },
  { 29, 9, 13, 11, 1, -13 },
  { 44, 6, 13, 7, 1, -13 },
  { 54, 1, 5, 3, 1, -13 },
  { 55, 3, 16, 5, 1, -13 },
  { 61, 3, 16, 5, 1, -13 },
  { 67, 5, 5, 6, 1, -14 },
  { 71, 6, 9, 7, 1, -11 },
  { 78, 1, 4, 3, 1, -2 },
  { 79, 4, 1, 5, 0, -5 },
  { 80, 1, 1, 3, 1, -1 },
  { 81, 6, 13, 6, 0, -13 },
  { 91, 5, 13, 7, 1, -13 },
  { 100, 4, 13, 7, 1, -13 },
  { 107, 5, 13, 7, 1, -13 },
  { 116, 5, 13, 7, 1, -13 },
  { 125, 7, 13, 7, 0, -13 },
  { 137, 5, 13, 7, 1, -13 },
  { 146, 5, 13, 7, 1, -13 },
  { 155, 5, 13, 7, 1, -13 },
  { 164, 6, 13, 7, 1, -13 },
  { 174, 5, 13, 7, 1, -13 },
  { 183, 1, 10, 3, 1, -10 },
  { 185, 1, 12, 3, 1, -10 },
  { 187, 6, 7, 7, 1, -10 },
  { 193, 6, 5, 7, 1, -9 },
  { 197, 6, 7, 7, 1, -10 },
  { 203, 5, 13, 5, 0, -13 },
  { 212, 9, 15, 11, 1, -13 },
  { 229, 7, 13, 7, 0, -13 },
  { 241, 6, 13, 8, 1, -13 },
  { 251, 6, 13, 8, 1, -13 },
  { 261, 7, 13, 9, 1, -13 },
  { 273, 5, 13, 7, 1, -13 },
  { 282, 5, 13, 6, 1, -13 },
  { 291, 7, 13, 9, 1, -13 },
  { 303, 7, 13, 9, 1, -13 },
  { 315, 3, 13, 4, 1, -13 },
  { 320, 3, 16, 3, -1, -13 },
  { 326, 6, 13, 7, 1, -13 },
  { 336, 5, 13, 6, 1, -13 },
  { 345, 10, 13, 12, 1, -13 },
  { 362, 7, 13, 9, 1, -13 },
  { 374, 7, 13, 9, 1, -13 },
  { 386, 6, 13, 7, 1, -13 },
  { 396, 7, 16, 9, 1, -13 },
  { 410, 6, 13, 7, 1, -13 },
  { 420, 5, 13, 7, 1, -13 },
  { 429, 6, 13, 6, 0, -13 },
  { 439, 7, 13, 9, 1, -13 },
  { 451, 7, 13, 7, 0, -13 },
  { 463, 12, 13, 12, 0, -13 },
  { 483, 6, 13, 6, 0, -13 },
  { 493, 6, 13, 6, 0, -13 },
  { 503, 6, 13, 6, 0, -13 },
  { 513, 4, 16, 6, 1, -13 },
  { 521, 6, 13, 6, 0, -13 },
  { 531, 3, 16, 6, 1, -13 },
  { 537, 7, 6, 7, 0, -13 },
  { 543, 7, 1, 7, 0, 1 },
  { 544, 2, 3, 4, 1, -14 },
  { 545, 5, 10, 7, 1, -10 },
  { 552, 6, 14, 8, 1, -14 },
  { 563, 4, 10, 6, 1, -10 },
  { 568, 6, 14, 8, 1, -14 },
  { 579, 5, 10, 7, 1, -10 },
  { 586, 4, 14, 4, 0, -14 },
  { 593, 6, 14, 8, 1, -10 },
  { 604, 5, 14, 8, 1, -14 },
  { 613, 1, 13, 3, 1, -13 },
  { 615, 2, 17, 3, 0, -13 },
  { 620, 5, 14, 6, 1, -14 },
  { 629, 1, 14, 3, 1, -14 },
  { 631, 9, 10, 11, 1, -10 },
  { 643, 5, 10, 8, 1, -10 },
  { 650, 6, 10, 7, 1, -10 },
  { 658, 6, 14, 8, 1, -10 },
  { 669, 6, 14, 8, 1, -10 },
  { 680, 4, 10, 5, 1, -10 },
  { 685, 4, 10, 6, 1, -10 },
  { 690, 4, 12, 4, 0, -12 },
  { 696, 5, 10, 8, 1, -10 },
  { 703, 5, 10, 6, 0, -10 },
  { 710, 9, 10, 10, 0, -10 },
  { 722, 6, 10, 6, 0, -10 },
  { 730, 6, 14, 6, 0, -10 },
  { 741, 4, 10, 5, 0, -10 },
  { 746, 4, 16, 6, 1, -13 },
  { 754, 1, 18, 7, 3, -14 },
  { 757, 4, 16, 6, 1, -13 },
  { 765, 6, 1, 7, 1, -7 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT18PT7B_H_
