#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight46pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x24, 0x92, 0x40, 0x00,
  0xBF, 0xE0, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0x03, 0x02, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x02,
  0x06, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10, 0x06, 0x04, 0x01, 0x81,
  0x07, 0xFF, 0xFC, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x03, 0x00, 0x40, 0x80,
  0x10, 0x20, 0x04, 0x08, 0x03, 0x02, 0x00, 0xC0, 0x80, 0x30, 0x60, 0x0C,
  0x18, 0x3F, 0xFF, 0xE0, 0x81, 0x80, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04,
  0x01, 0x81, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x03, 0x00,
  0x40, 0xC0, 0x10, 0x20, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x7F,
  0x83, 0xF7, 0xCC, 0x61, 0x30, 0xC0, 0x61, 0x80, 0x83, 0x01, 0x06, 0x02,
  0x0C, 0x04, 0x18, 0x08, 0x30, 0x18, 0x60, 0x18, 0xC0, 0x39, 0x80, 0x3B,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x33, 0x00, 0x63, 0x00, 0xC3,
  0x01, 0x83, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60,
  0x61, 0xA0, 0xC3, 0x61, 0x9C, 0xFF, 0xE0, 0x1F, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x3E, 0x00, 0xC0, 0x46, 0x01, 0x01, 0x84,
  0x06, 0x02, 0x0C, 0x0C, 0x0C, 0x18, 0x10, 0x18, 0x30, 0x60, 0x30, 0x20,
  0xC0, 0x60, 0x41, 0x00, 0xC0, 0x86, 0x01, 0x81, 0x0C, 0x03, 0x02, 0x10,
  0x06, 0x04, 0x60, 0x0C, 0x08, 0xC0, 0x18, 0x11, 0x1F, 0x30, 0x66, 0x22,
  0x20, 0xCC, 0xC6, 0x41, 0x91, 0x04, 0xC2, 0x66, 0x0C, 0xCC, 0xCC, 0x19,
  0xF1, 0x18, 0x30, 0x02, 0x30, 0x60, 0x0C, 0x40, 0x40, 0x10, 0x80, 0x80,
  0x21, 0x01, 0x00, 0xC2, 0x02, 0x01, 0x04, 0x04, 0x02, 0x0C, 0x18, 0x0C,
  0x18, 0x30, 0x10, 0x30, 0x60, 0x20, 0x20, 0x80, 0xC0, 0x63, 0x01, 0x00,
  0xC6, 0x06, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0x38, 0x00, 0x82, 0x00, 0x60,
  0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30,
  0x06, 0x08, 0x00, 0x82, 0x00, 0x31, 0x80, 0x0C, 0x40, 0x01, 0xB0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x06, 0x60, 0x03, 0x08, 0x00, 0x83,
  0x06, 0x60, 0x41, 0x98, 0x18, 0x44, 0x03, 0x13, 0x00, 0xCC, 0xC0, 0x1B,
  0x30, 0x06, 0x8C, 0x00, 0xE1, 0x00, 0x30, 0x60, 0x0E, 0x18, 0x06, 0xC3,
  0x03, 0x30, 0xE1, 0x86, 0x0F, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0x81,
  0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x07, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x02, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x06, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xC2, 0x3F, 0xAE, 0x0F, 0x00, 0x60, 0x09,
  0x01, 0x98, 0x30, 0xC6, 0x06, 0x20, 0x40, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x33, 0x32, 0x66, 0x64, 0xCC, 0x80, 0xFF, 0xC0, 0x5F, 0xF0, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0x7B,
  0x81, 0x83, 0x0C, 0x04, 0x30, 0x19, 0x80, 0x66, 0x00, 0x98, 0x03, 0x40,
  0x0D, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x40, 0x0D, 0x80, 0x36, 0x00, 0x98, 0x06, 0x30, 0x18,
  0xC0, 0x41, 0x83, 0x07, 0xB8, 0x0F, 0xC0, 0x01, 0x81, 0xC3, 0xE3, 0xB3,
  0x9B, 0x8F, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x1F, 0xC3, 0xE7,
  0x84, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x04, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1, 0xE7, 0x8C, 0x03,
  0x20, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x0E, 0x07, 0xE0, 0x1F,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x68,
  0x03, 0xB8, 0x3C, 0x7F, 0xC0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x05, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0x30, 0x01, 0x98,
  0x01, 0x8C, 0x00, 0xC6, 0x00, 0x43, 0x00, 0x61, 0x80, 0x20, 0xC0, 0x30,
  0x60, 0x10, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x04, 0x03, 0x06,
  0x01, 0x82, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x30, 0xFF, 0xFF, 0x80, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x3F, 0xF9, 0xFF, 0xE6, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x3C, 0x07, 0xFE, 0x10, 0x1C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x68, 0x03, 0x3C, 0x38,
  0x7F, 0xC0, 0x03, 0xF8, 0x1E, 0xE0, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0,
  0x03, 0x1F, 0x8C, 0xEF, 0x34, 0x06, 0xE0, 0x1B, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x05, 0x00, 0x16,
  0x00, 0xD8, 0x03, 0x60, 0x0C, 0xC0, 0x63, 0x01, 0x86, 0x0C, 0x0F, 0xE0,
  0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x0F, 0xE0, 0x39, 0xE0, 0xC0, 0x63, 0x00, 0xC6, 0x00, 0xC8, 0x01, 0xB0,
  0x03, 0x60, 0x06, 0x40, 0x0C, 0xC0, 0x19, 0x80, 0x21, 0x80, 0xC3, 0x03,
  0x03, 0x0C, 0x03, 0xB0, 0x01, 0xC0, 0x0F, 0xC0, 0x38, 0xC0, 0xC0, 0xC3,
  0x00, 0xC6, 0x00, 0xD8, 0x01, 0xB0, 0x01, 0x60, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x1C, 0x38,
  0x1F, 0xE0, 0x0F, 0xC0, 0xF3, 0x83, 0x03, 0x18, 0x04, 0x40, 0x1B, 0x00,
  0x6C, 0x00, 0xB0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x60, 0x1D, 0x80, 0xF3, 0x86, 0xC7,
  0xF3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x10, 0x70, 0x7F, 0x00,
  0x5F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xBF, 0xE0, 0x27, 0x77,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x33, 0x66, 0x64,
  0xCC, 0x80, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x7F, 0x1C, 0xF2, 0x07, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x18,
  0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0E,
  0x01, 0xC0, 0x18, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xF7, 0xC0, 0x03, 0x80,
  0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x08, 0x00, 0x08, 0x18, 0x00,
  0x0C, 0x10, 0x00, 0x04, 0x30, 0x00, 0x06, 0x20, 0x0E, 0x06, 0x20, 0x3F,
  0x82, 0x60, 0x61, 0x82, 0x60, 0xC1, 0x83, 0x40, 0xC1, 0x83, 0x40, 0x81,
  0x03, 0x41, 0x81, 0x03, 0x41, 0x81, 0x03, 0xC1, 0x81, 0x03, 0xC1, 0x81,
  0x03, 0xC1, 0x81, 0x03, 0xC1, 0x83, 0x03, 0xC1, 0x83, 0x03, 0x41, 0x83,
  0x02, 0x41, 0x83, 0x02, 0x40, 0x87, 0x86, 0x60, 0xC4, 0x8C, 0x60, 0x7C,
  0xFC, 0x60, 0x38, 0x70, 0x20, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x80, 0x03, 0xC7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x33, 0x00, 0x0C,
  0xC0, 0x02, 0x10, 0x00, 0x84, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18,
  0x01, 0x02, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x02, 0x01, 0x01,
  0x80, 0x60, 0x7F, 0xF8, 0x1F, 0xFE, 0x06, 0x01, 0x81, 0x00, 0x30, 0xC0,
  0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC2, 0x00, 0x11, 0x80, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x64, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0xFF, 0x83,
  0xFF, 0x88, 0x07, 0x20, 0x06, 0x80, 0x1A, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xA0, 0x06, 0x80, 0x1A, 0x00, 0xC8, 0x06,
  0x3F, 0xF0, 0xFF, 0xE2, 0x00, 0xC8, 0x01, 0xA0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x68, 0x03, 0x3F, 0xF8, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xC7,
  0x06, 0x01, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0xC7,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x80, 0x70, 0x80, 0x38, 0x80, 0x18,
  0x80, 0x0C, 0x80, 0x0C, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x06,
  0x80, 0x02, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06,
  0x80, 0x06, 0x80, 0x06, 0x80, 0x06, 0x80, 0x0C, 0x80, 0x0C, 0x80, 0x18,
  0x80, 0x38, 0x80, 0x70, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFE, 0xFF, 0xE8, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xEF,
  0xFE, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x3E, 0x3E, 0x07, 0x00, 0x60, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xC0, 0x00, 0x34,
  0x00, 0x03, 0x40, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00,
  0x30, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x3C, 0x1F, 0x01, 0xFF, 0xC0, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x02, 0xFE, 0xF0, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0xFE, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0xC1, 0xEE, 0xF8, 0x80, 0x0E, 0x00, 0x68, 0x03, 0x20,
  0x0C, 0x80, 0x62, 0x01, 0x88, 0x0C, 0x20, 0x60, 0x81, 0x82, 0x0C, 0x08,
  0x30, 0x21, 0x80, 0x8C, 0x02, 0x30, 0x09, 0x80, 0x27, 0x00, 0xBC, 0x02,
  0x98, 0x0C, 0x60, 0x30, 0xC0, 0x83, 0x02, 0x06, 0x08, 0x18, 0x20, 0x30,
  0x80, 0xC2, 0x01, 0x08, 0x06, 0x20, 0x08, 0x80, 0x32, 0x00, 0x48, 0x01,
  0xA0, 0x06, 0x80, 0x0C, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x07, 0xFF,
  0xFF, 0xE0, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFA, 0x00, 0x01, 0xF6, 0x00, 0x03, 0xEC, 0x00, 0x05, 0xC8, 0x00,
  0x1B, 0x98, 0x00, 0x37, 0x30, 0x00, 0x4E, 0x20, 0x01, 0x9C, 0x40, 0x03,
  0x38, 0xC0, 0x06, 0x71, 0x80, 0x18, 0xE1, 0x00, 0x31, 0xC3, 0x00, 0x63,
  0x86, 0x00, 0x87, 0x04, 0x03, 0x0E, 0x0C, 0x06, 0x1C, 0x18, 0x08, 0x38,
  0x30, 0x30, 0x70, 0x20, 0x60, 0xE0, 0x60, 0x81, 0xC0, 0xC3, 0x03, 0x80,
  0x86, 0x07, 0x01, 0x8C, 0x0E, 0x03, 0x10, 0x1C, 0x02, 0x60, 0x38, 0x06,
  0xC0, 0x70, 0x0D, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x30,
  0x06, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xB0, 0x01, 0xB0,
  0x01, 0x90, 0x01, 0x98, 0x01, 0x88, 0x01, 0x8C, 0x01, 0x8C, 0x01, 0x86,
  0x01, 0x86, 0x01, 0x82, 0x01, 0x83, 0x01, 0x81, 0x01, 0x81, 0x81, 0x81,
  0x81, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0x61, 0x80, 0x61, 0x80, 0x21, 0x80,
  0x31, 0x80, 0x11, 0x80, 0x19, 0x80, 0x19, 0x80, 0x0D, 0x80, 0x0D, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x03, 0xFC, 0x00, 0xF3, 0xC0,
  0x30, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x33,
  0x00, 0x02, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xA0, 0x00, 0x34,
  0x00, 0x06, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x06, 0x80, 0x00, 0xD8,
  0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x08, 0xC0, 0x03, 0x18,
  0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x03, 0x00, 0xC0, 0x38, 0x70, 0x03,
  0xFC, 0x00, 0xFE, 0x07, 0xFE, 0x20, 0x39, 0x00, 0x68, 0x03, 0x40, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xD0, 0x06, 0x80, 0x64, 0x3E, 0x3F, 0xE1, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xF3,
  0xC0, 0x30, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x60, 0x01, 0x8C, 0x00,
  0x33, 0x00, 0x02, 0x60, 0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xA0, 0x00,
  0x34, 0x00, 0x06, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x06, 0x80, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x08, 0xC0, 0x03,
  0x18, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x03, 0x00, 0xC0, 0x38, 0x70,
  0x03, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0xFE, 0x03,
  0xFF, 0x08, 0x0E, 0x20, 0x0C, 0x80, 0x32, 0x00, 0x68, 0x01, 0xA0, 0x06,
  0x80, 0x1A, 0x00, 0x68, 0x01, 0xA0, 0x06, 0x80, 0x1A, 0x00, 0x48, 0x03,
  0x20, 0x18, 0x81, 0xC3, 0xFE, 0x08, 0x30, 0x20, 0xC0, 0x81, 0x82, 0x06,
  0x08, 0x08, 0x20, 0x30, 0x80, 0xC2, 0x01, 0x88, 0x06, 0x20, 0x0C, 0x80,
  0x32, 0x00, 0x68, 0x01, 0xA0, 0x03, 0x80, 0x0C, 0x0F, 0xF8, 0x79, 0xF3,
  0x00, 0x58, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x68, 0x03, 0x3C, 0x3C, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x06,
  0x30, 0x0E, 0x1C, 0x3C, 0x0F, 0xF0, 0xC0, 0x00, 0xF0, 0x00, 0x64, 0x00,
  0x19, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0x46, 0x00, 0x30, 0x80, 0x0C,
  0x30, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x60, 0x40, 0x18, 0x18, 0x06, 0x06,
  0x01, 0x01, 0x80, 0xC0, 0x20, 0x30, 0x0C, 0x0C, 0x03, 0x02, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x04, 0x18, 0x01, 0x84, 0x00, 0x61, 0x00, 0x18, 0xC0,
  0x02, 0x30, 0x00, 0xCC, 0x00, 0x32, 0x00, 0x0D, 0x80, 0x01, 0x60, 0x00,
  0x58, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x03, 0x00,
  0x0D, 0x00, 0x0C, 0x00, 0x36, 0x00, 0x30, 0x00, 0xD8, 0x00, 0xE0, 0x03,
  0x60, 0x07, 0x80, 0x19, 0x80, 0x1E, 0x00, 0x62, 0x00, 0x68, 0x01, 0x8C,
  0x01, 0xA0, 0x06, 0x30, 0x04, 0xC0, 0x10, 0xC0, 0x33, 0x00, 0xC3, 0x00,
  0xCC, 0x03, 0x04, 0x03, 0x10, 0x0C, 0x18, 0x0C, 0x40, 0x30, 0x60, 0x21,
  0x80, 0x81, 0x81, 0x86, 0x06, 0x06, 0x06, 0x18, 0x18, 0x08, 0x18, 0x20,
  0x60, 0x30, 0x60, 0x81, 0x00, 0xC1, 0x03, 0x0C, 0x03, 0x0C, 0x0C, 0x30,
  0x04, 0x30, 0x30, 0xC0, 0x18, 0xC0, 0x43, 0x00, 0x63, 0x01, 0x08, 0x01,
  0x88, 0x06, 0x60, 0x06, 0x20, 0x19, 0x80, 0x09, 0x80, 0x66, 0x00, 0x36,
  0x00, 0x98, 0x00, 0xD8, 0x02, 0x40, 0x03, 0x40, 0x0F, 0x00, 0x0D, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x01, 0x80, 0x01, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x60, 0x0C, 0xC0, 0x10, 0xC0, 0x61, 0x80, 0xC3, 0x01,
  0x03, 0x06, 0x06, 0x0C, 0x04, 0x30, 0x0C, 0x60, 0x18, 0x80, 0x13, 0x00,
  0x36, 0x00, 0x68, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0D,
  0x00, 0x1B, 0x00, 0x66, 0x00, 0xC4, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x10,
  0x30, 0x30, 0x60, 0x60, 0x80, 0x43, 0x00, 0xC6, 0x01, 0x98, 0x01, 0xB0,
  0x03, 0xC0, 0x06, 0xC0, 0x07, 0x80, 0x0D, 0x80, 0x13, 0x00, 0x66, 0x00,
  0xC6, 0x01, 0x0C, 0x06, 0x18, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x60, 0xC0,
  0x61, 0x00, 0xC6, 0x01, 0x8C, 0x01, 0x90, 0x03, 0x60, 0x02, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x7F, 0xFB, 0xFF, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0xFF, 0xFF, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x80,
  0x00, 0xE0, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x22, 0x00, 0x31, 0x80, 0x10,
  0xC0, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x06, 0x00, 0xC3,
  0x00, 0x63, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0x80, 0x0F, 0x07, 0xFC, 0x20,
  0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x3F, 0x1F, 0x13, 0x01, 0x60, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x3C, 0x05, 0xC0, 0x56, 0x09, 0x3F, 0x10, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x0F, 0x06, 0x7F, 0x8D, 0x83, 0x9A, 0x03,
  0x38, 0x03, 0x70, 0x06, 0xE0, 0x0D, 0x80, 0x0B, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x2C, 0x00, 0x5C, 0x01, 0xB8, 0x03, 0x70, 0x0C, 0xD0, 0x19,
  0xB8, 0xE3, 0x3F, 0x80, 0x03, 0xC0, 0xFF, 0x1C, 0x13, 0x00, 0x30, 0x06,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0xC3, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x1E, 0x18, 0xFF, 0x31, 0x83, 0x66, 0x02, 0xD8, 0x03, 0xB0, 0x07,
  0x60, 0x0E, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x34, 0x00,
  0x6C, 0x01, 0xD8, 0x03, 0xB0, 0x0F, 0x30, 0x16, 0x30, 0xCC, 0x3F, 0x18,
  0x03, 0x80, 0x3F, 0x81, 0x83, 0x0C, 0x0C, 0x60, 0x19, 0x80, 0x64, 0x00,
  0x90, 0x02, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x87, 0x0E, 0x0F, 0xF0, 0x03, 0xE0, 0xEC, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x7F,
  0xC0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x07, 0x80, 0x3F,
  0xCC, 0xE0, 0xD9, 0x80, 0xB6, 0x00, 0xEC, 0x01, 0xD0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x3B, 0x00, 0x76, 0x00,
  0xEC, 0x02, 0xCC, 0x0D, 0x8C, 0x33, 0x0F, 0xC6, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x80,
  0x71, 0xFF, 0xC0, 0xFE, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xF1, 0x9F,
  0xCD, 0x87, 0x68, 0x1B, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x06, 0xFF, 0x00, 0x00, 0x1B, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB,
  0x6D, 0xB6, 0xC0, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x6F, 0x38,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0x8C, 0x18,
  0xC3, 0x0C, 0x30, 0xC6, 0x0C, 0xC0, 0xCC, 0x0D, 0xE0, 0xD6, 0x0F, 0x30,
  0xE3, 0x0C, 0x10, 0xC1, 0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0x4C, 0x06,
  0xC0, 0x2C, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x81, 0xE1, 0x9F, 0x87, 0xF3, 0x61, 0x98, 0x67, 0x81,
  0x20, 0x6E, 0x03, 0x80, 0xDC, 0x07, 0x00, 0xB0, 0x0E, 0x01, 0x60, 0x08,
  0x03, 0xC0, 0x10, 0x07, 0x80, 0x20, 0x0F, 0x00, 0x40, 0x1E, 0x00, 0x80,
  0x3C, 0x01, 0x00, 0x78, 0x02, 0x00, 0xF0, 0x04, 0x01, 0xE0, 0x08, 0x03,
  0xC0, 0x10, 0x07, 0x80, 0x20, 0x0F, 0x00, 0x40, 0x1E, 0x00, 0x80, 0x3C,
  0x01, 0x00, 0x78, 0x02, 0x00, 0xF0, 0x04, 0x01, 0xE0, 0x08, 0x03, 0xC0,
  0x10, 0x06, 0x03, 0x86, 0x7F, 0x36, 0x0D, 0xA0, 0x6E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x18, 0x03, 0x80, 0x3F, 0xC0, 0xE0,
  0xC1, 0x80, 0xC6, 0x00, 0xCC, 0x01, 0x90, 0x03, 0x60, 0x02, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x66, 0x00, 0xC4, 0x01,
  0x0C, 0x06, 0x0E, 0x38, 0x0F, 0xE0, 0x03, 0xC1, 0x9F, 0xE3, 0x60, 0xE6,
  0x80, 0xCE, 0x00, 0xDC, 0x01, 0xB8, 0x03, 0x60, 0x02, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0B, 0x00, 0x17, 0x00, 0x6E, 0x00, 0xDE, 0x03, 0x34,
  0x06, 0x66, 0x38, 0xC7, 0xE1, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x1F, 0xCC, 0x60, 0xD9, 0x80, 0xB6, 0x00, 0xEC,
  0x01, 0xD8, 0x03, 0xA0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0D,
  0x00, 0x1B, 0x00, 0x76, 0x00, 0xEC, 0x02, 0xCC, 0x05, 0x8E, 0x33, 0x0F,
  0xC6, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x03, 0x67,
  0xF6, 0x1A, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x00, 0x0F, 0x87, 0xFD, 0x81, 0x60, 0x0C, 0x01, 0x00, 0x20,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x37, 0x0E,
  0xFF, 0x80, 0x10, 0x30, 0x30, 0x30, 0x30, 0x30, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x19, 0x1F, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x56, 0x02, 0xB0, 0x35, 0xC3, 0x27, 0xF1, 0xC0,
  0x0D, 0x00, 0x36, 0x00, 0x98, 0x06, 0x60, 0x18, 0x80, 0x63, 0x01, 0x0C,
  0x0C, 0x30, 0x30, 0x40, 0xC1, 0x02, 0x06, 0x18, 0x18, 0x60, 0x21, 0x80,
  0x84, 0x03, 0x30, 0x0C, 0xC0, 0x13, 0x00, 0x48, 0x01, 0xA0, 0x07, 0x80,
  0x1E, 0x00, 0x30, 0x00, 0xC0, 0xC0, 0x18, 0x03, 0x60, 0x1C, 0x03, 0x60,
  0x1C, 0x02, 0x60, 0x14, 0x06, 0x20, 0x34, 0x06, 0x20, 0x36, 0x06, 0x30,
  0x36, 0x04, 0x30, 0x26, 0x04, 0x30, 0x62, 0x0C, 0x10, 0x62, 0x0C, 0x18,
  0x63, 0x0C, 0x18, 0x43, 0x08, 0x18, 0x43, 0x08, 0x08, 0xC1, 0x18, 0x08,
  0xC1, 0x18, 0x0C, 0xC1, 0x98, 0x0C, 0x81, 0x90, 0x0C, 0x81, 0xB0, 0x05,
  0x80, 0xB0, 0x05, 0x80, 0xB0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x03,
  0x00, 0xE0, 0x03, 0x00, 0x60, 0xC0, 0x1B, 0x01, 0x88, 0x0C, 0x60, 0xC3,
  0x06, 0x0C, 0x20, 0x63, 0x01, 0x90, 0x0D, 0x80, 0x2C, 0x01, 0xC0, 0x06,
  0x00, 0x70, 0x02, 0xC0, 0x36, 0x01, 0x10, 0x18, 0xC0, 0xC2, 0x0C, 0x18,
  0x60, 0xC6, 0x03, 0x30, 0x1B, 0x00, 0x78, 0x03, 0x60, 0x06, 0xC0, 0x18,
  0x80, 0x31, 0x80, 0x63, 0x00, 0x86, 0x03, 0x04, 0x06, 0x0C, 0x0C, 0x18,
  0x10, 0x30, 0x60, 0x20, 0xC0, 0x61, 0x80, 0xC2, 0x01, 0x8C, 0x01, 0x18,
  0x03, 0x30, 0x06, 0x40, 0x0D, 0x80, 0x0B, 0x00, 0x16, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0x7F, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10, 0x0C,
  0x03, 0x01, 0x80, 0x60, 0x10, 0x0F, 0xFF, 0xFF, 0x00, 0x70, 0x1F, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x0F, 0x80, 0xF0, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x0F, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03,
  0x00, 0x1F, 0x00, 0xF0, 0x38, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x3C, 0x0F, 0x00, 0x3F, 0x01, 0x63, 0xC1,
  0xC0, 0xFF, 0x80, 0x3C,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 33, 9, 3, -33 },
  { 14, 8, 12, 14, 3, -33 },
  { 26, 18, 33, 20, 1, -33 },
  { 101, 15, 38, 18, 2, -35 },
  { 173, 23, 33, 27, 2, -33 },
  { 268, 18, 33, 19, 1, -33 },
  { 343, 2, 12, 8, 3, -33 },
  { 346, 9, 40, 12, 2, -33 },
  { 391, 8, 40, 12, 2, -33 },
  { 431, 12, 13, 16, 2, -35 },
  { 451, 16, 21, 19, 1, -27 },
  { 493, 4, 11, 9, 2, -5 },
  { 499, 10, 1, 12, 1, -13 },
  { 501, 3, 4, 9, 3, -4 },
  { 503, 14, 33, 16, 1, -33 },
  { 561, 14, 33, 18, 2, -33 },
  { 619, 9, 33, 18, 3, -33 },
  { 657, 14, 33, 18, 2, -33 },
  { 715, 14, 33, 18, 2, -33 },
  { 773, 17, 33, 18, 1, -33 },
  { 844, 14, 33, 18, 2, -33 },
  { 902, 14, 34, 18, 2, -33 },
  { 962, 14, 33, 18, 2, -33 },
  { 1020, 15, 33, 18, 2, -33 },
  { 1082, 14, 33, 18, 2, -33 },
  { 1140, 3, 25, 9, 3, -25 },
  { 1150, 4, 31, 9, 2, -25 },
  { 1166, 16, 19, 19, 1, -26 },
  { 1204, 16, 12, 19, 1, -22 },
  { 1228, 16, 19, 19, 1, -26 },
  { 1266, 11, 33, 13, 1, -33 },
  { 1312, 24, 37, 28, 2, -33 },
  { 1423, 18, 33, 18, 0, -33 },
  { 1498, 14, 33, 20, 4, -33 },
  { 1556, 16, 33, 19, 2, -33 },
  { 1622, 16, 33, 22, 4, -33 },
  { 1688, 12, 33, 18, 4, -33 },
  { 1738, 12, 33, 16, 4, -33 },
  { 1788, 20, 33, 24, 2, -33 },
  { 1871, 15, 33, 23, 4, -33 },
  { 1933, 7, 33, 11, 2, -33 },
  { 1962, 7, 41, 9, -2, -33 },
  { 1998, 14, 33, 18, 4, -33 },
  { 2056, 11, 33, 16, 4, -33 },
  { 2102, 23, 33, 31, 4, -33 },
  { 2197, 16, 33, 24, 4, -33 },
  { 2263, 19, 33, 24, 2, -33 },
  { 2342, 13, 33, 19, 4, -33 },
  { 2396, 19, 41, 24, 2, -33 },
  { 2494, 14, 33, 19, 4, -33 },
  { 2552, 14, 33, 18, 2, -33 },
  { 2610, 16, 33, 16, 0, -33 },
  { 2676, 16, 33, 23, 3, -33 },
  { 2742, 18, 33, 18, 0, -33 },
  { 2817, 30, 33, 30, 0, -33 },
  { 2941, 15, 33, 16, 0, -33 },
  { 3003, 15, 33, 15, 0, -33 },
  { 3065, 13, 33, 15, 1, -33 },
  { 3119, 9, 40, 14, 4, -33 },
  { 3164, 14, 33, 15, 1, -33 },
  { 3222, 8, 40, 14, 2, -33 },
  { 3262, 17, 16, 19, 1, -33 },
  { 3296, 19, 2, 18, 0, 4 },
  { 3301, 7, 7, 11, 2, -35 },
  { 3308, 12, 25, 17, 2, -25 },
  { 3346, 15, 35, 20, 3, -35 },
  { 3412, 12, 25, 15, 2, -25 },
  { 3450, 15, 35, 20, 2, -35 },
  { 3516, 14, 25, 18, 2, -25 },
  { 3560, 11, 35, 10, 0, -35 },
  { 3609, 15, 36, 20, 2, -25 },
  { 3677, 13, 35, 19, 3, -35 },
  { 3734, 3, 33, 8, 3, -33 },
  { 3747, 6, 44, 8, 0, -33 },
  { 3780, 12, 35, 16, 3, -35 },
  { 3833, 2, 35, 8, 3, -35 },
  { 3842, 23, 25, 29, 3, -25 },
  { 3914, 13, 25, 19, 3, -25 },
  { 3955, 15, 25, 19, 2, -25 },
  { 4002, 15, 36, 20, 3, -25 },
  { 4070, 15, 36, 20, 2, -25 },
  { 4138, 9, 25, 12, 3, -25 },
  { 4167, 11, 25, 15, 2, -25 },
  { 4202, 8, 30, 10, 1, -30 },
  { 4232, 13, 24, 19, 3, -24 },
  { 4271, 14, 24, 14, 0, -24 },
  { 4313, 24, 24, 24, 0, -24 },
  { 4385, 13, 24, 15, 1, -24 },
  { 4424, 15, 35, 15, 0, -24 },
  { 4490, 10, 24, 12, 1, -24 },
  { 4520, 12, 40, 16, 2, -33 },
  { 4580, 2, 46, 18, 8, -35 },
  { 4592, 12, 40, 16, 2, -33 },
  { 4652, 16, 4, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT46PT7B_H_
