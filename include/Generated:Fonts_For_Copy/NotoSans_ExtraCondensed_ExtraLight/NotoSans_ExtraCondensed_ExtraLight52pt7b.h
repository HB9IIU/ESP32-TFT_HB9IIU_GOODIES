#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60,
  0x00, 0x1B, 0xFE, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x34, 0x0D,
  0x03, 0x40, 0xD0, 0x34, 0x0D, 0x03, 0x40, 0xC0, 0x01, 0x81, 0x80, 0x18,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x10, 0x18, 0x01,
  0x01, 0x00, 0x30, 0x10, 0x03, 0x03, 0x00, 0x30, 0x30, 0x03, 0x03, 0x07,
  0xFF, 0xFF, 0x03, 0x03, 0x00, 0x30, 0x30, 0x02, 0x03, 0x00, 0x20, 0x20,
  0x06, 0x02, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x04, 0x06, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xC0,
  0x40, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C,
  0x0C, 0x00, 0x80, 0xC0, 0x08, 0x08, 0x00, 0x80, 0x80, 0x18, 0x08, 0x01,
  0x81, 0x80, 0x18, 0x18, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0xFF, 0xC0, 0xFD, 0xF8, 0xC6, 0x08, 0xC3, 0x00, 0xE1, 0x80,
  0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x06,
  0x01, 0x83, 0x00, 0x61, 0x80, 0x38, 0xC0, 0x0E, 0x60, 0x03, 0xF0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0x38, 0x01, 0x8E, 0x00, 0xC1,
  0x80, 0x60, 0xC0, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03,
  0x03, 0x01, 0x81, 0x80, 0xC1, 0x80, 0x60, 0xD0, 0x30, 0xCF, 0x9B, 0xC3,
  0xFF, 0xC0, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x04, 0x00, 0x00, 0x07, 0xC0, 0x0C, 0x03, 0x18, 0x03, 0x00, 0x83,
  0x00, 0xC0, 0x60, 0xC0, 0x60, 0x18, 0x30, 0x18, 0x04, 0x04, 0x06, 0x01,
  0x01, 0x83, 0x00, 0xC0, 0x60, 0xC0, 0x30, 0x18, 0x30, 0x0C, 0x06, 0x18,
  0x03, 0x01, 0x86, 0x00, 0xC0, 0x61, 0x80, 0x30, 0x18, 0xC0, 0x0C, 0x06,
  0x30, 0x03, 0x01, 0x8C, 0x38, 0x40, 0x66, 0x3F, 0x10, 0x11, 0x8C, 0x66,
  0x0C, 0x66, 0x19, 0x83, 0x31, 0x83, 0x20, 0x8C, 0x40, 0xCC, 0x63, 0x30,
  0x31, 0xF1, 0x8C, 0x0C, 0x10, 0x63, 0x01, 0x00, 0x18, 0xC0, 0x40, 0x0C,
  0x30, 0x10, 0x03, 0x0C, 0x04, 0x00, 0xC3, 0x01, 0x00, 0x60, 0xC0, 0x40,
  0x18, 0x30, 0x10, 0x06, 0x0C, 0x0C, 0x03, 0x03, 0x03, 0x00, 0xC0, 0xC0,
  0xC0, 0x30, 0x10, 0x30, 0x18, 0x06, 0x0C, 0x06, 0x01, 0x86, 0x01, 0x80,
  0x33, 0x80, 0xC0, 0x07, 0xC0, 0x01, 0x00, 0x01, 0xFC, 0x00, 0x31, 0x80,
  0x0C, 0x18, 0x01, 0x83, 0x00, 0x20, 0x20, 0x0C, 0x04, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x02, 0x02, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x10, 0x40, 0x03, 0x18, 0x00, 0x66, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x0F, 0x80, 0x01, 0x98, 0x00, 0x61, 0x80, 0x18, 0x30, 0x33,
  0x03, 0x06, 0xC0, 0x60, 0xD8, 0x06, 0x1B, 0x00, 0xC2, 0x60, 0x0C, 0xCC,
  0x00, 0xD9, 0x80, 0x1A, 0x30, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x07, 0x18,
  0x01, 0xE1, 0x80, 0x76, 0x38, 0x1C, 0x63, 0x8F, 0x0C, 0x3F, 0x80, 0xC0,
  0x80, 0x00, 0xFF, 0xFF, 0x92, 0x49, 0x24, 0x01, 0x01, 0x81, 0x80, 0xC0,
  0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03,
  0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0xC0, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0C,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x01, 0x04, 0x3F,
  0x97, 0xC3, 0xF8, 0x03, 0x00, 0x1A, 0x00, 0xCC, 0x02, 0x18, 0x18, 0x30,
  0xC0, 0xC1, 0x01, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x39, 0xCC,
  0x63, 0x19, 0x8C, 0x62, 0x31, 0x80, 0xFF, 0xFF, 0xFC, 0x6E, 0xF6, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x07, 0xF0, 0x0E, 0x38, 0x1C, 0x1C, 0x18, 0x0C, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x02, 0x30, 0x06, 0x30, 0x06, 0x38, 0x06, 0x18, 0x0C, 0x1C,
  0x1C, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0x81, 0xC3, 0xE3, 0xB3, 0x9B, 0x8F,
  0x86, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x03,
  0x80, 0x1F, 0xF0, 0x78, 0x78, 0x60, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x1F, 0xF0, 0x78, 0x78, 0xE0, 0x1C, 0x40,
  0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0xF0, 0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x80, 0x1C, 0xF8, 0x78, 0x7F, 0xF0, 0x03, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x30, 0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x04,
  0x06, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x60, 0x60,
  0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60, 0x06, 0x18, 0x00, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x3F, 0xFE, 0x1F, 0xFF, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x20, 0x0E, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x30, 0x07, 0x1F, 0x1F, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xE3,
  0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x87, 0x80, 0xCF, 0xF0, 0x6C, 0x1C, 0x2C, 0x03, 0x14, 0x01,
  0x9E, 0x00, 0x6E, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x0C, 0xC0, 0x07, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x33, 0x00, 0x19,
  0x80, 0x0C, 0x60, 0x06, 0x30, 0x07, 0x1C, 0x03, 0x06, 0x03, 0x81, 0xC3,
  0x80, 0x7F, 0x80, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x07,
  0x8F, 0x07, 0x01, 0xC3, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x67, 0x00, 0x71, 0x80,
  0x30, 0x60, 0x30, 0x38, 0x38, 0x0E, 0x38, 0x01, 0xF0, 0x00, 0x70, 0x00,
  0xEC, 0x00, 0xE3, 0x80, 0xC0, 0xE0, 0xC0, 0x38, 0xE0, 0x0C, 0x60, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0x30, 0x01, 0x9C, 0x01, 0xC7, 0x01, 0xC1,
  0xE3, 0xC0, 0x7F, 0xC0, 0x02, 0x00, 0x03, 0x80, 0x0F, 0xF0, 0x1C, 0x38,
  0x38, 0x1C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07, 0x30, 0x0B,
  0x38, 0x3B, 0x1F, 0xF3, 0x07, 0xC3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x21, 0xE0, 0x3F, 0xC0, 0x0C, 0x00,
  0x6F, 0xFE, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x6F, 0xF6, 0x31, 0xCE, 0x71, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x46, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x07, 0xF8, 0xE1, 0xC8, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x81, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x66,
  0x00, 0xF8, 0x19, 0x80, 0x7F, 0x03, 0x60, 0x30, 0xC0, 0xF0, 0x18, 0x30,
  0x3C, 0x04, 0x0C, 0x0F, 0x03, 0x03, 0x03, 0xC0, 0xC0, 0xC0, 0xF0, 0x20,
  0x30, 0x3C, 0x18, 0x0C, 0x0F, 0x06, 0x03, 0x03, 0xC1, 0x80, 0xC0, 0xF0,
  0x60, 0x30, 0x3C, 0x18, 0x0C, 0x0F, 0x06, 0x07, 0x03, 0xC1, 0x81, 0xC0,
  0xF0, 0x20, 0x70, 0x3C, 0x0C, 0x1C, 0x0B, 0x03, 0x0D, 0x06, 0xC0, 0xC3,
  0x43, 0xB0, 0x1F, 0x9F, 0xC6, 0x03, 0xC3, 0xE1, 0x80, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x02, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0D, 0x00, 0x00, 0xD8, 0x00, 0x09, 0x80, 0x01,
  0x98, 0x00, 0x18, 0x80, 0x01, 0x8C, 0x00, 0x10, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x06, 0x00, 0x30, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x02, 0x00, 0x60, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80,
  0x0C, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x06, 0x30,
  0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x30, 0xFF, 0xE0, 0x7F, 0xFC, 0x30, 0x07, 0x18,
  0x00, 0xCC, 0x00, 0x66, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x33, 0x00,
  0x39, 0x80, 0x38, 0xC0, 0x78, 0x7F, 0xF0, 0x30, 0x3E, 0x18, 0x01, 0xCC,
  0x00, 0x66, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x07, 0x60, 0x07, 0x30, 0x07, 0x1F, 0xFF, 0x0F, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x7F, 0xF0, 0x7C, 0x38, 0x38, 0x02, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0x03, 0xC7, 0x80,
  0x7F, 0xE0, 0x01, 0x80, 0xFF, 0xC0, 0x3F, 0xFC, 0x0C, 0x03, 0xC3, 0x00,
  0x38, 0xC0, 0x06, 0x30, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x01,
  0xB0, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC,
  0x00, 0x33, 0x00, 0x1C, 0xC0, 0x06, 0x30, 0x03, 0x0C, 0x03, 0x83, 0xFF,
  0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xEC,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0xF8, 0x3E, 0x0E, 0x00,
  0x30, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x02, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x26,
  0x00, 0x01, 0x18, 0x00, 0x08, 0xE0, 0x00, 0x43, 0x80, 0x02, 0x0E, 0x00,
  0x10, 0x3E, 0x1F, 0x80, 0x7F, 0xF0, 0x00, 0x20, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xC0, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x3C, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0xFE, 0xFC, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x60,
  0xC0, 0x60, 0xC0, 0xC0, 0xC1, 0xC0, 0xC1, 0x80, 0xC3, 0x80, 0xC3, 0x00,
  0xC6, 0x00, 0xC6, 0x00, 0xCC, 0x00, 0xDE, 0x00, 0xDE, 0x00, 0xF3, 0x00,
  0xE3, 0x00, 0xE1, 0x80, 0xC1, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60,
  0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x37, 0xB0, 0x00, 0x06, 0xF6, 0x00, 0x00, 0xDE, 0xC0,
  0x00, 0x33, 0xC8, 0x00, 0x06, 0x79, 0x80, 0x00, 0xCF, 0x30, 0x00, 0x11,
  0xE6, 0x00, 0x06, 0x3C, 0x60, 0x00, 0xC7, 0x8C, 0x00, 0x18, 0xF1, 0x80,
  0x06, 0x1E, 0x18, 0x00, 0xC3, 0xC3, 0x00, 0x18, 0x78, 0x60, 0x06, 0x0F,
  0x04, 0x00, 0xC1, 0xE0, 0xC0, 0x18, 0x3C, 0x18, 0x02, 0x07, 0x83, 0x00,
  0xC0, 0xF0, 0x30, 0x18, 0x1E, 0x06, 0x03, 0x03, 0xC0, 0xC0, 0xC0, 0x78,
  0x0C, 0x18, 0x0F, 0x01, 0x83, 0x01, 0xE0, 0x30, 0xC0, 0x3C, 0x02, 0x18,
  0x07, 0x80, 0x63, 0x00, 0xF0, 0x0C, 0xC0, 0x1E, 0x01, 0x98, 0x03, 0xC0,
  0x1B, 0x00, 0x78, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x06, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xB0, 0x00, 0xF6, 0x00, 0x1E, 0x60, 0x03, 0xCC,
  0x00, 0x78, 0xC0, 0x0F, 0x18, 0x01, 0xE3, 0x00, 0x3C, 0x30, 0x07, 0x86,
  0x00, 0xF0, 0x60, 0x1E, 0x0C, 0x03, 0xC0, 0xC0, 0x78, 0x18, 0x0F, 0x01,
  0x81, 0xE0, 0x30, 0x3C, 0x06, 0x07, 0x80, 0x60, 0xF0, 0x0C, 0x1E, 0x00,
  0xC3, 0xC0, 0x18, 0x78, 0x01, 0x8F, 0x00, 0x31, 0xE0, 0x06, 0x3C, 0x00,
  0x67, 0x80, 0x0C, 0xF0, 0x00, 0xDE, 0x00, 0x1B, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x1F,
  0xF0, 0x01, 0xC1, 0xC0, 0x18, 0x03, 0x01, 0x80, 0x0C, 0x1C, 0x00, 0x70,
  0xC0, 0x01, 0x8E, 0x00, 0x0E, 0x60, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00,
  0x0D, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x36, 0x00, 0x03,
  0x30, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0x61, 0xC0,
  0x07, 0x07, 0x00, 0x30, 0x1C, 0x07, 0x00, 0x79, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0x00, 0xE6, 0x00, 0xEC, 0x00,
  0xD8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0D, 0x80,
  0x3B, 0x00, 0xE6, 0x1F, 0x8F, 0xFC, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x1F, 0xF0, 0x01, 0xE1, 0xC0, 0x1C, 0x03, 0x01,
  0x80, 0x0C, 0x1C, 0x00, 0x70, 0xC0, 0x01, 0x8E, 0x00, 0x0E, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x36, 0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xC6, 0x00,
  0x0E, 0x30, 0x00, 0x61, 0xC0, 0x07, 0x07, 0x00, 0x30, 0x1C, 0x07, 0x00,
  0x79, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x30, 0x0E, 0x18,
  0x03, 0x8C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x1C, 0x30, 0x3C, 0x1F, 0xF8, 0x0F,
  0xF8, 0x06, 0x0E, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x0C, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x71, 0x80,
  0x18, 0xC0, 0x0E, 0x60, 0x03, 0x30, 0x01, 0xD8, 0x00, 0x6C, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0xFE, 0x1E, 0x0F, 0x38, 0x01, 0x30, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x80, 0x1C,
  0xFC, 0xF8, 0x7F, 0xF0, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1B, 0x80, 0x06, 0x60, 0x01, 0x9C, 0x00, 0xC3, 0x80,
  0x70, 0x78, 0xF8, 0x0F, 0xF8, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x3C, 0x00,
  0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x20,
  0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x01, 0x81,
  0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x04, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30,
  0xC0, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01,
  0x98, 0x00, 0x1B, 0x00, 0x00, 0xB0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xD8, 0x00, 0x30,
  0x00, 0x36, 0x00, 0x0E, 0x00, 0x0D, 0x80, 0x07, 0x80, 0x06, 0x60, 0x01,
  0xE0, 0x01, 0x98, 0x00, 0x78, 0x00, 0x63, 0x00, 0x1A, 0x00, 0x18, 0xC0,
  0x06, 0xC0, 0x0E, 0x30, 0x03, 0x30, 0x03, 0x0C, 0x00, 0xCC, 0x00, 0xC1,
  0x80, 0x33, 0x00, 0x30, 0x60, 0x0C, 0xC0, 0x0C, 0x18, 0x03, 0x18, 0x06,
  0x06, 0x01, 0x86, 0x01, 0x81, 0x80, 0x61, 0x80, 0x60, 0x30, 0x18, 0x60,
  0x18, 0x0C, 0x06, 0x18, 0x06, 0x03, 0x01, 0x83, 0x03, 0x00, 0xC0, 0xC0,
  0xC0, 0xC0, 0x30, 0x30, 0x30, 0x30, 0x06, 0x0C, 0x0C, 0x0C, 0x01, 0x83,
  0x03, 0x06, 0x00, 0x60, 0xC0, 0x61, 0x80, 0x18, 0x60, 0x18, 0x60, 0x06,
  0x18, 0x06, 0x18, 0x00, 0xC6, 0x01, 0x86, 0x00, 0x31, 0x80, 0x63, 0x00,
  0x0C, 0x60, 0x0C, 0xC0, 0x03, 0x10, 0x03, 0x30, 0x00, 0x4C, 0x00, 0xCC,
  0x00, 0x1B, 0x00, 0x33, 0x00, 0x06, 0xC0, 0x0D, 0x80, 0x01, 0xB0, 0x01,
  0x60, 0x00, 0x68, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x30, 0x01, 0x98, 0x00, 0xC6,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0x60, 0x30, 0x30, 0x18, 0x18, 0x18,
  0x06, 0x0C, 0x03, 0x06, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x0D,
  0x80, 0x06, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0C, 0xC0, 0x06, 0x30, 0x06, 0x18,
  0x03, 0x0C, 0x01, 0x83, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xE0, 0x30, 0x60,
  0x18, 0x30, 0x0E, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xEC, 0x00, 0x3E,
  0x00, 0x18, 0xC0, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x63, 0x00,
  0x31, 0x80, 0x30, 0xC0, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x03, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60,
  0x03, 0x30, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x2C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x7F, 0xFE, 0xFF,
  0xFC, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xD8,
  0x00, 0x19, 0x80, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x30, 0x60, 0x06, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x38, 0x60, 0x03,
  0x0C, 0x00, 0x63, 0x00, 0x06, 0x60, 0x00, 0xD8, 0x00, 0x0C, 0xFF, 0xFF,
  0xF8, 0xE0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xE0, 0xFF,
  0xC3, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFC, 0x3F, 0xF1, 0xC0, 0xCC,
  0x03, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xE0, 0x1D, 0x80, 0xB3, 0x8E, 0xC7, 0xF3, 0x06, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC3, 0xE0, 0xCF, 0xF8, 0xD8, 0x1C, 0xF0, 0x0C, 0xE0, 0x06, 0xE0, 0x06,
  0xC0, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x06,
  0xB0, 0x0C, 0x98, 0x1C, 0x9C, 0x78, 0x87, 0xF0, 0x01, 0x80, 0x01, 0xF8,
  0x1F, 0xF0, 0xE0, 0x86, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF1, 0xC1, 0xFF, 0x00,
  0x40, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x3E, 0x18, 0x7F, 0xCC, 0x70, 0x76, 0x30, 0x1B, 0x30,
  0x07, 0x98, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x76, 0x00, 0x1B, 0x00, 0x0D,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0,
  0x01, 0xD8, 0x00, 0xE6, 0x00, 0xF3, 0x00, 0x58, 0xC0, 0x6C, 0x78, 0xE6,
  0x0F, 0xE3, 0x01, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x1C, 0x18, 0x18,
  0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02, 0x60, 0x03, 0x60,
  0x03, 0x60, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x02, 0x0F, 0x1E, 0x07,
  0xFC, 0x00, 0xC0, 0x01, 0xC0, 0x7F, 0x0E, 0x10, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0x8F, 0xF8,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x03, 0xE1, 0x87, 0xFC, 0xC7, 0x07, 0x67, 0x00, 0xB3,
  0x00, 0x79, 0x80, 0x1D, 0x80, 0x0E, 0xC0, 0x07, 0x60, 0x01, 0xB0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x3B,
  0x00, 0x1D, 0x80, 0x0E, 0x60, 0x0F, 0x30, 0x05, 0x8C, 0x06, 0xC7, 0x8E,
  0x60, 0xFE, 0x30, 0x18, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x62, 0x00, 0x71,
  0xE0, 0xF0, 0x7F, 0xE0, 0x01, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC7, 0xE3, 0x3F, 0xCD, 0x83, 0xBC, 0x06, 0xE0,
  0x0E, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x7F, 0xB0, 0x00, 0x01, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xC0, 0x0C, 0x71, 0xC3, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0x86, 0xBB, 0xC4, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01, 0xE0, 0x1B, 0x01, 0x98,
  0x0C, 0xC0, 0xC6, 0x06, 0x30, 0x61, 0x86, 0x0C, 0x30, 0x63, 0x03, 0x38,
  0x19, 0xC0, 0xDE, 0x06, 0xB0, 0x2C, 0xC1, 0xC6, 0x0C, 0x18, 0x60, 0xC3,
  0x06, 0x18, 0x18, 0xC0, 0xC6, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x03, 0x60,
  0x1B, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xC0, 0xF8, 0x47, 0xF0, 0xFF, 0x26, 0x1C, 0xC1, 0xD6,
  0x06, 0x40, 0x6A, 0x01, 0xE0, 0x36, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0xF0, 0x06, 0x00,
  0x78, 0x03, 0x00, 0x3C, 0x01, 0x80, 0x1E, 0x00, 0xC0, 0x0F, 0x00, 0x60,
  0x07, 0x80, 0x30, 0x03, 0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0xF0, 0x06,
  0x00, 0x78, 0x03, 0x00, 0x3C, 0x01, 0x80, 0x1E, 0x00, 0xC0, 0x0F, 0x00,
  0x60, 0x07, 0x80, 0x30, 0x03, 0xC0, 0x18, 0x01, 0xE0, 0x0C, 0x00, 0xF0,
  0x06, 0x00, 0x78, 0x03, 0x00, 0x30, 0x87, 0xE2, 0x3F, 0xC9, 0x83, 0xAC,
  0x06, 0xA0, 0x0E, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x03, 0xF0, 0x07, 0xFC, 0x07,
  0x03, 0x07, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x0C, 0x60, 0x06, 0x30, 0x06,
  0x0C, 0x07, 0x03, 0x8F, 0x00, 0xFF, 0x00, 0x08, 0x00, 0x83, 0xE0, 0x8F,
  0xF8, 0x98, 0x1C, 0x90, 0x0C, 0xA0, 0x0E, 0xA0, 0x06, 0xE0, 0x06, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xF0, 0x0C, 0xD8,
  0x1C, 0xCE, 0x78, 0xC7, 0xF0, 0xC1, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xE1, 0x87, 0xFC, 0xC7, 0x07, 0x63,
  0x01, 0xB3, 0x00, 0x79, 0x80, 0x1D, 0x80, 0x0E, 0xC0, 0x07, 0x60, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD0, 0x00, 0x6C, 0x00, 0x36,
  0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0E, 0x60, 0x0F, 0x30, 0x05, 0x8C, 0x06,
  0xC3, 0x8E, 0x60, 0xFE, 0x30, 0x08, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x87, 0xE3, 0xE9, 0x82, 0x40, 0xB0,
  0x28, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F, 0xE1, 0xFF, 0xDC, 0x04, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x34, 0x03, 0xBC,
  0x78, 0xFF, 0x80, 0x60, 0x00, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0xFF, 0xFF, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x43, 0xF0,
  0x20, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x3D, 0x81, 0x97, 0x9C,
  0x4F, 0xE1, 0x04, 0x00, 0xC0, 0x03, 0x40, 0x03, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60,
  0x02, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x80, 0x0C, 0x00, 0xF0, 0x03, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x02, 0xC0, 0x1E, 0x01, 0x90, 0x07, 0x80, 0x66, 0x01, 0x20, 0x19, 0x80,
  0xCC, 0x06, 0x60, 0x33, 0x03, 0x08, 0x0C, 0xC0, 0xC3, 0x03, 0x30, 0x30,
  0xC1, 0x84, 0x0C, 0x30, 0x61, 0x82, 0x0C, 0x18, 0x61, 0x81, 0x06, 0x18,
  0x60, 0x61, 0x06, 0x18, 0x18, 0xC0, 0x86, 0x06, 0x30, 0x31, 0x00, 0x8C,
  0x0C, 0xC0, 0x33, 0x03, 0x30, 0x0C, 0x80, 0xCC, 0x03, 0x60, 0x13, 0x00,
  0xD8, 0x06, 0x80, 0x16, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0xC0, 0x06, 0xC0, 0x19, 0x80,
  0x31, 0x80, 0xE3, 0x01, 0x83, 0x03, 0x06, 0x0C, 0x06, 0x18, 0x0C, 0x60,
  0x18, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x06, 0xC0, 0x0D, 0x80, 0x31, 0x80, 0x63, 0x01, 0x83, 0x03, 0x06,
  0x0C, 0x06, 0x18, 0x0C, 0x70, 0x1C, 0xC0, 0x19, 0x80, 0x36, 0x00, 0x30,
  0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0C,
  0x60, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x08, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60,
  0x04, 0x60, 0x06, 0x60, 0x06, 0x40, 0x06, 0xC0, 0x02, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0xB8, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xC0, 0xE0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x00, 0xC0, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xF0, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x3E, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x3F,
  0x80, 0xF8, 0x00, 0x1C, 0x00, 0x1F, 0xC0, 0x1C, 0x1C, 0x1E, 0x03, 0xFE,
  0x80, 0x3E, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 37, 11, 4, -37 },
  { 15, 10, 13, 16, 3, -37 },
  { 32, 20, 37, 22, 1, -37 },
  { 125, 17, 43, 21, 2, -40 },
  { 217, 26, 38, 31, 2, -38 },
  { 341, 19, 39, 21, 2, -38 },
  { 434, 3, 13, 9, 3, -37 },
  { 439, 9, 45, 14, 3, -37 },
  { 490, 9, 45, 14, 2, -37 },
  { 541, 14, 15, 18, 2, -40 },
  { 568, 18, 24, 21, 2, -30 },
  { 622, 5, 12, 10, 2, -5 },
  { 630, 11, 2, 14, 1, -15 },
  { 633, 4, 4, 10, 3, -4 },
  { 635, 16, 37, 18, 1, -37 },
  { 709, 16, 38, 21, 2, -38 },
  { 785, 9, 37, 21, 4, -37 },
  { 827, 16, 38, 21, 2, -38 },
  { 903, 16, 39, 21, 2, -38 },
  { 981, 19, 37, 21, 1, -37 },
  { 1069, 17, 37, 21, 2, -37 },
  { 1148, 17, 38, 21, 2, -37 },
  { 1229, 16, 37, 21, 2, -37 },
  { 1303, 17, 39, 21, 2, -38 },
  { 1386, 16, 39, 21, 2, -38 },
  { 1464, 4, 28, 10, 3, -28 },
  { 1478, 5, 35, 10, 2, -28 },
  { 1500, 18, 21, 21, 2, -29 },
  { 1548, 18, 13, 21, 2, -25 },
  { 1578, 18, 21, 21, 2, -29 },
  { 1626, 12, 38, 14, 1, -38 },
  { 1683, 26, 42, 32, 3, -37 },
  { 1820, 20, 37, 20, 0, -37 },
  { 1913, 17, 37, 23, 4, -37 },
  { 1992, 18, 39, 22, 3, -38 },
  { 2080, 18, 37, 25, 4, -37 },
  { 2164, 14, 37, 20, 4, -37 },
  { 2229, 14, 37, 19, 4, -37 },
  { 2294, 21, 39, 27, 3, -38 },
  { 2397, 18, 37, 26, 4, -37 },
  { 2481, 8, 37, 12, 2, -37 },
  { 2518, 8, 46, 10, -2, -37 },
  { 2564, 16, 37, 20, 4, -37 },
  { 2638, 13, 37, 18, 4, -37 },
  { 2699, 27, 37, 35, 4, -37 },
  { 2824, 19, 37, 27, 4, -37 },
  { 2912, 21, 39, 27, 3, -38 },
  { 3015, 15, 37, 21, 4, -37 },
  { 3085, 21, 47, 27, 3, -38 },
  { 3209, 17, 37, 22, 4, -37 },
  { 3288, 16, 39, 20, 2, -38 },
  { 3366, 18, 37, 18, 0, -37 },
  { 3450, 18, 38, 26, 4, -37 },
  { 3536, 20, 37, 20, 0, -37 },
  { 3629, 34, 37, 34, 0, -37 },
  { 3787, 17, 37, 18, 0, -37 },
  { 3866, 17, 37, 17, 0, -37 },
  { 3945, 15, 37, 17, 1, -37 },
  { 4015, 10, 45, 16, 4, -37 },
  { 4072, 16, 37, 17, 1, -37 },
  { 4146, 10, 45, 16, 2, -37 },
  { 4203, 19, 18, 21, 1, -37 },
  { 4246, 21, 1, 21, 0, 5 },
  { 4249, 8, 8, 12, 2, -40 },
  { 4257, 14, 29, 20, 2, -28 },
  { 4308, 16, 41, 22, 4, -40 },
  { 4390, 14, 29, 17, 2, -28 },
  { 4441, 17, 41, 22, 2, -40 },
  { 4529, 16, 29, 20, 2, -28 },
  { 4587, 12, 40, 11, 1, -40 },
  { 4647, 17, 41, 22, 2, -28 },
  { 4735, 14, 40, 22, 4, -40 },
  { 4805, 3, 38, 10, 3, -38 },
  { 4820, 6, 51, 10, 0, -38 },
  { 4859, 13, 40, 18, 4, -40 },
  { 4924, 2, 40, 9, 4, -40 },
  { 4934, 25, 28, 32, 4, -28 },
  { 5022, 14, 28, 22, 4, -28 },
  { 5071, 17, 29, 21, 2, -28 },
  { 5133, 16, 40, 22, 4, -28 },
  { 5213, 17, 40, 22, 2, -28 },
  { 5298, 10, 28, 14, 4, -28 },
  { 5333, 13, 29, 16, 2, -28 },
  { 5381, 10, 35, 11, 1, -34 },
  { 5425, 14, 29, 22, 4, -28 },
  { 5476, 16, 28, 16, 0, -28 },
  { 5532, 26, 28, 28, 1, -28 },
  { 5623, 15, 28, 17, 1, -28 },
  { 5676, 16, 41, 17, 1, -28 },
  { 5758, 12, 28, 14, 1, -28 },
  { 5800, 13, 45, 18, 3, -37 },
  { 5874, 2, 53, 20, 9, -40 },
  { 5888, 14, 45, 18, 2, -37 },
  { 5967, 18, 5, 21, 2, -21 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT52PT7B_H_
