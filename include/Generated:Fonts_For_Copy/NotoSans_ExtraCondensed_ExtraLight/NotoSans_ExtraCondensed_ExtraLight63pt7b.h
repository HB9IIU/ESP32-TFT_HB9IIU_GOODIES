#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT63PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight63pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x00, 0x00, 0x00, 0x77, 0xFF, 0x70,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06,
  0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x06,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x03, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00,
  0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x80,
  0x07, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x60, 0x18, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0x06, 0x03, 0x80, 0x06, 0x01, 0x80, 0x03, 0x00, 0xC0, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18,
  0x06, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xE0, 0x79, 0x87, 0x87, 0x8C, 0x0C, 0x30, 0x60, 0x03, 0x83, 0x00, 0x18,
  0x18, 0x01, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x60, 0x30, 0x03, 0x01, 0x80,
  0x18, 0x0C, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x00, 0x18, 0x18, 0x00, 0xE0,
  0xC0, 0x03, 0x86, 0x00, 0x0E, 0x30, 0x00, 0x3D, 0x80, 0x00, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xCF, 0x00, 0x06,
  0x3C, 0x00, 0x30, 0x70, 0x01, 0x81, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x38,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x07, 0x00, 0x60, 0x30, 0x03, 0x03, 0xB0,
  0x18, 0x39, 0xF0, 0xC7, 0x87, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x06, 0x00, 0xE7, 0x00,
  0x0C, 0x01, 0x87, 0x00, 0x30, 0x06, 0x06, 0x00, 0x60, 0x0C, 0x0C, 0x00,
  0xC0, 0x18, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x01, 0x80, 0xC0,
  0x0C, 0x03, 0x03, 0x00, 0x18, 0x06, 0x06, 0x00, 0x30, 0x0E, 0x0C, 0x00,
  0x60, 0x18, 0x30, 0x00, 0xC0, 0x30, 0x60, 0x01, 0x80, 0x60, 0xC0, 0x03,
  0x00, 0xC3, 0x03, 0x06, 0x01, 0x86, 0x1F, 0x8C, 0x03, 0x0C, 0x73, 0x98,
  0x06, 0x30, 0xC3, 0x98, 0x0C, 0x63, 0x03, 0x30, 0x30, 0xC6, 0x06, 0x60,
  0x63, 0x0C, 0x06, 0x61, 0xC6, 0x30, 0x0C, 0xF7, 0x0C, 0x60, 0x18, 0xFC,
  0x30, 0xC0, 0x30, 0x60, 0x61, 0x80, 0x60, 0x00, 0xC3, 0x00, 0xC0, 0x03,
  0x06, 0x01, 0x80, 0x06, 0x0C, 0x03, 0x00, 0x0C, 0x18, 0x06, 0x00, 0x30,
  0x30, 0x0C, 0x00, 0x60, 0x60, 0x18, 0x00, 0xC0, 0xC0, 0x30, 0x03, 0x01,
  0x80, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x18, 0x18, 0x03, 0x00, 0x30,
  0x30, 0x06, 0x00, 0x30, 0xE0, 0x0C, 0x00, 0x7B, 0x80, 0x30, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xBC, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C,
  0x07, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C,
  0x06, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x1C, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0x30, 0x0C, 0x30, 0x38, 0x0C, 0x70, 0x18, 0x0C, 0x60, 0x0C, 0x0C, 0xE0,
  0x0E, 0x0C, 0xE0, 0x06, 0x1C, 0xC0, 0x07, 0x18, 0xC0, 0x03, 0x18, 0xC0,
  0x03, 0xB8, 0xC0, 0x01, 0xB0, 0xC0, 0x00, 0xF0, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x60, 0x01, 0xF0, 0x70, 0x03, 0xB8, 0x30,
  0x07, 0x1C, 0x3C, 0x0E, 0x0C, 0x1F, 0xFC, 0x0E, 0x0F, 0xF8, 0x07, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0x00, 0x70, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80,
  0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x81, 0x81, 0xE1, 0x87, 0xFD, 0xBF, 0x1F, 0xF8,
  0x01, 0xC0, 0x03, 0xC0, 0x06, 0x60, 0x0E, 0x30, 0x0C, 0x30, 0x18, 0x18,
  0x30, 0x0C, 0x30, 0x0E, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x1C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x1C, 0x61, 0x8E, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x07, 0x03, 0x81, 0xC0,
  0x30, 0x30, 0x07, 0x0E, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01, 0xCE, 0x00,
  0x19, 0x80, 0x03, 0x30, 0x00, 0x66, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0x80, 0x03,
  0xB0, 0x00, 0x67, 0x00, 0x0C, 0xE0, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0C,
  0x38, 0x01, 0x83, 0x00, 0x70, 0x70, 0x1C, 0x07, 0x07, 0x00, 0x7F, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0xEE, 0x39, 0xCE,
  0x3B, 0x87, 0xE0, 0xE8, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x3F, 0xFF,
  0x07, 0x80, 0x78, 0x20, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0x80, 0x78, 0xE0, 0x01,
  0xC4, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x80, 0x01, 0xC6,
  0x00, 0x78, 0x7F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x1C,
  0xC0, 0x00, 0x18, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x70,
  0xC0, 0x00, 0x60, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xC0, 0xC0, 0x01, 0xC0,
  0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00,
  0xC0, 0x06, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x00,
  0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x9F, 0xC0, 0x3F, 0xFF,
  0x0F, 0xC1, 0xF0, 0x80, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x90, 0x00, 0xE3, 0x80, 0x3C, 0x7F, 0xFE, 0x07, 0xFF, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xC0, 0x40, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0xE3, 0xFE, 0x0E, 0x7F, 0xF0, 0xCC, 0x03, 0x8D, 0x80, 0x18, 0xD0, 0x01,
  0xCF, 0x00, 0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x67,
  0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xC0, 0x18,
  0x1E, 0x03, 0x80, 0xF9, 0xF0, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xE0, 0x1C, 0x07, 0x81, 0xC0, 0x0C, 0x1C, 0x00,
  0x70, 0xE0, 0x01, 0x86, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C,
  0x00, 0x0C, 0xE0, 0x00, 0x67, 0x00, 0x03, 0x18, 0x00, 0x38, 0xC0, 0x01,
  0x87, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x60, 0x0E, 0x03, 0x80, 0xE0, 0x0E,
  0x0E, 0x00, 0x3D, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3B, 0x80,
  0x07, 0x8E, 0x00, 0x70, 0x3C, 0x07, 0x00, 0x70, 0x30, 0x01, 0x83, 0x80,
  0x0E, 0x38, 0x00, 0x39, 0xC0, 0x00, 0xCC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1D, 0x80, 0x00, 0xEC, 0x00, 0x06, 0x70, 0x00, 0x71, 0xC0, 0x03, 0x0E,
  0x00, 0x38, 0x3C, 0x03, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0xE0, 0x70, 0x1C,
  0x03, 0x83, 0x80, 0x1C, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x70, 0x00, 0xE6,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x30, 0x00, 0xF3, 0x00,
  0x0B, 0x38, 0x01, 0xB1, 0xC0, 0x33, 0x0F, 0x1E, 0x70, 0x7F, 0xC7, 0x01,
  0xF0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x6F,
  0xFF, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x06, 0xFF, 0xFF, 0x18, 0xF3, 0xCF, 0x1C, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x1C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x30, 0xC7, 0x18, 0x63, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0x00, 0x7F, 0xC3,
  0xFF, 0xC3, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x03, 0x83, 0x00, 0x00, 0x00,
  0xC3, 0x80, 0x00, 0x00, 0x61, 0x80, 0x1F, 0xF0, 0x30, 0xC0, 0x1F, 0xF0,
  0x1C, 0xE0, 0x1C, 0x18, 0x06, 0x70, 0x0C, 0x0C, 0x03, 0x30, 0x0C, 0x06,
  0x01, 0x98, 0x06, 0x03, 0x00, 0xCC, 0x07, 0x01, 0x80, 0x66, 0x03, 0x00,
  0xC0, 0x33, 0x01, 0x80, 0x60, 0x1B, 0x80, 0xC0, 0x30, 0x0F, 0xC0, 0x60,
  0x18, 0x07, 0xE0, 0x30, 0x0C, 0x03, 0xF0, 0x38, 0x06, 0x01, 0xB8, 0x1C,
  0x03, 0x00, 0xDC, 0x0E, 0x01, 0x80, 0x6E, 0x03, 0x01, 0xC0, 0x37, 0x01,
  0x80, 0xE0, 0x1B, 0x80, 0xC0, 0x70, 0x0C, 0xC0, 0x60, 0x28, 0x0E, 0x60,
  0x30, 0x14, 0x06, 0x30, 0x1C, 0x1A, 0x03, 0x18, 0x06, 0x0D, 0x83, 0x8C,
  0x03, 0x8C, 0xE3, 0x87, 0x00, 0xFC, 0x3F, 0x83, 0x80, 0x3C, 0x0F, 0x80,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB0,
  0x00, 0x01, 0x98, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x70, 0x00, 0x0C, 0x18, 0x00, 0x06,
  0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00,
  0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x1C, 0x00, 0x30, 0x06, 0x00,
  0x18, 0x03, 0x00, 0x1C, 0x01, 0x80, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xC0, 0x03,
  0x80, 0x60, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00,
  0x1C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x07, 0x00, 0x01, 0x83, 0x80,
  0x00, 0xE1, 0x80, 0x00, 0x70, 0xC0, 0x00, 0x18, 0xE0, 0x00, 0x0C, 0x70,
  0x00, 0x07, 0x30, 0x00, 0x03, 0x98, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x38, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xC0, 0x1F, 0x8C, 0x00,
  0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x06, 0xC0, 0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0xCC, 0x00, 0x1C,
  0xC0, 0x03, 0x8C, 0x00, 0x70, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xC0, 0x7F,
  0x0C, 0x00, 0x38, 0xC0, 0x01, 0xCC, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x6C, 0x00, 0x0E, 0xC0, 0x01, 0xCC, 0x00, 0x3C,
  0xC0, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x78, 0x06, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0C,
  0x03, 0xF0, 0x30, 0x01, 0xE0, 0xC0, 0x03, 0xC3, 0x00, 0x07, 0x0C, 0x00,
  0x0E, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xCC, 0x00, 0x03,
  0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x3B, 0x00, 0x00, 0xEC, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x73,
  0x00, 0x01, 0x8C, 0x00, 0x0E, 0x30, 0x00, 0x70, 0xC0, 0x03, 0x83, 0x00,
  0x1E, 0x0C, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0xF8, 0x01, 0xE0,
  0x3C, 0x00, 0x08, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x76, 0x00, 0x00, 0x0E,
  0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1C, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0E, 0x30, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80,
  0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1D, 0x07, 0x3F,
  0xC7, 0xF0, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01, 0xCC, 0x00, 0x38,
  0xC0, 0x03, 0x8C, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C,
  0x0C, 0x01, 0xC0, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x0C, 0x06,
  0x00, 0xC0, 0xE0, 0x0C, 0x1C, 0x00, 0xC1, 0x80, 0x0C, 0x38, 0x00, 0xC3,
  0x00, 0x0C, 0x70, 0x00, 0xCF, 0x00, 0x0C, 0xF0, 0x00, 0xDF, 0x80, 0x0D,
  0x98, 0x00, 0xF1, 0xC0, 0x0F, 0x0C, 0x00, 0xE0, 0xE0, 0x0C, 0x06, 0x00,
  0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x0C, 0x01, 0x80, 0xC0, 0x1C,
  0x0C, 0x00, 0xC0, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xC0, 0x07, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0,
  0x00, 0xEC, 0x00, 0x0E, 0xC0, 0x00, 0x70, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xD8, 0x00, 0x00,
  0x1B, 0xD8, 0x00, 0x00, 0x1B, 0xDC, 0x00, 0x00, 0x3B, 0xCC, 0x00, 0x00,
  0x33, 0xCC, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x73, 0xCE, 0x00, 0x00,
  0x63, 0xC6, 0x00, 0x00, 0x63, 0xC6, 0x00, 0x00, 0x63, 0xC7, 0x00, 0x00,
  0xE3, 0xC3, 0x00, 0x00, 0xC3, 0xC3, 0x00, 0x00, 0xC3, 0xC3, 0x80, 0x01,
  0xC3, 0xC1, 0x80, 0x01, 0x83, 0xC1, 0x80, 0x01, 0x83, 0xC1, 0x80, 0x03,
  0x83, 0xC1, 0xC0, 0x03, 0x03, 0xC0, 0xC0, 0x03, 0x03, 0xC0, 0xC0, 0x03,
  0x03, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0x60, 0x06, 0x03, 0xC0, 0x60, 0x06,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0xC0, 0x30, 0x0C,
  0x03, 0xC0, 0x30, 0x1C, 0x03, 0xC0, 0x38, 0x18, 0x03, 0xC0, 0x18, 0x18,
  0x03, 0xC0, 0x18, 0x38, 0x03, 0xC0, 0x1C, 0x38, 0x03, 0xC0, 0x0C, 0x30,
  0x03, 0xC0, 0x0C, 0x30, 0x03, 0xC0, 0x0E, 0x70, 0x03, 0xC0, 0x06, 0x60,
  0x03, 0xC0, 0x06, 0x60, 0x03, 0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFB, 0x00, 0x01, 0xF7, 0x00, 0x03, 0xE6, 0x00, 0x07,
  0xCC, 0x00, 0x0F, 0x9C, 0x00, 0x1F, 0x18, 0x00, 0x3E, 0x38, 0x00, 0x7C,
  0x30, 0x00, 0xF8, 0x70, 0x01, 0xF0, 0x60, 0x03, 0xE0, 0xC0, 0x07, 0xC0,
  0xC0, 0x0F, 0x81, 0x80, 0x1F, 0x03, 0x80, 0x3E, 0x03, 0x00, 0x7C, 0x07,
  0x00, 0xF8, 0x06, 0x01, 0xF0, 0x0E, 0x03, 0xE0, 0x0C, 0x07, 0xC0, 0x18,
  0x0F, 0x80, 0x38, 0x1F, 0x00, 0x30, 0x3E, 0x00, 0x70, 0x7C, 0x00, 0x60,
  0xF8, 0x00, 0xE1, 0xF0, 0x00, 0xC3, 0xE0, 0x01, 0xC7, 0xC0, 0x01, 0x8F,
  0x80, 0x03, 0x1F, 0x00, 0x07, 0x3E, 0x00, 0x06, 0x7C, 0x00, 0x0E, 0x78,
  0x00, 0x0C, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x1B, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0E, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00,
  0x1C, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0xC0,
  0x00, 0x06, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x66, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x07, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x0C, 0x00, 0x0E,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF,
  0x0C, 0x07, 0xE3, 0x00, 0x3C, 0xC0, 0x07, 0xB0, 0x00, 0xEC, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00, 0xF3,
  0x00, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x0E, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x76,
  0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x60, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x07, 0x60, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x30,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x30, 0x70, 0x00, 0x1C,
  0x0C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0F, 0x01,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0xC0, 0x7E, 0x0C, 0x00, 0xF0, 0xC0, 0x03, 0x8C, 0x00, 0x18, 0xC0,
  0x01, 0xCC, 0x00, 0x1C, 0xC0, 0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x00, 0xCC, 0x00, 0x0C,
  0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x07,
  0x0C, 0x00, 0xF0, 0xC0, 0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0C, 0x06,
  0x00, 0xC0, 0x70, 0x0C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xC0,
  0x18, 0x0C, 0x01, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xE0, 0xC0, 0x06, 0x0C,
  0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xC0, 0x03, 0x8C, 0x00, 0x1C,
  0xC0, 0x01, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x06, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x8F, 0x00, 0x63, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x3A, 0x00, 0x0E, 0x70, 0x07, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x33, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x18, 0x00, 0x0C, 0x38,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0x3C, 0x03, 0x80, 0x3F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x38, 0x1C,
  0x00, 0x38, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x0E,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03,
  0x01, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x01,
  0x83, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xB0, 0x00, 0x0E, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x00, 0x00, 0xEE,
  0x00, 0x03, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xE0, 0x00, 0x33, 0x80, 0x01,
  0xF0, 0x00, 0x18, 0xC0, 0x00, 0xD8, 0x00, 0x1C, 0x60, 0x00, 0x6C, 0x00,
  0x0E, 0x38, 0x00, 0x37, 0x00, 0x07, 0x1C, 0x00, 0x19, 0x80, 0x03, 0x06,
  0x00, 0x0C, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x60, 0x01, 0xC1, 0x80, 0x06,
  0x30, 0x00, 0xE0, 0xE0, 0x03, 0x1C, 0x00, 0x60, 0x70, 0x01, 0x8E, 0x00,
  0x30, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x06,
  0x00, 0x60, 0xC0, 0x0E, 0x03, 0x80, 0x30, 0x70, 0x06, 0x01, 0xC0, 0x18,
  0x38, 0x03, 0x00, 0x60, 0x0C, 0x0C, 0x03, 0x80, 0x30, 0x0E, 0x06, 0x01,
  0xC0, 0x1C, 0x06, 0x03, 0x00, 0xE0, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x07,
  0x01, 0x80, 0xE0, 0x30, 0x01, 0x80, 0xC0, 0x30, 0x38, 0x00, 0xC0, 0xE0,
  0x18, 0x1C, 0x00, 0x70, 0x60, 0x0C, 0x0C, 0x00, 0x38, 0x30, 0x07, 0x06,
  0x00, 0x0C, 0x18, 0x03, 0x83, 0x00, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x03,
  0x0E, 0x00, 0x61, 0xC0, 0x01, 0xC6, 0x00, 0x30, 0xC0, 0x00, 0xE3, 0x00,
  0x1C, 0x60, 0x00, 0x31, 0x80, 0x0E, 0x70, 0x00, 0x18, 0xC0, 0x03, 0x38,
  0x00, 0x0C, 0xE0, 0x01, 0x98, 0x00, 0x07, 0x60, 0x00, 0xCC, 0x00, 0x03,
  0xB0, 0x00, 0x66, 0x00, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x00, 0x6C, 0x00,
  0x0F, 0x80, 0x00, 0x36, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x73, 0x00, 0x06, 0x30, 0x00, 0x63, 0x80, 0x0E, 0x18, 0x00, 0xC1,
  0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0xC0, 0x18, 0x0E, 0x03, 0x80, 0x60, 0x30,
  0x06, 0x03, 0x00, 0x70, 0x70, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x8E,
  0x00, 0x18, 0xC0, 0x01, 0x9C, 0x00, 0x0D, 0x80, 0x00, 0xD8, 0x00, 0x0F,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xD8, 0x00, 0x1D, 0x80, 0x01, 0x9C, 0x00, 0x18, 0xC0, 0x03, 0x8C, 0x00,
  0x30, 0xE0, 0x07, 0x06, 0x00, 0x60, 0x60, 0x06, 0x07, 0x00, 0xE0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x38, 0x18, 0x01, 0x81, 0x80, 0x18, 0x38, 0x01,
  0xC3, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00, 0x0E, 0x60, 0x00, 0x6E, 0x00,
  0x07, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x3B, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xE0, 0x00, 0xE3, 0x00, 0x06, 0x18, 0x00, 0x30, 0xE0, 0x03, 0x83, 0x00,
  0x18, 0x18, 0x00, 0xC0, 0xE0, 0x0E, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xE0, 0x38, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xE0, 0xE0, 0x03, 0x06,
  0x00, 0x18, 0x30, 0x00, 0xE3, 0x80, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00,
  0xEE, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x06, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0xE1, 0xC0,
  0x01, 0x81, 0x80, 0x07, 0x03, 0x80, 0x0C, 0x07, 0x00, 0x38, 0x06, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x18, 0x18,
  0x00, 0x38, 0x70, 0x00, 0x30, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x66, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x03, 0xF8, 0x07, 0xFE, 0x07, 0x83, 0x82, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xFF, 0x03, 0xFF,
  0x87, 0x80, 0xC7, 0x00, 0x67, 0x00, 0x37, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x76,
  0x00, 0x3B, 0x00, 0x3D, 0xC0, 0x16, 0x70, 0x1B, 0x1E, 0x38, 0x87, 0xF8,
  0x40, 0x70, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0xFC, 0x0E, 0x3F, 0xF0, 0xE7, 0x8F, 0x8E, 0xE0, 0x38,
  0xEC, 0x01, 0xCF, 0x80, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x06, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x6F, 0x00, 0x06,
  0xF0, 0x00, 0xEF, 0x80, 0x0C, 0xEC, 0x01, 0xCC, 0x60, 0x38, 0xC7, 0xFF,
  0x0C, 0x1F, 0xE0, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xC6,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x01, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x01, 0xF0, 0x30, 0x7F, 0xC3, 0x0F, 0x0E, 0x31, 0xC0,
  0x33, 0x38, 0x01, 0xB3, 0x80, 0x1B, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x60,
  0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x77, 0x00,
  0x0F, 0x70, 0x00, 0xB3, 0x00, 0x1B, 0x38, 0x03, 0x31, 0xC0, 0x73, 0x0F,
  0xFE, 0x30, 0x7F, 0xC3, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80,
  0x3C, 0x78, 0x0E, 0x03, 0x83, 0x80, 0x38, 0x60, 0x03, 0x1C, 0x00, 0x63,
  0x80, 0x0E, 0x60, 0x00, 0xCC, 0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0x6C,
  0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x10, 0x70, 0x0E, 0x07,
  0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x70,
  0x41, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC3,
  0x0F, 0x9E, 0x31, 0xC0, 0x33, 0x38, 0x01, 0xB3, 0x00, 0x0B, 0x70, 0x00,
  0xF7, 0x00, 0x0F, 0x60, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07,
  0x60, 0x00, 0xF7, 0x00, 0x0B, 0x70, 0x00, 0xB3, 0x00, 0x1F, 0x38, 0x03,
  0x71, 0xC0, 0x77, 0x0F, 0xFE, 0x70, 0x7F, 0x87, 0x00, 0xE0, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC4,
  0x00, 0x38, 0x70, 0x0F, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x0F, 0x83, 0x8F, 0xF8, 0xE7, 0x8F,
  0x3B, 0x81, 0xEE, 0xC0, 0x3B, 0xE0, 0x06, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0x6F, 0xFF,
  0x60, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x06, 0x0F, 0x0F,
  0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0xF8, 0xF0, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0xE0, 0x06, 0x70, 0x07,
  0x38, 0x07, 0x1C, 0x03, 0x0E, 0x03, 0x87, 0x03, 0x83, 0x81, 0x81, 0xC1,
  0xC0, 0xE0, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x78, 0x07,
  0x3C, 0x03, 0xB7, 0x01, 0xF9, 0x80, 0xF8, 0xE0, 0x78, 0x30, 0x38, 0x18,
  0x1C, 0x0E, 0x0E, 0x03, 0x07, 0x01, 0xC3, 0x80, 0x61, 0xC0, 0x38, 0xE0,
  0x1C, 0x70, 0x06, 0x38, 0x03, 0x9C, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x3B,
  0x80, 0x0D, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x07, 0xC1, 0x87, 0xF8, 0x3F, 0xE3, 0x1C, 0x78, 0x71, 0xE6, 0x60, 0x31,
  0x80, 0xED, 0x80, 0x76, 0x01, 0xDA, 0x00, 0x68, 0x01, 0xB4, 0x00, 0xF0,
  0x03, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0x00,
  0x0F, 0x80, 0x06, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x18, 0x00,
  0x7C, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x60, 0x01, 0xF0, 0x00, 0xC0, 0x03,
  0xE0, 0x01, 0x80, 0x07, 0xC0, 0x03, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x1F,
  0x00, 0x0C, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x7C, 0x00, 0x30, 0x00, 0xF8,
  0x00, 0x60, 0x01, 0xF0, 0x00, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x07, 0xC0,
  0x03, 0x00, 0x0F, 0x80, 0x06, 0x00, 0x1F, 0x00, 0x0C, 0x00, 0x3E, 0x00,
  0x18, 0x00, 0x7C, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x60, 0x01, 0xF0, 0x00,
  0xC0, 0x03, 0xE0, 0x01, 0x80, 0x07, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xF8,
  0x30, 0xFF, 0x8C, 0x78, 0xF3, 0x38, 0x0E, 0xCC, 0x03, 0xB6, 0x00, 0x6D,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x30, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x01, 0xC0,
  0x38, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00, 0x06, 0x60,
  0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0x67, 0x00,
  0x0E, 0x30, 0x00, 0xC3, 0x80, 0x1C, 0x18, 0x01, 0xC1, 0xE0, 0x38, 0x0F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x0C, 0x3F, 0xF0,
  0xC7, 0x87, 0x8C, 0xE0, 0x38, 0xCC, 0x01, 0xCD, 0x80, 0x0E, 0xD0, 0x00,
  0xED, 0x00, 0x06, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x6F, 0x00, 0x06, 0xF8, 0x00, 0xEF, 0x80, 0x0C, 0xEC, 0x01,
  0xCE, 0x60, 0x38, 0xE7, 0xFF, 0x0E, 0x1F, 0xE0, 0xE0, 0x20, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0xC3, 0x0F, 0x0E, 0x31, 0xC0, 0x33, 0x38, 0x01, 0xB3, 0x80,
  0x1B, 0x30, 0x00, 0xB7, 0x00, 0x0F, 0x60, 0x00, 0x76, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x76, 0x00, 0x07, 0x60, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xB3, 0x80,
  0x1F, 0x38, 0x03, 0x71, 0xE0, 0x67, 0x0F, 0xFE, 0x70, 0x7F, 0xC7, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0xFE, 0x1F, 0xB1, 0xFD, 0x8C, 0x0C, 0xC0, 0x64, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xF8, 0x0F,
  0xFE, 0x3E, 0x1F, 0x38, 0x02, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x80, 0x0E, 0xE0,
  0x1C, 0xFF, 0xFC, 0x3F, 0xF0, 0x07, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xFF, 0x07, 0xF0, 0x0C, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x3D, 0x80,
  0x0B, 0x70, 0x06, 0xDC, 0x01, 0xB3, 0x81, 0xCC, 0x7F, 0xE3, 0x0F, 0xF0,
  0xC0, 0x60, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0x38, 0x00,
  0x67, 0x00, 0x0C, 0x60, 0x03, 0x8C, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x01,
  0x83, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x01, 0x81, 0xC0, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x30, 0x0E, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x38,
  0x03, 0x06, 0x00, 0x70, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x18, 0xC0,
  0x03, 0x18, 0x00, 0x33, 0x00, 0x06, 0xE0, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x06, 0xE0, 0x03, 0xC0, 0x06, 0xE0, 0x03,
  0xC0, 0x06, 0x60, 0x03, 0xC0, 0x0E, 0x60, 0x07, 0xC0, 0x0E, 0x60, 0x06,
  0x60, 0x0C, 0x70, 0x06, 0x60, 0x0C, 0x30, 0x06, 0x60, 0x0C, 0x30, 0x0E,
  0x60, 0x1C, 0x30, 0x0E, 0x60, 0x18, 0x38, 0x0C, 0x30, 0x18, 0x38, 0x0C,
  0x30, 0x18, 0x18, 0x0C, 0x30, 0x18, 0x18, 0x1C, 0x30, 0x38, 0x18, 0x18,
  0x38, 0x30, 0x1C, 0x18, 0x18, 0x30, 0x0C, 0x18, 0x18, 0x30, 0x0C, 0x18,
  0x18, 0x70, 0x0C, 0x38, 0x18, 0x60, 0x0C, 0x30, 0x1C, 0x60, 0x0E, 0x30,
  0x0C, 0x60, 0x06, 0x30, 0x0C, 0x60, 0x06, 0x70, 0x0C, 0xE0, 0x06, 0x60,
  0x0C, 0xC0, 0x07, 0x60, 0x0E, 0xC0, 0x03, 0x60, 0x06, 0xC0, 0x03, 0x60,
  0x06, 0xC0, 0x03, 0x60, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01,
  0xCE, 0x00, 0x30, 0xC0, 0x0E, 0x1C, 0x01, 0xC1, 0x80, 0x30, 0x38, 0x0E,
  0x03, 0x01, 0x80, 0x70, 0x70, 0x06, 0x0C, 0x00, 0xC3, 0x80, 0x0C, 0x60,
  0x01, 0x9C, 0x00, 0x3B, 0x00, 0x03, 0x60, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x06, 0xC0, 0x01, 0xD8, 0x00, 0x33, 0x80,
  0x0E, 0x30, 0x01, 0x87, 0x00, 0x70, 0x60, 0x0C, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x1C, 0x0C, 0x01, 0x83, 0x80, 0x30, 0x60, 0x07, 0x1C, 0x00, 0x63,
  0x00, 0x0E, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03,
  0x38, 0x00, 0x67, 0x00, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0x61, 0xC0, 0x0C,
  0x38, 0x03, 0x83, 0x00, 0x70, 0x60, 0x0C, 0x0E, 0x01, 0x81, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0E, 0x0E, 0x00, 0xC1, 0xC0,
  0x18, 0x30, 0x03, 0x06, 0x00, 0x71, 0xC0, 0x06, 0x38, 0x00, 0xC6, 0x00,
  0x18, 0xC0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x01, 0x1C, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xF8, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x05, 0xFF, 0x80, 0x1E, 0x0F, 0x81, 0xF0, 0x0F, 0xFE,
  0x80, 0x0F, 0xF0, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 45, 13, 4, -45 },
  { 24, 12, 16, 20, 4, -45 },
  { 48, 25, 45, 27, 1, -45 },
  { 189, 21, 52, 25, 2, -48 },
  { 326, 31, 47, 37, 3, -46 },
  { 509, 24, 47, 25, 2, -46 },
  { 650, 3, 16, 11, 4, -45 },
  { 656, 12, 55, 17, 3, -45 },
  { 739, 12, 55, 17, 2, -45 },
  { 822, 16, 17, 22, 3, -48 },
  { 856, 22, 29, 26, 2, -37 },
  { 936, 6, 15, 12, 2, -7 },
  { 948, 13, 2, 17, 2, -18 },
  { 952, 4, 5, 12, 4, -5 },
  { 955, 18, 45, 21, 2, -45 },
  { 1057, 19, 46, 25, 3, -46 },
  { 1167, 11, 45, 25, 5, -45 },
  { 1229, 20, 46, 25, 2, -46 },
  { 1344, 20, 47, 25, 2, -46 },
  { 1462, 24, 45, 25, 1, -45 },
  { 1597, 19, 46, 25, 3, -45 },
  { 1707, 20, 46, 25, 3, -45 },
  { 1822, 19, 45, 25, 3, -45 },
  { 1929, 21, 47, 25, 2, -46 },
  { 2053, 20, 47, 25, 2, -46 },
  { 2171, 4, 34, 12, 4, -34 },
  { 2188, 6, 42, 12, 2, -34 },
  { 2220, 22, 26, 26, 2, -35 },
  { 2292, 22, 16, 26, 2, -30 },
  { 2336, 22, 26, 26, 2, -35 },
  { 2408, 15, 46, 17, 1, -46 },
  { 2495, 33, 51, 39, 3, -45 },
  { 2706, 25, 45, 25, 0, -45 },
  { 2847, 20, 45, 28, 5, -45 },
  { 2960, 22, 47, 27, 3, -46 },
  { 3090, 22, 45, 30, 5, -45 },
  { 3214, 16, 45, 24, 5, -45 },
  { 3304, 16, 45, 23, 5, -45 },
  { 3394, 27, 47, 33, 3, -46 },
  { 3553, 21, 45, 31, 5, -45 },
  { 3672, 10, 45, 15, 2, -45 },
  { 3729, 11, 56, 12, -3, -45 },
  { 3806, 20, 45, 25, 5, -45 },
  { 3919, 16, 45, 22, 5, -45 },
  { 4009, 32, 45, 42, 5, -45 },
  { 4189, 23, 45, 33, 5, -45 },
  { 4319, 26, 47, 33, 3, -46 },
  { 4472, 18, 45, 26, 5, -45 },
  { 4574, 26, 57, 33, 3, -46 },
  { 4760, 20, 45, 26, 5, -45 },
  { 4873, 19, 47, 25, 3, -46 },
  { 4985, 21, 45, 22, 0, -45 },
  { 5104, 23, 46, 31, 4, -45 },
  { 5237, 24, 45, 24, 0, -45 },
  { 5372, 41, 45, 42, 0, -45 },
  { 5603, 20, 45, 22, 1, -45 },
  { 5716, 21, 45, 21, 0, -45 },
  { 5835, 18, 45, 21, 2, -45 },
  { 5937, 12, 55, 19, 5, -45 },
  { 6020, 18, 45, 21, 2, -45 },
  { 6122, 12, 55, 19, 2, -45 },
  { 6205, 23, 22, 26, 1, -45 },
  { 6269, 25, 2, 25, 0, 6 },
  { 6276, 9, 10, 15, 3, -48 },
  { 6288, 17, 35, 24, 2, -34 },
  { 6363, 20, 49, 27, 4, -48 },
  { 6486, 16, 35, 20, 3, -34 },
  { 6556, 20, 49, 27, 3, -48 },
  { 6679, 19, 35, 24, 3, -34 },
  { 6763, 14, 48, 14, 1, -48 },
  { 6847, 20, 49, 27, 3, -34 },
  { 6970, 18, 48, 26, 4, -48 },
  { 7078, 4, 46, 12, 4, -46 },
  { 7101, 8, 61, 12, 0, -46 },
  { 7162, 17, 48, 21, 4, -48 },
  { 7264, 3, 48, 11, 4, -48 },
  { 7282, 31, 34, 39, 4, -34 },
  { 7414, 18, 34, 26, 4, -34 },
  { 7491, 20, 35, 26, 3, -34 },
  { 7579, 20, 49, 27, 4, -34 },
  { 7702, 20, 49, 27, 3, -34 },
  { 7825, 13, 34, 17, 4, -34 },
  { 7881, 16, 35, 20, 2, -34 },
  { 7951, 12, 42, 14, 1, -41 },
  { 8014, 18, 34, 26, 4, -33 },
  { 8091, 19, 33, 19, 0, -33 },
  { 8170, 32, 33, 33, 1, -33 },
  { 8302, 19, 33, 21, 1, -33 },
  { 8381, 19, 48, 21, 1, -33 },
  { 8495, 13, 33, 17, 2, -33 },
  { 8549, 16, 55, 22, 3, -45 },
  { 8659, 2, 63, 24, 11, -48 },
  { 8675, 16, 55, 22, 3, -45 },
  { 8785, 22, 6, 26, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight63pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT63PT7B_H_
