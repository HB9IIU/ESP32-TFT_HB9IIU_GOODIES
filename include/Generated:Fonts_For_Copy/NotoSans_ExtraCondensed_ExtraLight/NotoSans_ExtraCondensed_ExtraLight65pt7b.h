#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT65PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight65pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x60, 0x00, 0x00, 0x0E, 0xFF, 0xFE,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03,
  0x00, 0x70, 0x1C, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80,
  0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0xE0, 0x18, 0x00, 0x30, 0x0E, 0x00, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x18,
  0x07, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0xE0, 0x18,
  0x00, 0x38, 0x06, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x00, 0xC0, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0xC0, 0x30, 0x00, 0x70, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0xC0,
  0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01,
  0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x38, 0x06, 0x00, 0x0C,
  0x03, 0x80, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xE3,
  0x0F, 0x0E, 0x0C, 0x08, 0x30, 0x30, 0x01, 0xC0, 0xC0, 0x06, 0x03, 0x00,
  0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x03, 0x00, 0x38,
  0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x1C, 0x0C,
  0x00, 0x38, 0x30, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0xEC, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x33, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0xE0, 0x03, 0x07, 0x30, 0x0C, 0x38, 0xFC, 0x33, 0xC1, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0xC0, 0x0E, 0x38, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x60,
  0x06, 0x07, 0x00, 0x30, 0x03, 0x01, 0x80, 0x30, 0x01, 0x80, 0xC0, 0x18,
  0x01, 0xC0, 0x60, 0x0C, 0x00, 0xC0, 0x38, 0x0C, 0x00, 0x60, 0x0C, 0x06,
  0x00, 0x30, 0x06, 0x03, 0x00, 0x18, 0x03, 0x03, 0x00, 0x0C, 0x01, 0x81,
  0x80, 0x06, 0x00, 0xC0, 0xC0, 0x03, 0x00, 0x60, 0xC0, 0x01, 0x80, 0x30,
  0x60, 0x00, 0xC0, 0x18, 0x30, 0x00, 0x60, 0x0C, 0x30, 0x00, 0x30, 0x06,
  0x18, 0x18, 0x18, 0x03, 0x0C, 0x3F, 0x0C, 0x03, 0x8C, 0x39, 0xC7, 0x01,
  0x86, 0x38, 0x71, 0x80, 0xC3, 0x18, 0x18, 0xC0, 0x63, 0x0C, 0x0C, 0x60,
  0x71, 0x8C, 0x03, 0x18, 0x30, 0xC6, 0x01, 0x8E, 0x38, 0xC3, 0x00, 0xC3,
  0xF8, 0x61, 0x80, 0x60, 0xF8, 0x30, 0xC0, 0x30, 0x00, 0x30, 0x60, 0x18,
  0x00, 0x18, 0x30, 0x0C, 0x00, 0x0C, 0x38, 0x07, 0x00, 0x0C, 0x1C, 0x03,
  0x80, 0x06, 0x0E, 0x01, 0xC0, 0x03, 0x07, 0x00, 0xE0, 0x03, 0x01, 0x80,
  0x70, 0x01, 0x80, 0xC0, 0x30, 0x00, 0xC0, 0x60, 0x18, 0x00, 0xC0, 0x30,
  0x0C, 0x00, 0x60, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x03, 0x00, 0x30, 0x06,
  0x03, 0x80, 0x18, 0x01, 0x81, 0x80, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x00,
  0x70, 0xE0, 0x06, 0x00, 0x1F, 0xE0, 0x07, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x40, 0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x1E, 0x00, 0x06,
  0x06, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C,
  0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x06,
  0x06, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0x70, 0x00, 0x18, 0x38, 0x00, 0x38,
  0x18, 0x06, 0x70, 0x1C, 0x06, 0x70, 0x0C, 0x0E, 0x60, 0x0E, 0x0E, 0xE0,
  0x06, 0x0C, 0xE0, 0x07, 0x0C, 0xE0, 0x03, 0x0C, 0xC0, 0x01, 0x9C, 0xC0,
  0x01, 0xD8, 0xC0, 0x00, 0xD8, 0xE0, 0x00, 0xF8, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0x60, 0x00, 0xF8, 0x60, 0x00, 0xD8, 0x70, 0x01, 0xDC, 0x38,
  0x03, 0x8C, 0x3C, 0x0F, 0x0E, 0x1F, 0xFE, 0x06, 0x07, 0xF8, 0x07, 0x00,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0xDB, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x04, 0x04, 0x0F, 0xC2, 0x1E, 0xFD,
  0x7C, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x63, 0x00,
  0x60, 0xC0, 0x60, 0x70, 0x70, 0x1C, 0x30, 0x04, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1C, 0x70, 0xE1,
  0xC3, 0x86, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0C, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xE0, 0x07, 0x8F, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x81, 0x80, 0x18,
  0x38, 0x01, 0xC3, 0x80, 0x0C, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00,
  0x66, 0x00, 0x06, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00,
  0x0C, 0x38, 0x00, 0xC1, 0x80, 0x1C, 0x1C, 0x01, 0x80, 0xE0, 0x38, 0x0F,
  0x07, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x83,
  0xB0, 0xE6, 0x38, 0xCE, 0x1B, 0x83, 0xE0, 0x68, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x07,
  0xF8, 0x01, 0xFF, 0xE0, 0x7C, 0x1F, 0x0F, 0x00, 0x78, 0x40, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0xF8, 0x0F, 0x83, 0xE1, 0xF0, 0x07, 0x86, 0x00, 0x1E, 0x20, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x39, 0x00, 0x03, 0x87, 0x00, 0x7C, 0x3F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xE0,
  0x00, 0x06, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x0C, 0xE0, 0x00, 0x18, 0xE0,
  0x00, 0x18, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0,
  0x01, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x18, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x60, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x63, 0xF0, 0x07,
  0xFF, 0xE0, 0x7F, 0x3F, 0x06, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x80, 0x03, 0x8E,
  0x00, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xFC, 0x01, 0xFB, 0xC0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x20, 0x0E, 0x1F, 0xE0,
  0xE7, 0xFF, 0x0E, 0xE0, 0x38, 0xEC, 0x01, 0xCF, 0x80, 0x0E, 0xF0, 0x00,
  0xEF, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x36, 0x00, 0x07, 0x60, 0x00, 0x36, 0x00, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x06, 0x30, 0x00, 0x63, 0x80, 0x0E, 0x38, 0x00, 0xC1, 0xC0, 0x1C,
  0x0E, 0x03, 0x80, 0xFD, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xF8,
  0x7C, 0x03, 0x80, 0x78, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03,
  0x0C, 0x00, 0x0C, 0x30, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x01, 0xE1, 0xE0,
  0x03, 0xCF, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0x8F, 0x00, 0x1C, 0x0E, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x38, 0x38, 0x00,
  0x70, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x1B,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x76, 0x00, 0x01, 0x98, 0x00, 0x06, 0x70, 0x00, 0x39, 0xC0, 0x00,
  0xE3, 0x80, 0x07, 0x0F, 0x00, 0x38, 0x1E, 0x01, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0x1E,
  0x03, 0xC0, 0x70, 0x38, 0x03, 0x87, 0x00, 0x18, 0x60, 0x01, 0xC6, 0x00,
  0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x0E, 0xC0, 0x00, 0x6C, 0x00, 0x06, 0xC0,
  0x00, 0x6C, 0x00, 0x06, 0xC0, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0x60, 0x00, 0xF7, 0x00, 0x1F, 0x70, 0x01, 0xF3, 0x80, 0x37, 0x1C, 0x0E,
  0x70, 0xFF, 0xC6, 0x07, 0xF8, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x70, 0x00, 0x6F, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x18,
  0x38, 0xF9, 0xE1, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC1, 0xC7, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0xC3,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xE3, 0xE1,
  0xE2, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0xF8,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x03, 0x0E, 0x00, 0x00, 0x00, 0xC3,
  0x80, 0x1F, 0xE0, 0x38, 0xC0, 0x0F, 0x78, 0x0E, 0x30, 0x07, 0x06, 0x01,
  0x9C, 0x03, 0x81, 0x80, 0x67, 0x00, 0xC0, 0x60, 0x19, 0x80, 0x70, 0x18,
  0x06, 0x60, 0x18, 0x06, 0x01, 0x98, 0x06, 0x01, 0x80, 0x76, 0x03, 0x80,
  0x60, 0x1D, 0x80, 0xC0, 0x18, 0x07, 0xE0, 0x30, 0x06, 0x01, 0xF8, 0x0C,
  0x01, 0x80, 0x7E, 0x03, 0x00, 0xE0, 0x1F, 0x80, 0xC0, 0x38, 0x07, 0xE0,
  0x30, 0x0E, 0x01, 0xB8, 0x0C, 0x03, 0x80, 0x6E, 0x03, 0x00, 0xE0, 0x19,
  0x80, 0xC0, 0x38, 0x06, 0x60, 0x30, 0x0E, 0x01, 0x98, 0x0E, 0x07, 0x80,
  0xE6, 0x01, 0x81, 0xE0, 0x31, 0x80, 0x60, 0x48, 0x1C, 0x60, 0x1C, 0x33,
  0x06, 0x1C, 0x03, 0xFC, 0xF7, 0x87, 0x00, 0x7E, 0x1F, 0xC0, 0xC0, 0x0E,
  0x01, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x70, 0x00, 0x01, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x38, 0x60, 0x00, 0x1C, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x03, 0x81, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x18, 0x00, 0x70, 0x0C,
  0x00, 0x38, 0x06, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x1C, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x03, 0x83,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x1C,
  0x60, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x38, 0x00, 0x01, 0x98, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0C, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x30, 0x01, 0xF1, 0x80, 0x03, 0x8C, 0x00, 0x0E, 0x60,
  0x00, 0x33, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x01,
  0xB0, 0x00, 0x0D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00,
  0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0xE6, 0x00, 0x07, 0x30, 0x00, 0x71,
  0x80, 0x0F, 0x0C, 0x07, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xFC, 0x18, 0x00,
  0xF0, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x30, 0x00, 0x1D, 0x80, 0x00, 0x6C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0xC0, 0x00, 0x76, 0x00, 0x07,
  0x30, 0x00, 0xF1, 0x80, 0x1F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0xF8, 0x0F, 0x00, 0x20, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x01, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0x00,
  0x3E, 0x06, 0x00, 0x1E, 0x0C, 0x00, 0x1E, 0x18, 0x00, 0x1C, 0x30, 0x00,
  0x1C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x73, 0x00, 0x00,
  0x66, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x66, 0x00, 0x01,
  0xCC, 0x00, 0x03, 0x98, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x60, 0x00, 0x70,
  0xC0, 0x00, 0xE1, 0x80, 0x03, 0x83, 0x00, 0x1E, 0x06, 0x01, 0xF8, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFE, 0xFF,
  0xFF, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0xF0,
  0x3C, 0x00, 0x04, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0x70, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x33,
  0x80, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x0E, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x01, 0x81,
  0xE0, 0x00, 0x30, 0x0F, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0xFF,
  0xE3, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0xF7, 0xFC, 0xFF, 0x07, 0x00, 0xC0,
  0x00, 0x76, 0x00, 0x07, 0x30, 0x00, 0x71, 0x80, 0x03, 0x8C, 0x00, 0x38,
  0x60, 0x01, 0x83, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x06, 0x00,
  0xE0, 0x30, 0x07, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x38, 0x03,
  0x03, 0x80, 0x18, 0x1C, 0x00, 0xC1, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0xE0,
  0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0x67, 0xC0, 0x03, 0x3E, 0x00, 0x1B,
  0x38, 0x00, 0xD9, 0xC0, 0x07, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0,
  0x0C, 0x07, 0x00, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x80, 0xC0,
  0x1C, 0x06, 0x00, 0x70, 0x30, 0x03, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x70,
  0x60, 0x01, 0x83, 0x00, 0x0E, 0x18, 0x00, 0x30, 0xC0, 0x01, 0xC6, 0x00,
  0x06, 0x30, 0x00, 0x39, 0x80, 0x00, 0xCC, 0x00, 0x07, 0x60, 0x00, 0x1C,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFD, 0x80, 0x00, 0x00, 0xFE, 0xC0, 0x00, 0x00, 0x6F, 0x70, 0x00, 0x00,
  0x37, 0x98, 0x00, 0x00, 0x3B, 0xCC, 0x00, 0x00, 0x19, 0xE7, 0x00, 0x00,
  0x0C, 0xF3, 0x80, 0x00, 0x0E, 0x78, 0xC0, 0x00, 0x06, 0x3C, 0x60, 0x00,
  0x03, 0x1E, 0x38, 0x00, 0x03, 0x8F, 0x0C, 0x00, 0x01, 0xC7, 0x86, 0x00,
  0x00, 0xC3, 0xC3, 0x80, 0x00, 0x61, 0xE0, 0xC0, 0x00, 0x70, 0xF0, 0x60,
  0x00, 0x30, 0x78, 0x38, 0x00, 0x18, 0x3C, 0x1C, 0x00, 0x1C, 0x1E, 0x06,
  0x00, 0x0C, 0x0F, 0x03, 0x00, 0x06, 0x07, 0x81, 0xC0, 0x07, 0x03, 0xC0,
  0x60, 0x03, 0x81, 0xE0, 0x30, 0x01, 0x80, 0xF0, 0x1C, 0x00, 0xC0, 0x78,
  0x06, 0x00, 0xE0, 0x3C, 0x03, 0x00, 0x60, 0x1E, 0x01, 0xC0, 0x30, 0x0F,
  0x00, 0xE0, 0x38, 0x07, 0x80, 0x30, 0x18, 0x03, 0xC0, 0x18, 0x0C, 0x01,
  0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0x03, 0x07, 0x00, 0x78, 0x01, 0x83, 0x00,
  0x3C, 0x00, 0xE1, 0x80, 0x1E, 0x00, 0x31, 0xC0, 0x0F, 0x00, 0x18, 0xC0,
  0x07, 0x80, 0x0E, 0x60, 0x03, 0xC0, 0x07, 0x70, 0x01, 0xE0, 0x01, 0xB0,
  0x00, 0xF0, 0x00, 0xD8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xD8, 0x00, 0x07, 0xDC, 0x00, 0x07,
  0xCC, 0x00, 0x07, 0xCC, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xC6, 0x00, 0x07,
  0xC7, 0x00, 0x07, 0xC3, 0x00, 0x07, 0xC3, 0x80, 0x07, 0xC1, 0x80, 0x07,
  0xC1, 0x80, 0x07, 0xC1, 0xC0, 0x07, 0xC0, 0xC0, 0x07, 0xC0, 0xE0, 0x07,
  0xC0, 0x60, 0x07, 0xC0, 0x70, 0x07, 0xC0, 0x30, 0x07, 0xC0, 0x38, 0x07,
  0xC0, 0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0, 0x1C, 0x07, 0xC0, 0x0C, 0x07,
  0xC0, 0x0E, 0x07, 0xC0, 0x06, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x03, 0x07,
  0xC0, 0x03, 0x87, 0xC0, 0x03, 0x87, 0xC0, 0x01, 0x87, 0xC0, 0x01, 0xC7,
  0xC0, 0x00, 0xC7, 0xC0, 0x00, 0xE7, 0xC0, 0x00, 0x67, 0xC0, 0x00, 0x77,
  0xC0, 0x00, 0x37, 0xC0, 0x00, 0x37, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x1C, 0x18, 0x00, 0x03, 0x87, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x07, 0x18, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x9C,
  0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x1D, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x06, 0xC0, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x18, 0x00,
  0x00, 0x63, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x60,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x3C, 0x00,
  0x38, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0x00,
  0x7C, 0x60, 0x03, 0xCC, 0x00, 0x3D, 0x80, 0x03, 0xB0, 0x00, 0x36, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x07, 0x30, 0x01,
  0xE6, 0x00, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xF8, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x18,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07, 0x18, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x07, 0x60, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x18, 0x00, 0x00, 0x63, 0x80, 0x00,
  0x1C, 0x70, 0x00, 0x03, 0x86, 0x00, 0x00, 0x60, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x30, 0x07, 0xC1, 0x80, 0x0F, 0x0C, 0x00,
  0x1C, 0x60, 0x00, 0xE3, 0x00, 0x03, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xE6,
  0x00, 0x03, 0x30, 0x00, 0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00,
  0x33, 0x00, 0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xE6, 0x00, 0x07, 0x30,
  0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x38, 0x60, 0x03, 0x83, 0x00, 0x78,
  0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x06, 0x03, 0x00, 0x30, 0x1C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x70, 0x18, 0x01, 0x80,
  0xC0, 0x0E, 0x06, 0x00, 0x70, 0x30, 0x01, 0xC1, 0x80, 0x0E, 0x0C, 0x00,
  0x30, 0x60, 0x01, 0xC3, 0x00, 0x06, 0x18, 0x00, 0x38, 0xC0, 0x00, 0xC6,
  0x00, 0x07, 0x30, 0x00, 0x39, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x00,
  0x1C, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0x87, 0xE1, 0xC0, 0x06, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC8, 0x00, 0x38, 0xE0, 0x0F, 0x8F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xD8, 0x00, 0x06, 0x70, 0x00, 0x39, 0xE0, 0x00, 0xE3, 0xC0, 0x07,
  0x07, 0x80, 0x78, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x60, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0x80,
  0x06, 0x00, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0xE0, 0x30,
  0x00, 0x70, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x06,
  0x00, 0x03, 0x83, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x03, 0x38, 0x00, 0x01,
  0x9C, 0x00, 0x00, 0xEC, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xC0, 0x00, 0x19, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xE7, 0x00, 0x01,
  0xB0, 0x00, 0x1C, 0x60, 0x00, 0x36, 0x00, 0x03, 0x0C, 0x00, 0x06, 0xC0,
  0x00, 0x61, 0xC0, 0x00, 0xD8, 0x00, 0x1C, 0x38, 0x00, 0x3B, 0x00, 0x03,
  0x87, 0x00, 0x07, 0x70, 0x00, 0x70, 0x60, 0x00, 0xCE, 0x00, 0x0C, 0x0C,
  0x00, 0x18, 0xC0, 0x01, 0x81, 0xC0, 0x03, 0x18, 0x00, 0x70, 0x38, 0x00,
  0xE3, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x70, 0x01, 0x80, 0x60, 0x03, 0x0E,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x01, 0xC0, 0x0C, 0x18, 0x01,
  0xC0, 0x38, 0x03, 0x83, 0x00, 0x38, 0x03, 0x00, 0x70, 0x70, 0x06, 0x00,
  0x60, 0x0C, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x01, 0xC0,
  0x30, 0x18, 0x07, 0x00, 0x38, 0x0E, 0x03, 0x00, 0xE0, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x00, 0x60, 0x30, 0x0E, 0x03, 0x00, 0x0E, 0x06, 0x00, 0xC0,
  0xE0, 0x01, 0xC0, 0xC0, 0x18, 0x1C, 0x00, 0x38, 0x18, 0x03, 0x03, 0x00,
  0x03, 0x07, 0x00, 0x70, 0x60, 0x00, 0x60, 0xC0, 0x0E, 0x1C, 0x00, 0x0E,
  0x18, 0x00, 0xC3, 0x80, 0x01, 0xC3, 0x00, 0x18, 0x70, 0x00, 0x38, 0x60,
  0x03, 0x0C, 0x00, 0x03, 0x1C, 0x00, 0x61, 0x80, 0x00, 0x63, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x60, 0x00, 0xCE, 0x00, 0x01, 0xCC, 0x00, 0x19, 0x80,
  0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x03, 0x70, 0x00, 0x66, 0x00, 0x00,
  0x6C, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x39, 0x80,
  0x03, 0x8E, 0x00, 0x1C, 0x30, 0x00, 0xC1, 0x80, 0x0E, 0x0E, 0x00, 0x60,
  0x30, 0x03, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x30, 0x1C, 0x01, 0xC0,
  0xE0, 0x06, 0x06, 0x00, 0x30, 0x70, 0x01, 0xC3, 0x00, 0x06, 0x18, 0x00,
  0x31, 0xC0, 0x01, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x36, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x06, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x18, 0x00, 0x18, 0xE0,
  0x01, 0xC7, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x00, 0x30,
  0x18, 0x03, 0x80, 0xE0, 0x18, 0x03, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0xE0,
  0x60, 0x03, 0x07, 0x00, 0x1C, 0x30, 0x00, 0xE3, 0x80, 0x03, 0x1C, 0x00,
  0x1C, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x1D,
  0x80, 0x00, 0xE6, 0x00, 0x03, 0x9C, 0x00, 0x0C, 0x30, 0x00, 0x70, 0xC0,
  0x01, 0xC3, 0x80, 0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x70, 0x03,
  0x00, 0xC0, 0x1C, 0x03, 0x00, 0x70, 0x0E, 0x01, 0x80, 0x18, 0x0E, 0x00,
  0x60, 0x38, 0x01, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x1C, 0x00, 0x38,
  0x60, 0x00, 0x63, 0x80, 0x01, 0x8E, 0x00, 0x07, 0x30, 0x00, 0x0D, 0xC0,
  0x00, 0x37, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x77, 0x00, 0x00, 0x63, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0xC1, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x80,
  0xE0, 0x03, 0x00, 0x60, 0x07, 0x00, 0x70, 0x06, 0x00, 0x70, 0x0E, 0x00,
  0x38, 0x0C, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x1C, 0x38, 0x00,
  0x0C, 0x30, 0x00, 0x0E, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xE0, 0xF0, 0x60, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x7F, 0x01, 0xFF, 0xC1, 0xF8, 0x31,
  0xE0, 0x0C, 0xF0, 0x03, 0x38, 0x00, 0xDC, 0x00, 0x36, 0x00, 0x0D, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01,
  0xD8, 0x00, 0xF7, 0x00, 0x2D, 0xC0, 0x1B, 0x38, 0x0C, 0xC7, 0xCE, 0x30,
  0xFF, 0x0C, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC1, 0xF8, 0x0C, 0x7F, 0xE0, 0xCF, 0x0F, 0x0C, 0xC0,
  0x38, 0xD8, 0x01, 0xCD, 0x00, 0x0C, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0x6E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xE0, 0x00, 0xEF, 0x00, 0x0C, 0xD0, 0x01, 0xCD, 0x80, 0x38, 0xCE,
  0x07, 0x8C, 0x7F, 0xF0, 0xC3, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0xC1, 0xF0, 0xC1, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x83, 0xFF, 0x80, 0xFF, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x07, 0xE0, 0xE0, 0xFF, 0xC7, 0x0F, 0x0F, 0x38, 0xE0,
  0x1D, 0xC7, 0x00, 0x6E, 0x70, 0x01, 0xF3, 0x00, 0x07, 0xB8, 0x00, 0x3D,
  0xC0, 0x01, 0xEC, 0x00, 0x07, 0x60, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x60,
  0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0x60, 0x01, 0xF3, 0x80, 0x0B,
  0x8E, 0x00, 0xDC, 0x78, 0x0C, 0x61, 0xFF, 0xC3, 0x07, 0xFC, 0x18, 0x07,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3C, 0x3C, 0x0E, 0x01, 0x81,
  0x80, 0x38, 0x70, 0x03, 0x8C, 0x00, 0x33, 0x80, 0x06, 0x60, 0x00, 0xEC,
  0x00, 0x1D, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x02, 0x0F, 0x00, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFC, 0x0F, 0xF0, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xF1,
  0xFF, 0xE0, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE1, 0x0F, 0x8F, 0x31, 0xC0, 0x3B,
  0x38, 0x01, 0xB3, 0x80, 0x0F, 0x30, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00,
  0x76, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07,
  0x70, 0x00, 0x73, 0x00, 0x0F, 0x38, 0x01, 0xB1, 0xC0, 0x1B, 0x1E, 0x07,
  0x30, 0xFF, 0xE3, 0x07, 0xFC, 0x30, 0x0E, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x40, 0x01, 0xC7,
  0x00, 0x78, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x1F, 0x83, 0x1F, 0xF8, 0xCF, 0x1F,
  0x33, 0x01, 0xCD, 0x80, 0x3B, 0xC0, 0x0E, 0xF0, 0x01, 0xB8, 0x00, 0x6E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xC0, 0x7F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x07, 0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E,
  0x0C, 0xFC, 0xF8, 0xE0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x05,
  0x80, 0x0C, 0xC0, 0x0E, 0x60, 0x0E, 0x30, 0x06, 0x18, 0x07, 0x0C, 0x03,
  0x06, 0x03, 0x83, 0x03, 0x81, 0x81, 0x80, 0xC1, 0xC0, 0x60, 0xC0, 0x30,
  0xE0, 0x18, 0xE0, 0x0C, 0x70, 0x06, 0x7C, 0x03, 0x76, 0x01, 0xB3, 0x80,
  0xF1, 0xC0, 0x78, 0x60, 0x38, 0x38, 0x18, 0x0C, 0x0C, 0x07, 0x06, 0x03,
  0x83, 0x00, 0xC1, 0x80, 0x70, 0xC0, 0x18, 0x60, 0x0E, 0x30, 0x07, 0x18,
  0x01, 0x8C, 0x00, 0xE6, 0x00, 0x33, 0x00, 0x1D, 0x80, 0x0E, 0xC0, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xF0, 0x07, 0xE1, 0x0F, 0xF8, 0x3F, 0xE2, 0x38, 0x70,
  0xF1, 0xE4, 0xC0, 0x71, 0x80, 0xED, 0x00, 0x66, 0x01, 0xDE, 0x00, 0xE8,
  0x01, 0xB8, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x01, 0xF8, 0x21, 0xFF, 0x88, 0xF0,
  0xF3, 0x70, 0x1C, 0xD8, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x1B, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1C, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xC3, 0xE0, 0x38, 0x07, 0x83,
  0x80, 0x1C, 0x1C, 0x00, 0x70, 0xC0, 0x01, 0x8E, 0x00, 0x0E, 0x60, 0x00,
  0x73, 0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x06, 0xE0, 0x00, 0x33, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xE0, 0x00, 0xE7, 0x00, 0x06, 0x18, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80,
  0x38, 0x0E, 0x03, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x08, 0x3F, 0xE0, 0x8F, 0x0F, 0x08, 0xC0, 0x38, 0x98, 0x01,
  0xCD, 0x00, 0x0C, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00,
  0x06, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xF0, 0x00,
  0xEF, 0x00, 0x0C, 0xD8, 0x01, 0xCD, 0xC0, 0x38, 0xCE, 0x07, 0x8C, 0x7F,
  0xF0, 0xC3, 0xFC, 0x0C, 0x07, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE1, 0x0F, 0x8F,
  0x31, 0xE0, 0x3B, 0x1C, 0x01, 0xB3, 0x80, 0x0F, 0x30, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x76, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x03, 0x60, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0x73, 0x00, 0x0F, 0x38, 0x01, 0xB1, 0xC0,
  0x1B, 0x1E, 0x07, 0x30, 0xFF, 0xE3, 0x03, 0xFC, 0x30, 0x06, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x01, 0xE8,
  0x7F, 0xCF, 0xFC, 0xC0, 0xD8, 0x0D, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x1E, 0x0F, 0x38, 0x01, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x80, 0x0E, 0xE0, 0x1E, 0xFF, 0xFC, 0x3F,
  0xF8, 0x07, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0x07, 0xF0, 0x0C, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0x80,
  0x07, 0xB0, 0x00, 0xB7, 0x00, 0x36, 0xE0, 0x06, 0xCE, 0x01, 0x99, 0xE0,
  0x63, 0x1F, 0xFC, 0x61, 0xFE, 0x0C, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x76,
  0x00, 0x06, 0x60, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00, 0x0C,
  0x30, 0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC1, 0x80, 0x18, 0x18, 0x01,
  0x81, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x0E, 0x07, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x07,
  0x0E, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x9C, 0x00,
  0x19, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x01, 0xB8, 0x00, 0xF0, 0x00, 0xCC, 0x00,
  0x6C, 0x00, 0x66, 0x00, 0x36, 0x00, 0x73, 0x00, 0x1B, 0x00, 0x39, 0xC0,
  0x0D, 0x80, 0x18, 0xE0, 0x0E, 0xC0, 0x0C, 0x30, 0x06, 0x70, 0x06, 0x18,
  0x03, 0x18, 0x07, 0x0C, 0x01, 0x8C, 0x03, 0x07, 0x00, 0xC6, 0x01, 0x83,
  0x80, 0xE3, 0x80, 0xC0, 0xC0, 0x61, 0xC0, 0x60, 0x60, 0x30, 0x60, 0x70,
  0x38, 0x18, 0x30, 0x30, 0x1C, 0x1C, 0x18, 0x18, 0x06, 0x0E, 0x0E, 0x0C,
  0x03, 0x06, 0x03, 0x0E, 0x01, 0x83, 0x01, 0x87, 0x00, 0xE1, 0x80, 0xC3,
  0x00, 0x71, 0xC0, 0x61, 0x80, 0x18, 0xC0, 0x38, 0xC0, 0x0C, 0x60, 0x0C,
  0xE0, 0x06, 0x30, 0x06, 0x60, 0x03, 0x98, 0x03, 0x30, 0x00, 0xDC, 0x01,
  0x98, 0x00, 0x6C, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x3E, 0x00, 0x1B, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xC0,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0xE6, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x01, 0xC1, 0x80, 0x38, 0x38, 0x06, 0x03, 0x01, 0xC0,
  0x70, 0x30, 0x06, 0x0E, 0x00, 0xE1, 0x80, 0x0C, 0x70, 0x01, 0xCC, 0x00,
  0x1B, 0x80, 0x03, 0x70, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xDC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01,
  0xC7, 0x00, 0x30, 0x60, 0x0E, 0x0E, 0x01, 0xC0, 0xC0, 0x30, 0x1C, 0x0E,
  0x01, 0x81, 0x80, 0x38, 0x70, 0x07, 0x0C, 0x00, 0x73, 0x80, 0x0E, 0x60,
  0x00, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0x76, 0x00, 0x06, 0x60, 0x00, 0x67,
  0x00, 0x0E, 0x70, 0x00, 0xC3, 0x00, 0x0C, 0x30, 0x00, 0xC3, 0x80, 0x1C,
  0x38, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0xC0, 0x38, 0x1C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0x60,
  0x60, 0x06, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x39, 0xC0, 0x03, 0x98, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00,
  0x1B, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFD, 0xFF,
  0xF0, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80,
  0x3F, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x0F, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x04, 0xFF, 0x80, 0x1F, 0x0F, 0x80, 0xF0, 0x0F, 0x8F,
  0x80, 0x0F, 0xFA, 0x00, 0x0F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 46, 13, 5, -46 },
  { 24, 12, 16, 20, 4, -46 },
  { 48, 26, 46, 28, 1, -46 },
  { 198, 22, 53, 26, 2, -49 },
  { 344, 33, 48, 38, 3, -47 },
  { 542, 24, 48, 26, 2, -47 },
  { 686, 3, 16, 11, 4, -46 },
  { 692, 12, 56, 17, 3, -46 },
  { 776, 12, 56, 17, 2, -46 },
  { 860, 17, 17, 23, 3, -49 },
  { 897, 22, 30, 26, 2, -38 },
  { 980, 7, 15, 12, 2, -7 },
  { 994, 14, 3, 17, 2, -19 },
  { 1000, 4, 5, 12, 4, -5 },
  { 1003, 19, 46, 22, 2, -46 },
  { 1113, 20, 47, 26, 3, -47 },
  { 1231, 11, 46, 26, 5, -46 },
  { 1295, 20, 47, 26, 3, -47 },
  { 1413, 21, 48, 26, 2, -47 },
  { 1539, 24, 47, 26, 1, -47 },
  { 1680, 20, 47, 26, 3, -46 },
  { 1798, 20, 48, 26, 3, -47 },
  { 1918, 20, 46, 26, 3, -46 },
  { 2033, 22, 48, 26, 2, -47 },
  { 2165, 20, 48, 26, 3, -47 },
  { 2285, 4, 35, 12, 4, -35 },
  { 2303, 7, 43, 12, 2, -35 },
  { 2341, 22, 28, 26, 2, -37 },
  { 2418, 22, 16, 26, 2, -31 },
  { 2462, 22, 28, 26, 2, -37 },
  { 2539, 15, 47, 18, 1, -47 },
  { 2628, 34, 53, 40, 3, -47 },
  { 2854, 25, 46, 25, 0, -46 },
  { 2998, 21, 46, 29, 5, -46 },
  { 3119, 23, 48, 27, 3, -47 },
  { 3257, 23, 46, 31, 5, -46 },
  { 3390, 17, 46, 25, 5, -46 },
  { 3488, 17, 46, 23, 5, -46 },
  { 3586, 27, 48, 34, 3, -47 },
  { 3748, 22, 46, 32, 5, -46 },
  { 3875, 11, 46, 15, 2, -46 },
  { 3939, 11, 58, 13, -3, -46 },
  { 4019, 21, 46, 26, 5, -46 },
  { 4140, 16, 46, 23, 5, -46 },
  { 4232, 33, 46, 43, 5, -46 },
  { 4422, 24, 46, 34, 5, -46 },
  { 4560, 27, 48, 34, 3, -47 },
  { 4722, 19, 46, 26, 5, -46 },
  { 4832, 27, 58, 34, 3, -47 },
  { 5028, 21, 46, 27, 5, -46 },
  { 5149, 20, 48, 26, 3, -47 },
  { 5269, 21, 46, 22, 1, -46 },
  { 5390, 22, 47, 32, 5, -46 },
  { 5520, 25, 46, 25, 0, -46 },
  { 5664, 43, 46, 43, 0, -46 },
  { 5912, 21, 46, 22, 1, -46 },
  { 6033, 22, 46, 22, 0, -46 },
  { 6160, 18, 46, 22, 2, -46 },
  { 6264, 13, 56, 20, 5, -46 },
  { 6355, 19, 46, 22, 2, -46 },
  { 6465, 13, 56, 20, 2, -46 },
  { 6556, 24, 22, 26, 1, -46 },
  { 6622, 26, 2, 26, 0, 6 },
  { 6629, 10, 11, 15, 3, -50 },
  { 6643, 18, 36, 24, 2, -35 },
  { 6724, 20, 50, 28, 5, -49 },
  { 6849, 17, 36, 21, 3, -35 },
  { 6926, 21, 50, 28, 3, -49 },
  { 7058, 19, 36, 25, 3, -35 },
  { 7144, 15, 50, 14, 1, -50 },
  { 7238, 20, 51, 28, 3, -35 },
  { 7366, 18, 49, 27, 5, -49 },
  { 7477, 4, 47, 12, 4, -47 },
  { 7501, 8, 63, 12, 0, -47 },
  { 7564, 17, 49, 22, 5, -49 },
  { 7669, 2, 49, 11, 5, -49 },
  { 7682, 31, 35, 41, 5, -35 },
  { 7818, 18, 35, 27, 5, -35 },
  { 7897, 21, 36, 27, 3, -35 },
  { 7992, 20, 50, 28, 5, -35 },
  { 8117, 20, 50, 28, 3, -35 },
  { 8242, 12, 35, 18, 5, -35 },
  { 8295, 16, 36, 21, 2, -35 },
  { 8367, 12, 44, 14, 1, -43 },
  { 8433, 19, 35, 27, 4, -34 },
  { 8517, 20, 34, 20, 0, -34 },
  { 8602, 33, 34, 35, 1, -34 },
  { 8743, 19, 34, 21, 1, -34 },
  { 8824, 20, 50, 21, 1, -34 },
  { 8949, 14, 34, 17, 2, -34 },
  { 9009, 17, 56, 23, 3, -46 },
  { 9128, 3, 65, 25, 11, -49 },
  { 9153, 16, 56, 23, 3, -46 },
  { 9265, 22, 6, 26, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight65pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT65PT7B_H_
