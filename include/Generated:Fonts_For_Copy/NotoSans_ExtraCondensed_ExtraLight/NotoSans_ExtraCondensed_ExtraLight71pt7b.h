#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT71PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight71pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF2, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x03, 0x70,
  0x1B, 0x80, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03,
  0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x0C, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60,
  0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0x60, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xC0, 0x1C, 0x00,
  0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0,
  0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0xC0, 0x18, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xC0, 0x38, 0x00, 0x18, 0x03, 0x80, 0x01, 0x80, 0x30, 0x00, 0x18,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0x38, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x30, 0x07, 0x00, 0x03,
  0x00, 0x70, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x00, 0x60, 0x00, 0x70, 0x06, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00,
  0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0x18, 0x3C, 0x1C, 0x18, 0x08,
  0x38, 0x18, 0x00, 0x30, 0x18, 0x00, 0x70, 0x18, 0x00, 0x60, 0x18, 0x00,
  0x60, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00,
  0xE0, 0x18, 0x00, 0xE0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x70, 0x18, 0x00,
  0x70, 0x18, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x0E, 0x18, 0x00,
  0x07, 0x98, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1B, 0xE0, 0x00, 0x18, 0xF0, 0x00, 0x18, 0x78,
  0x00, 0x18, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x0E, 0x00, 0x18, 0x07,
  0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x03, 0x00, 0x18, 0x03,
  0x00, 0x18, 0x03, 0x00, 0x18, 0x07, 0x00, 0x18, 0x07, 0x00, 0x18, 0x06,
  0x00, 0x18, 0x0E, 0x00, 0x18, 0x1C, 0xC0, 0x18, 0x3C, 0xF0, 0x18, 0x78,
  0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x01, 0xFE, 0x00, 0x06, 0x00,
  0x38, 0x70, 0x00, 0xE0, 0x03, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0xC0, 0x07, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x1C, 0x01, 0xC0, 0x06, 0x01,
  0xC0, 0x18, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x38, 0x00,
  0xE0, 0x0C, 0x03, 0x00, 0x0E, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x0C, 0x07,
  0x00, 0x0E, 0x00, 0xC0, 0x60, 0x00, 0xE0, 0x0C, 0x0E, 0x00, 0x0E, 0x00,
  0xC0, 0xE0, 0x00, 0xE0, 0x0C, 0x0C, 0x00, 0x0E, 0x00, 0xC1, 0xC0, 0x00,
  0xE0, 0x0C, 0x1C, 0x00, 0x0E, 0x00, 0xC1, 0x80, 0x00, 0xE0, 0x0C, 0x38,
  0x3E, 0x0E, 0x00, 0xC3, 0x87, 0xF8, 0x60, 0x0C, 0x30, 0xE3, 0x86, 0x01,
  0xC7, 0x0C, 0x1C, 0x60, 0x1C, 0x71, 0x80, 0xC7, 0x01, 0x86, 0x18, 0x0E,
  0x30, 0x18, 0xE3, 0x80, 0x63, 0x83, 0x8E, 0x38, 0x06, 0x1C, 0x70, 0xC3,
  0x00, 0x61, 0xFE, 0x1C, 0x30, 0x06, 0x0F, 0xC1, 0xC3, 0x00, 0x70, 0x00,
  0x18, 0x30, 0x07, 0x00, 0x03, 0x83, 0x00, 0x70, 0x00, 0x38, 0x30, 0x07,
  0x00, 0x03, 0x03, 0x00, 0x70, 0x00, 0x70, 0x30, 0x07, 0x00, 0x07, 0x03,
  0x00, 0x70, 0x00, 0x60, 0x30, 0x07, 0x00, 0x0E, 0x03, 0x00, 0x70, 0x00,
  0xE0, 0x30, 0x07, 0x00, 0x0C, 0x03, 0x00, 0x70, 0x00, 0xC0, 0x30, 0x07,
  0x00, 0x1C, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x06, 0x00, 0x18, 0x03,
  0x80, 0x60, 0x03, 0x80, 0x18, 0x0E, 0x00, 0x30, 0x01, 0x80, 0xC0, 0x03,
  0x00, 0x1C, 0x0C, 0x00, 0x70, 0x00, 0xE1, 0xC0, 0x06, 0x00, 0x07, 0xF8,
  0x00, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x30, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x07, 0x0C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x18, 0x03, 0x0E, 0x03, 0x80, 0x63, 0x80, 0x38, 0x0C, 0x70, 0x07, 0x03,
  0x8C, 0x00, 0x70, 0x71, 0x80, 0x0E, 0x0E, 0x70, 0x00, 0xE1, 0x8E, 0x00,
  0x0C, 0x31, 0xC0, 0x01, 0xCE, 0x38, 0x00, 0x19, 0xC7, 0x00, 0x03, 0xB0,
  0xE0, 0x00, 0x3E, 0x1C, 0x00, 0x07, 0x81, 0x80, 0x00, 0x70, 0x30, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0xEE, 0x0E, 0x00, 0x39, 0xC1,
  0xE0, 0x0E, 0x1C, 0x1E, 0x07, 0x83, 0x81, 0xFF, 0xE0, 0x38, 0x1F, 0xF8,
  0x03, 0x80, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDB, 0x6D, 0xB6, 0xDB,
  0x00, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x10, 0x17,
  0xC2, 0x1F, 0x7E, 0x4F, 0xC1, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1B, 0x00, 0x06, 0x30, 0x01, 0xC3, 0x00, 0x70, 0x70, 0x1C, 0x07, 0x07,
  0x00, 0x70, 0x60, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x71, 0xC7,
  0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x63, 0x8E, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF4, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0xE0, 0x70, 0x03,
  0x81, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xE3,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x19, 0xC0, 0x00, 0x67, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x9C, 0x00, 0x0E, 0x30, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x70, 0x01, 0x80, 0xE0, 0x0E, 0x03, 0xC0, 0x70, 0x07, 0x83, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E,
  0x03, 0xF0, 0x3B, 0x83, 0x9C, 0x38, 0xE3, 0x87, 0x38, 0x3F, 0x81, 0xD8,
  0x0E, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x07,
  0xE0, 0x7C, 0x1C, 0x00, 0x70, 0x20, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x07, 0xE0, 0x7C, 0x3C,
  0x00, 0x78, 0xE0, 0x00, 0xE1, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x20, 0x00, 0x78, 0xF0, 0x07, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x70, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x38, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x18, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x38,
  0x70, 0x00, 0x06, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00,
  0x0E, 0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0C, 0x03,
  0x80, 0x03, 0x80, 0x70, 0x00, 0x60, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0x01,
  0xF0, 0x20, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x78, 0xF0, 0x07, 0xC3, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xC7, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0xFF, 0x01, 0x87, 0xFF, 0x06, 0x3C, 0x7E, 0x19, 0xC0, 0x38,
  0xEC, 0x00, 0x73, 0xA0, 0x00, 0xEF, 0x80, 0x03, 0xBC, 0x00, 0x06, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x80, 0x00, 0x37, 0x00, 0x00, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0x73, 0x00, 0x01, 0xCE, 0x00, 0x06, 0x38, 0x00, 0x38, 0x70, 0x00,
  0xE1, 0xC0, 0x07, 0x03, 0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x1F, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3E, 0x0F, 0x80, 0xF0,
  0x07, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x0C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0x80, 0x00, 0x73, 0x00, 0x00,
  0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x06, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x07, 0x00,
  0x70, 0x3C, 0x00, 0x70, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x37, 0x00, 0x00, 0xE6, 0x00, 0x01, 0xCE,
  0x00, 0x07, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x38, 0x1F, 0x01, 0xE0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0xF0, 0x78, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0, 0x03,
  0x87, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x60, 0x00, 0x33, 0x80, 0x00, 0xEE,
  0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00,
  0x01, 0xB8, 0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xD8,
  0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x01, 0xF3, 0x80, 0x0D, 0xCF, 0x00,
  0x77, 0x1E, 0x03, 0x9C, 0x3F, 0xFC, 0x70, 0x7F, 0xE1, 0x80, 0x1C, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x20, 0x1E, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0xEF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x18, 0xF3, 0xCF, 0x3C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x1C, 0x71, 0xCF, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x18, 0xE3,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xFC, 0x3E,
  0x0F, 0x08, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x70, 0x06, 0x00,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x0C, 0x00, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x00, 0x1C, 0x18, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x10, 0x00, 0xE3, 0x00, 0x0F, 0xF8, 0x0E, 0x70, 0x03,
  0xFF, 0x80, 0x67, 0x00, 0x78, 0x38, 0x06, 0x60, 0x07, 0x03, 0x80, 0x66,
  0x00, 0xE0, 0x38, 0x07, 0xE0, 0x0C, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x38,
  0x07, 0xE0, 0x18, 0x03, 0x00, 0x7E, 0x01, 0x80, 0x30, 0x07, 0xE0, 0x18,
  0x03, 0x00, 0x3C, 0x03, 0x80, 0x30, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x3C,
  0x03, 0x80, 0x30, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x3C, 0x03, 0x00, 0x30,
  0x07, 0xC0, 0x30, 0x07, 0x00, 0x7C, 0x03, 0x00, 0x70, 0x07, 0xC0, 0x38,
  0x07, 0x00, 0x7C, 0x03, 0x80, 0x70, 0x07, 0xC0, 0x38, 0x07, 0x00, 0x6C,
  0x03, 0x80, 0x70, 0x06, 0xE0, 0x18, 0x0D, 0x00, 0xEE, 0x01, 0x80, 0xD0,
  0x0E, 0xE0, 0x1C, 0x0D, 0x81, 0xCE, 0x00, 0xC1, 0x98, 0x1C, 0x60, 0x0F,
  0x38, 0xE7, 0x86, 0x00, 0x7F, 0x0F, 0xF0, 0x70, 0x03, 0xE0, 0x7E, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x08,
  0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x06, 0x0E, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0E, 0x06, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0C, 0x03,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0x80, 0x38, 0x00,
  0x18, 0x01, 0x80, 0x03, 0x80, 0x18, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x1C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0E, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x18,
  0x00, 0x01, 0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x30, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x06, 0xE0, 0x00,
  0x00, 0x70, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0x00,
  0x0F, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x37, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE,
  0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0x80, 0x07, 0xC7, 0x00, 0x03, 0xCE, 0x00,
  0x03, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC,
  0x00, 0x07, 0xB8, 0x00, 0x1E, 0x70, 0x00, 0x78, 0xE0, 0x1F, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0xF8, 0x1F, 0x03, 0xE0, 0x02, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xE0, 0x01, 0x00, 0xF8, 0x07, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1C, 0x00, 0xFC, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x38, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00,
  0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x03, 0xC1, 0xC0, 0x07, 0xC0, 0xE0,
  0x7F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0xFE,
  0x03, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x03, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x30, 0xF0, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0C,
  0x0E, 0x00, 0x00, 0x60, 0x3C, 0x00, 0x03, 0x00, 0xF8, 0x00, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xE0, 0xFF, 0xFF, 0xFC, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE8,
  0x3D, 0xFF, 0x3F, 0xC1, 0xE0, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x71,
  0xE0, 0x00, 0xE7, 0xC0, 0x01, 0xDD, 0xC0, 0x03, 0xB3, 0x80, 0x07, 0xE3,
  0x80, 0x0F, 0x87, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x70, 0x0C,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x07, 0x00, 0x30,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xB0, 0x00, 0x00, 0x07, 0xFD,
  0x80, 0x00, 0x00, 0x37, 0xEE, 0x00, 0x00, 0x03, 0xBF, 0x30, 0x00, 0x00,
  0x1D, 0xF9, 0x80, 0x00, 0x00, 0xCF, 0xCE, 0x00, 0x00, 0x0E, 0x7E, 0x70,
  0x00, 0x00, 0x73, 0xF1, 0x80, 0x00, 0x03, 0x1F, 0x8E, 0x00, 0x00, 0x18,
  0xFC, 0x70, 0x00, 0x01, 0xC7, 0xE1, 0x80, 0x00, 0x0E, 0x3F, 0x0C, 0x00,
  0x00, 0x61, 0xF8, 0x70, 0x00, 0x07, 0x0F, 0xC1, 0x80, 0x00, 0x38, 0x7E,
  0x0C, 0x00, 0x01, 0x83, 0xF0, 0x70, 0x00, 0x1C, 0x1F, 0x83, 0x80, 0x00,
  0xE0, 0xFC, 0x0C, 0x00, 0x06, 0x07, 0xE0, 0x70, 0x00, 0x30, 0x3F, 0x03,
  0x80, 0x03, 0x81, 0xF8, 0x0C, 0x00, 0x1C, 0x0F, 0xC0, 0x70, 0x00, 0xC0,
  0x7E, 0x03, 0x80, 0x0E, 0x03, 0xF0, 0x0C, 0x00, 0x70, 0x1F, 0x80, 0x60,
  0x03, 0x00, 0xFC, 0x03, 0x80, 0x38, 0x07, 0xE0, 0x1C, 0x01, 0xC0, 0x3F,
  0x00, 0x60, 0x0C, 0x01, 0xF8, 0x03, 0x80, 0x60, 0x0F, 0xC0, 0x1C, 0x07,
  0x00, 0x7E, 0x00, 0x60, 0x38, 0x03, 0xF0, 0x03, 0x81, 0x80, 0x1F, 0x80,
  0x1C, 0x1C, 0x00, 0xFC, 0x00, 0x60, 0xE0, 0x07, 0xE0, 0x03, 0x06, 0x00,
  0x3F, 0x00, 0x1C, 0x70, 0x01, 0xF8, 0x00, 0xE3, 0x80, 0x0F, 0xC0, 0x03,
  0x18, 0x00, 0x7E, 0x00, 0x1C, 0xC0, 0x03, 0xF0, 0x00, 0xEE, 0x00, 0x1F,
  0x80, 0x03, 0x70, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0x0F, 0xB8, 0x00,
  0x03, 0xE6, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3E, 0x70, 0x00, 0x0F, 0x8E,
  0x00, 0x03, 0xE3, 0x80, 0x00, 0xF8, 0x60, 0x00, 0x3E, 0x1C, 0x00, 0x0F,
  0x83, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0xF8, 0x18, 0x00, 0x3E, 0x07, 0x00,
  0x0F, 0x81, 0xC0, 0x03, 0xE0, 0x38, 0x00, 0xF8, 0x0E, 0x00, 0x3E, 0x01,
  0x80, 0x0F, 0x80, 0x70, 0x03, 0xE0, 0x0C, 0x00, 0xF8, 0x03, 0x80, 0x3E,
  0x00, 0xE0, 0x0F, 0x80, 0x1C, 0x03, 0xE0, 0x07, 0x00, 0xF8, 0x00, 0xC0,
  0x3E, 0x00, 0x38, 0x0F, 0x80, 0x06, 0x03, 0xE0, 0x01, 0xC0, 0xF8, 0x00,
  0x30, 0x3E, 0x00, 0x0E, 0x0F, 0x80, 0x03, 0x83, 0xE0, 0x00, 0x70, 0xF8,
  0x00, 0x1C, 0x3E, 0x00, 0x03, 0x0F, 0x80, 0x00, 0xE3, 0xE0, 0x00, 0x18,
  0xF8, 0x00, 0x07, 0x3E, 0x00, 0x01, 0xCF, 0x80, 0x00, 0x3B, 0xE0, 0x00,
  0x0E, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39,
  0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x37, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE1, 0xC0, 0x0F, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0x80, 0x01,
  0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xE7,
  0x00, 0x0F, 0x38, 0x01, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xF0,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x70,
  0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0x80,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0E, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x1E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCE, 0x00, 0x01, 0x9C, 0x00,
  0x03, 0x38, 0x00, 0x06, 0x70, 0x00, 0x0C, 0xE0, 0x00, 0x19, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x03, 0xC1, 0xC0, 0x1F, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1C, 0x03, 0x00, 0x38,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0x60, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x87, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x38,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0xFC, 0x0F, 0x87, 0x80, 0x06, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x20, 0x00, 0x78,
  0xF8, 0x07, 0xC3, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x67, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x71, 0x80, 0x00, 0x0C,
  0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x0C, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x30, 0x0C, 0x00, 0x06, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x38, 0x07, 0x00, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x03, 0x00, 0x03,
  0x00, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x60,
  0x00, 0x18, 0x0C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x0C, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x19, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0x8C, 0x00, 0x01, 0xB0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x60, 0x00,
  0x1C, 0x38, 0x00, 0x0E, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x70, 0x60, 0x00, 0x3B, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x67, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xC6, 0x00, 0x07, 0x03, 0x80, 0x03, 0x8C, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x38, 0x00, 0x30,
  0x0E, 0x00, 0x18, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x30, 0x60, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC1, 0x80, 0x06, 0x00,
  0x60, 0x03, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x18, 0x01, 0x80, 0x06, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x0E,
  0x01, 0x80, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x00, 0x30, 0x1C, 0x01, 0x80, 0x60, 0x00, 0x60,
  0x38, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0xC0, 0x0E, 0x07, 0x00, 0x03, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x03, 0x07,
  0x00, 0x18, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x70, 0xE0, 0x00, 0x1C, 0x30, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x60,
  0x00, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCC, 0x00,
  0x0E, 0x60, 0x00, 0x03, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x70, 0x00,
  0x1B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x37, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0,
  0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x06,
  0x00, 0x30, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x60, 0x60, 0x00, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x01, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x30, 0x00,
  0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06,
  0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC3,
  0x00, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x38, 0x01, 0x80, 0x30, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x38, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x87,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x60, 0x00, 0x1D, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x60,
  0x00, 0x0E, 0x70, 0x00, 0x0C, 0x70, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x38,
  0x00, 0x18, 0x38, 0x00, 0x38, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C,
  0x00, 0x70, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0xE0, 0x07, 0x00, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x03,
  0x81, 0x80, 0x03, 0x83, 0x80, 0x01, 0x83, 0x80, 0x01, 0xC3, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xC7, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x73, 0x00, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x60, 0xE0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x18,
  0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x06, 0x00, 0x0C, 0x01, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0x18, 0x0E, 0x00,
  0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x03, 0xFC,
  0x03, 0xFF, 0xE0, 0xF8, 0x3E, 0x08, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x0F, 0xE0, 0x3F, 0xFC, 0x1F, 0xF3, 0x87, 0x80, 0x73, 0xC0, 0x0E,
  0x70, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0x6C, 0x00, 0x6D, 0xC0, 0x19, 0x9C, 0x07, 0x33,
  0xF7, 0xC6, 0x1F, 0xF0, 0xC0, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0xFF, 0x01, 0xC7, 0xFF, 0x03, 0x9F,
  0x0F, 0x07, 0x70, 0x07, 0x0E, 0xC0, 0x07, 0x1F, 0x00, 0x0E, 0x3E, 0x00,
  0x0E, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x19, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03,
  0x70, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x70,
  0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00,
  0x00, 0xEE, 0x00, 0x01, 0xDE, 0x00, 0x03, 0x3C, 0x00, 0x0E, 0x78, 0x00,
  0x1C, 0xD8, 0x00, 0x71, 0x98, 0x00, 0xE3, 0x38, 0x03, 0x86, 0x38, 0x1E,
  0x0C, 0x3F, 0xFC, 0x18, 0x3F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x7E, 0x1C, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x01, 0x03, 0xFF, 0xC0, 0x7F, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x01, 0xFE, 0x0E, 0x07, 0xFE, 0x1C, 0x1E, 0x1F, 0x38, 0x78, 0x06, 0x71,
  0xC0, 0x06, 0xE3, 0x80, 0x07, 0xCE, 0x00, 0x0F, 0x9C, 0x00, 0x0F, 0x70,
  0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x76, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xEE,
  0x00, 0x03, 0xDC, 0x00, 0x07, 0x9C, 0x00, 0x1F, 0x38, 0x00, 0x3E, 0x38,
  0x00, 0xDC, 0x78, 0x03, 0xB8, 0x78, 0x0E, 0x30, 0x7F, 0xF8, 0x60, 0x7F,
  0xE0, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xE1,
  0xE0, 0x1C, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x30, 0xE0, 0x01, 0xC7,
  0x00, 0x06, 0x30, 0x00, 0x33, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x04, 0x0F, 0x00, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xC1, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x01, 0xFE, 0x06, 0x07, 0xFF, 0x1C, 0x1F, 0x1F, 0x38, 0x70, 0x07, 0x71,
  0xC0, 0x06, 0xE3, 0x80, 0x07, 0xCE, 0x00, 0x0F, 0x9C, 0x00, 0x0F, 0x70,
  0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEE,
  0x00, 0x03, 0xDC, 0x00, 0x07, 0x9C, 0x00, 0x1F, 0x38, 0x00, 0x2E, 0x38,
  0x00, 0xDC, 0x78, 0x03, 0x38, 0x78, 0x0E, 0x70, 0x7F, 0xF8, 0xE0, 0x7F,
  0xC1, 0xC0, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x71,
  0x00, 0x01, 0xC3, 0x80, 0x0F, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0xFE, 0x0E, 0x3F, 0xF8,
  0xE7, 0xC7, 0x8E, 0xE0, 0x1C, 0xEC, 0x01, 0xEF, 0x80, 0x0E, 0xD8, 0x00,
  0xEF, 0x00, 0x06, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x4E, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x02, 0x03, 0x81, 0xE1,
  0xF0, 0x70, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x2F, 0x9F,
  0x8F, 0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x0E, 0x0C, 0x01, 0xC3,
  0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE7, 0xC0, 0x1D, 0xD8, 0x03, 0xB3,
  0x80, 0x6E, 0x70, 0x0D, 0x87, 0x01, 0xE0, 0xE0, 0x3C, 0x0C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x06, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x03, 0x1C, 0x00,
  0x73, 0x80, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xFC, 0x01, 0xFC,
  0x30, 0xFF, 0x81, 0xFF, 0x8C, 0x70, 0xF0, 0xF0, 0xF3, 0x30, 0x0E, 0x30,
  0x1E, 0xC8, 0x03, 0x98, 0x03, 0xB6, 0x00, 0x76, 0x00, 0x7D, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0F,
  0x80, 0x03, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x3E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x03,
  0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x38, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x03,
  0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0E, 0x00,
  0x0F, 0x80, 0x03, 0x80, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x38,
  0x00, 0x30, 0xC0, 0xFE, 0x0C, 0x3F, 0xF8, 0xC7, 0x87, 0xCC, 0xE0, 0x1C,
  0xCC, 0x00, 0xED, 0x80, 0x0E, 0xD8, 0x00, 0xEF, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1E, 0x0F, 0x80, 0x70, 0x07,
  0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0C,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x66,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x67, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0xFF, 0x03, 0x0F, 0xFE, 0x0C,
  0x78, 0x3C, 0x31, 0x80, 0x38, 0xCC, 0x00, 0x73, 0x60, 0x01, 0xCD, 0x80,
  0x03, 0xB4, 0x00, 0x0E, 0xF0, 0x00, 0x1B, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x6F, 0x00, 0x03, 0xB6, 0x00, 0x0E, 0xF8, 0x00,
  0x73, 0xB0, 0x01, 0xCE, 0xE0, 0x0E, 0x39, 0xC0, 0xF0, 0xE3, 0xFF, 0x83,
  0x87, 0xFC, 0x0E, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x06, 0x07, 0xFF, 0x0C, 0x1F, 0x0F, 0x38, 0x78,
  0x06, 0x71, 0xE0, 0x06, 0xE3, 0x80, 0x07, 0xCE, 0x00, 0x0F, 0x9C, 0x00,
  0x0F, 0x30, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x76, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00,
  0x01, 0xEE, 0x00, 0x03, 0xCC, 0x00, 0x07, 0x9C, 0x00, 0x1F, 0x38, 0x00,
  0x2E, 0x38, 0x00, 0xDC, 0x78, 0x03, 0x38, 0x78, 0x0E, 0x70, 0x7F, 0xF8,
  0xE0, 0x7F, 0xC1, 0xC0, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0xC0, 0xFF, 0x0F, 0xEC, 0x7F, 0xB1, 0xC0,
  0xCE, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0xF0, 0x02, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xEC, 0x00, 0x7B, 0xC0, 0x3C, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x38, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0x60, 0x01, 0xF7, 0x00, 0x33, 0x78, 0x07, 0x33, 0xC0, 0xE3, 0x1F, 0xFC,
  0x30, 0xFF, 0x83, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x67,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x00,
  0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x0E,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x00, 0xC0, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x60, 0x18, 0x01, 0x80,
  0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0xC0,
  0x03, 0x87, 0x00, 0x0E, 0x18, 0x00, 0x18, 0x60, 0x00, 0x63, 0x80, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xDC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07,
  0xE0, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x06, 0x60, 0x00, 0xF0,
  0x00, 0x66, 0x00, 0x1F, 0x80, 0x0E, 0x70, 0x01, 0xF8, 0x00, 0xE7, 0x00,
  0x1D, 0x80, 0x0C, 0x70, 0x01, 0x98, 0x00, 0xC3, 0x00, 0x19, 0x80, 0x1C,
  0x30, 0x03, 0x9C, 0x01, 0xC3, 0x80, 0x39, 0xC0, 0x1C, 0x38, 0x03, 0x0C,
  0x01, 0x81, 0x80, 0x30, 0xC0, 0x18, 0x18, 0x03, 0x0C, 0x03, 0x81, 0xC0,
  0x70, 0xE0, 0x38, 0x1C, 0x07, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x60, 0x30,
  0x0C, 0x06, 0x06, 0x03, 0x00, 0xC0, 0xE0, 0x70, 0x70, 0x0E, 0x0E, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x70, 0x60, 0x06, 0x0C, 0x03, 0x06, 0x00, 0x60,
  0xC0, 0x30, 0xE0, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x38, 0xE0,
  0x07, 0x18, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x03, 0x18, 0x01,
  0x9C, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x03, 0xB8, 0x01, 0xD8, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x3B, 0x80, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x60, 0x30, 0x07,
  0x01, 0xC0, 0x30, 0x06, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0xE0, 0x00, 0xC7, 0x00, 0x07, 0x30, 0x00, 0x1B, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x6E, 0x00, 0x07, 0x70, 0x00, 0x39, 0x80, 0x03, 0x8E, 0x00,
  0x1C, 0x30, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x60, 0x38, 0x07, 0x01,
  0xC0, 0x30, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x18, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x1D, 0x80, 0x00, 0x67, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x38,
  0xC0, 0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x60,
  0x01, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x30, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x06, 0x00,
  0x60, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30,
  0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0,
  0x00, 0x73, 0x80, 0x01, 0xCC, 0x00, 0x03, 0x30, 0x00, 0x0D, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0xDE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x1F,
  0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x9F, 0xF8, 0x00, 0xDC,
  0x1F, 0x00, 0xFC, 0x03, 0xF1, 0xE8, 0x00, 0x7F, 0xE4, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 4, 52, 14, 5, -51 },
  { 27, 13, 19, 22, 5, -51 },
  { 58, 28, 51, 31, 1, -51 },
  { 237, 24, 58, 28, 2, -54 },
  { 411, 36, 52, 42, 3, -51 },
  { 645, 27, 52, 29, 2, -51 },
  { 821, 3, 19, 12, 5, -51 },
  { 829, 12, 62, 19, 4, -51 },
  { 922, 12, 62, 19, 3, -51 },
  { 1015, 19, 19, 25, 3, -54 },
  { 1061, 25, 32, 29, 2, -41 },
  { 1161, 6, 16, 13, 3, -7 },
  { 1173, 15, 3, 19, 2, -21 },
  { 1179, 4, 6, 13, 5, -5 },
  { 1182, 21, 51, 24, 2, -51 },
  { 1316, 22, 52, 28, 3, -51 },
  { 1459, 13, 51, 28, 5, -51 },
  { 1542, 22, 51, 28, 3, -51 },
  { 1683, 22, 52, 28, 3, -51 },
  { 1826, 27, 51, 28, 1, -51 },
  { 1999, 22, 52, 28, 3, -51 },
  { 2142, 22, 52, 28, 3, -51 },
  { 2285, 22, 51, 28, 3, -51 },
  { 2426, 23, 52, 28, 3, -51 },
  { 2576, 22, 52, 28, 3, -51 },
  { 2719, 4, 38, 13, 5, -38 },
  { 2738, 6, 47, 13, 3, -38 },
  { 2774, 25, 30, 29, 2, -40 },
  { 2868, 25, 18, 29, 2, -34 },
  { 2925, 25, 30, 29, 2, -40 },
  { 3019, 17, 52, 19, 1, -51 },
  { 3130, 36, 57, 44, 4, -51 },
  { 3387, 28, 51, 28, 0, -51 },
  { 3566, 23, 51, 31, 5, -51 },
  { 3713, 24, 52, 30, 4, -51 },
  { 3869, 25, 51, 34, 5, -51 },
  { 4029, 19, 51, 27, 5, -51 },
  { 4151, 19, 51, 25, 5, -51 },
  { 4273, 29, 52, 37, 4, -51 },
  { 4462, 25, 51, 35, 5, -51 },
  { 4622, 11, 51, 16, 3, -51 },
  { 4693, 11, 64, 14, -3, -51 },
  { 4781, 23, 51, 28, 5, -51 },
  { 4928, 18, 51, 25, 5, -51 },
  { 5043, 37, 51, 47, 5, -51 },
  { 5279, 26, 51, 37, 5, -51 },
  { 5445, 29, 52, 37, 4, -51 },
  { 5634, 21, 51, 29, 5, -51 },
  { 5768, 29, 63, 37, 4, -51 },
  { 5997, 23, 51, 30, 5, -51 },
  { 6144, 22, 52, 28, 3, -51 },
  { 6287, 23, 51, 25, 1, -51 },
  { 6434, 25, 52, 35, 5, -51 },
  { 6597, 27, 51, 27, 0, -51 },
  { 6770, 47, 51, 47, 0, -51 },
  { 7070, 23, 51, 25, 1, -51 },
  { 7217, 24, 51, 24, 0, -51 },
  { 7370, 20, 51, 24, 2, -51 },
  { 7498, 13, 62, 22, 6, -51 },
  { 7599, 21, 51, 24, 2, -51 },
  { 7733, 14, 62, 22, 2, -51 },
  { 7842, 27, 25, 29, 1, -51 },
  { 7927, 29, 3, 28, 0, 6 },
  { 7938, 11, 11, 17, 3, -54 },
  { 7954, 19, 39, 27, 3, -38 },
  { 8047, 23, 55, 31, 5, -54 },
  { 8206, 18, 39, 23, 3, -38 },
  { 8294, 23, 55, 31, 3, -54 },
  { 8453, 21, 39, 28, 3, -38 },
  { 8556, 16, 54, 16, 1, -54 },
  { 8664, 23, 55, 31, 3, -38 },
  { 8823, 20, 54, 30, 5, -54 },
  { 8958, 4, 52, 13, 5, -52 },
  { 8984, 9, 69, 13, 0, -52 },
  { 9062, 19, 54, 24, 5, -54 },
  { 9191, 3, 54, 13, 5, -54 },
  { 9212, 34, 38, 44, 5, -38 },
  { 9374, 20, 38, 30, 5, -38 },
  { 9469, 23, 39, 29, 3, -38 },
  { 9582, 22, 55, 31, 5, -38 },
  { 9734, 23, 55, 31, 3, -38 },
  { 9893, 14, 38, 19, 5, -38 },
  { 9960, 18, 39, 23, 2, -38 },
  { 10048, 14, 48, 16, 1, -47 },
  { 10132, 20, 39, 30, 5, -38 },
  { 10230, 22, 38, 22, 0, -38 },
  { 10335, 36, 38, 38, 1, -38 },
  { 10506, 21, 38, 23, 1, -38 },
  { 10606, 22, 55, 23, 1, -38 },
  { 10758, 15, 38, 19, 2, -38 },
  { 10830, 17, 62, 25, 4, -51 },
  { 10962, 3, 71, 27, 12, -54 },
  { 10989, 18, 62, 25, 3, -51 },
  { 11129, 25, 6, 29, 2, -28 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT71PT7B_H_
