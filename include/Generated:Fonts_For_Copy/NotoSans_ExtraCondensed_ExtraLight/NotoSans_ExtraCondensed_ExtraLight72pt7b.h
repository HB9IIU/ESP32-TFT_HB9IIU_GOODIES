#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT72PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight72pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x98, 0xC6,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xDE, 0xFF, 0xBC, 0x40, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06,
  0xC0, 0x36, 0x01, 0x80, 0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x01, 0x80, 0x30, 0x07, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x00, 0x38, 0x03,
  0x00, 0x01, 0xC0, 0x18, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x60, 0x0E, 0x00,
  0x03, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x30, 0x00, 0x1C, 0x01,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x30, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x00, 0x07,
  0x00, 0x60, 0x00, 0x38, 0x03, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x18, 0x03, 0x00,
  0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x03,
  0x80, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x1C, 0x00, 0x06, 0x00,
  0xE0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0x30, 0xFC, 0x1E, 0x18,
  0x0C, 0x1E, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x01,
  0x80, 0x03, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x00, 0xE0,
  0x18, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x07,
  0x01, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x60, 0x00, 0x78, 0x30, 0x00,
  0x1E, 0x18, 0x00, 0x07, 0x8C, 0x00, 0x01, 0xF6, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x33,
  0xC0, 0x00, 0x18, 0xF8, 0x00, 0x0C, 0x1E, 0x00, 0x06, 0x07, 0x80, 0x03,
  0x01, 0xC0, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x0C, 0x00,
  0x30, 0x06, 0x00, 0x18, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x38, 0x00, 0x60, 0x38,
  0x00, 0x30, 0x1C, 0x40, 0x18, 0x1C, 0x3C, 0x0C, 0x3C, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x1C,
  0x70, 0x00, 0x60, 0x03, 0x83, 0x80, 0x06, 0x00, 0x30, 0x18, 0x00, 0xE0,
  0x07, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0xC0,
  0x1C, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x00, 0xE0,
  0x0C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x0E, 0x03, 0x00,
  0x0E, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x0E, 0x06, 0x00, 0x0E, 0x00, 0xE0,
  0x60, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0xC0, 0x00, 0xE0,
  0x0E, 0x0C, 0x00, 0x0E, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0x0E, 0x18, 0x0C,
  0x0E, 0x00, 0xC1, 0x83, 0xF0, 0x60, 0x0C, 0x38, 0x7F, 0x86, 0x00, 0xC3,
  0x0E, 0x1C, 0x60, 0x0C, 0x30, 0xC0, 0xE7, 0x01, 0xC7, 0x1C, 0x0E, 0x70,
  0x18, 0x61, 0x80, 0x63, 0x01, 0x86, 0x18, 0x07, 0x38, 0x38, 0xE3, 0x80,
  0x71, 0xC7, 0x0C, 0x38, 0x07, 0x0F, 0xE0, 0xC3, 0x80, 0x30, 0x7C, 0x1C,
  0x30, 0x03, 0x00, 0x01, 0x83, 0x00, 0x30, 0x00, 0x18, 0x30, 0x03, 0x00,
  0x03, 0x83, 0x00, 0x30, 0x00, 0x30, 0x30, 0x03, 0x00, 0x03, 0x03, 0x00,
  0x30, 0x00, 0x70, 0x30, 0x03, 0x00, 0x06, 0x03, 0x00, 0x30, 0x00, 0x60,
  0x30, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x00,
  0x0C, 0x03, 0x80, 0x30, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x18, 0x01, 0x80,
  0x70, 0x01, 0x80, 0x18, 0x07, 0x00, 0x38, 0x01, 0x80, 0x60, 0x03, 0x00,
  0x1C, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0xE0, 0x07, 0x00, 0x0E, 0x1C, 0x00,
  0x60, 0x00, 0x7F, 0x80, 0x06, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x03, 0x80, 0x03, 0x80, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x18, 0x00, 0x38,
  0x03, 0x00, 0x07, 0x00, 0x60, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0x80, 0x70, 0x00, 0x30, 0x0C, 0x00, 0x07, 0x01, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x18, 0x60, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x37, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x71, 0xC0, 0x30,
  0x0C, 0x70, 0x07, 0x01, 0x8E, 0x00, 0x60, 0x31, 0x80, 0x0E, 0x06, 0x30,
  0x00, 0xE1, 0xCE, 0x00, 0x1C, 0x39, 0xC0, 0x01, 0xC6, 0x38, 0x00, 0x18,
  0xC7, 0x00, 0x03, 0xB8, 0xE0, 0x00, 0x36, 0x1C, 0x00, 0x07, 0xC3, 0x80,
  0x00, 0x78, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x7C,
  0x1C, 0x00, 0x1D, 0xC1, 0xC0, 0x07, 0x1C, 0x3C, 0x01, 0xE3, 0x83, 0xC0,
  0xF8, 0x38, 0x3F, 0xFC, 0x07, 0x03, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xB6, 0xD8, 0x00, 0x78, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x3C,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x20, 0x18, 0x0F, 0x83, 0x0F,
  0xFC, 0x67, 0xE3, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x1B, 0x00,
  0x07, 0x30, 0x00, 0xC7, 0x00, 0x30, 0x70, 0x0E, 0x06, 0x03, 0x80, 0x60,
  0xE0, 0x0E, 0x04, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x61, 0x8E,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF4, 0x00, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xBF, 0x00, 0x38, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x0C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80, 0x00, 0xC7, 0x00,
  0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00, 0x00,
  0xDC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0x70, 0x00, 0x06, 0xE0, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x18, 0x70, 0x00,
  0x30, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x0F, 0x87, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x3E, 0x07, 0xF0, 0x7B, 0x87, 0x9C, 0x78, 0xE7, 0x87, 0x78, 0x3F,
  0x81, 0xC8, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x03, 0xFC, 0x00, 0x3F,
  0xFC, 0x03, 0xF9, 0xFC, 0x1E, 0x00, 0xF8, 0x20, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xFC,
  0x03, 0xF9, 0xFC, 0x3E, 0x00, 0xF8, 0xE0, 0x00, 0xF1, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x80, 0x01, 0xE3, 0xC0, 0x1F,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x03, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0x1C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x18, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x06, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x30, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00,
  0x70, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x60, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x18,
  0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x1F, 0x80, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x18,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x60, 0x00, 0xF0, 0xF8,
  0x07, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0x00, 0x40, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x01, 0xC0, 0x0C,
  0x1F, 0xF0, 0x18, 0xFF, 0xF0, 0x33, 0xC0, 0xF0, 0x66, 0x00, 0x70, 0xD8,
  0x00, 0x73, 0xA0, 0x00, 0xE7, 0xC0, 0x00, 0xCF, 0x00, 0x01, 0xDE, 0x00,
  0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xC0, 0x00,
  0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x18,
  0xC0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x03, 0xC0, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0x1F, 0x80, 0xF0, 0x07, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0x70, 0x01, 0xC0,
  0xF0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0xF1, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x3C,
  0x00, 0x70, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0x80,
  0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x31, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x06, 0xE0,
  0x00, 0x1B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0,
  0x00, 0xF3, 0x00, 0x07, 0xCE, 0x00, 0x37, 0x1C, 0x01, 0xDC, 0x7C, 0x1E,
  0x70, 0xFF, 0xF1, 0xC0, 0xFF, 0x87, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x80, 0x7C, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF4, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x4F, 0xFF, 0xFF, 0x3C,
  0x78, 0xF1, 0xE3, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x30, 0xE1,
  0xC3, 0x06, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0xFC, 0x3F, 0x1F, 0x0C, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x60, 0x38, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x03,
  0x86, 0x00, 0x0F, 0xE0, 0x0C, 0x30, 0x01, 0xFF, 0x80, 0x63, 0x80, 0x1E,
  0x1C, 0x03, 0x9C, 0x01, 0xC0, 0x60, 0x1C, 0xC0, 0x0C, 0x07, 0x00, 0x66,
  0x00, 0xE0, 0x38, 0x03, 0x70, 0x06, 0x01, 0xC0, 0x1B, 0x80, 0x70, 0x0E,
  0x00, 0xDC, 0x03, 0x80, 0x70, 0x06, 0xE0, 0x18, 0x03, 0x80, 0x3F, 0x00,
  0xC0, 0x1C, 0x01, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x80, 0x70, 0x07, 0x00,
  0x7C, 0x03, 0x80, 0x38, 0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x1F, 0x00, 0xE0,
  0x0E, 0x00, 0xF8, 0x07, 0x00, 0x70, 0x06, 0xC0, 0x38, 0x03, 0x00, 0x36,
  0x01, 0xC0, 0x18, 0x01, 0xB0, 0x0E, 0x01, 0xC0, 0x0D, 0x80, 0x70, 0x0E,
  0x00, 0xEE, 0x01, 0x80, 0x78, 0x07, 0x70, 0x0C, 0x03, 0xC0, 0x33, 0x80,
  0x70, 0x36, 0x03, 0x9C, 0x03, 0x81, 0xB0, 0x1C, 0x60, 0x0E, 0x1C, 0xC1,
  0xC3, 0x00, 0x7F, 0xC7, 0xBC, 0x1C, 0x01, 0xFC, 0x1F, 0xC0, 0xE0, 0x03,
  0xC0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x01, 0x00, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1D,
  0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x38, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x06, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x01,
  0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x07, 0x00,
  0x0E, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x18, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0x00, 0x1F, 0x86, 0x00, 0x07, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x07,
  0x30, 0x00, 0x0E, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B,
  0x00, 0x00, 0x76, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0,
  0x00, 0x07, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x73, 0x00,
  0x00, 0xE6, 0x00, 0x03, 0x8C, 0x00, 0x0E, 0x18, 0x00, 0x3C, 0x30, 0x03,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0x80, 0x1F, 0x83, 0x00, 0x07,
  0x86, 0x00, 0x03, 0x8C, 0x00, 0x03, 0x98, 0x00, 0x07, 0xB0, 0x00, 0x07,
  0x60, 0x00, 0x0E, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x76, 0x00,
  0x00, 0xEC, 0x00, 0x03, 0x98, 0x00, 0x0F, 0x30, 0x00, 0x3C, 0x60, 0x00,
  0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0x9F, 0xE0, 0x3E, 0x00, 0x60, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x01, 0x00, 0x7C, 0x03, 0x80, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x30, 0x03, 0xF0, 0x18, 0x00, 0x7C, 0x0C, 0x00, 0x0F, 0x06,
  0x00, 0x03, 0x83, 0x00, 0x00, 0xE1, 0x80, 0x00, 0x78, 0xC0, 0x00, 0x1C,
  0x60, 0x00, 0x07, 0x30, 0x00, 0x03, 0x98, 0x00, 0x01, 0xCC, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x3B, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0xC0, 0x00,
  0x07, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x06,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0xB0, 0x00, 0x01, 0xD8, 0x00, 0x00,
  0xEC, 0x00, 0x00, 0x76, 0x00, 0x00, 0x33, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x1C, 0xC0, 0x00, 0x0E, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x18, 0x00,
  0x07, 0x0C, 0x00, 0x07, 0x86, 0x00, 0x07, 0x83, 0x00, 0x07, 0x81, 0x80,
  0x0F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xB0, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x3E, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x18, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xD8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xE0, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x81,
  0xCF, 0xFC, 0xFF, 0x87, 0xE0, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xEC, 0x00,
  0x07, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x00, 0x07, 0x0C, 0x00, 0x1C,
  0x30, 0x00, 0xE0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0xE0, 0x30,
  0x03, 0x80, 0xC0, 0x1C, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x30, 0x1C,
  0x00, 0xC0, 0x70, 0x03, 0x03, 0x80, 0x0C, 0x1E, 0x00, 0x30, 0x70, 0x00,
  0xC3, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x70, 0x00, 0x33, 0xE0, 0x00, 0xCF,
  0x80, 0x03, 0x77, 0x00, 0x0D, 0x9C, 0x00, 0x3E, 0x38, 0x00, 0xF0, 0xE0,
  0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x30, 0x0E, 0x00, 0xC0, 0x38, 0x03,
  0x00, 0x70, 0x0C, 0x01, 0xC0, 0x30, 0x03, 0x80, 0xC0, 0x0E, 0x03, 0x00,
  0x1C, 0x0C, 0x00, 0x70, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x07,
  0x0C, 0x00, 0x1C, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x00, 0x01, 0xCC,
  0x00, 0x07, 0x30, 0x00, 0x0E, 0xC0, 0x00, 0x3B, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFD, 0x80, 0x00, 0x00, 0x1B,
  0xDC, 0x00, 0x00, 0x03, 0xBD, 0xC0, 0x00, 0x00, 0x3B, 0xCC, 0x00, 0x00,
  0x03, 0x3C, 0xC0, 0x00, 0x00, 0x73, 0xCE, 0x00, 0x00, 0x07, 0x3C, 0xE0,
  0x00, 0x00, 0x63, 0xC6, 0x00, 0x00, 0x0E, 0x3C, 0x70, 0x00, 0x00, 0xE3,
  0xC7, 0x00, 0x00, 0x0E, 0x3C, 0x30, 0x00, 0x00, 0xC3, 0xC3, 0x80, 0x00,
  0x1C, 0x3C, 0x38, 0x00, 0x01, 0xC3, 0xC1, 0x80, 0x00, 0x18, 0x3C, 0x18,
  0x00, 0x03, 0x83, 0xC1, 0xC0, 0x00, 0x38, 0x3C, 0x1C, 0x00, 0x03, 0x03,
  0xC0, 0xC0, 0x00, 0x70, 0x3C, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0xE0, 0x00,
  0x70, 0x3C, 0x06, 0x00, 0x06, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0x0E, 0x03, 0xC0, 0x30, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0x1C, 0x03,
  0xC0, 0x38, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x18, 0x03, 0xC0, 0x18, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x3C, 0x00,
  0xC0, 0x30, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x70, 0x03,
  0xC0, 0x06, 0x06, 0x00, 0x3C, 0x00, 0x60, 0xE0, 0x03, 0xC0, 0x07, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0xC0, 0x03, 0xC0, 0x03, 0x1C, 0x00, 0x3C, 0x00,
  0x39, 0xC0, 0x03, 0xC0, 0x03, 0x9C, 0x00, 0x3C, 0x00, 0x19, 0x80, 0x03,
  0xC0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF6, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x1F, 0x30, 0x00,
  0x07, 0xCE, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x7C, 0x70, 0x00, 0x1F, 0x1C,
  0x00, 0x07, 0xC3, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x7C, 0x18, 0x00, 0x1F,
  0x07, 0x00, 0x07, 0xC1, 0xC0, 0x01, 0xF0, 0x38, 0x00, 0x7C, 0x0E, 0x00,
  0x1F, 0x01, 0xC0, 0x07, 0xC0, 0x70, 0x01, 0xF0, 0x0C, 0x00, 0x7C, 0x03,
  0x80, 0x1F, 0x00, 0x60, 0x07, 0xC0, 0x1C, 0x01, 0xF0, 0x07, 0x00, 0x7C,
  0x00, 0xE0, 0x1F, 0x00, 0x38, 0x07, 0xC0, 0x06, 0x01, 0xF0, 0x01, 0xC0,
  0x7C, 0x00, 0x30, 0x1F, 0x00, 0x0E, 0x07, 0xC0, 0x03, 0x81, 0xF0, 0x00,
  0x70, 0x7C, 0x00, 0x1C, 0x1F, 0x00, 0x03, 0x87, 0xC0, 0x00, 0xE1, 0xF0,
  0x00, 0x18, 0x7C, 0x00, 0x07, 0x1F, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x39,
  0xF0, 0x00, 0x0E, 0x7C, 0x00, 0x01, 0xDF, 0x00, 0x00, 0x77, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xF0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8,
  0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E,
  0x60, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x1C,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x30, 0x07, 0xE1,
  0x80, 0x0F, 0x8C, 0x00, 0x1E, 0x60, 0x00, 0x73, 0x00, 0x03, 0xD8, 0x00,
  0x0E, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0x80, 0x00, 0xEC, 0x00, 0x07, 0x60,
  0x00, 0x3B, 0x00, 0x03, 0x98, 0x00, 0x1C, 0xC0, 0x01, 0xC6, 0x00, 0x3E,
  0x30, 0x07, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x06, 0x0C,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xC7, 0x00,
  0x00, 0x03, 0x98, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x6E, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x06,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0x06, 0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0x1C, 0x00, 0x00, 0x1C,
  0x30, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x06,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03,
  0x00, 0x7E, 0x06, 0x00, 0x1E, 0x0C, 0x00, 0x1E, 0x18, 0x00, 0x1C, 0x30,
  0x00, 0x1C, 0x60, 0x00, 0x38, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x73, 0x00,
  0x00, 0xE6, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x07, 0x30, 0x00,
  0x0E, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0x80, 0x00, 0x73, 0x00, 0x00,
  0xC6, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x1C, 0x30, 0x00, 0x38,
  0x60, 0x00, 0xE0, 0xC0, 0x07, 0x81, 0x80, 0x7E, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x0C, 0x07, 0x00, 0x18, 0x07, 0x00, 0x30, 0x0E, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x38, 0x06, 0x00,
  0x38, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x30, 0x00, 0xE0, 0x60, 0x01,
  0xC0, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x03, 0x86, 0x00, 0x07,
  0x0C, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x1E, 0x60, 0x00, 0x1C,
  0xC0, 0x00, 0x39, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xC0, 0x06, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x80, 0x01, 0xE3,
  0xE0, 0x1F, 0x8F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x0F, 0x80, 0x7C, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x03, 0x8C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E,
  0x38, 0x00, 0x01, 0x87, 0x00, 0x00, 0x70, 0x60, 0x00, 0x0E, 0x0C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x38, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00,
  0x38, 0x03, 0x00, 0x07, 0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0x18, 0x01,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0x03, 0x80, 0x03,
  0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x70,
  0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x70, 0x70, 0x00, 0x06,
  0x0E, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x1C, 0x30, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x31, 0xC0, 0x00, 0x06, 0x38, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x37, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x67, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x06, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1D, 0xC0, 0x00,
  0x70, 0x60, 0x00, 0x39, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x73, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0xC7, 0x00, 0x03, 0x83, 0x80, 0x01, 0x8E, 0x00, 0x0E,
  0x03, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x18, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x30, 0x00, 0x70, 0x1C, 0x00, 0x30, 0x70, 0x00, 0xC0,
  0x38, 0x00, 0x60, 0xE0, 0x03, 0x80, 0x30, 0x01, 0xC1, 0xC0, 0x07, 0x00,
  0x70, 0x03, 0x81, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x03, 0x00, 0x1C, 0x01,
  0xC0, 0x0C, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x03,
  0x00, 0x70, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0x1C, 0x03, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x06, 0x00, 0xE0, 0x38, 0x00, 0x30, 0x1C, 0x01, 0xC0, 0x70, 0x00, 0x70,
  0x38, 0x01, 0x80, 0xE0, 0x00, 0xE0, 0x70, 0x03, 0x01, 0x80, 0x01, 0xC0,
  0xE0, 0x07, 0x07, 0x00, 0x01, 0x81, 0x80, 0x0E, 0x0E, 0x00, 0x03, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x0E, 0x1C,
  0x00, 0x30, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xC0, 0x00, 0x18, 0x60,
  0x00, 0xE3, 0x80, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x00, 0x73, 0x80,
  0x01, 0x8C, 0x00, 0x00, 0xE7, 0x00, 0x03, 0x38, 0x00, 0x01, 0xCE, 0x00,
  0x06, 0x70, 0x00, 0x01, 0x98, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB0, 0x00,
  0x1D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x36, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x03, 0x80, 0x0C, 0x07, 0x00,
  0x38, 0x06, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x18, 0x07,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0,
  0x00, 0xC3, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x30, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x06,
  0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0xC3,
  0x80, 0x03, 0x07, 0x00, 0x0E, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x18, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x60,
  0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x03, 0x87,
  0x00, 0x07, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x60, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x18, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0C,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0x83, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00,
  0xC3, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0x83, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x01, 0xF8,
  0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x0E, 0x01, 0xC1, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xF8, 0x31, 0xF0, 0x06,
  0x78, 0x00, 0xDE, 0x00, 0x1B, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x2D, 0x80, 0x0D, 0xB8, 0x03, 0x33,
  0x80, 0xE6, 0x7F, 0xF8, 0xC3, 0xFE, 0x18, 0x0E, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x3E, 0x01, 0xC3, 0xFF,
  0x03, 0x8F, 0xFF, 0x07, 0x38, 0x0F, 0x0E, 0xE0, 0x0F, 0x1D, 0x80, 0x0E,
  0x3E, 0x00, 0x0E, 0x7C, 0x00, 0x1C, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xBC, 0x00, 0x07,
  0x78, 0x00, 0x0C, 0xF8, 0x00, 0x39, 0xF0, 0x00, 0x73, 0xB0, 0x01, 0xC6,
  0x70, 0x07, 0x8C, 0x70, 0x1E, 0x18, 0x7F, 0xF8, 0x30, 0x7F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0x03, 0xC0, 0x20,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x04, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x7C, 0x0E, 0x03, 0xFE, 0x1C, 0x1F, 0xFE, 0x38, 0x78, 0x0E, 0x70, 0xE0,
  0x0E, 0xE3, 0x80, 0x0E, 0xC7, 0x00, 0x0D, 0x9C, 0x00, 0x0B, 0x38, 0x00,
  0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xEC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x16, 0x70, 0x00,
  0x6C, 0x70, 0x01, 0x98, 0xF0, 0x07, 0x30, 0xF0, 0x1C, 0x60, 0xFF, 0xF0,
  0xC0, 0xFF, 0xC1, 0x80, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xC0, 0x70, 0x0E, 0x00, 0xE0, 0x70, 0x01, 0x81, 0x80,
  0x07, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x38, 0xC0, 0x00, 0xE7, 0x00, 0x01,
  0x9C, 0x00, 0x06, 0x70, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x04, 0x07, 0x80, 0x70,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x79, 0xC0, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x7F, 0xFC, 0x3F, 0xFE,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x0C, 0x1F,
  0xFF, 0x18, 0x78, 0x0F, 0x30, 0xE0, 0x06, 0x63, 0x80, 0x06, 0xCE, 0x00,
  0x0D, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00,
  0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0x98, 0x00,
  0x0F, 0x38, 0x00, 0x3E, 0x70, 0x00, 0x7C, 0x70, 0x01, 0xB8, 0xF0, 0x07,
  0x70, 0xF0, 0x1C, 0xE0, 0xFF, 0xF1, 0xC0, 0xFF, 0xC3, 0x80, 0x3C, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE2, 0x00, 0x03, 0xC3, 0x00,
  0x0F, 0x07, 0x80, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x7C, 0x0E, 0x1F, 0xF0, 0xE3, 0xFF, 0x8E, 0x70, 0x3C,
  0xEE, 0x01, 0xEE, 0xC0, 0x0E, 0xF8, 0x00, 0x6F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x30, 0xEF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x27, 0x9F, 0x8F, 0x80,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x01, 0xCE,
  0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x18, 0x1C,
  0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x38,
  0x70, 0x07, 0x1C, 0x00, 0xE3, 0xC0, 0x1C, 0xF8, 0x03, 0xBB, 0x80, 0x76,
  0x70, 0x0F, 0xC6, 0x01, 0xF0, 0xE0, 0x3C, 0x1C, 0x07, 0x81, 0xC0, 0xE0,
  0x38, 0x1C, 0x03, 0x03, 0x80, 0x70, 0x70, 0x06, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x03, 0x1C, 0x00, 0x73, 0x80,
  0x0E, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xB8, 0x00, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x18, 0x7F, 0xC0, 0x7F, 0xC3, 0x1F, 0xFC, 0x1F, 0xFC, 0x63, 0x03, 0xC7,
  0x03, 0xCC, 0xC0, 0x38, 0xC0, 0x3D, 0xB0, 0x03, 0xB0, 0x03, 0xB6, 0x00,
  0x76, 0x00, 0x76, 0x80, 0x07, 0x80, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x1E, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38,
  0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00,
  0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x7E,
  0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00,
  0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C,
  0x00, 0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00,
  0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x3F,
  0x00, 0x07, 0x00, 0x07, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00,
  0x1F, 0x80, 0x03, 0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0E,
  0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x7C, 0x0C, 0x1F, 0xF0, 0xC3, 0xFF, 0xCC, 0x70, 0x3C, 0xCE, 0x00, 0xEC,
  0xC0, 0x0E, 0xD8, 0x00, 0x7D, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x30, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F,
  0x01, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x30, 0x00, 0x1C, 0xE0, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x76,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0E, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x30, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xF0, 0x1E, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x01, 0x83,
  0xFF, 0x03, 0x0F, 0xFF, 0x06, 0x38, 0x0F, 0x0C, 0xE0, 0x0F, 0x19, 0x80,
  0x0E, 0x36, 0x00, 0x0E, 0x6C, 0x00, 0x1C, 0xD0, 0x00, 0x1D, 0xE0, 0x00,
  0x3B, 0xC0, 0x00, 0x77, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xDC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x37, 0x00, 0x00, 0x6E, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00,
  0x07, 0x78, 0x00, 0x1C, 0xF8, 0x00, 0x39, 0xF0, 0x00, 0x73, 0xB0, 0x01,
  0xC7, 0x70, 0x07, 0x0E, 0x70, 0x1E, 0x1C, 0x7F, 0xF8, 0x38, 0x7F, 0xC0,
  0x70, 0x1E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x0C, 0x1F, 0xFF, 0x18, 0x7C, 0x0E,
  0x30, 0xE0, 0x06, 0x63, 0x80, 0x0E, 0xC7, 0x00, 0x0D, 0x9C, 0x00, 0x0B,
  0x38, 0x00, 0x1E, 0x60, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xEC, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x3E,
  0x78, 0x00, 0x7C, 0x70, 0x01, 0xB8, 0x70, 0x07, 0x70, 0xF8, 0x1C, 0xE0,
  0xFF, 0xF1, 0xC0, 0x7F, 0xC3, 0x80, 0x3C, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x33, 0x07, 0xFC, 0x3F, 0xF1,
  0xC1, 0xC6, 0x03, 0x30, 0x0C, 0xC0, 0x36, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0x80, 0x77,
  0x00, 0x0B, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xEF, 0x01, 0xE7, 0xFF, 0xE1,
  0xFF, 0xE0, 0x0F, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xC3,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x04, 0x1F,
  0xF0, 0x3F, 0xC0, 0x3C, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0B,
  0x70, 0x01, 0xB7, 0x00, 0x33, 0x78, 0x07, 0x33, 0xC0, 0xE3, 0x1F, 0xFC,
  0x30, 0xFF, 0x83, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x77,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xC0, 0x00, 0xE3, 0x80,
  0x03, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x60, 0x01, 0xC1, 0xC0, 0x06,
  0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x30, 0x03, 0x80, 0xC0, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x18, 0x01, 0xC0,
  0xE0, 0x07, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x30, 0x30, 0x00, 0xE0, 0xC0,
  0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x60, 0x00, 0x61, 0x80, 0x01,
  0xCE, 0x00, 0x07, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xEC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01,
  0xB8, 0x00, 0x3C, 0x00, 0x1C, 0xC0, 0x01, 0xF0, 0x00, 0xE6, 0x00, 0x0F,
  0x80, 0x07, 0x38, 0x00, 0x6C, 0x00, 0x31, 0xC0, 0x07, 0x60, 0x03, 0x8E,
  0x00, 0x3B, 0x00, 0x1C, 0x30, 0x01, 0xDC, 0x00, 0xE1, 0x80, 0x0C, 0xE0,
  0x06, 0x0E, 0x00, 0x63, 0x00, 0x30, 0x70, 0x07, 0x18, 0x03, 0x83, 0x80,
  0x38, 0xC0, 0x1C, 0x0C, 0x01, 0x87, 0x00, 0xE0, 0x70, 0x0C, 0x38, 0x06,
  0x03, 0x80, 0xE0, 0xC0, 0x30, 0x1C, 0x07, 0x06, 0x03, 0x80, 0x60, 0x38,
  0x38, 0x1C, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x1C, 0x0C, 0x0E, 0x06, 0x00,
  0xE0, 0xE0, 0x30, 0x70, 0x07, 0x07, 0x01, 0x83, 0x80, 0x18, 0x38, 0x0E,
  0x1C, 0x00, 0xE1, 0x80, 0x70, 0xC0, 0x07, 0x1C, 0x03, 0x86, 0x00, 0x38,
  0xE0, 0x0C, 0x70, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x06, 0x30, 0x03, 0x98,
  0x00, 0x39, 0x80, 0x1C, 0xC0, 0x01, 0xCC, 0x00, 0x66, 0x00, 0x0E, 0xE0,
  0x03, 0x70, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x01, 0xB0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x30, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x60, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x38,
  0x1C, 0x00, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x18, 0xE0, 0x00, 0xE7, 0x00,
  0x03, 0x30, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0x30, 0x00,
  0x39, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x07,
  0x00, 0x60, 0x38, 0x07, 0x00, 0xC0, 0x30, 0x07, 0x03, 0x80, 0x18, 0x1C,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x03,
  0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x67, 0x00, 0x01, 0x9C,
  0x00, 0x0E, 0x30, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00,
  0x1C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x38,
  0x0C, 0x00, 0xE0, 0x30, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x70, 0x06,
  0x01, 0xC0, 0x18, 0x06, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xE0, 0x03, 0x03,
  0x80, 0x0C, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0, 0x01, 0x87, 0x00,
  0x06, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x73, 0x80, 0x00, 0xCE, 0x00, 0x03,
  0x30, 0x00, 0x0E, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x8F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x5F, 0xFE, 0x00, 0x7E, 0x07,
  0xC0, 0x7C, 0x00, 0xFF, 0xF4, 0x00, 0x1F, 0xF2, 0x00, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 52, 15, 5, -51 },
  { 34, 13, 18, 22, 5, -51 },
  { 64, 29, 51, 31, 1, -51 },
  { 249, 25, 59, 29, 2, -55 },
  { 434, 36, 53, 43, 3, -52 },
  { 673, 27, 53, 29, 2, -52 },
  { 852, 3, 18, 12, 5, -51 },
  { 859, 13, 62, 19, 4, -51 },
  { 960, 13, 62, 19, 3, -51 },
  { 1061, 19, 20, 25, 3, -55 },
  { 1109, 25, 33, 29, 2, -42 },
  { 1213, 6, 16, 13, 3, -7 },
  { 1225, 15, 3, 19, 2, -21 },
  { 1231, 4, 6, 14, 5, -5 },
  { 1234, 21, 51, 24, 2, -51 },
  { 1368, 23, 53, 29, 3, -52 },
  { 1521, 13, 51, 29, 5, -51 },
  { 1604, 22, 52, 29, 3, -52 },
  { 1747, 22, 53, 29, 3, -52 },
  { 1893, 27, 52, 29, 1, -52 },
  { 2069, 23, 52, 29, 3, -51 },
  { 2219, 23, 53, 29, 3, -52 },
  { 2372, 22, 51, 29, 3, -51 },
  { 2513, 23, 53, 29, 3, -52 },
  { 2666, 22, 53, 29, 3, -52 },
  { 2812, 4, 38, 14, 5, -38 },
  { 2831, 7, 47, 13, 3, -38 },
  { 2873, 25, 30, 29, 2, -40 },
  { 2967, 25, 18, 29, 2, -34 },
  { 3024, 25, 30, 29, 2, -40 },
  { 3118, 17, 53, 20, 1, -52 },
  { 3231, 37, 58, 44, 4, -52 },
  { 3500, 28, 51, 28, 0, -51 },
  { 3679, 23, 51, 32, 6, -51 },
  { 3826, 25, 53, 30, 4, -52 },
  { 3992, 25, 51, 35, 6, -51 },
  { 4152, 18, 51, 28, 6, -51 },
  { 4267, 18, 51, 26, 6, -51 },
  { 4382, 30, 53, 38, 4, -52 },
  { 4581, 24, 51, 36, 6, -51 },
  { 4734, 11, 51, 17, 3, -51 },
  { 4805, 12, 64, 14, -3, -51 },
  { 4901, 22, 51, 28, 6, -51 },
  { 5042, 18, 51, 25, 6, -51 },
  { 5157, 36, 51, 48, 6, -51 },
  { 5387, 26, 51, 37, 6, -51 },
  { 5553, 30, 53, 37, 4, -52 },
  { 5752, 21, 51, 29, 6, -51 },
  { 5886, 30, 64, 37, 4, -52 },
  { 6126, 23, 51, 30, 6, -51 },
  { 6273, 22, 53, 28, 3, -52 },
  { 6419, 23, 51, 25, 1, -51 },
  { 6566, 25, 52, 36, 5, -51 },
  { 6729, 27, 51, 27, 0, -51 },
  { 6902, 47, 51, 48, 0, -51 },
  { 7202, 23, 51, 25, 1, -51 },
  { 7349, 24, 51, 24, 0, -51 },
  { 7502, 20, 51, 24, 2, -51 },
  { 7630, 14, 62, 22, 6, -51 },
  { 7739, 21, 51, 24, 2, -51 },
  { 7873, 13, 62, 22, 3, -51 },
  { 7974, 27, 25, 29, 1, -51 },
  { 8059, 29, 3, 29, 0, 6 },
  { 8070, 11, 11, 17, 3, -55 },
  { 8086, 19, 40, 27, 3, -39 },
  { 8181, 23, 56, 31, 5, -55 },
  { 8342, 19, 40, 23, 3, -39 },
  { 8437, 23, 56, 31, 3, -55 },
  { 8598, 22, 40, 28, 3, -39 },
  { 8708, 17, 55, 16, 1, -55 },
  { 8825, 23, 56, 31, 3, -39 },
  { 8986, 20, 55, 30, 5, -55 },
  { 9124, 4, 52, 13, 5, -52 },
  { 9150, 9, 69, 13, 0, -52 },
  { 9228, 19, 55, 24, 5, -55 },
  { 9359, 3, 55, 13, 5, -55 },
  { 9380, 35, 39, 45, 5, -39 },
  { 9551, 20, 39, 30, 5, -39 },
  { 9649, 23, 40, 30, 3, -39 },
  { 9764, 23, 56, 31, 5, -39 },
  { 9925, 23, 56, 31, 3, -39 },
  { 10086, 14, 39, 20, 5, -39 },
  { 10155, 17, 40, 23, 3, -39 },
  { 10240, 14, 48, 16, 1, -47 },
  { 10324, 20, 39, 30, 5, -38 },
  { 10422, 22, 38, 22, 0, -38 },
  { 10527, 37, 38, 38, 1, -38 },
  { 10703, 21, 38, 23, 1, -38 },
  { 10803, 22, 55, 24, 1, -38 },
  { 10955, 16, 38, 19, 2, -38 },
  { 11031, 18, 62, 25, 4, -51 },
  { 11171, 2, 72, 28, 13, -55 },
  { 11189, 18, 62, 25, 3, -51 },
  { 11329, 25, 7, 29, 2, -29 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight72pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT72PT7B_H_
