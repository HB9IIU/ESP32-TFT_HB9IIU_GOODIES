#ifndef _NOTOSANS_EXTRACONDENSED_EXTRALIGHT10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_EXTRALIGHT10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-ExtraLight.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_ExtraLight10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xC0, 0x55, 0xF6, 0xF6, 0x60, 0x47, 0xCC, 0x25, 0x5E, 0x40,
  0xF5, 0xA9, 0x77, 0x9D, 0x60, 0x66, 0x44, 0xB9, 0xF0, 0xC0, 0xFF, 0x80,
  0x95, 0x55, 0x80, 0x55, 0x80, 0x22, 0xF2, 0x20, 0xC0, 0xC0, 0x80, 0x24,
  0xA5, 0x20, 0x69, 0x99, 0x99, 0x60, 0xD5, 0x54, 0xE1, 0x12, 0x24, 0xF0,
  0xE1, 0x26, 0x11, 0xE0, 0x26, 0x66, 0xA7, 0x20, 0xE8, 0xC3, 0x11, 0xE0,
  0x68, 0xE9, 0x99, 0x60, 0xF2, 0x22, 0x44, 0x40, 0xF9, 0x66, 0x99, 0xF0,
  0xF6, 0xD6, 0x58, 0x08, 0x0C, 0x16, 0x86, 0x10, 0xF0, 0xF0, 0x86, 0x16,
  0x80, 0xE4, 0xA4, 0x10, 0xF4, 0x7B, 0x5A, 0xEA, 0x0C, 0x46, 0x66, 0x99,
  0x90, 0xF6, 0xFB, 0x78, 0xF2, 0x49, 0x38, 0xF6, 0xDB, 0x78, 0xEB, 0xAC,
  0xEB, 0xA8, 0xF8, 0x8B, 0x99, 0xF0, 0xB6, 0xFB, 0x68, 0xD5, 0x5C, 0xFF,
  0x80, 0xBA, 0x4D, 0xA8, 0xAA, 0xAC, 0x8C, 0x67, 0x3D, 0xF6, 0xA0, 0xB6,
  0xFB, 0x68, 0xE9, 0x99, 0x99, 0xE0, 0xF6, 0xE9, 0x20, 0xE9, 0x99, 0x99,
  0xE2, 0x20, 0xF6, 0xED, 0x68, 0xE8, 0x86, 0x11, 0xE0, 0xE9, 0x24, 0x90,
  0xB6, 0xDB, 0x78, 0x99, 0xA6, 0x64, 0x40, 0x93, 0x26, 0xD3, 0x66, 0xC9,
  0x12, 0x00, 0xAD, 0x25, 0x68, 0xB5, 0x24, 0x90, 0xE5, 0x25, 0x38, 0xEA,
  0xAA, 0xC0, 0x89, 0x22, 0x48, 0xD5, 0x55, 0xC0, 0x26, 0x90, 0xF0, 0x90,
  0x65, 0xDE, 0x93, 0x5B, 0x6F, 0x72, 0x46, 0x11, 0x79, 0x99, 0x97, 0xF7,
  0x46, 0x6E, 0xAA, 0xF9, 0x99, 0x71, 0x70, 0x93, 0x5B, 0x6D, 0xBE, 0xBF,
  0x80, 0xAB, 0xAF, 0xFF, 0xFD, 0x6B, 0x5A, 0x80, 0xF6, 0xDA, 0xF9, 0x99,
  0x60, 0xF6, 0xDF, 0x20, 0xF9, 0x99, 0x71, 0x10, 0xEA, 0x80, 0xF1, 0x1E,
  0xBA, 0xAC, 0xFF, 0xC0, 0xB6, 0xA4, 0xAD, 0x6A, 0xA5, 0x00, 0xA9, 0x2A,
  0xB5, 0x24, 0xB0, 0xD6, 0xC0, 0x69, 0x2C, 0x92, 0x20, 0xFF, 0xC0, 0xC9,
  0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_ExtraLight10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 1, 2, 3, 1, -7 },
  { 3, 4, 7, 4, 0, -7 },
  { 7, 4, 9, 4, 0, -8 },
  { 12, 5, 7, 6, 0, -7 },
  { 17, 4, 7, 4, 0, -7 },
  { 21, 1, 2, 2, 0, -7 },
  { 22, 1, 9, 3, 1, -7 },
  { 24, 2, 9, 3, 0, -7 },
  { 27, 3, 3, 4, 0, -8 },
  { 29, 4, 5, 4, 0, -6 },
  { 32, 1, 2, 2, 0, -1 },
  { 33, 2, 1, 3, 0, -3 },
  { 34, 1, 1, 2, 0, -1 },
  { 35, 3, 7, 3, 0, -7 },
  { 38, 4, 7, 4, 0, -7 },
  { 42, 2, 7, 4, 1, -7 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 4, 7, 4, 0, -7 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 7, 4, 0, -7 },
  { 68, 4, 7, 4, 0, -7 },
  { 72, 3, 7, 4, 0, -7 },
  { 75, 1, 5, 2, 0, -5 },
  { 76, 1, 6, 2, 0, -5 },
  { 77, 4, 5, 4, 0, -6 },
  { 80, 4, 3, 4, 0, -5 },
  { 82, 4, 5, 4, 0, -6 },
  { 85, 3, 7, 3, 0, -7 },
  { 88, 5, 8, 6, 1, -7 },
  { 93, 4, 7, 4, 0, -7 },
  { 97, 3, 7, 4, 1, -7 },
  { 100, 3, 7, 4, 1, -7 },
  { 103, 3, 7, 5, 1, -7 },
  { 106, 2, 7, 4, 1, -7 },
  { 108, 2, 7, 4, 1, -7 },
  { 110, 4, 7, 5, 1, -7 },
  { 114, 3, 7, 5, 1, -7 },
  { 117, 2, 7, 2, 0, -7 },
  { 119, 1, 9, 2, 0, -7 },
  { 121, 3, 7, 4, 1, -7 },
  { 124, 2, 7, 3, 1, -7 },
  { 126, 5, 7, 7, 1, -7 },
  { 131, 3, 7, 5, 1, -7 },
  { 134, 4, 7, 5, 1, -7 },
  { 138, 3, 7, 4, 1, -7 },
  { 141, 4, 9, 5, 1, -7 },
  { 146, 3, 7, 4, 1, -7 },
  { 149, 4, 7, 4, 0, -7 },
  { 153, 3, 7, 3, 0, -7 },
  { 156, 3, 7, 5, 1, -7 },
  { 159, 4, 7, 4, 0, -7 },
  { 163, 7, 7, 7, 0, -7 },
  { 170, 3, 7, 3, 0, -7 },
  { 173, 3, 7, 3, 0, -7 },
  { 176, 3, 7, 3, 0, -7 },
  { 179, 2, 9, 3, 1, -7 },
  { 182, 3, 7, 3, 0, -7 },
  { 185, 2, 9, 3, 0, -7 },
  { 188, 4, 3, 4, 0, -7 },
  { 190, 4, 1, 4, 0, 1 },
  { 191, 2, 2, 2, 0, -8 },
  { 192, 3, 5, 4, 0, -5 },
  { 194, 3, 8, 4, 1, -8 },
  { 197, 3, 5, 3, 0, -5 },
  { 199, 4, 8, 4, 0, -8 },
  { 203, 3, 5, 4, 0, -5 },
  { 205, 2, 8, 2, 0, -8 },
  { 207, 4, 7, 4, 0, -5 },
  { 211, 3, 8, 4, 1, -8 },
  { 214, 1, 7, 2, 0, -7 },
  { 215, 1, 9, 2, 0, -7 },
  { 217, 2, 8, 3, 1, -8 },
  { 219, 1, 8, 2, 0, -8 },
  { 220, 5, 5, 6, 1, -5 },
  { 224, 3, 5, 4, 1, -5 },
  { 226, 4, 5, 4, 0, -5 },
  { 229, 3, 7, 4, 1, -5 },
  { 232, 4, 7, 4, 0, -5 },
  { 236, 2, 5, 3, 1, -5 },
  { 238, 3, 5, 3, 0, -5 },
  { 240, 2, 7, 2, 0, -7 },
  { 242, 2, 5, 4, 1, -5 },
  { 244, 3, 5, 3, 0, -5 },
  { 246, 5, 5, 5, 0, -5 },
  { 250, 3, 5, 3, 0, -5 },
  { 252, 3, 7, 3, 0, -5 },
  { 255, 2, 5, 3, 0, -5 },
  { 257, 3, 9, 3, 0, -7 },
  { 261, 1, 10, 4, 1, -8 },
  { 263, 3, 9, 3, 0, -7 },
  { 267, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_ExtraLight10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_ExtraLight10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_ExtraLight10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_EXTRALIGHT10PT7B_H_
