#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM25PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xDB, 0x6C, 0x07, 0xFC, 0xE7, 0x67, 0x67, 0x67,
  0x63, 0x63, 0x62, 0x0C, 0x60, 0x63, 0x03, 0x18, 0x18, 0xC0, 0xC4, 0x7F,
  0xFF, 0xFF, 0xE3, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x61, 0xFF, 0xEF, 0xFF,
  0x18, 0xC0, 0xC6, 0x06, 0x30, 0x33, 0x03, 0x18, 0x00, 0x04, 0x00, 0x80,
  0x7E, 0x3F, 0xF7, 0x4D, 0xC8, 0x39, 0x07, 0x20, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x4E, 0x09, 0xC1, 0x3F, 0xAE, 0xFF, 0xC7, 0xC0, 0x10, 0x02,
  0x00, 0x38, 0x0C, 0x1F, 0x07, 0x0E, 0x61, 0x83, 0x18, 0x60, 0xC6, 0x30,
  0x31, 0x8C, 0x0C, 0x66, 0x03, 0x19, 0x9C, 0xE6, 0xCF, 0x9F, 0x36, 0x63,
  0x99, 0x8C, 0x06, 0x63, 0x03, 0x18, 0xC0, 0xC6, 0x30, 0x61, 0x8C, 0x18,
  0x66, 0x0C, 0x1F, 0x83, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0xC7, 0x01,
  0x8E, 0x03, 0x1C, 0x06, 0x38, 0x0E, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7E,
  0x19, 0xDE, 0x77, 0x1C, 0xEE, 0x1D, 0x9C, 0x1F, 0x38, 0x1C, 0x78, 0x7C,
  0x7F, 0xDC, 0x7F, 0x1C, 0xED, 0xB6, 0xD8, 0x1C, 0x63, 0x8C, 0x71, 0x86,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x18, 0x61, 0xC3, 0x0C, 0x18, 0x70,
  0xC1, 0x87, 0x0C, 0x30, 0xE1, 0x86, 0x18, 0x61, 0xC7, 0x1C, 0x61, 0x86,
  0x38, 0xC3, 0x1C, 0x63, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x66, 0x6F, 0xFC,
  0xFF, 0xC7, 0x81, 0xD8, 0x33, 0x8E, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x77, 0x66, 0xEC, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0x81, 0xC0, 0xC0, 0x60,
  0x70, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0x80, 0xC0,
  0xE0, 0x60, 0x70, 0x00, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xD8,
  0x33, 0x8E, 0x3F, 0x83, 0xE0, 0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0x0F, 0xF3,
  0x87, 0x20, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0x1F,
  0xF1, 0x87, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x3C, 0x3E, 0x07, 0xF0,
  0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x0E, 0xFF, 0xDF, 0xE0, 0x00,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x6C, 0x07, 0x60, 0x33, 0x03, 0x18,
  0x18, 0xC1, 0x86, 0x1C, 0x30, 0xC1, 0x8F, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x7F, 0xCF, 0xF9, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0xF8, 0x7F, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x36, 0x0E, 0xFF, 0x8F, 0xE0, 0x07, 0xC3, 0xF8, 0xF0, 0x38, 0x06,
  0x00, 0xC0, 0x38, 0x07, 0x7C, 0xFF, 0xDE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xD8, 0x3B, 0x8E, 0x3F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x1F, 0x0F, 0xF9, 0xC7,
  0x30, 0x76, 0x0E, 0xC1, 0x9C, 0x71, 0xFC, 0x1F, 0x07, 0xF1, 0xC7, 0x70,
  0x7E, 0x0F, 0xC0, 0xF8, 0x3F, 0x07, 0x7F, 0xC7, 0xF0, 0x1F, 0x0F, 0xF1,
  0xC7, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xEF, 0xFC, 0xFB,
  0x84, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x7F, 0x0F, 0xC0, 0x5F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x27, 0x76, 0x00, 0x00, 0x00, 0x07, 0x66, 0xEC,
  0xC0, 0x00, 0x20, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x38, 0x3E, 0x1F, 0x0F, 0x83, 0x80, 0x40, 0x00, 0x3F, 0x3F, 0xE6,
  0x38, 0x06, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0x60,
  0x18, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x07, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0x81, 0xE0, 0x70, 0x60, 0x0E, 0x30, 0x01, 0x98, 0x7E, 0x76, 0x3F, 0x8D,
  0x9C, 0x63, 0xC6, 0x18, 0xF1, 0x86, 0x3C, 0x61, 0x8F, 0x18, 0x63, 0xC6,
  0x38, 0xD9, 0xFB, 0xE6, 0x3E, 0xF1, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x01,
  0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x36,
  0x00, 0xEC, 0x01, 0xDC, 0x03, 0x38, 0x0E, 0x30, 0x1C, 0x70, 0x30, 0xE0,
  0xE0, 0xC1, 0xFF, 0xC3, 0xFF, 0x8E, 0x07, 0x1C, 0x07, 0x38, 0x0E, 0xE0,
  0x1D, 0xC0, 0x1C, 0xFF, 0x0F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E,
  0xE0, 0xEE, 0x3C, 0xFF, 0x0F, 0xFC, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xEE, 0x1E, 0xFF, 0xCF, 0xF8, 0x07, 0xF8, 0xFF, 0x8F, 0x0C, 0x70,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x82, 0x1F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xFE, 0x38, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3B, 0x83,
  0xDC, 0x7C, 0xFF, 0xC7, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00,
  0x07, 0xF8, 0x3F, 0xF3, 0xE1, 0x8E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xD8, 0x07, 0x70, 0x1D, 0xC0,
  0x73, 0x81, 0xCF, 0x07, 0x1F, 0xFC, 0x3F, 0xE0, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xC0, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0xFF, 0xF0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7B, 0xDF, 0xBC,
  0x00, 0xE0, 0x7E, 0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x70, 0xEE, 0x0E,
  0xE0, 0xFE, 0x0F, 0xE0, 0xF7, 0x0E, 0x70, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE,
  0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF,
  0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFB, 0x01, 0xBD, 0x80, 0xDF,
  0xE0, 0x6F, 0xB0, 0x67, 0xD8, 0x33, 0xEE, 0x19, 0xF3, 0x18, 0xF9, 0x8C,
  0x7C, 0xE6, 0x3E, 0x36, 0x1F, 0x1B, 0x0F, 0x8F, 0x87, 0xC3, 0x83, 0xE1,
  0xC1, 0xF0, 0xE0, 0xC0, 0xE0, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xDC,
  0x1F, 0x70, 0x7E, 0xE1, 0xF9, 0x87, 0xE7, 0x1F, 0x8E, 0x7E, 0x39, 0xF8,
  0x77, 0xE1, 0xDF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xF0,
  0x07, 0xE0, 0x3F, 0xE0, 0xF1, 0xE3, 0xC0, 0xE7, 0x00, 0xCE, 0x01, 0xD8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3B, 0x00, 0x77, 0x00,
  0xEE, 0x01, 0xDE, 0x07, 0x1E, 0x1E, 0x1F, 0xF8, 0x1F, 0xC0, 0xFE, 0x1F,
  0xF3, 0x9F, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xDF, 0xF3,
  0xFC, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0xE0, 0x3F, 0xF0, 0xF1, 0xE3, 0xC0, 0xE7, 0x00, 0xCE, 0x01, 0xD8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3B, 0x00, 0x77, 0x00, 0xEE,
  0x01, 0xDE, 0x07, 0x1E, 0x1E, 0x1F, 0xF8, 0x1F, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0xFE, 0x0F, 0xF8, 0xE7, 0xCE, 0x0E, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE7, 0xCF, 0xF8, 0xFF, 0x0E, 0x30, 0xE3,
  0x8E, 0x1C, 0xE1, 0xCE, 0x0E, 0xE0, 0xEE, 0x07, 0x1F, 0x9F, 0xF7, 0x0F,
  0x80, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x00,
  0xC0, 0x30, 0x0F, 0x07, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1B, 0x81, 0xCE, 0x1E,
  0x3F, 0xE0, 0xFE, 0x00, 0xE0, 0x1F, 0x80, 0x76, 0x01, 0x9C, 0x0E, 0x70,
  0x38, 0xC0, 0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x60, 0x63, 0x81, 0xCE, 0x03,
  0x30, 0x0C, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xE0, 0x70, 0x1F, 0x03, 0x81, 0xD8, 0x1E, 0x0E, 0xE0, 0xF0, 0x77, 0x0F,
  0x83, 0x38, 0x6C, 0x18, 0xC3, 0x71, 0xC6, 0x19, 0x8E, 0x39, 0xCC, 0x61,
  0xCC, 0x63, 0x06, 0x63, 0xB8, 0x33, 0x0D, 0xC1, 0xF8, 0x6C, 0x0F, 0x83,
  0x60, 0x3C, 0x1B, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x00,
  0xF0, 0x3B, 0x81, 0x8E, 0x1C, 0x71, 0xC1, 0xCE, 0x0E, 0xE0, 0x3F, 0x00,
  0xF0, 0x07, 0x00, 0x3C, 0x03, 0xE0, 0x1B, 0x81, 0xCC, 0x0C, 0x70, 0xE1,
  0x8E, 0x0E, 0x70, 0x3F, 0x01, 0xC0, 0xE0, 0x3B, 0x01, 0x9C, 0x1C, 0x60,
  0xC3, 0x8E, 0x0C, 0x70, 0x77, 0x03, 0xB8, 0x0F, 0x80, 0x7C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8F, 0xFC, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x3F, 0xFC, 0x04, 0x00, 0xE0, 0x0E, 0x01, 0xB0, 0x1B, 0x03, 0x18, 0x31,
  0x86, 0x0C, 0x60, 0xCE, 0x06, 0xC0, 0x70, 0xFF, 0xFF, 0xFC, 0xE3, 0x8E,
  0x30, 0x0E, 0x1F, 0xE3, 0x3C, 0x07, 0x00, 0xC0, 0x33, 0xFD, 0xFB, 0xE0,
  0xF8, 0x3E, 0x1F, 0x87, 0x7F, 0xDF, 0xB0, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x8E, 0x37, 0xE7, 0xDE, 0xE0, 0xDC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xF1, 0xDB, 0xFB, 0x3E, 0x00, 0x0F, 0x1F,
  0xDF, 0xEE, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x13,
  0xF8, 0xFC, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x1C, 0xCF, 0xDB,
  0xDF, 0x70, 0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1B, 0x07,
  0x70, 0xE7, 0xFC, 0x7D, 0x80, 0x0E, 0x07, 0xF1, 0xEF, 0x30, 0x66, 0x0F,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x23, 0xFC, 0x3F,
  0x80, 0x0F, 0x8F, 0xC6, 0x07, 0x03, 0x81, 0xC3, 0xFD, 0xFE, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x0C,
  0x07, 0xED, 0xEF, 0xB8, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0D, 0x83, 0xB8, 0x73, 0xFE, 0x3E, 0xC0, 0x18, 0x03, 0x00, 0xEC, 0x3D,
  0xFF, 0x1F, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x31, 0xCD, 0xFB,
  0xEF, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0C, 0x5F, 0x80, 0x36, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x08,
  0x71, 0xC0, 0x00, 0x01, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x18, 0x63, 0xBE, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x76, 0x1C, 0xC7, 0x19, 0xC3, 0x70, 0x6E, 0x0F, 0xE1,
  0xDC, 0x31, 0xC6, 0x18, 0xC3, 0x98, 0x3B, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x0E, 0x37, 0xEF, 0xEF, 0xBF, 0xFB, 0x87, 0x86, 0xE1,
  0xC1, 0xF8, 0x70, 0x7C, 0x1C, 0x1F, 0x07, 0x07, 0xC1, 0xC1, 0xF0, 0x70,
  0x7C, 0x1C, 0x1F, 0x07, 0x07, 0xC1, 0xC1, 0xF0, 0x70, 0x70, 0x07, 0x37,
  0xEF, 0xBF, 0x87, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x30, 0x0F, 0x03, 0xFC, 0x7D, 0xC7, 0x0E, 0xE0, 0x6E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0x60, 0xE7, 0x0E, 0x3F, 0xC1,
  0xF8, 0x06, 0x1B, 0xF3, 0xEF, 0x70, 0xEE, 0x0F, 0xC1, 0xF0, 0x3E, 0x07,
  0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0xED, 0xFD, 0x9F, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x00, 0x0E, 0x07, 0xED, 0xEF, 0xB8, 0x7E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0D, 0x83, 0xB8, 0x73, 0xF6, 0x3E,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xBF, 0x7F,
  0x8E, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x00, 0x1E, 0x3F,
  0xFC, 0xDC, 0x0E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xC0, 0xF0, 0x7F,
  0xF7, 0xF0, 0x18, 0x18, 0x38, 0x38, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x7E, 0x1F, 0xFF, 0x7E, 0xC0,
  0xE0, 0x76, 0x06, 0x70, 0xE7, 0x0E, 0x30, 0xC3, 0x9C, 0x39, 0xC1, 0x98,
  0x1B, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0xE0, 0xF8, 0x38,
  0x76, 0x1E, 0x1D, 0xC7, 0x87, 0x71, 0xB1, 0x8C, 0x6C, 0x63, 0x33, 0x38,
  0xCC, 0xCC, 0x3B, 0x1B, 0x06, 0xC6, 0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x1E,
  0x0E, 0x03, 0x83, 0x80, 0x70, 0xF3, 0x0C, 0x39, 0xC1, 0xD8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x83, 0x9C, 0x38, 0xC7, 0x0E, 0xE0, 0x70,
  0xE0, 0x76, 0x06, 0x70, 0xE7, 0x0E, 0x30, 0xC3, 0x9C, 0x19, 0xC1, 0x98,
  0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x1C, 0x0F, 0x80, 0xF0, 0x00, 0xFF, 0xFF, 0x81, 0xC1, 0xC0, 0xE0, 0xE0,
  0x60, 0x70, 0x70, 0x38, 0x38, 0x1F, 0xFF, 0xF8, 0x06, 0x3C, 0x70, 0xC1,
  0x83, 0x06, 0x0C, 0x38, 0x73, 0xC7, 0x83, 0x87, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xE1, 0xE0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0xF0, 0x78, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x0F, 0x0F, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF0, 0xE0, 0x20, 0x3F, 0xC7,
  0xFF, 0xC1, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Medium25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 18, 7, 2, -18 },
  { 8, 8, 7, 10, 1, -18 },
  { 15, 13, 18, 15, 1, -18 },
  { 45, 11, 20, 13, 1, -19 },
  { 73, 18, 18, 20, 1, -18 },
  { 114, 15, 18, 16, 1, -18 },
  { 148, 3, 7, 6, 1, -18 },
  { 151, 6, 22, 8, 1, -18 },
  { 168, 6, 22, 8, 1, -18 },
  { 185, 11, 10, 12, 1, -19 },
  { 199, 11, 12, 13, 1, -15 },
  { 216, 4, 6, 6, 1, -3 },
  { 219, 6, 2, 8, 1, -8 },
  { 221, 3, 3, 6, 2, -3 },
  { 223, 9, 18, 10, 0, -18 },
  { 244, 11, 18, 13, 1, -18 },
  { 269, 7, 18, 13, 2, -18 },
  { 285, 11, 18, 13, 1, -18 },
  { 310, 11, 18, 13, 1, -18 },
  { 335, 13, 18, 13, 0, -18 },
  { 365, 11, 18, 13, 1, -18 },
  { 390, 11, 18, 13, 1, -18 },
  { 415, 11, 18, 13, 1, -18 },
  { 440, 11, 18, 13, 1, -18 },
  { 465, 11, 18, 13, 1, -18 },
  { 490, 3, 14, 6, 2, -14 },
  { 496, 4, 17, 7, 1, -14 },
  { 505, 11, 12, 13, 1, -15 },
  { 522, 11, 7, 13, 1, -12 },
  { 532, 11, 12, 13, 1, -15 },
  { 549, 10, 18, 10, 0, -18 },
  { 572, 18, 20, 20, 1, -18 },
  { 617, 15, 18, 15, 0, -18 },
  { 651, 12, 18, 15, 2, -18 },
  { 678, 13, 18, 14, 1, -18 },
  { 708, 13, 18, 16, 2, -18 },
  { 738, 9, 18, 13, 2, -18 },
  { 759, 9, 18, 12, 2, -18 },
  { 780, 14, 18, 17, 1, -18 },
  { 812, 13, 18, 17, 2, -18 },
  { 842, 6, 18, 8, 1, -18 },
  { 856, 7, 23, 7, -2, -18 },
  { 877, 12, 18, 14, 2, -18 },
  { 904, 9, 18, 12, 2, -18 },
  { 925, 17, 18, 21, 2, -18 },
  { 964, 14, 18, 18, 2, -18 },
  { 996, 15, 18, 18, 1, -18 },
  { 1030, 11, 18, 14, 2, -18 },
  { 1055, 15, 22, 18, 1, -18 },
  { 1097, 12, 18, 14, 2, -18 },
  { 1124, 10, 18, 13, 1, -18 },
  { 1147, 12, 18, 13, 0, -18 },
  { 1174, 13, 18, 17, 2, -18 },
  { 1204, 14, 18, 14, 0, -18 },
  { 1236, 21, 18, 22, 0, -18 },
  { 1284, 13, 18, 14, 0, -18 },
  { 1314, 13, 18, 13, 0, -18 },
  { 1344, 11, 18, 13, 1, -18 },
  { 1369, 5, 22, 8, 2, -18 },
  { 1383, 9, 18, 10, 0, -18 },
  { 1404, 5, 22, 8, 1, -18 },
  { 1418, 12, 11, 13, 1, -18 },
  { 1435, 11, 2, 11, 0, 2 },
  { 1438, 5, 4, 7, 1, -19 },
  { 1441, 10, 14, 13, 1, -14 },
  { 1459, 11, 19, 14, 2, -19 },
  { 1486, 9, 14, 11, 1, -14 },
  { 1502, 11, 19, 14, 1, -19 },
  { 1529, 11, 14, 13, 1, -14 },
  { 1549, 9, 19, 8, 0, -19 },
  { 1571, 11, 20, 14, 1, -14 },
  { 1599, 10, 19, 14, 2, -19 },
  { 1623, 3, 19, 6, 2, -19 },
  { 1631, 6, 25, 6, -1, -19 },
  { 1650, 11, 19, 13, 2, -19 },
  { 1677, 2, 19, 6, 2, -19 },
  { 1682, 18, 14, 21, 2, -14 },
  { 1714, 10, 14, 14, 2, -14 },
  { 1732, 12, 14, 14, 1, -14 },
  { 1753, 11, 20, 14, 2, -14 },
  { 1781, 11, 20, 14, 1, -14 },
  { 1809, 7, 14, 10, 2, -14 },
  { 1822, 9, 14, 11, 1, -14 },
  { 1838, 8, 17, 9, 0, -17 },
  { 1855, 10, 13, 14, 2, -13 },
  { 1872, 12, 13, 12, 0, -13 },
  { 1892, 18, 14, 19, 0, -14 },
  { 1924, 12, 13, 12, 0, -13 },
  { 1944, 12, 19, 12, 0, -13 },
  { 1973, 9, 13, 10, 1, -13 },
  { 1988, 7, 22, 9, 1, -18 },
  { 2008, 2, 25, 13, 5, -19 },
  { 2015, 8, 22, 9, 1, -18 },
  { 2037, 11, 4, 13, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Medium25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium25pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM25PT7B_H_
