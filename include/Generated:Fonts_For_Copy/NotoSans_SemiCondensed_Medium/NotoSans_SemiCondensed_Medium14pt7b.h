#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM14PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xA8, 0xF0, 0xB9, 0x99, 0x12, 0x16, 0x14, 0x7F, 0x24, 0x24,
  0xFE, 0x2C, 0x28, 0x68, 0x20, 0x8F, 0xA8, 0xA3, 0x83, 0x8B, 0xAF, 0xE2,
  0x08, 0xE3, 0x28, 0x8B, 0x42, 0xD0, 0xAB, 0xBA, 0xA1, 0x2C, 0x4B, 0x22,
  0x88, 0xE0, 0x78, 0xC8, 0xC8, 0x58, 0x70, 0xF3, 0x9A, 0x8E, 0xCE, 0xFB,
  0xF0, 0x6B, 0x49, 0x24, 0x99, 0x30, 0xC6, 0x22, 0x33, 0x33, 0x22, 0x6C,
  0x10, 0x45, 0x6E, 0x29, 0xB0, 0x20, 0x8F, 0xFF, 0x20, 0x80, 0xEA, 0xF0,
  0xF0, 0x08, 0xC4, 0x23, 0x11, 0x88, 0x46, 0x00, 0x73, 0x28, 0xA3, 0x8E,
  0x38, 0xE2, 0xC9, 0xC0, 0x37, 0xF3, 0x33, 0x33, 0x33, 0xFA, 0x20, 0x82,
  0x18, 0x42, 0x10, 0x83, 0xF0, 0xFA, 0x20, 0x82, 0x70, 0xE0, 0xC3, 0x8B,
  0xE0, 0x0C, 0x38, 0x71, 0x62, 0xC9, 0xB3, 0x7F, 0x0C, 0x18, 0xFB, 0x08,
  0x20, 0xF8, 0x20, 0xC3, 0x9B, 0xC0, 0x39, 0x08, 0x20, 0xFA, 0x38, 0xE3,
  0xC9, 0xE0, 0xFE, 0x0C, 0x10, 0x60, 0x83, 0x06, 0x08, 0x30, 0x40, 0x7A,
  0x28, 0xB2, 0x73, 0x68, 0xE3, 0x8F, 0xE0, 0x73, 0x28, 0xA3, 0x8F, 0xF0,
  0x82, 0x1B, 0xC0, 0xB0, 0x0F, 0x4C, 0x00, 0x1A, 0x58, 0x0C, 0xCC, 0x30,
  0x30, 0x30, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x87, 0x72, 0x00, 0xFC, 0x42,
  0x11, 0x10, 0x80, 0x23, 0x00, 0x1E, 0x18, 0x64, 0x0A, 0x7B, 0xB2, 0x68,
  0x9B, 0x2E, 0x7E, 0x80, 0x10, 0x03, 0xE0, 0x18, 0x18, 0x3C, 0x34, 0x24,
  0x66, 0x7E, 0x42, 0xC3, 0xC3, 0xF9, 0x9B, 0x16, 0x2F, 0x99, 0xB1, 0xE3,
  0xCD, 0xF0, 0x3E, 0xCB, 0x04, 0x08, 0x10, 0x20, 0x60, 0x62, 0x78, 0xF9,
  0x9B, 0x1E, 0x1C, 0x38, 0x70, 0xE3, 0xCD, 0xF0, 0xFE, 0x31, 0x8F, 0xE3,
  0x18, 0xC7, 0xC0, 0xFE, 0x31, 0x8C, 0x7F, 0x18, 0xC6, 0x00, 0x3E, 0xC7,
  0x04, 0x08, 0x11, 0xE0, 0xE1, 0x62, 0x7C, 0xC3, 0x87, 0x0E, 0x1F, 0xF8,
  0x70, 0xE1, 0xC3, 0x84, 0xF2, 0x22, 0x22, 0x22, 0x2F, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3E, 0xC0, 0xC7, 0x9B, 0x66, 0x8F, 0x1E, 0x36, 0x64, 0xCD,
  0x8C, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xC0, 0xC1, 0xF8, 0x7E, 0x1F,
  0x8F, 0xF2, 0xF4, 0xBD, 0x6F, 0x73, 0xCC, 0xF3, 0x30, 0xC3, 0xE3, 0xA3,
  0xF3, 0xD3, 0xDB, 0xCF, 0xC7, 0xC7, 0xC3, 0x3C, 0x66, 0xC3, 0x83, 0x81,
  0x81, 0x83, 0xC3, 0x66, 0x3C, 0xFB, 0x3C, 0x71, 0xCF, 0xEC, 0x30, 0xC3,
  0x00, 0x3C, 0x66, 0xC3, 0x83, 0x81, 0x81, 0x83, 0xC3, 0x66, 0x3C, 0x0C,
  0x07, 0xF9, 0x9B, 0x16, 0x2C, 0xDF, 0x36, 0x66, 0xCD, 0x8C, 0x7E, 0x61,
  0x8E, 0x1C, 0x21, 0x9F, 0x80, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x46, 0xF8, 0xC3,
  0xC2, 0x42, 0x66, 0x64, 0x24, 0x2C, 0x38, 0x18, 0x18, 0xC6, 0x3C, 0x63,
  0x46, 0x24, 0xF2, 0x69, 0x66, 0x96, 0x29, 0x43, 0x9C, 0x30, 0xC3, 0x0C,
  0xC6, 0x64, 0x2C, 0x38, 0x18, 0x18, 0x2C, 0x64, 0x46, 0xC3, 0xC2, 0x8D,
  0x91, 0x63, 0x83, 0x04, 0x08, 0x10, 0x20, 0x7E, 0x08, 0x30, 0x41, 0x86,
  0x08, 0x30, 0x41, 0xFC, 0xF2, 0x49, 0x24, 0x92, 0x70, 0xC2, 0x10, 0xC2,
  0x18, 0x42, 0x18, 0x40, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x10, 0x30,
  0xA1, 0x24, 0x58, 0x40, 0xFC, 0x88, 0x80, 0x76, 0xC2, 0x7C, 0xC6, 0x7D,
  0x82, 0x08, 0x26, 0xFF, 0x1C, 0x61, 0xC7, 0x3B, 0x80, 0x37, 0xE1, 0x08,
  0x43, 0x2F, 0x0C, 0x30, 0xDB, 0xFE, 0x38, 0xE3, 0x8F, 0x37, 0x40, 0x33,
  0x68, 0xFF, 0xFE, 0x0C, 0x5E, 0x39, 0xD8, 0xEF, 0x31, 0x8C, 0x63, 0x18,
  0x67, 0xF8, 0xE3, 0x8E, 0x3C, 0xDF, 0x0C, 0x3F, 0x80, 0x82, 0x08, 0x26,
  0xFF, 0x3C, 0x61, 0x86, 0x18, 0x40, 0xCA, 0xAA, 0xA0, 0x30, 0x22, 0x22,
  0x22, 0x22, 0x22, 0xE0, 0x82, 0x08, 0x23, 0x9A, 0x4A, 0x3C, 0x92, 0x28,
  0xC0, 0xFF, 0xE0, 0xB9, 0xBE, 0xFC, 0xCF, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x9B, 0xFC, 0xF1, 0x86, 0x18, 0x61, 0x33, 0xE8, 0xE1, 0x86, 0x3C,
  0xDE, 0x9B, 0xFC, 0x71, 0x87, 0x1C, 0xEE, 0x82, 0x08, 0x00, 0x67, 0xF8,
  0xE3, 0x8E, 0x3C, 0xDF, 0x0C, 0x30, 0xC0, 0x9B, 0xCC, 0x88, 0x88, 0x76,
  0xA1, 0x87, 0x0E, 0x5E, 0x63, 0xBC, 0xC6, 0x31, 0x8C, 0x38, 0x8E, 0x38,
  0xE3, 0x8E, 0x3C, 0xDD, 0xC7, 0x89, 0x12, 0x66, 0x85, 0x0E, 0x18, 0xCC,
  0x73, 0x14, 0xED, 0x2A, 0x7A, 0x9C, 0xA3, 0x38, 0xC4, 0xC6, 0x98, 0xA1,
  0xC3, 0x05, 0x1B, 0x63, 0xC7, 0x89, 0x13, 0x66, 0x85, 0x0E, 0x08, 0x10,
  0x63, 0x80, 0x7B, 0xC6, 0x23, 0x31, 0x1F, 0x19, 0x88, 0x42, 0x33, 0x84,
  0x21, 0x08, 0x70, 0xFF, 0xFC, 0xE1, 0x08, 0x42, 0x18, 0xE4, 0x21, 0x09,
  0xC0, 0xE6, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Medium14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 4, 1, -10 },
  { 4, 4, 4, 6, 1, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 6, 12, 7, 1, -11 },
  { 25, 10, 10, 11, 1, -10 },
  { 38, 8, 10, 9, 1, -10 },
  { 48, 1, 4, 3, 1, -10 },
  { 49, 3, 12, 4, 1, -10 },
  { 54, 4, 12, 4, 0, -10 },
  { 60, 6, 6, 7, 0, -11 },
  { 65, 6, 6, 7, 1, -8 },
  { 70, 2, 4, 4, 1, -2 },
  { 71, 4, 1, 4, 0, -4 },
  { 72, 2, 2, 4, 1, -2 },
  { 73, 5, 10, 5, 0, -10 },
  { 80, 6, 10, 7, 1, -10 },
  { 88, 4, 10, 7, 1, -10 },
  { 93, 6, 10, 7, 1, -10 },
  { 101, 6, 10, 7, 1, -10 },
  { 109, 7, 10, 7, 0, -10 },
  { 118, 6, 10, 7, 1, -10 },
  { 126, 6, 10, 7, 1, -10 },
  { 134, 7, 10, 7, 0, -10 },
  { 143, 6, 10, 7, 1, -10 },
  { 151, 6, 10, 7, 1, -10 },
  { 159, 2, 8, 4, 1, -8 },
  { 161, 3, 10, 4, 0, -8 },
  { 165, 6, 6, 7, 1, -8 },
  { 170, 6, 4, 7, 1, -7 },
  { 173, 6, 6, 7, 1, -8 },
  { 178, 5, 10, 6, 0, -10 },
  { 185, 10, 11, 11, 1, -10 },
  { 199, 8, 10, 8, 0, -10 },
  { 209, 7, 10, 8, 1, -10 },
  { 218, 7, 10, 8, 1, -10 },
  { 227, 7, 10, 9, 1, -10 },
  { 236, 5, 10, 7, 1, -10 },
  { 243, 5, 10, 7, 1, -10 },
  { 250, 7, 10, 9, 1, -10 },
  { 259, 7, 10, 9, 1, -10 },
  { 268, 4, 10, 5, 0, -10 },
  { 273, 4, 13, 4, -1, -10 },
  { 280, 7, 10, 8, 1, -10 },
  { 289, 5, 10, 7, 1, -10 },
  { 296, 10, 10, 12, 1, -10 },
  { 309, 8, 10, 10, 1, -10 },
  { 319, 8, 10, 10, 1, -10 },
  { 329, 6, 10, 8, 1, -10 },
  { 337, 8, 12, 10, 1, -10 },
  { 349, 7, 10, 8, 1, -10 },
  { 358, 5, 10, 7, 1, -10 },
  { 365, 7, 10, 7, 0, -10 },
  { 374, 7, 10, 9, 1, -10 },
  { 383, 8, 10, 8, 0, -10 },
  { 393, 12, 10, 12, 0, -10 },
  { 408, 8, 10, 8, 0, -10 },
  { 418, 7, 10, 7, 0, -10 },
  { 427, 7, 10, 7, 0, -10 },
  { 436, 3, 12, 5, 1, -10 },
  { 441, 5, 10, 5, 0, -10 },
  { 448, 4, 12, 5, 0, -10 },
  { 454, 7, 6, 7, 0, -10 },
  { 460, 6, 1, 6, 0, 1 },
  { 461, 3, 3, 4, 1, -11 },
  { 463, 5, 8, 7, 1, -8 },
  { 468, 6, 11, 8, 1, -11 },
  { 477, 5, 8, 6, 1, -8 },
  { 482, 6, 11, 8, 1, -11 },
  { 491, 6, 8, 7, 1, -8 },
  { 497, 5, 11, 5, 0, -11 },
  { 504, 6, 11, 8, 1, -8 },
  { 513, 6, 11, 8, 1, -11 },
  { 522, 2, 10, 4, 1, -10 },
  { 525, 4, 13, 4, -1, -10 },
  { 532, 6, 11, 7, 1, -11 },
  { 541, 1, 11, 4, 1, -11 },
  { 543, 10, 8, 12, 1, -8 },
  { 553, 6, 8, 8, 1, -8 },
  { 559, 6, 8, 8, 1, -8 },
  { 565, 6, 11, 8, 1, -8 },
  { 574, 6, 11, 8, 1, -8 },
  { 583, 4, 8, 5, 1, -8 },
  { 587, 5, 8, 6, 1, -8 },
  { 592, 5, 9, 5, 0, -9 },
  { 598, 6, 8, 8, 1, -8 },
  { 604, 7, 8, 7, 0, -8 },
  { 611, 10, 8, 10, 0, -8 },
  { 621, 7, 8, 7, 0, -8 },
  { 628, 7, 11, 7, 0, -8 },
  { 638, 5, 8, 6, 0, -8 },
  { 643, 5, 12, 5, 0, -10 },
  { 651, 1, 14, 7, 3, -11 },
  { 653, 5, 12, 5, 0, -10 },
  { 661, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Medium14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium14pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM14PT7B_H_
