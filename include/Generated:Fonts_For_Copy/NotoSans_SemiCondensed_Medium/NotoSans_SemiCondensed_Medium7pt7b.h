#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM7PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xB4, 0x5F, 0x6F, 0x60, 0x79, 0xBE, 0xD6, 0xBE, 0x75, 0x80,
  0x63, 0x15, 0x6F, 0x80, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xE9, 0x80, 0x5D,
  0x00, 0xC0, 0xC0, 0x80, 0x29, 0x48, 0x76, 0xD6, 0x75, 0x40, 0xE4, 0xAE,
  0xE5, 0x9E, 0x26, 0xAF, 0x20, 0x71, 0x9E, 0x73, 0xD6, 0xE4, 0xA4, 0x75,
  0xDE, 0x77, 0x96, 0x90, 0x98, 0x39, 0x80, 0xFC, 0xC7, 0x00, 0xE5, 0x24,
  0x7D, 0xF7, 0x74, 0x18, 0x66, 0x6F, 0x90, 0xD7, 0x5E, 0x78, 0x88, 0x70,
  0xD6, 0xDC, 0xEE, 0xC0, 0xEE, 0x80, 0x78, 0x99, 0x70, 0xB7, 0xDA, 0xD5,
  0xC0, 0xFC, 0xBA, 0x6A, 0xAA, 0xC0, 0x99, 0xBF, 0xD0, 0xB7, 0xDA, 0x74,
  0x63, 0x17, 0x00, 0xD7, 0x48, 0x74, 0x63, 0x17, 0x08, 0xD7, 0x6A, 0x71,
  0x9E, 0xE9, 0x24, 0xB6, 0xDE, 0x99, 0x66, 0x60, 0xA6, 0xDB, 0x52, 0x48,
  0xB6, 0x46, 0x90, 0x96, 0x44, 0x40, 0xE5, 0x2E, 0xFC, 0x91, 0x22, 0xD5,
  0x70, 0x46, 0xB0, 0xE0, 0xC0, 0x67, 0xF0, 0x9A, 0xDC, 0x72, 0x30, 0x2E,
  0xD6, 0x77, 0x30, 0x79, 0x24, 0x76, 0xB2, 0xC0, 0xBF, 0xC0, 0xF8, 0xFE,
  0x9A, 0x6E, 0xF8, 0xF5, 0x6B, 0x50, 0xFF, 0x69, 0x96, 0xD6, 0xE9, 0x00,
  0x76, 0xB2, 0x40, 0xEA, 0x71, 0xF0, 0x7A, 0x40, 0xB6, 0xB0, 0xB5, 0xA0,
  0xAD, 0x76, 0xA0, 0xA9, 0x50, 0xB5, 0xA5, 0x00, 0xE9, 0x70, 0x57, 0x50,
  0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Medium7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 3, 2, 3, 0, -5 },
  { 3, 4, 5, 4, 0, -5 },
  { 6, 3, 5, 4, 0, -5 },
  { 8, 5, 5, 6, 0, -5 },
  { 12, 5, 5, 5, 0, -5 },
  { 16, 1, 2, 2, 0, -5 },
  { 17, 2, 6, 2, 0, -5 },
  { 19, 2, 6, 2, 0, -5 },
  { 21, 3, 3, 3, 0, -5 },
  { 23, 3, 3, 4, 0, -4 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -2 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 3, 5, 3, 0, -5 },
  { 30, 3, 5, 4, 0, -5 },
  { 32, 2, 5, 4, 0, -5 },
  { 34, 3, 5, 4, 0, -5 },
  { 36, 3, 5, 4, 0, -5 },
  { 38, 4, 5, 4, 0, -5 },
  { 41, 3, 5, 4, 0, -5 },
  { 43, 3, 5, 4, 0, -5 },
  { 45, 3, 5, 4, 0, -5 },
  { 47, 3, 5, 4, 0, -5 },
  { 49, 3, 5, 4, 0, -5 },
  { 51, 1, 4, 2, 0, -4 },
  { 52, 1, 5, 2, 0, -4 },
  { 53, 3, 3, 4, 0, -4 },
  { 55, 3, 2, 4, 0, -3 },
  { 56, 3, 3, 4, 0, -4 },
  { 58, 3, 5, 3, 0, -5 },
  { 60, 5, 6, 6, 0, -5 },
  { 64, 4, 5, 4, 0, -5 },
  { 67, 3, 5, 4, 1, -5 },
  { 69, 4, 5, 4, 0, -5 },
  { 72, 3, 5, 5, 1, -5 },
  { 74, 2, 5, 4, 1, -5 },
  { 76, 2, 5, 3, 1, -5 },
  { 78, 4, 5, 5, 0, -5 },
  { 81, 3, 5, 5, 1, -5 },
  { 83, 2, 5, 2, 0, -5 },
  { 85, 1, 6, 2, 0, -5 },
  { 86, 3, 5, 4, 1, -5 },
  { 88, 2, 5, 3, 1, -5 },
  { 90, 4, 5, 6, 1, -5 },
  { 93, 3, 5, 5, 1, -5 },
  { 95, 5, 5, 5, 0, -5 },
  { 99, 3, 5, 4, 1, -5 },
  { 101, 5, 6, 5, 0, -5 },
  { 105, 3, 5, 4, 1, -5 },
  { 107, 3, 5, 4, 0, -5 },
  { 109, 3, 5, 4, 0, -5 },
  { 111, 3, 5, 5, 1, -5 },
  { 113, 4, 5, 4, 0, -5 },
  { 116, 6, 5, 6, 0, -5 },
  { 120, 4, 5, 4, 0, -5 },
  { 123, 4, 5, 4, 0, -5 },
  { 126, 3, 5, 4, 0, -5 },
  { 128, 1, 6, 2, 1, -5 },
  { 129, 3, 5, 3, 0, -5 },
  { 131, 2, 6, 2, 0, -5 },
  { 133, 4, 3, 4, 0, -5 },
  { 135, 3, 1, 3, 0, 0 },
  { 136, 2, 1, 2, 0, -5 },
  { 137, 3, 4, 4, 0, -4 },
  { 139, 3, 5, 4, 1, -5 },
  { 141, 3, 4, 3, 0, -4 },
  { 143, 3, 5, 4, 0, -5 },
  { 145, 3, 4, 4, 0, -4 },
  { 147, 3, 5, 2, 0, -5 },
  { 149, 3, 6, 4, 0, -4 },
  { 152, 2, 5, 4, 1, -5 },
  { 154, 1, 5, 2, 0, -5 },
  { 155, 1, 7, 2, 0, -5 },
  { 156, 3, 5, 4, 1, -5 },
  { 158, 1, 5, 2, 0, -5 },
  { 159, 5, 4, 6, 1, -4 },
  { 162, 2, 4, 4, 1, -4 },
  { 163, 4, 4, 4, 0, -4 },
  { 165, 3, 6, 4, 1, -4 },
  { 168, 3, 6, 4, 0, -4 },
  { 171, 2, 4, 3, 1, -4 },
  { 172, 3, 4, 3, 0, -4 },
  { 174, 2, 5, 2, 0, -5 },
  { 176, 3, 4, 4, 0, -4 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 5, 4, 5, 0, -4 },
  { 183, 3, 4, 3, 0, -4 },
  { 185, 3, 6, 3, 0, -4 },
  { 188, 3, 4, 3, 0, -4 },
  { 190, 2, 6, 3, 0, -5 },
  { 192, 1, 7, 4, 1, -5 },
  { 193, 2, 6, 3, 0, -5 },
  { 195, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Medium7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium7pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM7PT7B_H_
