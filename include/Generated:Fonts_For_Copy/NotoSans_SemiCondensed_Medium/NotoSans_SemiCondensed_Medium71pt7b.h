#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM71PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC7, 0x80,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0,
  0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7E, 0x03, 0xFB,
  0xF0, 0x1F, 0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x07,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xEF, 0x8F, 0xE3, 0xFE, 0x3E, 0x03, 0x8F, 0xF0, 0xF8,
  0x00, 0x3F, 0x83, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x03, 0xF8, 0x3E, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0xFE, 0x0F, 0x80, 0x03,
  0xFC, 0x3E, 0x00, 0x0F, 0xF8, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3E, 0x7F,
  0xE0, 0x00, 0xF8, 0x7F, 0x80, 0x03, 0xE0, 0xFF, 0x00, 0x0F, 0x83, 0xFC,
  0x00, 0x3E, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0xC0, 0x03, 0xE0, 0x7F, 0x00,
  0x0F, 0x81, 0xFE, 0x00, 0x3E, 0x0F, 0xEC, 0x00, 0xF8, 0x7F, 0xBE, 0x03,
  0xE3, 0xFE, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xE1,
  0xF8, 0x3F, 0xF8, 0x1F, 0x00, 0xFC, 0x3F, 0x0F, 0xFF, 0x83, 0xF0, 0x3F,
  0x0F, 0xC3, 0xFF, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0xFF, 0xFF, 0x07, 0xE1,
  0xFC, 0x7E, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF, 0x0F, 0xC7, 0xF0, 0x7E, 0x0F,
  0xFF, 0xC3, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xF8, 0x7E, 0x1F, 0x80, 0xFC,
  0x1F, 0xFE, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFF, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x83, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x1F,
  0xFF, 0xE0, 0x01, 0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0x81, 0xFF, 0x3F,
  0xE0, 0x07, 0xF0, 0x7F, 0xC3, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0x83, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xE1, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x7F,
  0x80, 0x07, 0xFD, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x81, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x0B, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E,
  0x3E, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x70, 0x0F, 0x80, 0x79, 0xFC, 0x1F, 0x07, 0xF3, 0xFF, 0xBE, 0x7F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x04, 0x01, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x1F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x87,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFD, 0xFC,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80,
  0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0x7F, 0x3F, 0xE7,
  0xF7, 0xFC, 0x7F, 0xFF, 0x87, 0xF7, 0xE0, 0x7F, 0x3C, 0x07, 0xF1, 0x80,
  0x7F, 0x10, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x1F, 0x80, 0x07, 0xF8,
  0x1E, 0x00, 0x0F, 0xF8, 0x30, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0,
  0x0F, 0xFC, 0x1F, 0x00, 0x07, 0xFC, 0x18, 0x00, 0x07, 0xF8, 0x20, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFA, 0x00, 0x00, 0x1F, 0xF6, 0x00, 0x00,
  0x7F, 0xCF, 0x80, 0x03, 0xFF, 0x9F, 0xFE, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x1F, 0x87, 0xF8, 0x00,
  0x03, 0xF0, 0xFF, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x07, 0xE0, 0x7F, 0x80, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xFE,
  0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC8, 0x00, 0x00, 0xFF, 0x30, 0x00,
  0x0F, 0xFC, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F,
  0xF0, 0x07, 0xF1, 0xFF, 0xF8, 0x0F, 0xC7, 0xFF, 0xF8, 0x1F, 0x9F, 0xFF,
  0xF8, 0x7F, 0x7F, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F,
  0xF3, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x1F,
  0xDF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xDF, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x8F, 0xFE, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F,
  0xC7, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0xBF, 0xC0, 0x03,
  0xFF, 0x7F, 0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF7, 0xF0, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0xFF, 0x1F,
  0x80, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x14, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xC7,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF,
  0x7F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xDF, 0xE3, 0xF8, 0x78, 0x07, 0x81, 0xFE, 0x1F, 0xE1, 0xFF, 0x3F, 0xF3,
  0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE7, 0xF0, 0x0F, 0xF8, 0xE0, 0x01, 0xFF, 0x20, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0xFF, 0xC0, 0x7E, 0x3F,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xE7,
  0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xF8, 0x0F, 0xC0, 0x3F,
  0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xDF, 0x00, 0xFE, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xFF, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x1F, 0x80, 0x0F,
  0xC0, 0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x01, 0xF8, 0x00,
  0xFC, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0x80,
  0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x01, 0xF8,
  0x01, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xFB, 0xF0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7E, 0xFC, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x3F, 0x00,
  0xFE, 0x0F, 0xBE, 0x1F, 0xCF, 0xC0, 0x1F, 0xFF, 0xEF, 0xFF, 0xE1, 0xF8,
  0x07, 0xFF, 0xF1, 0xFF, 0xF0, 0x7E, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F,
  0x80, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0xFF,
  0xF1, 0xFC, 0x00, 0x1F, 0xFC, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFF, 0x87, 0xF0,
  0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0xC7, 0xF0, 0x00, 0x1F, 0xF3,
  0xF8, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0xFF, 0xCF, 0xE0, 0x03,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xF8, 0x1F, 0xFC, 0x00,
  0x1C, 0x0F, 0xFC, 0x00, 0x01, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x07, 0xFF,
  0x80, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0xFE, 0x00, 0x03,
  0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0xF1, 0xFC,
  0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x00, 0x1F,
  0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x03, 0xFE, 0xFE, 0x00,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x0F,
  0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0x80,
  0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xE0,
  0x00, 0x3C, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xF0,
  0x00, 0x01, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0xC0, 0x00, 0x1F,
  0xC1, 0xFF, 0x80, 0x00, 0x7F, 0x07, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFE, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x1F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0xFE, 0xFE, 0x00, 0x00,
  0x3F, 0x7F, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0xFE, 0x7E, 0x00, 0x00,
  0x7E, 0x7F, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0x80, 0x00,
  0xFC, 0x7F, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0xFE, 0x1F, 0x80, 0x01,
  0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x03,
  0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x0F,
  0xE0, 0x7F, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0xFE, 0x01, 0xF8, 0x1F,
  0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x3F,
  0x00, 0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x7E,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0xFF, 0x00, 0x01, 0xFF, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xE7, 0xF8, 0x00,
  0x1F, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0xF8,
  0x7F, 0x80, 0x07, 0xFF, 0xE1, 0xFE, 0x00, 0x1F, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xE0,
  0x7F, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0xF8, 0x01, 0xFE, 0x07,
  0xFF, 0xE0, 0x03, 0xFC, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xFE, 0x00,
  0x1F, 0xE1, 0xFF, 0xF8, 0x00, 0x7F, 0xC7, 0xFF, 0xE0, 0x00, 0xFF, 0x1F,
  0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0xF8, 0x00,
  0x0F, 0xF7, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0xFF, 0x80, 0x00, 0x7F, 0xBF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7A,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0x80, 0x0F, 0xFE, 0xFE, 0x00, 0x0F, 0xFB,
  0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xFE, 0xFE, 0x00, 0x3F, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFE, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xF8, 0x3F,
  0x80, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0,
  0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x83, 0xF8,
  0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00,
  0xFF, 0xBF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0x81, 0xFE,
  0x0F, 0xF8, 0x00, 0x78, 0x7F, 0xC0, 0x00, 0x21, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xEC,
  0x00, 0x00, 0x7F, 0xBC, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x7F, 0xF3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0xC3, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xC7, 0xF0, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xF8, 0x3F, 0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x7F,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFF,
  0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0xC0, 0xE0, 0x01,
  0xFE, 0x04, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF,
  0x9F, 0xF8, 0x01, 0xFD, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFB, 0xFE, 0x07, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFE, 0x7F, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0x1F, 0x87, 0xFF,
  0xF0, 0xFC, 0x1F, 0xFE, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0xFE, 0x0F, 0xFF, 0x00, 0xFE, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F, 0xFF,
  0xE0, 0xFE, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xF8, 0xFF, 0xE0, 0x07, 0xF8, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x03,
  0xFC, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0xC0, 0x03,
  0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xF0, 0x0F, 0xF8, 0xFF, 0xFE, 0x3F,
  0xF8, 0xFE, 0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF,
  0xC0, 0xFC, 0x1F, 0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0x83,
  0xE0, 0xFF, 0x80, 0x0C, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x02, 0x1F, 0xF8, 0x01, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0xF0, 0x7F,
  0x01, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xFE, 0x7F, 0x07, 0xFF, 0xFF, 0x7F,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x1F, 0xFF, 0x1F, 0xF0, 0x07, 0xFF,
  0x3F, 0xE0, 0x03, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF,
  0x1F, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0x7F,
  0x07, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFC, 0x3F,
  0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04,
  0x1F, 0xF8, 0x00, 0x38, 0x1F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xF8, 0x08, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x03, 0xFF, 0xFE, 0x7F,
  0x07, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x1F, 0xFF,
  0x1F, 0xF0, 0x07, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0x3F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xFF, 0x7F, 0x03, 0xFF, 0xFE, 0x7F,
  0x01, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x0F, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x10, 0x00, 0x03, 0xFE, 0x1C, 0x00, 0x07, 0xFC,
  0x1F, 0xC0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x0F, 0xFF, 0x83, 0xF8, 0xFF, 0xFF, 0x0F,
  0xE7, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xF0, 0x7F, 0xEF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xF0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x83, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00,
  0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0xFF, 0x80, 0x01,
  0xFD, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFD, 0xFE, 0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x7F,
  0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0x81,
  0xFF, 0xE0, 0x0F, 0xFF, 0x83, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x7F,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xF7, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFB, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x3F, 0xFE, 0x0F, 0xC3, 0xFF, 0xFC,
  0x3F, 0x9F, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xF3, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xC1, 0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0xBF,
  0x80, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x1F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xFF, 0x00, 0xFE, 0x3F, 0xFF,
  0xC0, 0xFE, 0x7F, 0xFF, 0xE0, 0xFE, 0x7F, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x03,
  0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01,
  0xFC, 0xFF, 0xC0, 0x03, 0xFC, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xF0, 0x0F,
  0xF8, 0xFF, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF,
  0xE0, 0xFE, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0x0F, 0xFF,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x03, 0xFF, 0xFE,
  0x7F, 0x07, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0x1F,
  0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x3F, 0xC0, 0x01,
  0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x01,
  0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xFE, 0x7F, 0x03, 0xFF, 0xFE,
  0x7F, 0x01, 0xFF, 0xF8, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x0F, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0xF9, 0xFE, 0x00,
  0x0C, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x03, 0xE0, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB,
  0xF3, 0xFF, 0xFF, 0xCF, 0xC7, 0xFF, 0xFE, 0x3F, 0x0F, 0xFF, 0xF0, 0xFC,
  0x0F, 0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0x80, 0x03, 0xFB, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xE1, 0xFC,
  0x00, 0xFD, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFC, 0xFC, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF1, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xC7, 0xE0,
  0x3F, 0x80, 0x7F, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x1F,
  0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x80, 0x3F, 0xC3, 0xF8,
  0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x0F,
  0xC0, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0xCF, 0xC0, 0x3F, 0x1F, 0xC0, 0x03,
  0xF9, 0xF8, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xEF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F,
  0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x7F, 0xFC, 0x00, 0x05,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x80,
  0x00, 0xFF, 0xF1, 0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Medium71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 52, 19, 5, -51 },
  { 60, 21, 19, 30, 4, -51 },
  { 110, 38, 51, 41, 2, -51 },
  { 353, 30, 58, 37, 4, -54 },
  { 571, 51, 52, 56, 3, -51 },
  { 903, 43, 52, 46, 3, -51 },
  { 1183, 8, 19, 16, 4, -51 },
  { 1202, 17, 62, 22, 3, -51 },
  { 1334, 17, 62, 22, 2, -51 },
  { 1466, 31, 30, 35, 2, -54 },
  { 1583, 31, 34, 37, 3, -42 },
  { 1715, 11, 17, 18, 3, -8 },
  { 1739, 17, 6, 22, 2, -22 },
  { 1752, 10, 10, 18, 4, -9 },
  { 1765, 26, 51, 27, 1, -51 },
  { 1931, 31, 52, 37, 3, -51 },
  { 2133, 20, 51, 37, 5, -51 },
  { 2261, 31, 51, 37, 3, -51 },
  { 2459, 31, 52, 37, 3, -51 },
  { 2661, 35, 51, 37, 1, -51 },
  { 2885, 30, 52, 37, 4, -51 },
  { 3080, 31, 52, 37, 3, -51 },
  { 3282, 32, 51, 37, 2, -51 },
  { 3486, 31, 52, 37, 3, -51 },
  { 3688, 31, 52, 37, 3, -51 },
  { 3890, 10, 40, 18, 4, -39 },
  { 3940, 12, 48, 18, 2, -39 },
  { 4012, 31, 35, 37, 3, -43 },
  { 4148, 31, 20, 37, 3, -35 },
  { 4226, 31, 35, 37, 3, -43 },
  { 4362, 26, 52, 29, 1, -51 },
  { 4531, 50, 57, 58, 4, -51 },
  { 4888, 42, 51, 42, 0, -51 },
  { 5156, 33, 51, 42, 6, -51 },
  { 5367, 34, 52, 40, 4, -51 },
  { 5588, 37, 51, 47, 6, -51 },
  { 5824, 26, 51, 36, 6, -51 },
  { 5990, 26, 51, 34, 6, -51 },
  { 6156, 38, 52, 47, 4, -51 },
  { 6403, 36, 51, 48, 6, -51 },
  { 6633, 19, 51, 24, 2, -51 },
  { 6755, 18, 65, 19, -5, -51 },
  { 6902, 35, 51, 41, 6, -51 },
  { 7126, 26, 51, 34, 6, -51 },
  { 7292, 48, 51, 60, 6, -51 },
  { 7598, 38, 51, 50, 6, -51 },
  { 7841, 42, 52, 50, 4, -51 },
  { 8114, 30, 51, 39, 6, -51 },
  { 8306, 42, 63, 50, 4, -51 },
  { 8637, 34, 51, 41, 6, -51 },
  { 8854, 30, 52, 36, 3, -51 },
  { 9049, 34, 51, 36, 1, -51 },
  { 9266, 35, 52, 47, 6, -51 },
  { 9494, 40, 51, 40, 0, -51 },
  { 9749, 61, 51, 61, 0, -51 },
  { 10138, 38, 51, 38, 0, -51 },
  { 10381, 37, 51, 37, 0, -51 },
  { 10617, 32, 51, 36, 2, -51 },
  { 10821, 16, 62, 23, 5, -51 },
  { 10945, 26, 51, 27, 1, -51 },
  { 11111, 16, 62, 23, 2, -51 },
  { 11235, 34, 31, 38, 2, -51 },
  { 11367, 31, 5, 31, 0, 6 },
  { 11387, 15, 11, 21, 3, -54 },
  { 11408, 29, 40, 37, 3, -39 },
  { 11553, 32, 55, 40, 5, -54 },
  { 11773, 27, 40, 32, 3, -39 },
  { 11908, 32, 55, 40, 3, -54 },
  { 12128, 31, 40, 37, 3, -39 },
  { 12283, 25, 54, 23, 1, -54 },
  { 12452, 32, 56, 40, 3, -39 },
  { 12676, 30, 54, 40, 5, -54 },
  { 12879, 8, 53, 18, 5, -53 },
  { 12932, 16, 70, 18, -3, -53 },
  { 13072, 31, 54, 36, 5, -54 },
  { 13282, 8, 54, 18, 5, -54 },
  { 13336, 51, 39, 61, 5, -39 },
  { 13585, 30, 39, 40, 5, -39 },
  { 13732, 33, 40, 39, 3, -39 },
  { 13897, 32, 56, 40, 5, -39 },
  { 14121, 32, 56, 40, 3, -39 },
  { 14345, 21, 39, 27, 5, -39 },
  { 14448, 25, 40, 31, 3, -39 },
  { 14573, 22, 48, 25, 1, -47 },
  { 14705, 30, 39, 40, 5, -38 },
  { 14852, 34, 38, 34, 0, -38 },
  { 15014, 51, 38, 53, 1, -38 },
  { 15257, 33, 38, 35, 1, -38 },
  { 15414, 34, 55, 34, 0, -38 },
  { 15648, 26, 38, 30, 2, -38 },
  { 15772, 22, 62, 27, 2, -51 },
  { 15943, 6, 71, 36, 15, -54 },
  { 15997, 22, 62, 27, 3, -51 },
  { 16168, 31, 10, 37, 3, -30 },
};

const GFXfont NotoSans_SemiCondensed_Medium71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium71pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM71PT7B_H_
