#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFF, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x9F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xC7, 0x80,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFE, 0x7F,
  0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x01,
  0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9,
  0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x8F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0x1E, 0x07, 0x8F, 0xF0, 0x78,
  0x02, 0x3F, 0x81, 0xE0, 0x00, 0xFE, 0x07, 0x80, 0x03, 0xF8, 0x1E, 0x00,
  0x0F, 0xE0, 0x78, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0xFE, 0x07, 0x80, 0x03,
  0xFC, 0x1E, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x1F, 0xF9, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1E, 0xFF,
  0xE0, 0x00, 0x78, 0xFF, 0x80, 0x01, 0xE0, 0xFF, 0x00, 0x07, 0x83, 0xFC,
  0x00, 0x1E, 0x07, 0xF0, 0x00, 0x78, 0x1F, 0xC0, 0x01, 0xE0, 0x7F, 0x00,
  0x07, 0x81, 0xFC, 0x00, 0x1E, 0x07, 0xF8, 0x00, 0x78, 0x3F, 0xF8, 0x01,
  0xE1, 0xFE, 0xFC, 0x07, 0x8F, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0C,
  0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x1F, 0xF0, 0x1F, 0x00, 0xFC, 0x3F, 0x07,
  0xFF, 0x83, 0xF0, 0x1F, 0x87, 0xE1, 0xFF, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x7F, 0xFF, 0x0F, 0xE0, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0, 0xFE, 0x3F, 0x8F,
  0xC3, 0xF8, 0x7F, 0x1F, 0xFF, 0xE1, 0xF8, 0x7E, 0x07, 0xE1, 0xFF, 0xFC,
  0x7F, 0x0F, 0xC0, 0xFC, 0x1F, 0xFF, 0x0F, 0xC3, 0xF0, 0x1F, 0xC1, 0xFF,
  0xC3, 0xF8, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0x03, 0xF8, 0x0F,
  0xFB, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0xC0, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xF1,
  0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x9F, 0xC0, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x9F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x01, 0x80, 0x3F, 0x00, 0x6F, 0xC0, 0xF8, 0x0F, 0xBF, 0xF3, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0x00, 0x30, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x7F, 0x9F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x7F, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01,
  0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xF7, 0xF3, 0xFE, 0x7F, 0x7F, 0xC7, 0xFF, 0xF8, 0x7F, 0x7F,
  0x07, 0xF3, 0xE0, 0x7F, 0x1C, 0x07, 0xF0, 0x80, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xC0, 0x0F, 0xFC, 0x3E, 0x00, 0x0F, 0xF8,
  0x38, 0x00, 0x0F, 0xF0, 0x20, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0x80, 0x07, 0xFC, 0x3C, 0x00, 0x07, 0xF8, 0x20, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF4, 0x00, 0x00,
  0x3F, 0xEE, 0x00, 0x00, 0xFF, 0xDF, 0x80, 0x07, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xCF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE8, 0x00, 0x00, 0xFF, 0x38, 0x00, 0x07, 0xFC, 0xFC, 0x00,
  0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x10, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xF0, 0x00,
  0x7F, 0x07, 0xFF, 0x00, 0x7F, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F, 0xFF, 0xE0,
  0x7F, 0x7F, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xF8,
  0xFF, 0xF0, 0x07, 0xFC, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0xC0, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC,
  0x3F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC,
  0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x7F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE,
  0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xBF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x1F,
  0xFC, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xEF,
  0xE1, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0xF8, 0x7F,
  0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x08, 0x3F,
  0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x87, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3C, 0x00, 0x01, 0x00, 0xFE,
  0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFE,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0xFF,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xFC, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF,
  0xE3, 0xE0, 0x03, 0xFE, 0x30, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x8F,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0xFC, 0x1F, 0x80, 0x1F, 0xFF, 0xF8, 0x0F,
  0xC7, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0x3F, 0x00, 0x7F, 0x80, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0xE0, 0x1F,
  0x80, 0x7E, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xDF, 0x00, 0xFE, 0x00,
  0x7E, 0x01, 0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0xFC, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x1F,
  0x80, 0x0F, 0xE0, 0x1F, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xC0,
  0x7E, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xFE,
  0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x3F,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xDF, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xFB, 0xF0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x7E, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xEF, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xF0, 0x1F,
  0xF0, 0x3F, 0x3F, 0x00, 0xFF, 0x07, 0xFF, 0x0F, 0xC7, 0xE0, 0x0F, 0xFF,
  0xF3, 0xFF, 0xF8, 0x7E, 0x00, 0xFF, 0xFE, 0x7F, 0xFE, 0x0F, 0xC0, 0x0F,
  0xFF, 0x87, 0xFF, 0x81, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0x80,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x00, 0x7F, 0xF9,
  0xFE, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0xBF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0,
  0x07, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x7F, 0xEF, 0xF0, 0x03, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x7F, 0xE0, 0x3F, 0xFC, 0x00,
  0x7C, 0x07, 0xFE, 0x00, 0x01, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x08, 0x0F, 0xFF, 0x80, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0x00, 0x01, 0xFF, 0x87,
  0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00,
  0x7F, 0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xFB, 0xFC,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0xE1, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0xF8, 0x07, 0xFF, 0x00, 0x00, 0x30, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00,
  0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF3, 0xDF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x8F, 0xF8, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xDF, 0xFF, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xFF, 0xDF, 0xC0,
  0x00, 0x07, 0xF7, 0xFF, 0xEF, 0xE0, 0x00, 0x03, 0xF3, 0xFF, 0xF3, 0xF0,
  0x00, 0x01, 0xF9, 0xFF, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0xFC, 0xFE,
  0x00, 0x00, 0xFC, 0x7F, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0xFF, 0x1F,
  0xC0, 0x00, 0x7F, 0x1F, 0xFF, 0x8F, 0xE0, 0x00, 0x3F, 0x0F, 0xFF, 0xC3,
  0xF0, 0x00, 0x1F, 0x87, 0xFF, 0xE1, 0xFC, 0x00, 0x1F, 0xC3, 0xFF, 0xF0,
  0xFE, 0x00, 0x0F, 0xC1, 0xFF, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFF, 0xFC,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0xFF,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xFF,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFF,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0xFF, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xE3, 0xF0, 0x03,
  0xFF, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF7, 0xF8, 0x00,
  0x07, 0xFF, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xCF, 0xF0, 0x00, 0x1F, 0xFF,
  0x9F, 0xF0, 0x00, 0x3F, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x3F, 0xE0,
  0x00, 0xFF, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x3F, 0xC0, 0x03, 0xFF,
  0xF0, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x03,
  0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xF8, 0x0F,
  0xFF, 0xC0, 0x07, 0xF8, 0x1F, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xFC, 0x00, 0x1F, 0xE1,
  0xFF, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0xF0, 0x00, 0x3F, 0xC7, 0xFF, 0xE0,
  0x00, 0x3F, 0xCF, 0xFF, 0xC0, 0x00, 0x7F, 0x9F, 0xFF, 0x80, 0x00, 0x7F,
  0xBF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xFE,
  0x7F, 0x80, 0x0F, 0xFC, 0xFF, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xC0,
  0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xFC, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x05, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF8, 0x7F,
  0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC,
  0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x0F, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x00,
  0xFC, 0x3F, 0xC0, 0x00, 0x61, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xB0, 0x00, 0x01, 0xFE, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xFC, 0x03,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0xFD, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFF, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xF0, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F,
  0xBF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xE1, 0xFF, 0xC0,
  0xF0, 0x01, 0xFE, 0x02, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xC1, 0xFC, 0xFF, 0xC0, 0x0F, 0xEF, 0xF8, 0x00,
  0x7F, 0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xDF, 0xF8, 0x3F, 0xFE, 0xFF, 0xFF, 0xFB, 0xF3, 0xFF, 0xFF, 0x9F,
  0x8F, 0xFF, 0xF8, 0xFC, 0x3F, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x60, 0x00, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0x1F, 0xFF, 0x80, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0x7F, 0xFF, 0xF0, 0xFE,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF,
  0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFE, 0xFF,
  0xE0, 0x03, 0xFC, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xFF, 0x7F, 0xF8, 0xFE,
  0xFF, 0xFF, 0xF8, 0xFE, 0x7F, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0xE0, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F,
  0xE0, 0x1C, 0x1F, 0xF0, 0x00, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x43, 0xFF, 0x00, 0x38, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x7F, 0x00, 0x7F,
  0xF0, 0x7F, 0x01, 0xFF, 0xFC, 0x7F, 0x03, 0xFF, 0xFE, 0x7F, 0x07, 0xFF,
  0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8,
  0x0F, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0,
  0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0,
  0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0x1F, 0xFF,
  0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x3F, 0x03, 0xFF,
  0xFE, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x08, 0x1F, 0xF0,
  0x00, 0x70, 0x3F, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFC, 0x18, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x03, 0xFF, 0xFE,
  0x3F, 0x07, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x01,
  0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x07,
  0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x7F, 0x03, 0xFF, 0xFE, 0x7F, 0x01, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xF0,
  0x7F, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x10, 0x00, 0x01,
  0xFE, 0x1C, 0x00, 0x07, 0xFE, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x30, 0x00, 0xFF,
  0x07, 0xFF, 0x01, 0xFE, 0x3F, 0xFF, 0x83, 0xFC, 0xFF, 0xFF, 0x87, 0xFB,
  0xFF, 0xFF, 0x8F, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE,
  0x03, 0xFF, 0x7F, 0xF0, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x18, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x83, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFD, 0xFF, 0x80, 0x03, 0xFB,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xF9, 0xFE, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF, 0x83,
  0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x01, 0x00, 0x0F, 0xC0,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x0F,
  0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xCF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0x30, 0x01, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x7F, 0xFF, 0x07,
  0xF1, 0xFF, 0xFF, 0x0F, 0xE7, 0xFF, 0xFF, 0x1F, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x03, 0xFD, 0xFF,
  0x80, 0x07, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFC, 0x07,
  0xFF, 0x00, 0xFE, 0x1F, 0xFF, 0x80, 0xFE, 0x3F, 0xFF, 0xE0, 0xFE, 0x7F,
  0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0,
  0x0F, 0xFC, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0x80,
  0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0xC0,
  0x03, 0xFE, 0xFF, 0xE0, 0x07, 0xFC, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xFF,
  0x7F, 0xF8, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF0, 0xFF, 0x3F,
  0xFF, 0xE0, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x00,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x03, 0xFF, 0xFE, 0x3F, 0x07, 0xFF,
  0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8,
  0x0F, 0xFF, 0x1F, 0xE0, 0x03, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0,
  0x01, 0xFF, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0,
  0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0x1F, 0xFF,
  0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x7F, 0x03, 0xFF,
  0xFE, 0x7F, 0x01, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0x00, 0x0F,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x63, 0xF0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x87, 0xFE, 0xFE, 0x3F, 0xFB, 0xF9, 0xFF, 0xEF, 0xEF,
  0xFF, 0xBF, 0xBF, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xF1, 0xFE, 0x00, 0x38, 0xFF, 0x00,
  0x02, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0xC0, 0x00, 0x7F, 0xBE, 0x00, 0x3F, 0xEF, 0xF8,
  0x7F, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFB, 0xC0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07,
  0x80, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xE0, 0x01,
  0xFF, 0xBF, 0xC0, 0x07, 0xFF, 0x7F, 0xC0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFB, 0xF8, 0xFF, 0xFF, 0xE7, 0xF1, 0xFF, 0xFF, 0x8F,
  0xE0, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03,
  0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0xE0, 0x01,
  0xFC, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFB, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x81, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0x01, 0xFC,
  0x03, 0xF1, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x1F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xF1, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7E, 0x0F, 0xC0,
  0xFE, 0x00, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x07,
  0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFC,
  0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC0, 0x03, 0xF9,
  0xFC, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0x3F, 0x80, 0x03,
  0xF9, 0xF8, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x80,
  0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xBF,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0x3F, 0xFF, 0x00, 0x03, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0xC0, 0x01, 0xFF, 0xFC, 0x80, 0x00, 0x3F, 0xF0, 0x80, 0x00,
  0x07, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Medium72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 9, 52, 19, 5, -51 },
  { 60, 22, 18, 30, 4, -51 },
  { 110, 38, 51, 42, 2, -51 },
  { 353, 30, 59, 38, 4, -55 },
  { 575, 51, 53, 57, 3, -52 },
  { 913, 44, 53, 47, 3, -52 },
  { 1205, 8, 18, 16, 4, -51 },
  { 1223, 17, 63, 22, 3, -52 },
  { 1357, 17, 63, 22, 2, -52 },
  { 1491, 30, 30, 36, 3, -55 },
  { 1604, 32, 35, 38, 3, -43 },
  { 1744, 11, 17, 19, 3, -8 },
  { 1768, 18, 7, 22, 2, -23 },
  { 1784, 9, 10, 19, 5, -9 },
  { 1796, 26, 52, 28, 1, -52 },
  { 1965, 32, 53, 38, 3, -52 },
  { 2177, 20, 51, 38, 5, -51 },
  { 2305, 31, 52, 38, 3, -52 },
  { 2507, 31, 53, 38, 3, -52 },
  { 2713, 35, 52, 38, 1, -52 },
  { 2941, 30, 52, 38, 4, -51 },
  { 3136, 32, 53, 38, 3, -52 },
  { 3348, 32, 51, 38, 3, -51 },
  { 3552, 32, 53, 38, 3, -52 },
  { 3764, 31, 53, 38, 3, -52 },
  { 3970, 9, 41, 19, 5, -40 },
  { 4017, 12, 49, 19, 2, -40 },
  { 4091, 32, 35, 38, 3, -43 },
  { 4231, 31, 21, 38, 3, -36 },
  { 4313, 32, 35, 38, 3, -43 },
  { 4453, 27, 53, 29, 1, -52 },
  { 4632, 51, 58, 59, 4, -52 },
  { 5002, 42, 52, 42, 0, -52 },
  { 5275, 33, 51, 43, 6, -51 },
  { 5486, 35, 53, 41, 4, -52 },
  { 5718, 37, 51, 47, 6, -51 },
  { 5954, 26, 51, 36, 6, -51 },
  { 6120, 26, 51, 34, 6, -51 },
  { 6286, 39, 53, 48, 4, -52 },
  { 6545, 36, 51, 49, 6, -51 },
  { 6775, 18, 51, 24, 3, -51 },
  { 6890, 19, 65, 20, -5, -51 },
  { 7045, 35, 51, 41, 6, -51 },
  { 7269, 27, 51, 34, 6, -51 },
  { 7442, 49, 51, 61, 6, -51 },
  { 7755, 39, 51, 51, 6, -51 },
  { 8004, 43, 53, 51, 4, -52 },
  { 8289, 31, 51, 40, 6, -51 },
  { 8487, 43, 64, 51, 4, -52 },
  { 8831, 35, 51, 41, 6, -51 },
  { 9055, 30, 53, 36, 3, -52 },
  { 9254, 34, 51, 36, 1, -51 },
  { 9471, 36, 52, 48, 6, -51 },
  { 9705, 40, 51, 40, 0, -51 },
  { 9960, 62, 51, 62, 0, -51 },
  { 10356, 39, 51, 39, 0, -51 },
  { 10605, 38, 51, 38, 0, -51 },
  { 10848, 32, 51, 36, 2, -51 },
  { 11052, 16, 63, 23, 5, -52 },
  { 11178, 26, 52, 28, 1, -52 },
  { 11347, 16, 63, 23, 2, -52 },
  { 11473, 34, 32, 38, 2, -52 },
  { 11609, 31, 5, 31, 0, 6 },
  { 11629, 15, 11, 21, 3, -55 },
  { 11650, 29, 41, 37, 3, -40 },
  { 11799, 32, 56, 41, 5, -55 },
  { 12023, 27, 41, 32, 3, -40 },
  { 12162, 32, 56, 41, 3, -55 },
  { 12386, 31, 41, 38, 3, -40 },
  { 12545, 25, 55, 23, 1, -55 },
  { 12717, 32, 57, 41, 3, -40 },
  { 12945, 31, 55, 41, 5, -55 },
  { 13159, 8, 54, 18, 5, -54 },
  { 13213, 16, 71, 18, -3, -54 },
  { 13355, 31, 55, 37, 5, -55 },
  { 13569, 8, 55, 18, 5, -55 },
  { 13624, 52, 40, 62, 5, -40 },
  { 13884, 31, 40, 41, 5, -40 },
  { 14039, 34, 41, 40, 3, -40 },
  { 14214, 32, 57, 41, 5, -40 },
  { 14442, 32, 57, 41, 3, -40 },
  { 14670, 22, 40, 28, 5, -40 },
  { 14780, 26, 41, 31, 3, -40 },
  { 14914, 22, 49, 25, 1, -48 },
  { 15049, 31, 40, 41, 5, -39 },
  { 15204, 34, 39, 34, 0, -39 },
  { 15370, 52, 39, 53, 1, -39 },
  { 15624, 33, 39, 35, 1, -39 },
  { 15785, 34, 56, 34, 0, -39 },
  { 16023, 26, 39, 30, 2, -39 },
  { 16150, 22, 62, 27, 2, -51 },
  { 16321, 6, 72, 36, 15, -55 },
  { 16375, 22, 62, 27, 3, -51 },
  { 16546, 32, 10, 38, 3, -30 },
};

const GFXfont NotoSans_SemiCondensed_Medium72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM72PT7B_H_
