#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM45PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x07, 0x3E, 0xFF, 0xFF,
  0xFE, 0x20, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x77, 0x83, 0x9C, 0x1C, 0x00, 0x70, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03,
  0xC1, 0xE0, 0x03, 0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0x81, 0xC0, 0x03,
  0x83, 0xC0, 0x03, 0x83, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0x7E, 0x7C, 0xE0, 0x9F, 0x1C, 0x03, 0xE3, 0x80, 0x7C, 0x70,
  0x0F, 0x8E, 0x00, 0xF9, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xC7,
  0xC0, 0x38, 0x78, 0x07, 0x0F, 0x00, 0xE1, 0xE0, 0x1C, 0x3F, 0x03, 0x8F,
  0xFC, 0x77, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0x80, 0x7F, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x1F, 0xC0, 0x07, 0x80, 0x3F, 0xE0, 0x07, 0x80,
  0x7F, 0xE0, 0x0F, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x00,
  0xF0, 0x70, 0x1E, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x38, 0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x70, 0x00,
  0xF0, 0x78, 0xF0, 0x00, 0xF0, 0x78, 0xE0, 0xE0, 0xF0, 0x71, 0xE3, 0xF8,
  0xF0, 0xF1, 0xC7, 0xFC, 0x78, 0xF3, 0xCF, 0xFE, 0x7F, 0xE3, 0x8F, 0x1E,
  0x3F, 0xE7, 0x8E, 0x0E, 0x1F, 0xC7, 0x9E, 0x0F, 0x02, 0x0F, 0x1E, 0x0F,
  0x00, 0x0F, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x0F,
  0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x0F,
  0x00, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0x0E, 0x1E, 0x00, 0xF0, 0x0F, 0x1E,
  0x01, 0xE0, 0x07, 0xFC, 0x01, 0xE0, 0x07, 0xFC, 0x03, 0xC0, 0x03, 0xF8,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0xF0, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0xF8, 0xFD, 0xF0, 0x1E, 0x3F, 0x1F, 0x07, 0xC7, 0xC3, 0xF0, 0xF9, 0xF0,
  0x3F, 0x1E, 0x3E, 0x03, 0xF7, 0xC7, 0xC0, 0x3F, 0xF8, 0xF8, 0x03, 0xFE,
  0x1F, 0x00, 0x3F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF7, 0xE0, 0xFF, 0xF8, 0x7E,
  0x0F, 0xFC, 0x07, 0xE0, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0x9C, 0x03,
  0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF8, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0x03,
  0xC0, 0xBE, 0x38, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x80, 0xF0,
  0xF8, 0x3E, 0x1F, 0x01, 0x81, 0x80, 0x10, 0x20, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x79, 0xF3, 0xE7, 0xCF, 0x1E, 0x78, 0xF1,
  0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x73, 0xEF, 0xFF, 0xFF,
  0xE2, 0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xBF, 0x83, 0xE0, 0xFC, 0x7C, 0x07, 0xC7,
  0xC0, 0x3C, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80,
  0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x7C,
  0x03, 0xC7, 0xC0, 0x7C, 0x3E, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF1,
  0xFF, 0x9F, 0xFD, 0xFB, 0xFF, 0x9F, 0x78, 0xF9, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x40, 0x01,
  0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xF3, 0xF8, 0xF0, 0x1F, 0x8C,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xF3, 0xFC, 0xE0, 0x0F, 0x88, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x3F, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00,
  0xFD, 0xFD, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0,
  0x07, 0x9F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x1E,
  0x1F, 0x00, 0xF0, 0x7C, 0x07, 0x81, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1F,
  0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x10, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x70, 0x07, 0xEF, 0xFF, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xF0, 0xC1, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x9F, 0xE0, 0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0x9F, 0xCF, 0xE0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1E,
  0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8,
  0x3F, 0x0F, 0xC7, 0xC0, 0x7C, 0x7C, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x03,
  0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xC7, 0xC0, 0x7C, 0x3E, 0x0F, 0x81, 0xF9,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xBF, 0x83, 0xE0, 0xFC, 0x7C, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x01, 0xEF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3E,
  0xFC, 0x03, 0xE7, 0xF0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xFB,
  0xF8, 0xF8, 0x1F, 0x9E, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0x7C, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xF7, 0x8F, 0xFC,
  0xF0, 0xFF, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x67, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x33, 0xEF, 0xFF, 0xFF,
  0xE3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xFB,
  0xFF, 0xFF, 0xF8, 0x80, 0x0C, 0x3E, 0x3F, 0x3F, 0x3F, 0x3E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0xC0,
  0x0F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE7, 0xF1, 0x80, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0xE0, 0x1E, 0x3C,
  0x07, 0xFF, 0x0E, 0x3C, 0x0F, 0xFF, 0x0F, 0x78, 0x1F, 0x9F, 0x0F, 0x78,
  0x3C, 0x0E, 0x07, 0x78, 0x7C, 0x0E, 0x07, 0x70, 0x78, 0x0E, 0x07, 0x70,
  0x78, 0x0E, 0x07, 0xF0, 0x78, 0x1E, 0x07, 0xF0, 0x70, 0x1E, 0x07, 0xF0,
  0x70, 0x1E, 0x07, 0xF0, 0x70, 0x1E, 0x07, 0xF0, 0x70, 0x1E, 0x0F, 0xF0,
  0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x3E, 0x0E, 0x70, 0x3C, 0x77, 0x1E, 0x78,
  0x3F, 0xF7, 0xFC, 0x78, 0x1F, 0xE3, 0xF8, 0x78, 0x07, 0x81, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x80, 0x07, 0xFE, 0x3F, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x7E, 0x7C, 0x01, 0xF3, 0xE0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x79,
  0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC7, 0xC0, 0x7F, 0x3E, 0x00, 0xFD, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xEF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0x00, 0x61,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xE0, 0x08, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xFF, 0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0x80, 0xFF, 0x1F, 0x00, 0x7F, 0x3E, 0x00, 0x7E, 0x7C, 0x00,
  0x7E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8,
  0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x0C,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x1F, 0xC0, 0x1F, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xF8, 0xFF, 0xFF, 0xBF, 0xE7, 0xF8, 0x7C, 0x00, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x01, 0xF8, 0xF8, 0x07, 0xC3,
  0xE0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE1,
  0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFB, 0xE0, 0x0F,
  0xCF, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBE,
  0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x78, 0x00, 0x7B, 0xFD, 0xE0, 0x01, 0xEF,
  0xF7, 0x80, 0x07, 0xBF, 0xDF, 0x00, 0x3C, 0xFF, 0x3C, 0x00, 0xF3, 0xFC,
  0xF0, 0x03, 0xCF, 0xF3, 0xE0, 0x1E, 0x3F, 0xC7, 0x80, 0x78, 0xFF, 0x1E,
  0x01, 0xE3, 0xFC, 0x7C, 0x0F, 0x0F, 0xF0, 0xF0, 0x3C, 0x3F, 0xC3, 0xC0,
  0xF0, 0xFF, 0x0F, 0x87, 0x83, 0xFC, 0x1E, 0x1E, 0x0F, 0xF0, 0x78, 0x78,
  0x3F, 0xC1, 0xF3, 0xC0, 0xFF, 0x03, 0xCF, 0x03, 0xFC, 0x0F, 0x3C, 0x0F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x00,
  0xF8, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x0F, 0xF7, 0xC0, 0x0F, 0xF7, 0xC0, 0x0F, 0xF3, 0xE0, 0x0F,
  0xF3, 0xE0, 0x0F, 0xF1, 0xF0, 0x0F, 0xF1, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F,
  0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F,
  0xF0, 0x1F, 0x0F, 0xF0, 0x1F, 0x0F, 0xF0, 0x0F, 0x8F, 0xF0, 0x0F, 0xCF,
  0xF0, 0x07, 0xCF, 0xF0, 0x03, 0xEF, 0xF0, 0x03, 0xEF, 0xF0, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0x80, 0x7E, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x3E, 0x0F, 0xC0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x81, 0xFD, 0xF0, 0x0F,
  0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xBE, 0x03, 0xF7, 0xC1, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE0,
  0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x0F,
  0xC1, 0xFC, 0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0xFC, 0x7C, 0x03,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x7F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x60, 0x00,
  0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFC, 0x03, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x40, 0x03, 0xEE, 0x00, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x80, 0x7E, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0xBC,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x3C,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0xF8, 0x00, 0xF9, 0xF0, 0x03,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0xE0, 0x07,
  0x87, 0x80, 0x1F, 0xC0, 0x1F, 0x0F, 0x80, 0x7F, 0x80, 0x3E, 0x1F, 0x00,
  0xF7, 0x80, 0x7C, 0x3E, 0x01, 0xEF, 0x00, 0xF0, 0x3C, 0x03, 0xDE, 0x01,
  0xE0, 0x78, 0x0F, 0x3C, 0x07, 0xC0, 0xF8, 0x1E, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x78, 0x1F, 0x01, 0xE0, 0x78, 0xF0, 0x3C, 0x03, 0xC1, 0xF1, 0xE0,
  0xF8, 0x07, 0xC3, 0xC3, 0xE1, 0xF0, 0x0F, 0x87, 0x83, 0xC3, 0xE0, 0x1F,
  0x0F, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x1F,
  0x3E, 0x00, 0x7C, 0xF0, 0x1E, 0x7C, 0x00, 0xF9, 0xE0, 0x3C, 0xF0, 0x00,
  0xF7, 0xC0, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0x03, 0xDE, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0,
  0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0,
  0x0F, 0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xE0, 0x0F, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x78, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0xF1, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1C, 0x0F, 0xC4,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0xDF, 0xF0, 0xF7, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF,
  0x0F, 0xF7, 0xFF, 0xBC, 0xFF, 0xCF, 0x1F, 0xE1, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83, 0x80, 0xF9, 0xFF,
  0x0F, 0xBF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF0, 0xFE, 0xFE, 0x03, 0xEF, 0xC0,
  0x3E, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0xE0, 0x7E,
  0xFF, 0x8F, 0xCF, 0xFF, 0xFC, 0xF3, 0xFF, 0x8F, 0x0F, 0xE0, 0x00, 0xF8,
  0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xF8, 0x71, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x11, 0xFE, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x1C, 0x0F, 0x07, 0xF8, 0xF1, 0xFF, 0xCF, 0x1F, 0xFE,
  0xF3, 0xF0, 0xFF, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0x9F, 0xF1, 0xFF, 0xEF,
  0x0F, 0xFC, 0xF0, 0x7F, 0x8F, 0x00, 0x70, 0x00, 0xFF, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC3, 0xF0, 0xFC, 0x7C, 0x0F, 0x9F, 0x00, 0xFB, 0xC0, 0x1F,
  0x78, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x04, 0x7F, 0x8F, 0x87, 0xFF, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7E,
  0x60, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x01,
  0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x83, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x7F, 0x8F, 0x1F, 0xFC, 0xF1, 0xFF, 0xEF, 0x3F, 0x0F, 0xF7, 0xE0, 0x3F,
  0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x3E,
  0x03, 0xF3, 0xF9, 0xFF, 0x1F, 0xFE, 0xF0, 0xFF, 0xCF, 0x07, 0xF8, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x20, 0x03, 0xE3, 0xC0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x07, 0x83, 0xE7, 0xFC, 0x7D, 0xFF, 0xCF, 0xFF, 0xFD, 0xFF, 0x1F,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3C,
  0x27, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x01,
  0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x8F, 0xFF, 0xEF, 0xFB, 0xFC, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xEF, 0x80,
  0x7C, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8,
  0x7C, 0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xEF, 0x80, 0xFC, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F,
  0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0xF1, 0xFF,
  0x07, 0xFC, 0xF3, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0x0F,
  0xFC, 0x7F, 0xFE, 0x07, 0xF0, 0x1F, 0xFC, 0x03, 0xF0, 0x1F, 0xFC, 0x03,
  0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03,
  0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03,
  0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03,
  0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03,
  0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03,
  0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x1E, 0x3F, 0xE3, 0xCF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF8, 0xFF, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F,
  0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x00, 0xF7, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF3, 0xC0, 0x07, 0x9F, 0x00, 0x7C,
  0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0xC7, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFE, 0x00, 0x00, 0x38, 0x0F, 0x1F, 0xF0, 0xF3, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0x0F, 0xEF, 0xE0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3E, 0xFE, 0x07, 0xEF, 0xFD, 0xFC, 0xFF,
  0xFF, 0xCF, 0xBF, 0xF8, 0xF8, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x7F, 0x8F, 0x1F, 0xFC, 0xF1, 0xFF, 0xEF, 0x3F, 0x0F, 0xF7, 0xE0,
  0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F,
  0x7E, 0x03, 0xF3, 0xF9, 0xFF, 0x1F, 0xFE, 0xF0, 0xFF, 0xCF, 0x07, 0xF8,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3B, 0xC3, 0xFF, 0x1F, 0xFC, 0xFE, 0xFF,
  0xFB, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00,
  0x01, 0xC0, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0xFC, 0x1C, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xF8, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC,
  0x7F, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x07, 0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01,
  0xFC, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xBE, 0x07, 0xF7, 0xFF, 0xFE, 0x7F, 0xFB, 0xCF,
  0xFE, 0x78, 0x7F, 0x8F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x83, 0xC0,
  0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC1, 0xF0, 0x1E, 0x0F, 0x00,
  0xF8, 0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF9, 0xE0, 0x03, 0xDF,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xBE,
  0x01, 0xF8, 0x07, 0x9F, 0x01, 0xFC, 0x03, 0xCF, 0x80, 0xFE, 0x03, 0xE3,
  0xC0, 0x7F, 0x01, 0xF1, 0xE0, 0x3B, 0xC0, 0xF0, 0xF8, 0x3D, 0xE0, 0x78,
  0x7C, 0x1E, 0xF0, 0x7C, 0x1E, 0x0F, 0x3C, 0x3E, 0x0F, 0x07, 0x1E, 0x1E,
  0x07, 0xC7, 0x8F, 0x0F, 0x03, 0xE3, 0xC7, 0x8F, 0x80, 0xF1, 0xE1, 0xE7,
  0xC0, 0x78, 0xE0, 0xF3, 0xC0, 0x3E, 0xF0, 0x79, 0xE0, 0x1F, 0x78, 0x3C,
  0xF0, 0x07, 0xBC, 0x0E, 0xF8, 0x03, 0xDC, 0x07, 0xF8, 0x01, 0xEE, 0x03,
  0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF7, 0xC0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0x81, 0xF0,
  0xF0, 0x0F, 0x9F, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0x9F, 0x00, 0xF1, 0xF0, 0x1F, 0x0F, 0x83, 0xE0, 0x7C,
  0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0x83, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x78, 0x1E,
  0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC7, 0xC0, 0x1F,
  0x3E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x81, 0xFE, 0x0F, 0xF0, 0x3E, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFF,
  0x01, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F,
  0xE0, 0x3F, 0xC0, 0x1F, 0x03, 0xFC, 0x1F, 0xC0, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x17, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Medium45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 33, 12, 3, -32 },
  { 26, 13, 11, 19, 3, -32 },
  { 44, 24, 32, 26, 1, -32 },
  { 140, 19, 37, 24, 2, -34 },
  { 228, 32, 33, 36, 2, -33 },
  { 360, 27, 33, 29, 2, -33 },
  { 472, 5, 11, 10, 3, -32 },
  { 479, 11, 39, 14, 2, -32 },
  { 533, 11, 39, 14, 1, -32 },
  { 587, 19, 19, 22, 2, -34 },
  { 633, 20, 22, 24, 2, -27 },
  { 688, 7, 11, 12, 2, -5 },
  { 698, 11, 4, 14, 1, -14 },
  { 704, 6, 7, 12, 3, -6 },
  { 710, 16, 32, 17, 1, -32 },
  { 774, 20, 33, 24, 2, -33 },
  { 857, 13, 32, 24, 3, -32 },
  { 909, 19, 33, 24, 2, -33 },
  { 988, 19, 33, 24, 2, -33 },
  { 1067, 22, 32, 24, 1, -32 },
  { 1155, 19, 32, 24, 2, -32 },
  { 1231, 20, 33, 24, 2, -33 },
  { 1314, 20, 32, 24, 2, -32 },
  { 1394, 20, 33, 24, 2, -33 },
  { 1477, 19, 33, 24, 2, -33 },
  { 1556, 6, 26, 12, 3, -25 },
  { 1576, 8, 31, 12, 1, -25 },
  { 1607, 20, 22, 24, 2, -27 },
  { 1662, 20, 13, 24, 2, -22 },
  { 1695, 20, 22, 24, 2, -27 },
  { 1750, 17, 34, 18, 0, -33 },
  { 1823, 32, 36, 37, 2, -32 },
  { 1967, 26, 32, 26, 0, -32 },
  { 2071, 21, 32, 27, 4, -32 },
  { 2155, 22, 33, 26, 2, -33 },
  { 2246, 23, 32, 30, 4, -32 },
  { 2338, 16, 32, 23, 4, -32 },
  { 2402, 16, 32, 22, 4, -32 },
  { 2466, 24, 33, 30, 3, -33 },
  { 2565, 23, 32, 30, 4, -32 },
  { 2657, 11, 32, 15, 2, -32 },
  { 2701, 11, 41, 12, -3, -32 },
  { 2758, 22, 32, 26, 4, -32 },
  { 2846, 16, 32, 22, 4, -32 },
  { 2910, 30, 32, 38, 4, -32 },
  { 3030, 24, 32, 32, 4, -32 },
  { 3126, 27, 33, 32, 2, -33 },
  { 3238, 19, 32, 25, 4, -32 },
  { 3314, 27, 41, 32, 2, -33 },
  { 3453, 21, 32, 26, 4, -32 },
  { 3537, 19, 33, 23, 2, -33 },
  { 3616, 21, 32, 23, 1, -32 },
  { 3700, 22, 32, 30, 4, -32 },
  { 3788, 25, 32, 25, 0, -32 },
  { 3888, 39, 32, 39, 0, -32 },
  { 4044, 24, 32, 24, 0, -32 },
  { 4140, 23, 32, 23, 0, -32 },
  { 4232, 20, 32, 23, 1, -32 },
  { 4312, 10, 39, 15, 3, -32 },
  { 4361, 17, 32, 17, 0, -32 },
  { 4429, 10, 39, 15, 1, -32 },
  { 4478, 22, 19, 24, 1, -32 },
  { 4531, 20, 3, 19, 0, 4 },
  { 4539, 10, 7, 13, 2, -34 },
  { 4548, 18, 25, 23, 2, -25 },
  { 4605, 20, 34, 25, 3, -34 },
  { 4690, 17, 25, 20, 2, -25 },
  { 4744, 20, 34, 25, 2, -34 },
  { 4829, 19, 25, 23, 2, -25 },
  { 4889, 15, 34, 15, 1, -34 },
  { 4953, 20, 36, 25, 2, -25 },
  { 5043, 19, 34, 26, 3, -34 },
  { 5124, 5, 34, 11, 3, -34 },
  { 5146, 10, 45, 11, -2, -34 },
  { 5203, 20, 34, 23, 3, -34 },
  { 5288, 5, 34, 11, 3, -34 },
  { 5310, 32, 25, 39, 3, -25 },
  { 5410, 19, 25, 26, 3, -25 },
  { 5470, 21, 25, 25, 2, -25 },
  { 5536, 20, 36, 25, 3, -25 },
  { 5626, 20, 36, 25, 2, -25 },
  { 5716, 14, 25, 17, 3, -25 },
  { 5760, 16, 25, 20, 2, -25 },
  { 5810, 14, 30, 16, 1, -30 },
  { 5863, 19, 24, 26, 3, -24 },
  { 5920, 21, 24, 21, 0, -24 },
  { 5983, 33, 24, 33, 0, -24 },
  { 6082, 20, 24, 22, 1, -24 },
  { 6142, 21, 35, 22, 0, -24 },
  { 6234, 17, 24, 19, 1, -24 },
  { 6285, 14, 39, 17, 1, -32 },
  { 6354, 4, 45, 23, 9, -34 },
  { 6377, 14, 39, 17, 2, -32 },
  { 6446, 20, 6, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Medium45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium45pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM45PT7B_H_
