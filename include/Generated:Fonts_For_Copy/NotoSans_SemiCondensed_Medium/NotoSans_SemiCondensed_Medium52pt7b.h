#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM52PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0x00, 0x00, 0x00, 0x0E, 0x3F, 0xFF, 0xFF, 0xFB, 0xF7, 0xC3, 0x00, 0xFC,
  0x3F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xF8, 0x3E, 0x78, 0x3E, 0x78,
  0x3E, 0x78, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xF8, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0x73, 0xF3,
  0xF1, 0xC0, 0xCF, 0x87, 0x00, 0x3E, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xE1,
  0xC0, 0x0F, 0x87, 0x00, 0x3F, 0x1C, 0x00, 0x7F, 0x70, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1D, 0xFE, 0x00, 0x71, 0xF8, 0x01, 0xC3, 0xF0, 0x07,
  0x07, 0xC0, 0x1C, 0x1F, 0x00, 0x70, 0x7C, 0x01, 0xC3, 0xF8, 0x07, 0x0F,
  0xBE, 0x1C, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x7F, 0xF0, 0x01,
  0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x01, 0xE0,
  0xF0, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x3E, 0x03, 0xC0,
  0x07, 0xC0, 0xF0, 0x3E, 0x00, 0x3C, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x3C,
  0x1F, 0x00, 0x0F, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x0F, 0x0F, 0x80, 0x03,
  0xE0, 0x78, 0x78, 0x00, 0x1F, 0x07, 0xC7, 0xC3, 0xE0, 0x78, 0x3E, 0x3C,
  0x3F, 0xC3, 0xC1, 0xE3, 0xE3, 0xFF, 0x1E, 0x0F, 0x1E, 0x3F, 0xF8, 0xF8,
  0xF9, 0xF3, 0xE3, 0xE3, 0xFF, 0x8F, 0x1F, 0x0F, 0x0F, 0xF8, 0xF8, 0xF0,
  0x7C, 0x3F, 0x87, 0x87, 0x83, 0xE0, 0x70, 0x7C, 0x7C, 0x0F, 0x00, 0x03,
  0xC3, 0xE0, 0x78, 0x00, 0x3E, 0x1F, 0x03, 0xC0, 0x01, 0xE0, 0xF8, 0x1E,
  0x00, 0x0F, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x3E, 0x07, 0x80, 0x07, 0x81,
  0xF0, 0x3C, 0x00, 0x78, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x3C, 0x1F, 0x00,
  0x3E, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x00, 0x3E,
  0x7C, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x1F,
  0xFF, 0x00, 0xFC, 0x3F, 0x9F, 0x80, 0xFC, 0x3F, 0x1F, 0xC0, 0xF8, 0x7E,
  0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xF1, 0xF8, 0xFC, 0x03, 0xF9, 0xF0, 0xFC,
  0x01, 0xFB, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xE0, 0xFC,
  0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0xFF, 0xE0, 0x7F, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x00,
  0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E,
  0x78, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x18, 0x1E, 0x0E, 0xFE, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7,
  0xC0, 0x07, 0xCF, 0x80, 0x3E, 0x3F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF8,
  0x0F, 0x03, 0xC0, 0x0C, 0x0C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xF0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0x80,
  0x3F, 0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3,
  0xF7, 0xDF, 0x9F, 0xFC, 0x7D, 0xE1, 0xF3, 0x07, 0xC8, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F,
  0x00, 0x7E, 0x08, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xC0,
  0x7F, 0x0E, 0x00, 0x7E, 0x10, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0xC0, 0x01, 0xFD, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7E, 0x00,
  0x1F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x0F, 0xC0, 0x0F, 0x87, 0xE0,
  0x07, 0x83, 0xF0, 0x07, 0xC1, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xC0, 0x7E,
  0x03, 0xE0, 0x3F, 0x01, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x07,
  0xE0, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF7,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xB0, 0x01,
  0xFC, 0xF8, 0x1F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x03,
  0x00, 0x3E, 0x3F, 0xE0, 0x7C, 0xFF, 0xE0, 0xFB, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE7, 0xFC, 0x0F, 0xEF, 0xF0, 0x0F, 0xDF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F,
  0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x87,
  0xE0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xF3, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xF9,
  0xFE, 0x0F, 0xC0, 0xFE, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF8,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xF0, 0x7E, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x7C, 0x7C, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0xF8, 0x01, 0xFD, 0xF8, 0x07, 0xFB, 0xF8, 0x1F,
  0xF3, 0xFF, 0xFB, 0xE3, 0xFF, 0xF7, 0xC3, 0xFF, 0xDF, 0x03, 0xFE, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x40, 0x3F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0x9C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7, 0xC2, 0x00, 0x08,
  0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3F, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F,
  0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xC1,
  0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xF0, 0x3F, 0x98, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x00, 0x0F, 0x0F, 0x80, 0x7F, 0xE0, 0x7C, 0x78, 0x0F, 0xFF, 0xC1, 0xE7,
  0xC0, 0xFF, 0xFE, 0x0F, 0x3C, 0x0F, 0xC1, 0xE0, 0x79, 0xE0, 0x7C, 0x0F,
  0x03, 0xFF, 0x07, 0xC0, 0x78, 0x1F, 0xF0, 0x3C, 0x03, 0xC0, 0x7F, 0x81,
  0xE0, 0x1E, 0x03, 0xFC, 0x1F, 0x00, 0xF0, 0x1F, 0xE0, 0xF8, 0x07, 0x80,
  0xFF, 0x07, 0xC0, 0x3C, 0x07, 0xF8, 0x3E, 0x01, 0xE0, 0x7F, 0xC1, 0xF0,
  0x1F, 0x03, 0xDE, 0x0F, 0x80, 0xF8, 0x1E, 0xF0, 0x7C, 0x07, 0xC0, 0xF7,
  0x81, 0xE0, 0x3E, 0x0F, 0xBC, 0x0F, 0x83, 0xF8, 0x79, 0xE0, 0x7F, 0x7F,
  0xEF, 0xCF, 0x81, 0xFF, 0xCF, 0xFC, 0x3C, 0x07, 0xFC, 0x7F, 0xC1, 0xE0,
  0x1F, 0xC0, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x83, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x07, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xC0, 0xF8,
  0x7F, 0x80, 0x08, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x01,
  0x07, 0xFE, 0x1F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xF8, 0x03, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x7C, 0x0F, 0xF0, 0x00,
  0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03,
  0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xE0, 0x03, 0xF0, 0xFF, 0xC0, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0x40, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x83,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x7F, 0xC3, 0xF8, 0x00,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x8F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x81, 0xF0, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x07,
  0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xF3,
  0xF0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF0, 0xFC, 0x01,
  0xF0, 0x7F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0,
  0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x07,
  0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7F, 0x3E, 0x00,
  0x1F, 0x9F, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFD, 0xE0, 0x00, 0x1E, 0xFF,
  0xBE, 0x00, 0x07, 0xDF, 0xF7, 0xC0, 0x00, 0xFB, 0xFE, 0x78, 0x00, 0x1E,
  0x7F, 0xCF, 0x80, 0x07, 0xCF, 0xF9, 0xF0, 0x00, 0xF9, 0xFF, 0x3E, 0x00,
  0x1E, 0x7F, 0xE3, 0xE0, 0x07, 0xCF, 0xFE, 0x7C, 0x00, 0xF9, 0xFF, 0xCF,
  0x80, 0x1E, 0x3F, 0xF8, 0xF8, 0x07, 0xC7, 0xFF, 0x1F, 0x00, 0xF8, 0xFF,
  0xE3, 0xE0, 0x1E, 0x1F, 0xFC, 0x3E, 0x07, 0xC3, 0xFF, 0x87, 0xC0, 0xF8,
  0x7F, 0xF0, 0xF8, 0x1E, 0x0F, 0xFE, 0x0F, 0x87, 0xC1, 0xFF, 0xC1, 0xF0,
  0xF8, 0x3F, 0xF8, 0x3E, 0x1E, 0x07, 0xFF, 0x03, 0xE7, 0xC0, 0xFF, 0xE0,
  0x7C, 0xF8, 0x1F, 0xFC, 0x0F, 0x9E, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xC0,
  0x3F, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xC0, 0x1F, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xF7, 0xE0, 0x03, 0xFE, 0xFC, 0x00, 0x7F, 0xCF, 0xC0, 0x0F,
  0xF8, 0xFC, 0x01, 0xFF, 0x1F, 0x80, 0x3F, 0xE1, 0xF8, 0x07, 0xFC, 0x3F,
  0x00, 0xFF, 0xC3, 0xF0, 0x1F, 0xF8, 0x7E, 0x03, 0xFF, 0x07, 0xE0, 0x7F,
  0xE0, 0xFC, 0x0F, 0xFC, 0x0F, 0xC1, 0xFF, 0x80, 0xFC, 0x3F, 0xF0, 0x1F,
  0x87, 0xFE, 0x01, 0xF8, 0xFF, 0xC0, 0x3F, 0x1F, 0xF8, 0x03, 0xF3, 0xFF,
  0x00, 0x7E, 0x7F, 0xE0, 0x07, 0xEF, 0xFC, 0x00, 0xFD, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x01,
  0xFD, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF0,
  0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xE0, 0x0F, 0xE3, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xE3, 0xF0, 0x03,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xF0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0x07, 0xC7, 0xF0, 0x03, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0xE0, 0x03, 0xFB, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0xE0, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xFB, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x87,
  0xE0, 0x07, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3D, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xEF, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF3, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0x9F, 0x00, 0xFC, 0x07, 0xC0, 0x7C,
  0x78, 0x07, 0xC0, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x1F,
  0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0x83, 0xC0,
  0xF8, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x00, 0x7C, 0x3E, 0x07, 0xC3, 0xF0, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xC0, 0x3E, 0x7E, 0x00, 0x1F, 0xBE, 0x00, 0xF3, 0xE0, 0x00, 0x7D,
  0xF0, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x00, 0x1F, 0x78,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xC0, 0x07, 0xBC, 0x00, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xC0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07,
  0xC3, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0x7C,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x78, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x1E, 0x00, 0xF8, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0x87, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x00, 0x18, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0x01, 0xFC, 0x20, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xDF,
  0x7F, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x7E, 0x07, 0xFB,
  0xFF, 0xFB, 0xCF, 0xFF, 0x9E, 0x7F, 0xF8, 0xF0, 0xFF, 0x87, 0x80, 0x80,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x40, 0x0F,
  0x8F, 0xF8, 0x1F, 0x3F, 0xFC, 0x3E, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0x83, 0xF9, 0xFC, 0x03, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0xC0,
  0x07, 0xDF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFD,
  0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xE7, 0xFC, 0x1F, 0xCF, 0xFF, 0xFF, 0x1F,
  0x7F, 0xFE, 0x3C, 0x7F, 0xF8, 0x78, 0x7F, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x08, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xFC, 0x0C, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x02, 0x1F,
  0xC0, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x20, 0x3F, 0x03, 0xFE, 0x3F, 0x07, 0xFF, 0xBF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xDF, 0x3F, 0x81, 0xFF, 0x3F, 0x00, 0xFF, 0x3F, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x00, 0xFF, 0x3F,
  0x81, 0xFF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x07, 0xFF, 0x1F, 0x03,
  0xFE, 0x1F, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x0F, 0xC0,
  0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01,
  0xFB, 0xE0, 0x01, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x02, 0x1F, 0xC0, 0x38, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3F,
  0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x30, 0x00, 0x03, 0xFE, 0x1F, 0x07, 0xFF, 0x9F, 0x0F,
  0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0xC1, 0xFF, 0x3F, 0x00, 0xFF, 0x3F,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F,
  0x00, 0xFF, 0x3F, 0x81, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x07,
  0xFF, 0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x20, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x30,
  0x00, 0xFC, 0x3E, 0x03, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x02, 0x00, 0xF8, 0x7F, 0xC3, 0xE7, 0xFF, 0x8F, 0xBF, 0xFF, 0x3F, 0xFF,
  0xFE, 0xFF, 0x83, 0xFB, 0xF8, 0x07, 0xEF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x73, 0xEF, 0xFF, 0xFF, 0xE7,
  0x00, 0x00, 0x00, 0x3E, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0x80, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xE0, 0x3E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x8F, 0xEF,
  0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E,
  0x01, 0xF8, 0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F, 0x83, 0xF0, 0x3E, 0x0F,
  0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0xFC, 0x00,
  0xFB, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFE,
  0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F,
  0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8, 0x03, 0xF3,
  0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x18, 0x07, 0x87, 0xFC, 0x07, 0xFC, 0x3C, 0x7F, 0xF8, 0xFF, 0xF1, 0xF7,
  0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0x83, 0xFF, 0x83,
  0xFB, 0xF8, 0x07, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F, 0x80, 0x3F, 0xFC, 0x01,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x7F,
  0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x7C,
  0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0xFC, 0x00,
  0x7C, 0x00, 0x7F, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x07, 0xFE, 0x00, 0x3E,
  0x00, 0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x00, 0x04, 0x03, 0xC3, 0xFF, 0x0F, 0x1F, 0xFE, 0x3E, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xFE, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0xC1, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7E,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0xC1, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x08, 0x01, 0xE1, 0xFF, 0x03, 0xE7, 0xFF, 0x87, 0xDF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xF0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00,
  0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0xFC, 0xFF,
  0x83, 0xF9, 0xFF, 0xFF, 0xE3, 0xEF, 0xFF, 0xC7, 0xCF, 0xFF, 0x0F, 0x8F,
  0xF8, 0x1F, 0x01, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x03, 0xFE, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F,
  0x1F, 0xFF, 0xDF, 0x3F, 0x81, 0xFF, 0x3F, 0x00, 0xFF, 0x3E, 0x00, 0x7F,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x7F, 0x3F, 0x00, 0xFF,
  0x3F, 0x81, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xBF, 0x07, 0xFF, 0x3F,
  0x03, 0xFE, 0x3F, 0x00, 0x20, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x09, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x60,
  0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFC, 0x07,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3E, 0xF0, 0x0F, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC1, 0x0F, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x20, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0x7F, 0xFF, 0x7C, 0xFF, 0xFD, 0xF3, 0xFF, 0xE7, 0xC3, 0xFE,
  0x1F, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x7D, 0xF8, 0x07,
  0xF8, 0x03, 0xE7, 0xC0, 0x3F, 0xC0, 0x1F, 0x3E, 0x01, 0xFF, 0x01, 0xF9,
  0xF0, 0x0F, 0x78, 0x0F, 0x8F, 0xC0, 0xFB, 0xC0, 0x7C, 0x3E, 0x07, 0x9E,
  0x03, 0xE1, 0xF0, 0x3C, 0xF8, 0x3F, 0x0F, 0x81, 0xE7, 0xC1, 0xF0, 0x7E,
  0x1F, 0x1E, 0x0F, 0x81, 0xF0, 0xF8, 0xF0, 0x7C, 0x0F, 0x87, 0x87, 0xC7,
  0xE0, 0x7C, 0x7C, 0x3E, 0x3E, 0x03, 0xF3, 0xE0, 0xF1, 0xF0, 0x0F, 0x9F,
  0x07, 0x8F, 0x80, 0x7C, 0xF0, 0x3E, 0x78, 0x03, 0xE7, 0x81, 0xF7, 0xC0,
  0x1F, 0x7C, 0x07, 0xBE, 0x00, 0x7B, 0xE0, 0x3D, 0xF0, 0x03, 0xFE, 0x01,
  0xEF, 0x00, 0x1F, 0xF0, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xEF, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0x83, 0xF0,
  0x1F, 0x81, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00, 0xFC,
  0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F,
  0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF8, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xBE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x02, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xA0, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 38, 14, 3, -37 },
  { 35, 16, 13, 22, 3, -37 },
  { 61, 28, 37, 30, 1, -37 },
  { 191, 22, 42, 27, 3, -39 },
  { 307, 37, 38, 41, 2, -38 },
  { 483, 32, 39, 34, 2, -38 },
  { 639, 6, 13, 12, 3, -37 },
  { 649, 13, 45, 16, 2, -37 },
  { 723, 13, 45, 16, 1, -37 },
  { 797, 22, 22, 26, 2, -40 },
  { 858, 23, 25, 27, 2, -31 },
  { 930, 8, 13, 13, 2, -6 },
  { 943, 12, 4, 16, 2, -16 },
  { 949, 7, 8, 13, 3, -7 },
  { 956, 18, 37, 20, 1, -37 },
  { 1040, 23, 39, 27, 2, -38 },
  { 1153, 14, 37, 27, 4, -37 },
  { 1218, 23, 38, 27, 2, -38 },
  { 1328, 23, 39, 27, 2, -38 },
  { 1441, 25, 37, 27, 1, -37 },
  { 1557, 22, 38, 27, 3, -37 },
  { 1662, 23, 39, 27, 2, -38 },
  { 1775, 23, 37, 27, 2, -37 },
  { 1882, 23, 39, 27, 2, -38 },
  { 1995, 23, 39, 27, 2, -38 },
  { 2108, 7, 30, 13, 3, -29 },
  { 2135, 8, 36, 14, 2, -29 },
  { 2171, 23, 25, 27, 2, -31 },
  { 2243, 23, 15, 27, 2, -26 },
  { 2287, 23, 25, 27, 2, -31 },
  { 2359, 19, 39, 21, 1, -38 },
  { 2452, 37, 41, 42, 3, -37 },
  { 2642, 31, 37, 31, 0, -37 },
  { 2786, 24, 37, 31, 4, -37 },
  { 2897, 25, 39, 30, 3, -38 },
  { 3019, 27, 37, 34, 4, -37 },
  { 3144, 18, 37, 26, 5, -37 },
  { 3228, 18, 37, 25, 5, -37 },
  { 3312, 28, 39, 34, 3, -38 },
  { 3449, 26, 37, 35, 5, -37 },
  { 3570, 13, 37, 17, 2, -37 },
  { 3631, 13, 47, 14, -3, -37 },
  { 3708, 25, 37, 30, 5, -37 },
  { 3824, 20, 37, 25, 4, -37 },
  { 3917, 35, 37, 44, 5, -37 },
  { 4079, 27, 37, 37, 5, -37 },
  { 4204, 31, 39, 37, 3, -38 },
  { 4356, 23, 37, 29, 4, -37 },
  { 4463, 31, 47, 37, 3, -38 },
  { 4646, 25, 37, 30, 4, -37 },
  { 4762, 22, 39, 26, 2, -38 },
  { 4870, 24, 37, 26, 1, -37 },
  { 4981, 26, 38, 35, 4, -37 },
  { 5105, 29, 37, 29, 0, -37 },
  { 5240, 45, 37, 45, 0, -37 },
  { 5449, 28, 37, 28, 0, -37 },
  { 5579, 27, 37, 27, 0, -37 },
  { 5704, 23, 37, 26, 2, -37 },
  { 5811, 11, 45, 17, 4, -37 },
  { 5873, 18, 37, 20, 1, -37 },
  { 5957, 12, 45, 17, 1, -37 },
  { 6025, 25, 22, 28, 1, -37 },
  { 6094, 23, 3, 22, 0, 5 },
  { 6103, 11, 8, 15, 2, -40 },
  { 6114, 21, 30, 27, 2, -29 },
  { 6193, 23, 41, 29, 4, -40 },
  { 6311, 20, 30, 23, 2, -29 },
  { 6386, 24, 41, 29, 2, -40 },
  { 6509, 23, 30, 27, 2, -29 },
  { 6596, 18, 40, 17, 1, -40 },
  { 6686, 24, 41, 29, 2, -29 },
  { 6809, 22, 40, 30, 4, -40 },
  { 6919, 6, 39, 13, 4, -39 },
  { 6949, 12, 51, 13, -2, -39 },
  { 7026, 22, 40, 27, 4, -40 },
  { 7136, 5, 40, 13, 4, -40 },
  { 7161, 37, 29, 45, 4, -29 },
  { 7296, 22, 29, 30, 4, -29 },
  { 7376, 24, 30, 29, 2, -29 },
  { 7466, 23, 41, 29, 4, -29 },
  { 7584, 24, 41, 29, 2, -29 },
  { 7707, 15, 29, 20, 4, -29 },
  { 7762, 19, 30, 23, 2, -29 },
  { 7834, 16, 35, 18, 1, -34 },
  { 7904, 22, 29, 30, 4, -28 },
  { 7984, 25, 28, 25, 0, -28 },
  { 8072, 37, 28, 39, 1, -28 },
  { 8202, 24, 28, 25, 1, -28 },
  { 8286, 25, 40, 25, 0, -28 },
  { 8411, 18, 28, 22, 2, -28 },
  { 8474, 17, 45, 19, 1, -37 },
  { 8570, 4, 52, 26, 11, -40 },
  { 8596, 16, 45, 19, 2, -37 },
  { 8686, 23, 7, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_Medium52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium52pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM52PT7B_H_
