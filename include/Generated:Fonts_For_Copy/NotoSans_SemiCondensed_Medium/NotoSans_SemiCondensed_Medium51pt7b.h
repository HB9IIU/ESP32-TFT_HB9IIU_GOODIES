#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x00,
  0x00, 0x00, 0x02, 0x1F, 0x7F, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xFC, 0x3F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0xBC,
  0x1F, 0x78, 0x3E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC0, 0xE7, 0x81, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xF3, 0x87, 0x3E, 0x1C, 0x09, 0xF0, 0xE0,
  0x0F, 0x87, 0x00, 0x7C, 0x38, 0x03, 0xE1, 0xC0, 0x1F, 0x8E, 0x00, 0xFE,
  0x70, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x73, 0xF8, 0x03,
  0x8F, 0xC0, 0x1C, 0x3E, 0x00, 0xE1, 0xF0, 0x07, 0x0F, 0x80, 0x38, 0x7E,
  0x01, 0xC7, 0xFE, 0x0E, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0xF0, 0x00, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x3E, 0x00, 0x78,
  0x3C, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x3C, 0x00, 0xF0, 0x3E, 0x07, 0x80,
  0x0F, 0x03, 0xE0, 0x78, 0x00, 0xF0, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xE0,
  0xF0, 0x00, 0xF0, 0x3E, 0x1E, 0x00, 0x0F, 0x03, 0xE1, 0xE0, 0x00, 0xF0,
  0x3E, 0x3C, 0x00, 0x0F, 0x83, 0xC3, 0xC3, 0xF0, 0x78, 0x3C, 0x78, 0xFF,
  0xC7, 0x83, 0xC7, 0x8F, 0xFC, 0x7C, 0x7C, 0xF9, 0xF3, 0xE3, 0xFF, 0x8F,
  0x1E, 0x1E, 0x3F, 0xF1, 0xF3, 0xE1, 0xF1, 0xFE, 0x1E, 0x3C, 0x0F, 0x07,
  0xC3, 0xE3, 0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x07, 0xC3, 0xC0,
  0xF0, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x0F, 0x00,
  0x3E, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x01, 0xE1,
  0xE0, 0x07, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0x00,
  0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFC,
  0x7F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x07,
  0xC1, 0xFB, 0xF0, 0x0F, 0x87, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0x7C,
  0x3E, 0x03, 0xF0, 0xF8, 0xFC, 0x03, 0xF3, 0xF1, 0xF8, 0x07, 0xF7, 0xC3,
  0xF0, 0x07, 0xFF, 0x87, 0xE0, 0x07, 0xFE, 0x0F, 0xC0, 0x07, 0xFC, 0x1F,
  0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0xE0, 0x7F,
  0x83, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xE0, 0x7F, 0xF0, 0x0F, 0xE0, 0x06, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0xF0, 0x1F,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x08, 0x07, 0x80, 0xBE, 0x1C, 0x1E, 0xFF,
  0x77, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF9, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F, 0x80,
  0x3E, 0x3F, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x07, 0x03, 0x00, 0x08,
  0x08, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0x08, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0x80,
  0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x1F,
  0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xF9, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x8F, 0xC0, 0x7C, 0x1F, 0x87, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF7, 0xF7,
  0xFF, 0x9F, 0xFC, 0x7D, 0xC1, 0xF2, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x01, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xF8, 0x0F, 0xC3, 0x80, 0x1F, 0x84, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xF0,
  0x0F, 0xE3, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x7E, 0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x0F,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07,
  0xC0, 0xF8, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x78, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x08, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFA, 0x00, 0x1F, 0xDE,
  0x03, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xE0, 0x3E,
  0x7F, 0xF0, 0x79, 0xFF, 0xF1, 0xF7, 0xFF, 0xE3, 0xFF, 0x0F, 0xE7, 0xF8,
  0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7E, 0x00,
  0x3E, 0xFC, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x80, 0xFC,
  0x1F, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFC, 0x7F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xF0, 0x07,
  0xC3, 0xE0, 0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xF1, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFE, 0x01,
  0xFD, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7C,
  0x00, 0xFD, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xBF, 0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7F, 0x01,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F,
  0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0x7C, 0x00, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0x7C, 0x7F, 0xFD, 0xF0, 0x7F, 0xC7, 0xC0, 0x3C, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0C, 0x00,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFB, 0xE1, 0x00, 0x1E, 0x3E, 0x7F, 0x7F, 0x7F, 0x3F, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0,
  0xF0, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDC, 0x03, 0xF4, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0xFC, 0x03, 0xE3, 0xC0, 0x3F, 0xFC,
  0x1E, 0x7C, 0x0F, 0xFF, 0xC1, 0xE7, 0x80, 0xFF, 0xFC, 0x1E, 0x78, 0x1F,
  0x03, 0xC0, 0xFF, 0x83, 0xE0, 0x3C, 0x0F, 0xF0, 0x3C, 0x07, 0xC0, 0xFF,
  0x07, 0xC0, 0x7C, 0x0F, 0xF0, 0x7C, 0x07, 0xC0, 0xFF, 0x07, 0x80, 0x7C,
  0x0F, 0xF0, 0x78, 0x07, 0xC0, 0xFF, 0x07, 0x80, 0x7C, 0x0F, 0xF0, 0x78,
  0x07, 0xC0, 0xFF, 0x07, 0x80, 0x78, 0x1F, 0xF0, 0x7C, 0x07, 0x81, 0xEF,
  0x07, 0xC0, 0xFC, 0x1E, 0xF0, 0x3C, 0x0F, 0xC3, 0xCF, 0x03, 0xF3, 0xDE,
  0x7C, 0xF8, 0x1F, 0xFD, 0xFF, 0x8F, 0x81, 0xFF, 0x8F, 0xF0, 0x78, 0x07,
  0xF0, 0x7E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C,
  0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFC, 0xFC, 0x00,
  0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00,
  0xFC, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0x80, 0x70, 0x7F, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x02, 0x0F,
  0xF8, 0x1E, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xC0, 0x7F, 0xE1, 0xF8,
  0x01, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x1F,
  0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xFE, 0x3F,
  0x00, 0x7F, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xE0, 0x07, 0x87, 0xF8, 0x00, 0x20,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0xF8, 0xFF, 0x00, 0x1F,
  0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7F, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF7,
  0xFF, 0x3F, 0xF9, 0xFF, 0x8F, 0xF8, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xF3,
  0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xDF, 0x00,
  0x03, 0xDF, 0xFB, 0xE0, 0x00, 0xFB, 0xFF, 0x7C, 0x00, 0x1F, 0x7F, 0xE7,
  0xC0, 0x03, 0xCF, 0xFC, 0xF8, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x1F, 0x3F,
  0xF1, 0xF0, 0x03, 0xC7, 0xFE, 0x3E, 0x00, 0xF8, 0xFF, 0xC7, 0xC0, 0x1F,
  0x1F, 0xF8, 0x7C, 0x03, 0xC3, 0xFF, 0x0F, 0x80, 0xF8, 0x7F, 0xE1, 0xF0,
  0x1F, 0x0F, 0xFC, 0x1F, 0x03, 0xC1, 0xFF, 0x83, 0xE0, 0xF8, 0x3F, 0xF0,
  0x7C, 0x1F, 0x07, 0xFE, 0x07, 0x83, 0xC0, 0xFF, 0xC0, 0xF8, 0xF8, 0x1F,
  0xF8, 0x1F, 0x1F, 0x03, 0xFF, 0x01, 0xE3, 0xC0, 0x7F, 0xE0, 0x3E, 0xF8,
  0x0F, 0xFC, 0x07, 0xDF, 0x01, 0xFF, 0x80, 0x7B, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8,
  0x03, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F,
  0xFC, 0x00, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xF0, 0x01,
  0xFF, 0x9F, 0x00, 0x1F, 0xF9, 0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x1F, 0xF8,
  0xFC, 0x01, 0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x7E, 0x01, 0xFF, 0x83, 0xF0,
  0x1F, 0xF8, 0x3F, 0x01, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xFF,
  0x80, 0xFC, 0x1F, 0xF8, 0x07, 0xC1, 0xFF, 0x80, 0x7E, 0x1F, 0xF8, 0x03,
  0xF1, 0xFF, 0x80, 0x3F, 0x1F, 0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x1F, 0x9F,
  0xF8, 0x00, 0xFD, 0xFF, 0x80, 0x0F, 0xDF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xF8, 0x00,
  0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFC, 0x0F, 0xFB,
  0xF0, 0x0F, 0xEF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x81,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x03,
  0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1B, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xC0, 0xFF, 0x87, 0xE0, 0x0F,
  0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07,
  0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF,
  0x1F, 0x80, 0x79, 0xF8, 0x00, 0x8F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC,
  0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xE0,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF0, 0xFF, 0x03, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7C,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC1,
  0xF0, 0x07, 0xBE, 0x00, 0xF8, 0x1F, 0x00, 0x79, 0xE0, 0x0F, 0x81, 0xF0,
  0x0F, 0x9F, 0x00, 0xF8, 0x1F, 0x80, 0xF9, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0x9F, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x00, 0x7C, 0x3E, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x03,
  0xE3, 0xC0, 0x3C, 0x7C, 0x00, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0x80,
  0x1E, 0xF8, 0x00, 0x1F, 0x78, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xF8, 0x7C,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x01, 0xF0, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xCF,
  0x80, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xC0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0x3E,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7C,
  0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3F,
  0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x78,
  0x1F, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x87, 0x80, 0x03, 0xC7,
  0xC0, 0x01, 0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xF0, 0x7F, 0x06, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xF0,
  0x1F, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xF7, 0xCF, 0xFF, 0x1E, 0x1F, 0xF0, 0xF0, 0x18, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0xC0, 0xF9, 0xFF, 0xC3,
  0xEF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xF3, 0xFC, 0xFE, 0x03, 0xFB, 0xF8,
  0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFB, 0xF8, 0x07, 0xEF, 0xF0, 0x3F,
  0xBF, 0xFF, 0xFC, 0xF3, 0xFF, 0xE3, 0xC7, 0xFF, 0x0F, 0x0F, 0xF8, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0x7C, 0x7F, 0x00, 0x8F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x09, 0xFE, 0x07, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0xE1, 0xF0, 0x7F, 0xF3,
  0xE1, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0x3F, 0x01, 0xFE,
  0x7E, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x01,
  0xFC, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFB, 0xE0, 0xFF, 0xE3,
  0xC0, 0xFF, 0x87, 0x80, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xC3, 0xF0, 0xFC, 0x07, 0xE3, 0xE0,
  0x0F, 0x9F, 0x80, 0x3F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x87, 0xF0, 0x0E,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0x30, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x07, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x3C, 0x3F, 0xFE, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFE, 0xFF, 0xE7, 0xE0, 0x3F, 0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xE0,
  0x07, 0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0xC0, 0xFF, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0x7C, 0x1F, 0xFC, 0xF8, 0x1F, 0xF1, 0xF0, 0x06, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0xC0, 0x03, 0xF1, 0xF0, 0x3F, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0xFE, 0x0F, 0x9F, 0xFC, 0x7D, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF,
  0xFD, 0xFE, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xE0, 0x39, 0xFF, 0xFF, 0x7D, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF0, 0x01, 0xC0, 0x7C, 0x1F,
  0x83, 0xF0, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7F, 0x1F, 0xFF,
  0xF7, 0xFE, 0xFF, 0x9F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x02, 0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x03,
  0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00,
  0xF8, 0xFC, 0x03, 0xE7, 0xE0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0x9F, 0x00, 0xFC, 0x7E,
  0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0xC3,
  0xE0, 0x3F, 0x0F, 0x80, 0x7E, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xE0,
  0x07, 0xEF, 0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x0F, 0x1F,
  0xFC, 0x3F, 0xF8, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xCF, 0xFF, 0x9F, 0xEF, 0xE0, 0x3F, 0xE0, 0x7F, 0xFE, 0x01, 0xFC,
  0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F,
  0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F,
  0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x7F, 0x07, 0x8F, 0xFE, 0x3C, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFC,
  0xFF, 0x7F, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0xE7, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F,
  0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x03, 0xC7, 0xFF, 0x0F, 0x3F,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xCF, 0xF3, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F,
  0xBF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xE0, 0x1F, 0xBF, 0xC0, 0xFE, 0xFF,
  0xFF, 0xF3, 0xEF, 0xFF, 0x8F, 0x9F, 0xFC, 0x3E, 0x3F, 0xE0, 0xF8, 0x08,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFE,
  0x3C, 0x3F, 0xFE, 0xF8, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F, 0xE7, 0xE0, 0x3F,
  0xCF, 0xC0, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x9F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0x7C, 0x1F, 0xFC,
  0xF8, 0x1F, 0xF1, 0xF0, 0x06, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x3F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x7F, 0xDF,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xE3,
  0xFF, 0xFD, 0xFF, 0xFE, 0x7E, 0x0F, 0xBF, 0x00, 0x4F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x80,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x87,
  0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFE,
  0x79, 0xFF, 0xE3, 0xC3, 0xFE, 0x1E, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E,
  0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x00, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0,
  0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x3F,
  0x7C, 0x03, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0xC0, 0x3E, 0x7C, 0x07, 0xFC,
  0x03, 0xE7, 0xC0, 0x7B, 0xE0, 0x7C, 0x3E, 0x07, 0x9E, 0x07, 0xC3, 0xE0,
  0x79, 0xE0, 0x7C, 0x3E, 0x0F, 0x9E, 0x07, 0xC3, 0xE0, 0xF9, 0xF0, 0xF8,
  0x1F, 0x0F, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F,
  0x0F, 0x81, 0xF1, 0xF0, 0xF9, 0xF0, 0x0F, 0x9E, 0x0F, 0x9F, 0x00, 0xF9,
  0xE0, 0x79, 0xF0, 0x0F, 0xBE, 0x07, 0x9F, 0x00, 0xFB, 0xE0, 0x79, 0xE0,
  0x07, 0xBC, 0x07, 0xFE, 0x00, 0x7B, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0xF8, 0x0F, 0x81,
  0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xF1, 0xF8, 0x03, 0xE7, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x0F, 0xDF, 0x00, 0x1F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xF8, 0x3E,
  0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0,
  0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE7, 0xC0,
  0x01, 0xF7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0x06, 0x00, 0x02, 0x7F, 0xC0, 0x0D, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xA0, 0x03, 0xFE, 0x40, 0x00,
  0x40,
};

const GFXglyph NotoSans_SemiCondensed_Medium51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 37, 13, 3, -36 },
  { 34, 15, 13, 21, 3, -36 },
  { 59, 28, 36, 30, 1, -36 },
  { 185, 21, 42, 27, 3, -39 },
  { 296, 36, 37, 41, 2, -37 },
  { 463, 31, 38, 33, 2, -37 },
  { 611, 6, 13, 12, 3, -36 },
  { 621, 12, 45, 16, 2, -37 },
  { 689, 12, 45, 16, 1, -37 },
  { 757, 22, 22, 25, 2, -39 },
  { 818, 23, 24, 27, 2, -30 },
  { 887, 8, 13, 13, 2, -6 },
  { 900, 12, 5, 16, 2, -16 },
  { 908, 7, 8, 13, 3, -7 },
  { 915, 18, 37, 20, 1, -37 },
  { 999, 22, 38, 27, 2, -37 },
  { 1104, 14, 36, 27, 4, -36 },
  { 1167, 22, 37, 27, 2, -37 },
  { 1269, 22, 38, 27, 2, -37 },
  { 1374, 25, 37, 27, 1, -37 },
  { 1490, 21, 37, 27, 3, -36 },
  { 1588, 23, 38, 27, 2, -37 },
  { 1698, 23, 36, 27, 2, -36 },
  { 1802, 23, 38, 27, 2, -37 },
  { 1912, 22, 38, 27, 2, -37 },
  { 2017, 7, 29, 13, 3, -28 },
  { 2043, 8, 35, 13, 2, -28 },
  { 2078, 23, 25, 27, 2, -31 },
  { 2150, 22, 14, 27, 2, -25 },
  { 2189, 23, 25, 27, 2, -31 },
  { 2261, 18, 38, 21, 1, -37 },
  { 2347, 36, 41, 42, 3, -37 },
  { 2532, 30, 37, 30, 0, -37 },
  { 2671, 24, 36, 30, 4, -36 },
  { 2779, 25, 38, 29, 3, -37 },
  { 2898, 27, 36, 34, 4, -36 },
  { 3020, 19, 36, 26, 4, -36 },
  { 3106, 19, 36, 24, 4, -36 },
  { 3192, 27, 38, 34, 3, -37 },
  { 3321, 26, 36, 34, 4, -36 },
  { 3438, 13, 36, 17, 2, -36 },
  { 3497, 13, 46, 14, -3, -36 },
  { 3572, 25, 36, 29, 4, -36 },
  { 3685, 19, 36, 24, 4, -36 },
  { 3771, 35, 36, 43, 4, -36 },
  { 3929, 28, 36, 36, 4, -36 },
  { 4055, 30, 38, 36, 3, -37 },
  { 4198, 22, 36, 28, 4, -36 },
  { 4297, 30, 46, 36, 3, -37 },
  { 4470, 25, 36, 29, 4, -36 },
  { 4583, 21, 38, 26, 2, -37 },
  { 4683, 24, 36, 26, 1, -36 },
  { 4791, 26, 37, 34, 4, -36 },
  { 4912, 28, 36, 28, 0, -36 },
  { 5038, 44, 36, 44, 0, -36 },
  { 5236, 27, 36, 28, 0, -36 },
  { 5358, 27, 36, 27, 0, -36 },
  { 5480, 22, 36, 26, 2, -36 },
  { 5579, 11, 45, 16, 4, -37 },
  { 5641, 18, 37, 20, 1, -37 },
  { 5725, 12, 45, 16, 1, -37 },
  { 5793, 25, 23, 27, 1, -37 },
  { 5865, 22, 4, 22, 0, 4 },
  { 5876, 11, 8, 15, 2, -39 },
  { 5887, 21, 29, 27, 2, -28 },
  { 5964, 22, 40, 29, 4, -39 },
  { 6074, 19, 29, 23, 2, -28 },
  { 6143, 23, 40, 29, 2, -39 },
  { 6258, 22, 29, 27, 2, -28 },
  { 6338, 17, 39, 17, 1, -39 },
  { 6421, 23, 40, 29, 2, -28 },
  { 6536, 21, 39, 29, 4, -39 },
  { 6639, 6, 38, 13, 3, -38 },
  { 6668, 11, 50, 13, -2, -38 },
  { 6737, 22, 39, 26, 4, -39 },
  { 6845, 5, 39, 13, 4, -39 },
  { 6870, 36, 28, 44, 4, -28 },
  { 6996, 21, 28, 29, 4, -28 },
  { 7070, 24, 29, 28, 2, -28 },
  { 7157, 22, 40, 29, 4, -28 },
  { 7267, 23, 40, 29, 2, -28 },
  { 7382, 15, 28, 20, 4, -28 },
  { 7435, 18, 29, 22, 2, -28 },
  { 7501, 15, 35, 18, 1, -34 },
  { 7567, 21, 28, 29, 4, -27 },
  { 7641, 24, 27, 24, 0, -27 },
  { 7722, 36, 28, 38, 1, -28 },
  { 7848, 23, 27, 25, 1, -27 },
  { 7926, 24, 39, 24, 0, -27 },
  { 8043, 18, 27, 21, 2, -27 },
  { 8104, 16, 44, 19, 1, -36 },
  { 8192, 4, 51, 26, 11, -39 },
  { 8218, 16, 44, 19, 2, -36 },
  { 8306, 23, 8, 27, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_Medium51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM51PT7B_H_
