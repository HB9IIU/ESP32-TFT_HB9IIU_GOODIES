#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium65pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE3,
  0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xF3, 0xF8, 0x70, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xE0,
  0x3F, 0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xF8, 0xF0, 0x78,
  0x7F, 0x0F, 0x00, 0x87, 0xE0, 0xF0, 0x00, 0xFE, 0x0F, 0x00, 0x0F, 0xE0,
  0xF0, 0x00, 0xFE, 0x0F, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x7E, 0x0F, 0x00,
  0x07, 0xF0, 0xF0, 0x00, 0x7F, 0xCF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0x1F, 0xE0, 0x00, 0xF0, 0xFF, 0x00, 0x0F,
  0x07, 0xF0, 0x00, 0xF0, 0x7F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3F,
  0x00, 0x0F, 0x07, 0xF8, 0x00, 0xF0, 0x7F, 0xE0, 0x0F, 0x0F, 0xEF, 0xC0,
  0xF3, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0,
  0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0xF8,
  0x00, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0x80, 0x3E, 0x03, 0xF0, 0xFC, 0x3F, 0xE0, 0xFC, 0x0F, 0xC3, 0xE1, 0xFF,
  0xC3, 0xF0, 0x3E, 0x1F, 0x8F, 0xFF, 0x87, 0xC0, 0xF8, 0x7C, 0x7F, 0xFF,
  0x1F, 0x87, 0xE3, 0xF1, 0xF8, 0xFC, 0x3F, 0xFF, 0x0F, 0x87, 0xC1, 0xF8,
  0xFF, 0xFC, 0x7E, 0x3F, 0x07, 0xE1, 0xFF, 0xE1, 0xF0, 0xF8, 0x0F, 0x83,
  0xFF, 0x0F, 0xC3, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x0F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x00, 0x07,
  0xE0, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xF8, 0x3F, 0xFF, 0xE0, 0x07, 0xF0, 0xFF, 0x9F, 0xE0, 0x0F, 0xC1,
  0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFC, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xF0,
  0xFE, 0x00, 0x3F, 0xDF, 0xC1, 0xFC, 0x00, 0x3F, 0xFF, 0x83, 0xF8, 0x00,
  0x3F, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0x80,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x7F, 0x81, 0xFF,
  0xFF, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFC, 0x00,
  0xFF, 0x80, 0x17, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x04, 0x00, 0xF8, 0x02, 0x78, 0x0F,
  0x81, 0xE7, 0xF8, 0xF0, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x40, 0x10, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE3, 0xF8,
  0x7F, 0x0F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xE0, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFD, 0xFC, 0xFE, 0x1C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x3F, 0xDF, 0xDF, 0xE7, 0xFF, 0xF1, 0xFD, 0xF8, 0x7F,
  0x38, 0x1F, 0xCC, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xE0, 0x03, 0xFC, 0x38, 0x00, 0x1F,
  0xC1, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0x00, 0x7F, 0xC3, 0x80, 0x03, 0xFC, 0x30, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE8, 0x00, 0x01, 0xFE, 0xE0, 0x00,
  0x7F, 0xCF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xC0, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xA0, 0x00, 0x1F, 0xE7, 0x00, 0x07,
  0xFC, 0xFC, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7D, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x08, 0x00, 0x7E, 0x1F, 0xF8, 0x0F, 0xE3, 0xFF, 0xE0, 0xFE,
  0x7F, 0xFF, 0x0F, 0xCF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0x03,
  0xFC, 0xFF, 0xC0, 0x1F, 0xEF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xE1, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7E,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0x83, 0xFC,
  0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xE7,
  0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F,
  0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xF7, 0xF8, 0x07, 0xFF,
  0x3F, 0xF3, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xF0, 0xFF,
  0xFE, 0x7F, 0x07, 0xFF, 0xC7, 0xE0, 0x0F, 0xF0, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x02,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xCF, 0xE1, 0xC0, 0x07, 0x03, 0xF8, 0xFF, 0x1F, 0xF3,
  0xFE, 0x7F, 0xCF, 0xF8, 0xFE, 0x1F, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7C, 0x01, 0xFE, 0x30, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0x07, 0xE0,
  0x0F, 0xFF, 0xF0, 0x3E, 0x0F, 0x80, 0x3F, 0xFF, 0xE0, 0x7E, 0x3F, 0x00,
  0xFF, 0xFF, 0xC0, 0x7C, 0x7C, 0x03, 0xFC, 0x3F, 0x80, 0xF8, 0xF8, 0x0F,
  0xE0, 0x3F, 0x01, 0xF3, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xE7, 0xC0, 0x7E,
  0x00, 0xFC, 0x07, 0xEF, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xDF, 0x01, 0xF0,
  0x03, 0xF0, 0x0F, 0xBE, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xFC, 0x0F, 0xC0,
  0x0F, 0xC0, 0x3F, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0xF0, 0x3F, 0x00,
  0x3E, 0x01, 0xFF, 0xE0, 0x7E, 0x00, 0x7C, 0x03, 0xEF, 0xC0, 0xFC, 0x00,
  0xF8, 0x07, 0xDF, 0x81, 0xF8, 0x01, 0xF0, 0x0F, 0xBF, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0x7E, 0xFC, 0x07, 0xC0, 0x1F,
  0x80, 0xF8, 0xF8, 0x0F, 0xC0, 0x7F, 0x81, 0xF1, 0xF0, 0x0F, 0xC1, 0xEF,
  0x07, 0xC3, 0xE0, 0x1F, 0xFF, 0xDF, 0xFF, 0x87, 0xE0, 0x1F, 0xFF, 0x1F,
  0xFE, 0x0F, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0x80, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0x3F, 0x00,
  0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x7F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x7F, 0x8F, 0xC0, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE3, 0xF0, 0x00, 0xFF, 0x8F, 0xC0, 0x00,
  0xFF, 0x3F, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0xFF, 0x3F, 0x00,
  0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xC0, 0x3F, 0x07, 0xFE, 0x00, 0x0C, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x1C, 0x0F, 0xFF, 0x83, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7D, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x00, 0xFF, 0xE1,
  0xF8, 0x00, 0x1F, 0xF0, 0xFC, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x01, 0xFF,
  0x3F, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F,
  0xF7, 0xE0, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFF, 0x7E,
  0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x7F, 0x8F,
  0xC0, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x7F, 0xC3, 0xF0, 0x00, 0x7F, 0xE1,
  0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0,
  0x0F, 0xE0, 0x7F, 0xE0, 0x00, 0x18, 0x0F, 0xF8, 0x00, 0x01, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00,
  0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0xC0,
  0x00, 0x7F, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFE, 0x83, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x7F, 0x8F, 0xC0, 0x01, 0xFE,
  0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x07,
  0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x3F,
  0x03, 0xFC, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8,
  0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x0F, 0xCF,
  0xF0, 0x00, 0x1F, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xC0, 0x03, 0xFE, 0x3F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0x80, 0xFF,
  0x00, 0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFE,
  0x01, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xE0, 0x03, 0xFC,
  0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF8, 0x3F, 0x00, 0x07, 0xF8,
  0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xBF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0x7F, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xFF, 0xDF,
  0x80, 0x00, 0x3F, 0x7F, 0xFD, 0xFC, 0x00, 0x03, 0xE7, 0xFF, 0xCF, 0xC0,
  0x00, 0x7E, 0x7F, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xFF, 0xCF, 0xC0, 0x00,
  0x7C, 0x7F, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xFF, 0xC7, 0xE0, 0x00, 0xFC,
  0x7F, 0xFC, 0x7E, 0x00, 0x0F, 0x87, 0xFF, 0xC3, 0xF0, 0x01, 0xF8, 0x7F,
  0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xFF, 0xC3, 0xF0, 0x01, 0xF0, 0x7F, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xFF, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0xFC, 0x1F,
  0x80, 0x3E, 0x07, 0xFF, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xFF, 0xC0, 0xFC, 0x07, 0xC0, 0x7F, 0xFC, 0x07, 0xE0, 0xFC,
  0x07, 0xFF, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFC, 0x07, 0xE0, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0x1F, 0x80, 0x7F, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xFF,
  0xC0, 0x3F, 0x1F, 0x00, 0x7F, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0xC0,
  0x1F, 0xBF, 0x00, 0x7F, 0xFC, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0xF0,
  0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xC0, 0x03, 0xFF, 0xC7,
  0xF0, 0x00, 0xFF, 0xF1, 0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x0F, 0xFF,
  0x0F, 0xF0, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0x80, 0x3F,
  0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0x00, 0x7F,
  0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xF0, 0x03, 0xF8, 0x3F, 0xFC, 0x00,
  0xFF, 0x0F, 0xFF, 0x00, 0x1F, 0xC3, 0xFF, 0xC0, 0x03, 0xF8, 0xFF, 0xF0,
  0x00, 0xFF, 0x3F, 0xFC, 0x00, 0x1F, 0xCF, 0xFF, 0x00, 0x07, 0xFB, 0xFF,
  0xC0, 0x00, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0x3F,
  0x00, 0x3F, 0xF7, 0xE0, 0x01, 0xFE, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0,
  0x03, 0xFD, 0xF8, 0x01, 0xFF, 0x3F, 0x07, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
  0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0xF0, 0x7E, 0x00, 0x1F, 0xF0, 0xFC, 0x00,
  0x1F, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F,
  0xC3, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xF8,
  0x1F, 0x81, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8,
  0x01, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xFC, 0x0F, 0xC0,
  0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xF0, 0xFC, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x1F, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0xDF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xF8,
  0x07, 0xE3, 0xFC, 0x00, 0x18, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF6, 0x00, 0x01, 0xFE, 0xF8, 0x00, 0x7F, 0x9F, 0xF8, 0x7F, 0xF3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xD0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0x81,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x3E, 0x7F, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F,
  0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xF8, 0x07,
  0xF8, 0x10, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x3F, 0x7F, 0x80, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xCF, 0xFF, 0xF1, 0xF1, 0xFF, 0xF8, 0x7C, 0x3F, 0xF8, 0x1F, 0x00,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x01, 0xE0, 0x03, 0xF0, 0x7F, 0xE0, 0x1F, 0x8F, 0xFF,
  0xC0, 0xFC, 0xFF, 0xFF, 0x07, 0xEF, 0xFF, 0xFC, 0x3F, 0x7F, 0xFF, 0xF1,
  0xFF, 0xC0, 0xFF, 0x8F, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xF3, 0xFC,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x7F, 0x3F,
  0xE0, 0x07, 0xF9, 0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7E, 0xFF,
  0xFF, 0xC3, 0xF3, 0xFF, 0xFC, 0x1F, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0xF0, 0x1C, 0x3F, 0xE0, 0x04, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x02, 0x1F,
  0xF0, 0x1E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0x01, 0xFC, 0x03,
  0xFF, 0x0F, 0xE0, 0x7F, 0xFE, 0x7F, 0x07, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF,
  0xEF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x7F, 0xF3, 0xFC, 0x01, 0xFF,
  0x9F, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x07,
  0xF9, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xF1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xE7, 0xE0, 0x7F,
  0xFE, 0x3F, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x04, 0x1F, 0xF0, 0x03, 0xC0, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xC0, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xC0, 0xFF, 0xFC,
  0x7E, 0x0F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xDF, 0x8F, 0xFF, 0xFE, 0xFC,
  0x7F, 0xC0, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0x3F, 0x80, 0x0F, 0xFB, 0xFC,
  0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xDF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x9F,
  0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xE3, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xDF, 0xC0, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0x87,
  0xF0, 0x01, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x40, 0x00, 0x1F, 0xE3, 0x80, 0x01, 0xFE, 0x1F, 0x80, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x3F, 0x07,
  0xFF, 0x07, 0xE3, 0xFF, 0xF8, 0xFC, 0xFF, 0xFF, 0x9F, 0xBF, 0xFF, 0xF3,
  0xF7, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F, 0xEF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x00, 0x7C, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFD, 0x07, 0xFB, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x06, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0,
  0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x7F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC,
  0xFE, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFD, 0xFC, 0x00, 0xFF, 0x9F, 0xE0, 0x0F,
  0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xE0,
  0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x03, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0x87, 0xFF, 0xE0, 0xFF,
  0xFE, 0x3F, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xBF, 0xE0, 0x0F, 0xFE, 0x00, 0xFE, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xE0, 0x1F, 0x03, 0xFF, 0x83, 0xE1, 0xFF, 0xFC, 0x7E, 0x7F, 0xFF,
  0xCF, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x0F, 0xF7, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFE,
  0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0xFF, 0xC0, 0x3F, 0x1F, 0xFF, 0x81, 0xF9, 0xFF, 0xFE, 0x0F, 0xDF,
  0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x03,
  0xFC, 0xFF, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFD,
  0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFD, 0xFE, 0x00,
  0x1F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0xE0, 0x0F, 0xF3, 0xFF, 0x81, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0x87, 0xE7, 0xFF, 0xF8, 0x3F,
  0x1F, 0xFF, 0x81, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x3C, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x0F,
  0xC0, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xDF, 0x8F,
  0xFF, 0xFE, 0xFC, 0x7F, 0x80, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0x3F, 0x80,
  0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0xE3, 0xFF, 0xFF,
  0xBF, 0x0F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xDF, 0xC0, 0xFF, 0xFC, 0xFE,
  0x01, 0xFF, 0x87, 0xF0, 0x01, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xDF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0xCF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xC0, 0x1E,
  0x7F, 0x00, 0x08, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xBE, 0x00, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x81, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xE0, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x81, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xE7, 0xE1, 0xFF, 0xF8, 0x7C,
  0x1F, 0xFC, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFB, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xE7, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0x1F, 0xC0,
  0x0F, 0xFE, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x7E, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xF9, 0xF0, 0x07, 0xE0, 0xFE, 0x01,
  0xF3, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x81, 0xF8, 0x0F,
  0xCF, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x3E,
  0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC0, 0x1F, 0xC3, 0xE0, 0x7C, 0x1F, 0x80, 0x3F, 0x87, 0xC0,
  0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x03, 0xE3, 0xF0, 0x01, 0xFC, 0xF8, 0x07,
  0xC7, 0xE0, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x1F,
  0xBF, 0x00, 0x07, 0xEF, 0x80, 0x1F, 0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x3E,
  0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x11, 0xFF, 0x00, 0x01, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x80, 0x01, 0xFF, 0x88, 0x00,
  0x00, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Medium65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 9, 47, 17, 4, -46 },
  { 54, 19, 16, 27, 4, -46 },
  { 92, 35, 46, 38, 1, -46 },
  { 294, 28, 53, 34, 3, -49 },
  { 480, 46, 48, 52, 3, -47 },
  { 756, 39, 48, 42, 3, -47 },
  { 990, 7, 16, 15, 4, -46 },
  { 1004, 15, 57, 20, 3, -47 },
  { 1111, 15, 57, 20, 2, -47 },
  { 1218, 28, 27, 32, 2, -49 },
  { 1313, 28, 32, 34, 3, -39 },
  { 1425, 11, 15, 17, 2, -7 },
  { 1446, 16, 6, 20, 2, -20 },
  { 1458, 9, 9, 17, 4, -8 },
  { 1469, 23, 47, 25, 1, -47 },
  { 1605, 28, 48, 34, 3, -47 },
  { 1773, 18, 46, 34, 5, -46 },
  { 1877, 28, 47, 34, 3, -47 },
  { 2042, 28, 48, 34, 3, -47 },
  { 2210, 32, 47, 34, 1, -47 },
  { 2398, 27, 47, 34, 4, -46 },
  { 2557, 28, 48, 34, 3, -47 },
  { 2725, 29, 46, 34, 2, -46 },
  { 2892, 28, 48, 34, 3, -47 },
  { 3060, 28, 48, 34, 3, -47 },
  { 3228, 9, 37, 17, 4, -36 },
  { 3270, 11, 44, 17, 2, -36 },
  { 3331, 28, 31, 34, 3, -39 },
  { 3440, 28, 18, 34, 3, -32 },
  { 3503, 28, 31, 34, 3, -39 },
  { 3612, 24, 48, 26, 1, -47 },
  { 3756, 47, 53, 53, 3, -47 },
  { 4068, 38, 47, 38, 0, -47 },
  { 4292, 30, 46, 39, 6, -46 },
  { 4465, 31, 48, 37, 4, -47 },
  { 4651, 33, 46, 43, 6, -46 },
  { 4841, 23, 46, 33, 6, -46 },
  { 4974, 23, 46, 31, 6, -46 },
  { 5107, 35, 48, 43, 4, -47 },
  { 5317, 32, 46, 44, 6, -46 },
  { 5501, 17, 46, 22, 2, -46 },
  { 5599, 16, 59, 18, -4, -46 },
  { 5717, 31, 46, 37, 6, -46 },
  { 5896, 24, 46, 31, 6, -46 },
  { 6034, 44, 46, 55, 6, -46 },
  { 6287, 34, 46, 46, 6, -46 },
  { 6483, 38, 48, 46, 4, -47 },
  { 6711, 27, 46, 36, 6, -46 },
  { 6867, 38, 58, 46, 4, -47 },
  { 7143, 31, 46, 37, 6, -46 },
  { 7322, 27, 48, 33, 3, -47 },
  { 7484, 31, 46, 33, 1, -46 },
  { 7663, 33, 47, 43, 5, -46 },
  { 7857, 36, 46, 36, 0, -46 },
  { 8064, 56, 46, 56, 0, -46 },
  { 8386, 35, 46, 35, 0, -46 },
  { 8588, 34, 46, 34, 0, -46 },
  { 8784, 29, 46, 33, 2, -46 },
  { 8951, 14, 57, 21, 5, -47 },
  { 9051, 23, 47, 25, 1, -47 },
  { 9187, 14, 57, 21, 2, -47 },
  { 9287, 31, 29, 35, 2, -47 },
  { 9400, 28, 4, 28, 0, 6 },
  { 9414, 14, 11, 19, 3, -50 },
  { 9434, 26, 37, 34, 3, -36 },
  { 9555, 29, 50, 37, 5, -49 },
  { 9737, 24, 37, 29, 3, -36 },
  { 9848, 29, 50, 37, 3, -49 },
  { 10030, 28, 37, 34, 3, -36 },
  { 10160, 22, 50, 21, 1, -50 },
  { 10298, 29, 52, 37, 3, -36 },
  { 10487, 27, 49, 37, 5, -49 },
  { 10653, 8, 48, 16, 4, -48 },
  { 10701, 15, 64, 16, -3, -48 },
  { 10821, 28, 49, 33, 5, -49 },
  { 10993, 7, 49, 16, 5, -49 },
  { 11036, 46, 36, 56, 5, -36 },
  { 11243, 27, 36, 37, 5, -36 },
  { 11365, 30, 37, 36, 3, -36 },
  { 11504, 29, 52, 37, 5, -36 },
  { 11693, 29, 52, 37, 3, -36 },
  { 11882, 19, 36, 25, 5, -36 },
  { 11968, 23, 37, 28, 3, -36 },
  { 12075, 20, 44, 22, 1, -43 },
  { 12185, 27, 36, 37, 5, -35 },
  { 12307, 31, 35, 31, 0, -35 },
  { 12443, 47, 35, 48, 1, -35 },
  { 12649, 30, 35, 32, 1, -35 },
  { 12781, 31, 51, 31, 0, -35 },
  { 12979, 23, 35, 27, 2, -35 },
  { 13080, 20, 56, 24, 2, -46 },
  { 13220, 5, 64, 33, 14, -49 },
  { 13260, 21, 56, 24, 2, -46 },
  { 13407, 28, 10, 34, 3, -28 },
};

const GFXfont NotoSans_SemiCondensed_Medium65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM65PT7B_H_
