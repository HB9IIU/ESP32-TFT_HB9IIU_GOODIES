#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xFB, 0xF7,
  0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x21, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x70, 0xFE, 0x1F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3E, 0x7C,
  0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0x78,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x3C, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x1F, 0xCF, 0x0F, 0x1F, 0xC7, 0x80, 0x8F, 0xC3, 0xC0,
  0x07, 0xE1, 0xE0, 0x03, 0xF0, 0xF0, 0x01, 0xF8, 0x78, 0x00, 0xFC, 0x3C,
  0x00, 0x7F, 0x1E, 0x00, 0x1F, 0xCF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0x9F, 0xE0,
  0x03, 0xC3, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x7E, 0x00, 0x78, 0x3F,
  0x00, 0x3C, 0x1F, 0x80, 0x1E, 0x1F, 0xB0, 0x0F, 0x0F, 0xDF, 0x07, 0x9F,
  0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x01,
  0xF0, 0x3C, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x00, 0x1E, 0x03,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x80, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0x00, 0x78,
  0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x03, 0xE3, 0xE0, 0xFE, 0x07, 0xC0, 0xF0,
  0xF8, 0xFF, 0xC1, 0xF0, 0x7C, 0x7C, 0x7F, 0xF8, 0x7C, 0x1F, 0x1F, 0x1F,
  0xFF, 0x0F, 0x8F, 0x8F, 0x8F, 0xC7, 0xC3, 0xFF, 0xE3, 0xE3, 0xE0, 0xF8,
  0x7F, 0xF1, 0xF0, 0xF8, 0x3E, 0x0F, 0xF8, 0x7C, 0x7C, 0x0F, 0x80, 0xFC,
  0x1E, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0x03, 0xC1,
  0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00, 0xF8,
  0x03, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3E,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFC,
  0x0F, 0xFF, 0xC0, 0x1F, 0x81, 0xFE, 0xFE, 0x01, 0xF8, 0x3F, 0xC7, 0xF0,
  0x1F, 0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x07, 0xE0,
  0x1F, 0xE3, 0xF0, 0x7E, 0x00, 0xFF, 0x7E, 0x0F, 0xE0, 0x07, 0xF7, 0xE0,
  0xFE, 0x00, 0x3F, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x0F,
  0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x0F, 0xF8, 0x07, 0xF0,
  0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xFF, 0xF8,
  0x1F, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE,
  0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC7, 0x8F,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0xC0, 0x7C, 0x06, 0x7E, 0x3C, 0x3F, 0x3F, 0xFE,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x01,
  0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0x1E, 0x03, 0xC0, 0x03, 0x01, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F,
  0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x38, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFC, 0x07,
  0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F,
  0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F,
  0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xDF,
  0x3F, 0xBF, 0x7F, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x38, 0x3F, 0x10, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x1F, 0xF0, 0xFF, 0x83, 0xE0, 0x0F, 0xF0, 0x70, 0x01, 0xFC, 0x10, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFC, 0x0F, 0xF0, 0xF0, 0x01, 0xFC, 0x20,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xEF, 0x00, 0x0F, 0xF7, 0xFE, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E,
  0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x87, 0xE0,
  0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7C,
  0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0x0F, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x80, 0x00, 0xFE, 0xF0, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xE0, 0x20, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x3F, 0xE0, 0x7E, 0x7F, 0xF8, 0x3F, 0x7F, 0xFE,
  0x1F, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFC, 0x07, 0xFB, 0xFC, 0x01,
  0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x1F, 0x9F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x3E, 0x00, 0x1F, 0x8F,
  0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xE1,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xCF, 0xF0,
  0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x8F, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF8, 0x7F, 0x83, 0xF8, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07,
  0xF7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0x7F, 0xCF, 0xF0,
  0x7F, 0xF1, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xBE, 0x0F, 0xFF, 0xCF, 0x80,
  0xFF, 0xE3, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x39, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBE, 0x38, 0x0E, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE7, 0xF3, 0xF1,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x07, 0xF9,
  0xC0, 0x0F, 0xE8, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xDF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x40, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0x81, 0xF1, 0xF0, 0x0F, 0xFF, 0xE0,
  0xF8, 0xF8, 0x0F, 0xFF, 0xF0, 0x3E, 0xF8, 0x0F, 0xFB, 0xF8, 0x1F, 0x7C,
  0x07, 0xE0, 0x7C, 0x0F, 0xBE, 0x07, 0xE0, 0x3E, 0x03, 0xDE, 0x03, 0xE0,
  0x1F, 0x01, 0xFF, 0x03, 0xE0, 0x0F, 0x80, 0xFF, 0x81, 0xF0, 0x07, 0xC0,
  0x7F, 0xC0, 0xF8, 0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0xF0,
  0x3E, 0x00, 0xF8, 0x0F, 0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0x80,
  0x7C, 0x07, 0xFE, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0x03, 0xE0, 0x1F, 0x01,
  0xFF, 0x81, 0xF0, 0x0F, 0x80, 0xF7, 0xC0, 0xF8, 0x0F, 0xE0, 0xFB, 0xE0,
  0x3E, 0x0F, 0xF0, 0x79, 0xF0, 0x1F, 0xFF, 0xBE, 0xFC, 0x7C, 0x07, 0xFF,
  0x9F, 0xFC, 0x3E, 0x01, 0xFF, 0x87, 0xFC, 0x1F, 0x00, 0x7F, 0x81, 0xFC,
  0x07, 0xC0, 0x04, 0x00, 0x10, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0x3F, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0,
  0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x01, 0xFE, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x3F, 0xE7, 0xE0, 0x01, 0xFC, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0x7E,
  0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF0, 0x7E, 0x0F, 0xF8, 0x00, 0xE0, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x02, 0x0F, 0xFC, 0x00, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x03,
  0xFF, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x0F,
  0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFE,
  0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F,
  0x00, 0x03, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFF, 0x0F, 0xC0,
  0x07, 0xFC, 0x3F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F,
  0x81, 0xFF, 0x00, 0x0E, 0x07, 0xF8, 0x00, 0x04, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0xFC, 0x7F, 0x80, 0x01, 0xF8, 0x7F, 0x80, 0x03, 0xF0, 0xFF, 0xC0, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xE0, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x01, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0x80, 0x0F, 0xF1, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFD, 0xF0,
  0x00, 0x07, 0xDF, 0xFB, 0xF0, 0x00, 0x0F, 0xBF, 0xF7, 0xE0, 0x00, 0x3F,
  0x7F, 0xE7, 0xC0, 0x00, 0x7C, 0xFF, 0xCF, 0xC0, 0x00, 0xF9, 0xFF, 0xDF,
  0x80, 0x03, 0xF3, 0xFF, 0x9F, 0x00, 0x07, 0xCF, 0xFF, 0x3F, 0x00, 0x0F,
  0x9F, 0xFE, 0x7E, 0x00, 0x3F, 0x3F, 0xFC, 0x7C, 0x00, 0x7C, 0x7F, 0xF8,
  0xF8, 0x00, 0xF8, 0xFF, 0xF1, 0xF8, 0x03, 0xF1, 0xFF, 0xE1, 0xF0, 0x07,
  0xC3, 0xFF, 0xC3, 0xE0, 0x0F, 0x87, 0xFF, 0x87, 0xE0, 0x3F, 0x0F, 0xFF,
  0x07, 0xC0, 0x7C, 0x1F, 0xFE, 0x0F, 0x80, 0xF8, 0x3F, 0xFC, 0x1F, 0x83,
  0xF0, 0x7F, 0xF8, 0x1F, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x0F, 0x81, 0xFF,
  0xE0, 0x7E, 0x3F, 0x03, 0xFF, 0xC0, 0x7C, 0x7C, 0x07, 0xFF, 0x80, 0xF8,
  0xF8, 0x0F, 0xFF, 0x01, 0xFB, 0xF0, 0x1F, 0xFE, 0x01, 0xF7, 0xC0, 0x3F,
  0xFC, 0x03, 0xEF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFB, 0xF0, 0x00, 0x7F, 0xF7, 0xF0, 0x00, 0xFF, 0xE7,
  0xE0, 0x01, 0xFF, 0xCF, 0xE0, 0x03, 0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0x1F,
  0xC0, 0x0F, 0xFF, 0x1F, 0xC0, 0x1F, 0xFE, 0x1F, 0x80, 0x3F, 0xFC, 0x3F,
  0x80, 0x7F, 0xF8, 0x3F, 0x00, 0xFF, 0xF0, 0x7F, 0x01, 0xFF, 0xE0, 0x7E,
  0x03, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x80, 0xFC, 0x0F, 0xFF, 0x01, 0xFC,
  0x1F, 0xFE, 0x01, 0xFC, 0x3F, 0xFC, 0x01, 0xF8, 0x7F, 0xF8, 0x03, 0xF8,
  0xFF, 0xF0, 0x03, 0xF1, 0xFF, 0xE0, 0x07, 0xF1, 0xFF, 0xC0, 0x07, 0xE3,
  0xFF, 0x80, 0x0F, 0xE7, 0xFF, 0x00, 0x0F, 0xCF, 0xFE, 0x00, 0x1F, 0xDF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x1F,
  0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xE0, 0x1F, 0xF3, 0xF0, 0x03, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0x80, 0x7F, 0xCF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0,
  0x1F, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC,
  0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC,
  0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xE3, 0xFC, 0x7F,
  0x00, 0x3C, 0xFE, 0x00, 0x04, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0xC0, 0x00, 0xFE, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x9F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7C, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x3E, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0xFC,
  0x01, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x80, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x0F, 0x81,
  0xF8, 0x00, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x07,
  0xC3, 0xF0, 0x00, 0x7C, 0x7E, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x01, 0xF9, 0xF0,
  0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0xFC, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x1F, 0x80,
  0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0xFE, 0x04, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0x7F, 0x80, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7E, 0x01, 0xFF, 0x7F,
  0x87, 0xFF, 0x3F, 0xFF, 0xDF, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0x1F, 0x07,
  0xFC, 0x0F, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x0F, 0xFC, 0x0F, 0xCF, 0xFF, 0x83, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xF8, 0x7F, 0xCF, 0xF8, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFB, 0xF8,
  0x00, 0x7E, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF8, 0x07, 0xF3,
  0xFF, 0xC7, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0x7F, 0xFF, 0x0F, 0x8F, 0xFF,
  0x83, 0xE0, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xF0, 0xF8,
  0xFE, 0x00, 0x4F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x06, 0x7F, 0xF7, 0xF1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0xFF, 0xC3, 0xF0, 0x7F, 0xFC, 0xFC,
  0x3F, 0xFF, 0xBF, 0x1F, 0xFF, 0xEF, 0xCF, 0xF0, 0x7F, 0xF3, 0xF8, 0x07,
  0xFD, 0xFC, 0x00, 0xFF, 0x7E, 0x00, 0x3F, 0xDF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xDF,
  0xC0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xEF,
  0xC3, 0xFF, 0xF3, 0xF0, 0x7F, 0xF8, 0xFC, 0x0F, 0xFC, 0x1F, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFC, 0x01, 0xF8,
  0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x8F,
  0xF0, 0x01, 0x83, 0xFE, 0x0F, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF,
  0xBF, 0x1F, 0xFF, 0xEF, 0xCF, 0xF0, 0x7F, 0xF3, 0xF8, 0x07, 0xFD, 0xFC,
  0x00, 0xFF, 0x7E, 0x00, 0x3F, 0xDF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xDF, 0xC0, 0x0F,
  0xF3, 0xF8, 0x07, 0xFC, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xEF, 0xC3, 0xFF,
  0xF3, 0xF0, 0x7F, 0xF8, 0xFC, 0x0F, 0xFC, 0x3F, 0x00, 0x78, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0xC0, 0x01, 0xFC, 0x3E, 0x01,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x07, 0xE1,
  0xFF, 0xC3, 0xF3, 0xFF, 0xF1, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F,
  0xF0, 0xFF, 0xBF, 0xE0, 0x1F, 0xDF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF0,
  0x7D, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFD, 0x0F, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xFB, 0xF0, 0x03, 0xF9, 0xF8, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0xFE, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFE, 0xFE, 0x01,
  0xFE, 0x3F, 0x00, 0xFE, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x07,
  0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xBF, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x1F, 0xFC, 0x07, 0xFF,
  0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0xE3, 0xF7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xF8, 0x7F, 0xFC, 0x3F, 0xEF, 0xF8, 0x0F,
  0xFC, 0x03, 0xFB, 0xFC, 0x01, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xBF, 0x80, 0x0F, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x1F, 0xFC, 0x3E, 0x3F, 0xFF, 0x1F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0x0F, 0xFB, 0xFE, 0x01, 0xFD,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0x7F, 0xC7,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3E, 0x0F, 0xFC,
  0x0F, 0xCF, 0xFF, 0x83, 0xF7, 0xFF, 0xF0, 0xFD, 0xFF, 0xFE, 0x3F, 0xF8,
  0x3F, 0xCF, 0xF8, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF,
  0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E,
  0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF8, 0x07, 0xF3, 0xFF, 0xEF,
  0xFC, 0xFD, 0xFF, 0xFE, 0x3F, 0x7F, 0xFF, 0x0F, 0xCF, 0xFF, 0x83, 0xF0,
  0xFF, 0xC0, 0xFC, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC3, 0xF0, 0x7F, 0xFC, 0xFC, 0x3F, 0xFF,
  0xBF, 0x1F, 0xFF, 0xEF, 0xCF, 0xF0, 0x7F, 0xF3, 0xF8, 0x07, 0xFD, 0xFC,
  0x00, 0xFF, 0x7E, 0x00, 0x3F, 0xDF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xDF, 0xC0, 0x0F,
  0xF3, 0xF8, 0x07, 0xFC, 0xFF, 0x8F, 0xFF, 0x1F, 0xFF, 0xEF, 0xC3, 0xFF,
  0xF3, 0xF0, 0x7F, 0xF8, 0xFC, 0x0F, 0xFC, 0x3F, 0x00, 0x70, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xEF, 0x87,
  0xFB, 0xE3, 0xFE, 0xFD, 0xFF, 0xBF, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x80, 0xF1, 0xF8, 0x00,
  0x8F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xD8, 0x00, 0xFE, 0xFC, 0x3F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xFE, 0x70, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x01,
  0x80, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0xDF, 0xFB,
  0xFF, 0xE7, 0xFF, 0xFB, 0xF3, 0xFF, 0xFD, 0xF8, 0xFF, 0xFC, 0x7C, 0x1F,
  0xF8, 0x3E, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07,
  0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x1F, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xEF, 0x80, 0x1F,
  0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xBC, 0x01,
  0xF9, 0xF8, 0x07, 0xDF, 0x00, 0xFC, 0x7C, 0x03, 0xEF, 0x80, 0x7C, 0x3F,
  0x01, 0xF7, 0xC0, 0x7E, 0x1F, 0x80, 0xFB, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8,
  0xF8, 0x1F, 0x83, 0xE0, 0x7C, 0x7C, 0x0F, 0x81, 0xF8, 0x3E, 0x3E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x1F, 0x07, 0xE0, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x07, 0xE3, 0xE0,
  0xF8, 0xFC, 0x03, 0xF3, 0xE0, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x1F, 0x3E,
  0x00, 0x7C, 0xF8, 0x0F, 0x9F, 0x00, 0x3F, 0x7C, 0x07, 0xDF, 0x80, 0x1F,
  0xBC, 0x03, 0xEF, 0xC0, 0x07, 0xFE, 0x00, 0xF7, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xDF, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x03,
  0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x1F, 0x80,
  0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07,
  0xF0, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xFF, 0xE0,
  0x00, 0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x47, 0xFC, 0x00, 0x17, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFB,
  0x00, 0x0F, 0xFC, 0x80, 0x00, 0x10, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 42, 15, 4, -41 },
  { 38, 18, 15, 24, 3, -41 },
  { 72, 32, 41, 34, 1, -41 },
  { 236, 25, 47, 30, 3, -44 },
  { 383, 42, 43, 46, 2, -42 },
  { 609, 36, 43, 38, 2, -42 },
  { 803, 7, 15, 13, 3, -41 },
  { 817, 14, 51, 18, 2, -42 },
  { 907, 13, 51, 18, 2, -42 },
  { 990, 25, 24, 29, 2, -44 },
  { 1065, 26, 27, 30, 2, -34 },
  { 1153, 9, 15, 15, 2, -7 },
  { 1170, 14, 5, 18, 2, -18 },
  { 1179, 7, 9, 15, 4, -8 },
  { 1187, 21, 42, 22, 1, -42 },
  { 1298, 26, 43, 30, 2, -42 },
  { 1438, 16, 41, 30, 4, -41 },
  { 1520, 26, 42, 30, 2, -42 },
  { 1657, 25, 43, 30, 2, -42 },
  { 1792, 28, 42, 30, 1, -42 },
  { 1939, 24, 42, 30, 3, -41 },
  { 2065, 25, 43, 30, 3, -42 },
  { 2200, 26, 41, 30, 2, -41 },
  { 2334, 26, 43, 30, 2, -42 },
  { 2474, 26, 43, 30, 2, -42 },
  { 2614, 7, 33, 15, 4, -32 },
  { 2643, 9, 40, 15, 2, -32 },
  { 2688, 26, 28, 30, 2, -35 },
  { 2779, 25, 17, 30, 3, -29 },
  { 2833, 26, 28, 30, 2, -35 },
  { 2924, 21, 43, 23, 1, -42 },
  { 3037, 41, 47, 47, 3, -42 },
  { 3278, 34, 42, 34, 0, -42 },
  { 3457, 27, 41, 35, 5, -41 },
  { 3596, 28, 43, 33, 3, -42 },
  { 3747, 30, 41, 38, 5, -41 },
  { 3901, 21, 41, 29, 5, -41 },
  { 4009, 21, 41, 28, 5, -41 },
  { 4117, 31, 43, 38, 3, -42 },
  { 4284, 29, 41, 39, 5, -41 },
  { 4433, 15, 41, 19, 2, -41 },
  { 4510, 15, 52, 16, -4, -41 },
  { 4608, 28, 41, 33, 5, -41 },
  { 4752, 21, 41, 28, 5, -41 },
  { 4860, 39, 41, 49, 5, -41 },
  { 5060, 31, 41, 41, 5, -41 },
  { 5219, 35, 43, 41, 3, -42 },
  { 5408, 25, 41, 32, 5, -41 },
  { 5537, 35, 52, 41, 3, -42 },
  { 5765, 28, 41, 33, 5, -41 },
  { 5909, 24, 43, 29, 3, -42 },
  { 6038, 27, 41, 29, 1, -41 },
  { 6177, 29, 42, 39, 5, -41 },
  { 6330, 32, 41, 32, 0, -41 },
  { 6494, 50, 41, 50, 0, -41 },
  { 6751, 31, 41, 31, 0, -41 },
  { 6910, 30, 41, 30, 0, -41 },
  { 7064, 25, 41, 29, 2, -41 },
  { 7193, 13, 51, 19, 4, -42 },
  { 7276, 21, 42, 22, 1, -42 },
  { 7387, 13, 51, 19, 2, -42 },
  { 7470, 27, 26, 31, 2, -42 },
  { 7558, 25, 4, 25, 0, 5 },
  { 7571, 13, 9, 17, 2, -44 },
  { 7586, 24, 33, 30, 2, -32 },
  { 7685, 26, 45, 33, 4, -44 },
  { 7832, 21, 33, 26, 3, -32 },
  { 7919, 26, 45, 33, 3, -44 },
  { 8066, 25, 33, 30, 3, -32 },
  { 8170, 20, 44, 19, 1, -44 },
  { 8280, 26, 46, 33, 3, -32 },
  { 8430, 25, 44, 33, 4, -44 },
  { 8568, 7, 43, 15, 4, -43 },
  { 8606, 13, 57, 15, -2, -43 },
  { 8699, 25, 44, 30, 4, -44 },
  { 8837, 6, 44, 15, 4, -44 },
  { 8870, 42, 32, 50, 4, -32 },
  { 9038, 25, 32, 33, 4, -32 },
  { 9138, 26, 33, 32, 3, -32 },
  { 9246, 26, 46, 33, 4, -32 },
  { 9396, 26, 46, 33, 3, -32 },
  { 9546, 18, 32, 22, 4, -32 },
  { 9618, 21, 33, 25, 2, -32 },
  { 9705, 18, 39, 20, 1, -38 },
  { 9793, 25, 32, 33, 4, -31 },
  { 9893, 28, 31, 28, 0, -31 },
  { 10002, 41, 31, 43, 1, -31 },
  { 10161, 26, 31, 28, 1, -31 },
  { 10262, 28, 45, 28, 0, -31 },
  { 10420, 21, 31, 24, 2, -31 },
  { 10502, 18, 50, 22, 2, -41 },
  { 10615, 5, 58, 29, 12, -44 },
  { 10652, 18, 50, 22, 2, -41 },
  { 10765, 26, 9, 30, 2, -25 },
};

const GFXfont NotoSans_SemiCondensed_Medium58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM58PT7B_H_
