#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium31pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x66, 0x66, 0x60, 0x00, 0x7F, 0xFF,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x03, 0x0C, 0x07,
  0x1C, 0x07, 0x1C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x38,
  0xE0, 0x38, 0xE0, 0x30, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x3F, 0x87,
  0xFF, 0x7F, 0xFB, 0x98, 0x5C, 0xC0, 0xE6, 0x07, 0x30, 0x3D, 0x80, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xCE, 0x06, 0x38, 0x31, 0xE1, 0x9F,
  0xCD, 0xEF, 0xFE, 0x7F, 0xE0, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00,
  0x3E, 0x01, 0xC1, 0xFC, 0x06, 0x06, 0x38, 0x38, 0x18, 0xE0, 0xC0, 0xE3,
  0x87, 0x03, 0x86, 0x18, 0x0E, 0x18, 0xE0, 0x38, 0x63, 0x00, 0xE3, 0x9C,
  0x41, 0x8E, 0x67, 0xE7, 0x3B, 0xBF, 0x9F, 0xCC, 0xE7, 0x3E, 0x73, 0x1C,
  0x01, 0x8C, 0x30, 0x0E, 0x70, 0xC0, 0x31, 0xC3, 0x01, 0xC3, 0x0C, 0x06,
  0x0C, 0x30, 0x38, 0x31, 0xC0, 0xC0, 0xE7, 0x07, 0x01, 0xF8, 0x1C, 0x03,
  0xC0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xF1, 0xC0, 0x1C, 0x38, 0x03, 0x87,
  0x80, 0x70, 0xE0, 0x0F, 0x1C, 0x00, 0xE7, 0x80, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xE0, 0xE7, 0x9E, 0x3C, 0xE1, 0xE7, 0x3C, 0x1C,
  0xE7, 0x83, 0xFC, 0xF0, 0x3F, 0x1E, 0x03, 0xC1, 0xC0, 0xFC, 0x3F, 0xFF,
  0xC3, 0xFF, 0x3C, 0x3F, 0xC3, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0x0E, 0x1C,
  0x3C, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0F,
  0xE0, 0xE0, 0xC1, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x80,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x04, 0x30, 0xFD, 0xFF, 0xFF, 0xE1,
  0xF0, 0x0F, 0x80, 0xEE, 0x07, 0x38, 0x71, 0xE1, 0x86, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x3B, 0xDE, 0xE7, 0x3B, 0x9C, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0xC0, 0x7F, 0xC3,
  0xCF, 0x1E, 0x1E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x03, 0xDC, 0x0F,
  0x70, 0x39, 0xC0, 0xE3, 0x87, 0x8F, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x07,
  0x87, 0xC7, 0xE7, 0xF7, 0xBF, 0x9D, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x1F, 0xE1, 0xFF, 0xCF, 0x8F, 0x18, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFF, 0xC7, 0x8F, 0x98, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x7F, 0x81, 0xF8, 0x07, 0xFC,
  0x00, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE8, 0x07,
  0xBE, 0x7E, 0xFF, 0xF1, 0xFF, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x37, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x38, 0x1C, 0x70, 0x38,
  0xE0, 0xE1, 0xC1, 0x83, 0x87, 0x07, 0x1C, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xA0, 0x3D, 0xE7, 0xCF, 0xFC, 0x7F, 0xC0,
  0x07, 0xF0, 0x3F, 0xC1, 0xF0, 0x8F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x73, 0xE1, 0xFF, 0xCF, 0xFF, 0xBE, 0x0E, 0xF0, 0x3F, 0xC0,
  0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0xF3, 0x83, 0x8F, 0xBE, 0x1F,
  0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x00, 0x1F, 0xE0, 0xFF, 0xC7, 0x87, 0x9C,
  0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x8E, 0x1E, 0x3C, 0xF0, 0x7F, 0x80,
  0xFC, 0x07, 0xF8, 0x3C, 0xF1, 0xC1, 0xE7, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x77, 0x03, 0xDE, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF,
  0x87, 0xCF, 0x1C, 0x1E, 0x70, 0x3B, 0xC0, 0xEE, 0x03, 0xF8, 0x07, 0xF0,
  0x3D, 0xC0, 0xF7, 0x87, 0xDF, 0xF7, 0x3F, 0xDC, 0x3C, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x08, 0xF8, 0x3F, 0xC0, 0xFE, 0x00,
  0x6F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x33, 0xDE, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEE, 0x73, 0x99, 0xCE, 0x00, 0x00,
  0x04, 0x00, 0x30, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0xCF, 0xFE, 0x79, 0xE4,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x3E,
  0x07, 0x00, 0x38, 0x38, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x0F, 0xF3, 0xB8,
  0x7F, 0xC6, 0xE3, 0x87, 0x1F, 0x0E, 0x1C, 0x7C, 0x70, 0x61, 0xF1, 0xC1,
  0x87, 0xC7, 0x06, 0x1F, 0x1C, 0x18, 0x6C, 0x70, 0xE1, 0xB0, 0xC3, 0x8E,
  0xC3, 0xFB, 0xF3, 0x87, 0xCF, 0x8E, 0x04, 0x0C, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x04, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xB0,
  0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x1C, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFC, 0x38, 0x07, 0x1E, 0x01, 0xE7, 0x80, 0x39, 0xC0, 0x0E, 0xF0, 0x03,
  0xFC, 0x00, 0x70, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8, 0x1E, 0xE0, 0x3B,
  0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0xFF, 0x8F, 0xFC, 0x3F, 0xFC,
  0xE0, 0x7B, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x07,
  0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xFC, 0xFC, 0xF1,
  0xE0, 0x27, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x3C, 0xE0, 0x1E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x3C,
  0xE0, 0x78, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFB, 0xFF, 0x7F,
  0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xFF, 0x7F, 0xEF, 0xFD, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0xFE,
  0x0F, 0xFF, 0x1F, 0x9F, 0x3C, 0x02, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x07, 0x3C, 0x07,
  0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xC0,
  0xFF, 0xFF, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0xFE,
  0xFC, 0xF8, 0xE0, 0x3F, 0xC0, 0x73, 0x81, 0xE7, 0x07, 0x8E, 0x1E, 0x1C,
  0x38, 0x38, 0xF0, 0x73, 0xC0, 0xEF, 0x01, 0xDC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0x78, 0x1C, 0x78, 0x38, 0xF0, 0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xE3,
  0x81, 0xE7, 0x01, 0xCE, 0x03, 0xDC, 0x03, 0xC0, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x1B, 0xFE, 0x01, 0xDF, 0xB0, 0x0E, 0xFD, 0xC0, 0x67,
  0xEE, 0x07, 0x3F, 0x30, 0x39, 0xF9, 0xC1, 0x8F, 0xCE, 0x1C, 0x7E, 0x30,
  0xE3, 0xF1, 0xCE, 0x1F, 0x8E, 0x70, 0xFC, 0x33, 0x87, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xE0, 0x7E, 0x0F, 0x03, 0xF0, 0x78,
  0x1C, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xDC, 0x07, 0xFE,
  0x07, 0xEE, 0x07, 0xEF, 0x07, 0xE7, 0x07, 0xE7, 0x87, 0xE3, 0xC7, 0xE1,
  0xC7, 0xE1, 0xE7, 0xE0, 0xE7, 0xE0, 0xF7, 0xE0, 0x77, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0x0F, 0xF8, 0x07,
  0xFF, 0x83, 0xF3, 0xF1, 0xF0, 0x3C, 0x78, 0x07, 0xBC, 0x00, 0xEF, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x03, 0x9E,
  0x01, 0xE7, 0xC0, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xB8, 0x7D, 0xFF, 0xCF, 0xFC, 0x7E, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x0F,
  0xF8, 0x07, 0xFF, 0x83, 0xF3, 0xF1, 0xF0, 0x3C, 0x78, 0x07, 0xBC, 0x00,
  0xEF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x70,
  0x03, 0x9E, 0x01, 0xE3, 0xC0, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x07, 0x8E, 0x07, 0x9C, 0x0F, 0x38,
  0x0E, 0x70, 0x3C, 0xE0, 0x79, 0xC1, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8,
  0x1C, 0x78, 0x38, 0x70, 0x70, 0xF0, 0xE0, 0xE1, 0xC1, 0xE3, 0x81, 0xE7,
  0x03, 0xCE, 0x03, 0xDC, 0x03, 0xC0, 0x1F, 0xF1, 0xFF, 0xDF, 0xBC, 0xE0,
  0x27, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xF0,
  0x1F, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0F,
  0x78, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xF0, 0x03, 0xB8, 0x03,
  0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x38, 0x78,
  0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x07, 0x07, 0x01, 0xC7, 0x80, 0xE3, 0x80,
  0x71, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xEE, 0x03,
  0xC0, 0x39, 0xC0, 0x7C, 0x07, 0x38, 0x0F, 0x81, 0xE7, 0x01, 0xF0, 0x38,
  0x70, 0x76, 0x07, 0x0E, 0x0E, 0xE0, 0xE1, 0xC1, 0xDC, 0x1C, 0x38, 0x33,
  0x87, 0x07, 0x8E, 0x70, 0xE0, 0x71, 0xC7, 0x1C, 0x0E, 0x38, 0xE3, 0x81,
  0xC6, 0x1C, 0xF0, 0x3D, 0xC1, 0x9C, 0x03, 0xB8, 0x3B, 0x80, 0x77, 0x07,
  0x70, 0x0E, 0xC0, 0xEE, 0x01, 0xD8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x0F,
  0x1C, 0x07, 0x0F, 0x07, 0x83, 0x83, 0x81, 0xE3, 0xC0, 0x71, 0xC0, 0x3D,
  0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3B, 0x80, 0x3D, 0xC0, 0x1C, 0x70, 0x1E, 0x3C, 0x0E, 0x0E,
  0x0E, 0x07, 0x87, 0x01, 0xC7, 0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x70,
  0x0E, 0x78, 0x0E, 0x38, 0x1C, 0x3C, 0x1C, 0x1C, 0x3C, 0x1C, 0x38, 0x0E,
  0x78, 0x0E, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xFF, 0xFF, 0xF8, 0xF0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFC, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0xEC, 0x03, 0x9C, 0x07, 0x18, 0x0C, 0x38, 0x38, 0x30, 0x60, 0x71,
  0xC0, 0x63, 0x00, 0xEE, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF0,
  0xE0, 0xE0, 0xE0, 0x0F, 0xC1, 0xFF, 0x8F, 0xFC, 0x40, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE1, 0xFF, 0x3F, 0xFB, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07,
  0xF8, 0x3D, 0xE3, 0xEF, 0xF7, 0x3F, 0x38, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0xF0, 0xEF, 0xF3, 0xFF,
  0xEF, 0x87, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF8, 0x3B, 0xF3, 0xEE, 0xFF, 0x39,
  0xF8, 0x07, 0xE1, 0xFF, 0x3F, 0xE3, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x3E, 0x71,
  0xFF, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC3, 0xE7, 0x1F, 0xDC, 0xFF, 0xF7, 0x83, 0xDE, 0x0F,
  0x70, 0x1D, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0x77, 0x01,
  0xDC, 0x07, 0x78, 0x3C, 0xFB, 0xF3, 0xFF, 0xC3, 0xE3, 0x07, 0xC0, 0x7F,
  0xC3, 0xEF, 0x0E, 0x0E, 0x70, 0x39, 0xC0, 0x77, 0x01, 0xDF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xE3, 0x87,
  0xFE, 0x0F, 0xF0, 0x03, 0xC1, 0xFC, 0x3F, 0x8F, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xFE, 0xFF, 0xDF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x0F, 0x8C, 0x7F, 0x73, 0xFF, 0xDE, 0x0F, 0x78, 0x3D, 0xC0, 0x77, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xE0,
  0xF3, 0xEF, 0xCF, 0xFF, 0x0F, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0xC1, 0xE3, 0xFF, 0x8F, 0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7C, 0xEF, 0xF7, 0xFF, 0xFE, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xEF, 0xF6, 0x00,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x1C, 0x3C, 0x78,
  0x60, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x75, 0xEF, 0xDF, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x0E, 0xE0, 0x73, 0x83, 0x8E, 0x1E, 0x38, 0xF0, 0xE7, 0x83, 0x9C,
  0x0E, 0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xCF, 0x0E, 0x1C, 0x38, 0x78, 0xE0,
  0xE3, 0x83, 0xCE, 0x07, 0xB8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xC1, 0xF3, 0xBF, 0xDF, 0xEF, 0xFF, 0x7F, 0xFE,
  0x1F, 0x0F, 0xF0, 0x78, 0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E,
  0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x81, 0xF8, 0x0E, 0x07,
  0xE0, 0x38, 0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0,
  0x38, 0x1C, 0xE3, 0xE7, 0x7F, 0xBF, 0xFF, 0xF0, 0xFF, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x38, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE1,
  0xC1, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xE0,
  0x3D, 0xC0, 0x7B, 0x80, 0xE7, 0x01, 0xCF, 0x07, 0x8F, 0x1E, 0x0F, 0xF8,
  0x0F, 0xE0, 0xE3, 0xC3, 0xBF, 0xCF, 0xFF, 0xBE, 0x1E, 0xF0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0xEF, 0xCF, 0xBB, 0xFC, 0xE7, 0xE3, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0x8C, 0x7F, 0x73,
  0xFF, 0xDE, 0x0F, 0x78, 0x3D, 0xC0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xE0, 0xF3, 0xE7, 0xCF, 0xFF,
  0x0F, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0xE3, 0xF9, 0xEE, 0xFB, 0xF0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00,
  0x1F, 0xC7, 0xFD, 0xFF, 0x78, 0x2E, 0x01, 0xE0, 0x1E, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xFC, 0x7F, 0xFE, 0x7F, 0x80,
  0x38, 0x1C, 0x0E, 0x0F, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x4F, 0xE3, 0xF0, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x3D, 0xF7, 0xEF,
  0xFB, 0x3F, 0x98, 0xE0, 0x1F, 0xE0, 0x39, 0xC0, 0x73, 0x81, 0xE7, 0x83,
  0x87, 0x07, 0x0E, 0x0E, 0x1E, 0x38, 0x1C, 0x70, 0x38, 0xE0, 0x73, 0x80,
  0x77, 0x00, 0xEE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0xF0,
  0x38, 0x1E, 0xE0, 0xF8, 0x39, 0xC1, 0xF0, 0x73, 0x83, 0x60, 0xE7, 0x86,
  0xC3, 0xC7, 0x1D, 0xC7, 0x0E, 0x3B, 0x8E, 0x1C, 0x77, 0x1C, 0x38, 0xC6,
  0x38, 0x3B, 0x8E, 0xE0, 0x77, 0x1D, 0xC0, 0xEE, 0x3B, 0x81, 0xD8, 0x37,
  0x01, 0xB0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x01, 0xC0,
  0x70, 0x1C, 0xF0, 0x78, 0xE0, 0xE0, 0xE3, 0xC1, 0xE7, 0x01, 0xDC, 0x03,
  0xF8, 0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x77, 0x01, 0xC7,
  0x03, 0x8F, 0x0E, 0x0E, 0x3C, 0x1E, 0xF0, 0x1E, 0xE0, 0x1F, 0xE0, 0x39,
  0xC0, 0x73, 0x81, 0xE3, 0x83, 0x87, 0x07, 0x0E, 0x0E, 0x0E, 0x38, 0x1C,
  0x70, 0x38, 0xE0, 0x3B, 0x80, 0x77, 0x00, 0xEE, 0x00, 0xD8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x03,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C,
  0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x87, 0xC3, 0xE3, 0xC1, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x8F, 0x87, 0x83, 0xE0, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0F, 0x83, 0xC0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0x3E, 0x07, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x38, 0x0F, 0xC0, 0xF0, 0xFC, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFC, 0x3E, 0x0E, 0x00, 0x7E, 0x07,
  0xFE, 0x3E, 0xFF, 0xE0, 0x7E,
};

const GFXglyph NotoSans_SemiCondensed_Medium31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 22, 8, 2, -22 },
  { 12, 9, 8, 13, 2, -22 },
  { 21, 16, 22, 18, 1, -22 },
  { 65, 13, 26, 16, 2, -24 },
  { 108, 22, 22, 25, 1, -22 },
  { 169, 19, 22, 20, 1, -22 },
  { 222, 3, 8, 7, 2, -22 },
  { 225, 8, 27, 10, 1, -22 },
  { 252, 7, 27, 10, 1, -22 },
  { 276, 13, 13, 15, 1, -24 },
  { 298, 14, 15, 16, 1, -18 },
  { 325, 5, 8, 8, 1, -4 },
  { 330, 8, 3, 10, 1, -10 },
  { 333, 4, 4, 8, 2, -4 },
  { 335, 12, 22, 12, 0, -22 },
  { 368, 14, 22, 16, 1, -22 },
  { 407, 9, 22, 16, 2, -22 },
  { 432, 14, 22, 16, 1, -22 },
  { 471, 14, 22, 16, 1, -22 },
  { 510, 15, 22, 16, 1, -22 },
  { 552, 13, 22, 16, 2, -22 },
  { 588, 14, 22, 16, 1, -22 },
  { 627, 14, 22, 16, 1, -22 },
  { 666, 14, 22, 16, 1, -22 },
  { 705, 14, 22, 16, 1, -22 },
  { 744, 4, 17, 8, 2, -17 },
  { 753, 5, 21, 8, 1, -17 },
  { 767, 14, 15, 16, 1, -19 },
  { 794, 14, 8, 16, 1, -15 },
  { 808, 14, 15, 16, 1, -19 },
  { 835, 12, 22, 13, 0, -22 },
  { 868, 22, 25, 25, 2, -22 },
  { 937, 18, 22, 18, 0, -22 },
  { 987, 14, 22, 18, 3, -22 },
  { 1026, 15, 22, 18, 2, -22 },
  { 1068, 16, 22, 20, 3, -22 },
  { 1112, 11, 22, 16, 3, -22 },
  { 1143, 11, 22, 15, 3, -22 },
  { 1174, 16, 22, 21, 2, -22 },
  { 1218, 15, 22, 21, 3, -22 },
  { 1260, 8, 22, 10, 1, -22 },
  { 1282, 8, 28, 8, -2, -22 },
  { 1310, 15, 22, 18, 3, -22 },
  { 1352, 11, 22, 15, 3, -22 },
  { 1383, 21, 22, 26, 3, -22 },
  { 1441, 16, 22, 22, 3, -22 },
  { 1485, 18, 22, 22, 2, -22 },
  { 1535, 13, 22, 17, 3, -22 },
  { 1571, 18, 27, 22, 2, -22 },
  { 1632, 15, 22, 18, 3, -22 },
  { 1674, 13, 22, 16, 1, -22 },
  { 1710, 15, 22, 16, 0, -22 },
  { 1752, 16, 22, 21, 2, -22 },
  { 1796, 17, 22, 17, 0, -22 },
  { 1843, 27, 22, 27, 0, -22 },
  { 1918, 17, 22, 17, 0, -22 },
  { 1965, 16, 22, 16, 0, -22 },
  { 2009, 14, 22, 16, 1, -22 },
  { 2048, 7, 27, 10, 2, -22 },
  { 2072, 12, 22, 12, 0, -22 },
  { 2105, 7, 27, 10, 1, -22 },
  { 2129, 15, 13, 17, 1, -22 },
  { 2154, 13, 2, 13, 0, 3 },
  { 2158, 7, 5, 9, 1, -24 },
  { 2163, 13, 17, 16, 1, -17 },
  { 2191, 14, 24, 18, 2, -24 },
  { 2233, 12, 17, 14, 1, -17 },
  { 2259, 14, 24, 18, 1, -24 },
  { 2301, 14, 17, 16, 1, -17 },
  { 2331, 11, 24, 10, 0, -24 },
  { 2364, 14, 24, 18, 1, -17 },
  { 2406, 13, 24, 18, 2, -24 },
  { 2445, 4, 23, 8, 2, -23 },
  { 2457, 7, 30, 8, -1, -23 },
  { 2484, 14, 24, 16, 2, -24 },
  { 2526, 3, 24, 8, 2, -24 },
  { 2535, 22, 17, 27, 2, -17 },
  { 2582, 13, 17, 18, 2, -17 },
  { 2610, 15, 17, 17, 1, -17 },
  { 2642, 14, 24, 18, 2, -17 },
  { 2684, 14, 24, 18, 1, -17 },
  { 2726, 10, 17, 12, 2, -17 },
  { 2748, 11, 17, 14, 1, -17 },
  { 2772, 9, 20, 11, 1, -20 },
  { 2795, 13, 17, 18, 2, -17 },
  { 2823, 15, 17, 15, 0, -17 },
  { 2855, 23, 17, 23, 0, -17 },
  { 2904, 15, 17, 15, 0, -17 },
  { 2936, 15, 24, 15, 0, -17 },
  { 2981, 11, 17, 13, 1, -17 },
  { 3005, 9, 27, 12, 1, -22 },
  { 3036, 3, 31, 16, 6, -24 },
  { 3048, 10, 27, 12, 1, -22 },
  { 3082, 14, 4, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Medium31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM31PT7B_H_
