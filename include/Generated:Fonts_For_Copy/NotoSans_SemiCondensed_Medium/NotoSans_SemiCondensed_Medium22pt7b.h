#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium22pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0xFB, 0xEF, 0xCF, 0x9A, 0x34, 0x68,
  0x80, 0x04, 0x60, 0x44, 0x0C, 0x40, 0xCC, 0x0C, 0xC7, 0xFF, 0x08, 0xC0,
  0x88, 0x18, 0x81, 0x98, 0xFF, 0xF1, 0x98, 0x11, 0x81, 0x10, 0x31, 0x03,
  0x30, 0x08, 0x04, 0x0F, 0xCF, 0xFE, 0x8E, 0x43, 0x20, 0xF0, 0x7C, 0x0F,
  0x82, 0xE1, 0x30, 0x9C, 0x4F, 0xFE, 0xFC, 0x08, 0x04, 0x00, 0x78, 0x30,
  0x78, 0x30, 0xCC, 0x20, 0xCC, 0x60, 0xCC, 0x40, 0xCC, 0xC0, 0xCC, 0x98,
  0xCD, 0xBE, 0x79, 0x36, 0x3B, 0x62, 0x03, 0x63, 0x06, 0x63, 0x06, 0x63,
  0x0C, 0x22, 0x0C, 0x36, 0x18, 0x1C, 0x1E, 0x01, 0xF8, 0x1C, 0xC0, 0xC7,
  0x07, 0x30, 0x19, 0x80, 0xF8, 0x03, 0x80, 0x7E, 0x3B, 0x31, 0xB0, 0xCD,
  0x87, 0xCC, 0x1E, 0x70, 0xF1, 0xFF, 0xC7, 0xE7, 0xFF, 0xA4, 0x80, 0x19,
  0x8C, 0xC6, 0x33, 0x18, 0xC6, 0x31, 0x8C, 0x71, 0x8C, 0x61, 0x8E, 0xC7,
  0x18, 0xE3, 0x18, 0xC7, 0x18, 0xC6, 0x33, 0x98, 0xC6, 0x63, 0x30, 0x1C,
  0x0C, 0x02, 0x19, 0x3F, 0xF8, 0xE0, 0xD8, 0x6C, 0x63, 0x00, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x6D, 0xED, 0x80, 0xFF, 0xC0, 0x7D, 0x80, 0x03, 0x03, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x1E,
  0x1F, 0xC6, 0x3B, 0x86, 0xE1, 0xB0, 0x6C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1B, 0x06, 0xE1, 0x98, 0xE7, 0xF0, 0xF8, 0x0C, 0xF7, 0xFF, 0xDC, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3E, 0x3F, 0xCE, 0x38, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x18,
  0x0F, 0xFF, 0xFF, 0x3E, 0x7F, 0x90, 0xE0, 0x30, 0x18, 0x1C, 0x1C, 0x7C,
  0x3F, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x1F, 0xFD, 0xFC, 0x01, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0xD8, 0x1B, 0x06, 0x61, 0x8C, 0x31, 0x8C, 0x31, 0x86,
  0x7F, 0xFF, 0xFE, 0x03, 0x00, 0x60, 0x0C, 0x7F, 0x3F, 0x98, 0x0C, 0x06,
  0x03, 0x01, 0xF1, 0xFE, 0x43, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x1F, 0xFD,
  0xFC, 0x0F, 0x8F, 0xE3, 0x01, 0x80, 0x60, 0x30, 0x0C, 0xF3, 0x7E, 0xE1,
  0xB0, 0x6C, 0x1F, 0x07, 0xE1, 0x98, 0x67, 0xF8, 0xFC, 0xFF, 0xFF, 0xF0,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70,
  0x18, 0x06, 0x03, 0x80, 0xC0, 0x1E, 0x1F, 0xC6, 0x3B, 0x86, 0xE1, 0x98,
  0xE7, 0x70, 0xF8, 0x3F, 0x18, 0xEC, 0x1B, 0x07, 0xC1, 0xF8, 0x67, 0xF8,
  0xFC, 0x1E, 0x1F, 0xC6, 0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x1F, 0x86, 0x7F,
  0x8F, 0x60, 0x18, 0x06, 0x03, 0x81, 0xC7, 0xE1, 0xF0, 0x7D, 0x80, 0x00,
  0x0F, 0xB0, 0x7D, 0x80, 0x00, 0x0D, 0xFD, 0xB0, 0x00, 0xC0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x38, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0xF0, 0xF0, 0xF0, 0x30, 0x00, 0x3C, 0xFF, 0x43, 0x03, 0x03, 0x03,
  0x07, 0x0E, 0x1C, 0x18, 0x18, 0x00, 0x00, 0x18, 0x38, 0x38, 0x03, 0xE0,
  0x0F, 0xF8, 0x18, 0x1C, 0x30, 0x06, 0x60, 0xC6, 0x63, 0xF3, 0x46, 0x23,
  0xCC, 0x23, 0xCC, 0x23, 0xCC, 0x63, 0xCC, 0x63, 0xCE, 0x66, 0xC7, 0xFE,
  0x61, 0x08, 0x60, 0x00, 0x38, 0x10, 0x1F, 0xF0, 0x07, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1B, 0x00, 0xD8, 0x0E, 0xC0, 0x63, 0x03, 0x18, 0x38,
  0xC1, 0xFF, 0x0F, 0xF8, 0xE0, 0xC7, 0x07, 0x30, 0x1B, 0x80, 0xDC, 0x07,
  0xFC, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x6C, 0x3B, 0xFC, 0xFF, 0xB0,
  0x7C, 0x0F, 0x03, 0xC1, 0xF0, 0x7F, 0xFB, 0xFC, 0x0F, 0xC3, 0xFC, 0xE1,
  0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30,
  0x07, 0x00, 0xF0, 0x0F, 0xF0, 0x7E, 0xFC, 0x1F, 0xF3, 0x0F, 0x60, 0xEC,
  0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0D,
  0x87, 0xBF, 0xE7, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x07, 0xE1, 0xFF, 0x38, 0x27, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE1, 0xFE, 0x1F, 0xE0, 0x36, 0x03, 0x70, 0x33, 0x83, 0x3F, 0xF0, 0xFF,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xDC,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0xFF, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xFF, 0xE0, 0xC0, 0xD8, 0x3B,
  0x0E, 0x63, 0x8C, 0x61, 0x9C, 0x37, 0x06, 0xC0, 0xFC, 0x1D, 0xC3, 0x18,
  0x63, 0x8C, 0x31, 0x87, 0x30, 0x76, 0x07, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xBF, 0x83, 0x7B, 0x06, 0xF6, 0x19,
  0xEE, 0x33, 0xCC, 0x67, 0x99, 0x8F, 0x3B, 0x1E, 0x36, 0x3C, 0x78, 0x78,
  0xF0, 0xF0, 0xE1, 0xE1, 0x83, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xD8,
  0x7D, 0xC7, 0xCC, 0x7C, 0xE7, 0xC6, 0x7C, 0x73, 0xC3, 0x3C, 0x3B, 0xC1,
  0xBC, 0x1F, 0xC0, 0xFC, 0x07, 0x0F, 0x81, 0xFF, 0x0E, 0x1C, 0xE0, 0x66,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xC0,
  0x77, 0x03, 0x38, 0x38, 0xFF, 0x81, 0xF8, 0xFC, 0x7F, 0xB1, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0xFF, 0x7F, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x0F, 0x81, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xC0, 0x77, 0x03, 0x38, 0x38,
  0xFF, 0x81, 0xF8, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xFC, 0x3F,
  0xCC, 0x7B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x1C, 0xFE, 0x3F, 0x8C, 0x63,
  0x1C, 0xC3, 0x30, 0xEC, 0x1F, 0x03, 0x1F, 0x3F, 0xF8, 0x5C, 0x0C, 0x07,
  0x01, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xE0, 0x30, 0x1C, 0x1F, 0xFD, 0xFC,
  0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0xC1, 0x9F, 0xF1, 0xF8, 0xC0, 0x3E, 0x03, 0x60,
  0x76, 0x06, 0x70, 0x63, 0x0E, 0x30, 0xC3, 0x0C, 0x19, 0xC1, 0x98, 0x19,
  0x81, 0xD8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0xC0, 0xE0, 0xFC, 0x1C,
  0x1D, 0x83, 0x83, 0x30, 0x70, 0x66, 0x1B, 0x0C, 0xE3, 0x63, 0x8C, 0x6C,
  0x61, 0x8D, 0x8C, 0x33, 0x19, 0x87, 0x63, 0x70, 0x6C, 0x6C, 0x0D, 0x8D,
  0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x03, 0x83, 0x80, 0x70, 0x70, 0xE0, 0x77,
  0x0E, 0x30, 0xC3, 0x9C, 0x19, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1B, 0x81, 0x98, 0x31, 0xC7, 0x0C, 0x60, 0xEE, 0x07, 0xE0, 0x6C,
  0x1D, 0x83, 0x18, 0x63, 0x18, 0x73, 0x06, 0xE0, 0xF8, 0x0F, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xC0, 0xE0,
  0x60, 0x70, 0x30, 0x38, 0x18, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03,
  0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x3F, 0xF0, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x18, 0x18, 0x18,
  0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0x03, 0xFF, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xF0, 0x08, 0x03, 0x01, 0xC0,
  0x58, 0x32, 0x08, 0xC6, 0x11, 0x86, 0xC0, 0xB0, 0x30, 0xFF, 0xC0, 0xE3,
  0x0C, 0x30, 0x3E, 0x3F, 0x90, 0xE0, 0x30, 0x19, 0xFD, 0xC7, 0x83, 0xC1,
  0xE1, 0xFF, 0xEF, 0xB0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3, 0xFD,
  0xC7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x8F, 0xFE, 0x9E, 0x00,
  0x1F, 0x7F, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x7F, 0x3F,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF, 0x37, 0xED, 0x87, 0xE1, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x76, 0x1D, 0xFF, 0x3E, 0xC0, 0x1E, 0x3F,
  0x98, 0x7C, 0x3C, 0x1F, 0xFF, 0xFF, 0x80, 0xE0, 0x30, 0x1F, 0xE7, 0xF0,
  0x0F, 0x1F, 0x38, 0x30, 0x30, 0x7E, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x3C, 0xDF, 0xB6, 0x1F, 0x87, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE1, 0xD8, 0x77, 0xFC, 0xFB, 0x00, 0xC0, 0x70, 0x19,
  0xFE, 0x7F, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3, 0xFD, 0xC7,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0x80, 0xEC,
  0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x38, 0xC0, 0x01, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x1F, 0x1D, 0x9C, 0xCC, 0x6C, 0x3E, 0x1F, 0x8C, 0xC6, 0x73, 0x1D,
  0x86, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xDE, 0x3D, 0xFE, 0xFF,
  0x8E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3,
  0x87, 0x87, 0x0F, 0x0E, 0x1E, 0x1C, 0x30, 0xDE, 0x7F, 0xB8, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x1F, 0x1F, 0xE6,
  0x1B, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xD8, 0x67, 0xF8, 0xFC,
  0xDE, 0x7F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xFF,
  0xDB, 0xCC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x3C, 0xDF, 0xB6, 0x1F,
  0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xD8, 0x77, 0xEC, 0xFB, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x9F, 0xFE, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0x7F, 0xFE, 0xC0, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x07,
  0x87, 0xFE, 0xFC, 0x10, 0x60, 0xC3, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x07, 0xC7, 0x80, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xE1, 0xFF, 0xEF, 0xB0, 0xC0, 0xF8, 0x36, 0x1D, 0x86,
  0x71, 0x8C, 0xE3, 0x30, 0xEC, 0x1B, 0x07, 0x81, 0xE0, 0x38, 0xE1, 0xC3,
  0x61, 0xC3, 0x63, 0xC6, 0x63, 0xC6, 0x73, 0x66, 0x32, 0x66, 0x36, 0x6C,
  0x36, 0x6C, 0x36, 0x2C, 0x1C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0xE0, 0xDC,
  0x63, 0x38, 0x6C, 0x1F, 0x03, 0x80, 0xE0, 0x7C, 0x3B, 0x0C, 0xE7, 0x1F,
  0x83, 0xE0, 0xEC, 0x19, 0x87, 0x30, 0xC3, 0x18, 0x67, 0x0C, 0xC0, 0xD8,
  0x1B, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x07, 0xC0, 0xF0,
  0x00, 0xFE, 0xFE, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0xFF,
  0xFF, 0x0C, 0x73, 0x8C, 0x30, 0xC3, 0x0C, 0x33, 0x8E, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xE1, 0xC1, 0xFF, 0xFF, 0xFC, 0xC1, 0xC1, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x38, 0x3C, 0x79, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xE3, 0x84,
  0x00, 0xF8, 0x7F, 0xF8, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_Medium22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 16, 6, 1, -16 },
  { 7, 7, 6, 9, 1, -16 },
  { 13, 12, 16, 13, 0, -16 },
  { 37, 9, 18, 12, 1, -17 },
  { 58, 16, 16, 17, 1, -16 },
  { 90, 13, 16, 14, 1, -16 },
  { 116, 3, 6, 5, 1, -16 },
  { 119, 5, 19, 7, 1, -16 },
  { 131, 5, 19, 7, 1, -16 },
  { 143, 9, 9, 11, 1, -17 },
  { 154, 10, 11, 12, 1, -13 },
  { 168, 3, 6, 6, 1, -3 },
  { 171, 5, 2, 7, 1, -7 },
  { 173, 3, 3, 6, 1, -3 },
  { 175, 8, 16, 8, 0, -16 },
  { 191, 10, 16, 12, 1, -16 },
  { 211, 6, 16, 12, 2, -16 },
  { 223, 10, 16, 12, 1, -16 },
  { 243, 9, 16, 12, 1, -16 },
  { 261, 11, 16, 12, 0, -16 },
  { 283, 9, 16, 12, 1, -16 },
  { 301, 10, 16, 12, 1, -16 },
  { 321, 10, 16, 12, 1, -16 },
  { 341, 10, 16, 12, 1, -16 },
  { 361, 10, 16, 12, 1, -16 },
  { 381, 3, 12, 6, 1, -12 },
  { 386, 3, 15, 6, 1, -12 },
  { 392, 10, 10, 12, 1, -13 },
  { 405, 10, 6, 12, 1, -11 },
  { 413, 10, 10, 12, 1, -13 },
  { 426, 8, 16, 9, 0, -16 },
  { 442, 16, 18, 18, 1, -16 },
  { 478, 13, 16, 13, 0, -16 },
  { 504, 10, 16, 13, 2, -16 },
  { 524, 11, 16, 13, 1, -16 },
  { 546, 11, 16, 14, 2, -16 },
  { 568, 8, 16, 11, 2, -16 },
  { 584, 8, 16, 11, 2, -16 },
  { 600, 12, 16, 15, 1, -16 },
  { 624, 11, 16, 15, 2, -16 },
  { 646, 5, 16, 7, 1, -16 },
  { 656, 5, 20, 6, -1, -16 },
  { 669, 11, 16, 13, 2, -16 },
  { 691, 8, 16, 11, 2, -16 },
  { 707, 15, 16, 19, 2, -16 },
  { 737, 12, 16, 16, 2, -16 },
  { 761, 13, 16, 15, 1, -16 },
  { 787, 9, 16, 12, 2, -16 },
  { 805, 13, 20, 15, 1, -16 },
  { 838, 10, 16, 13, 2, -16 },
  { 858, 9, 16, 11, 1, -16 },
  { 876, 11, 16, 11, 0, -16 },
  { 898, 11, 16, 15, 2, -16 },
  { 920, 12, 16, 12, 0, -16 },
  { 944, 19, 16, 19, 0, -16 },
  { 982, 12, 16, 12, 0, -16 },
  { 1006, 11, 16, 11, 0, -16 },
  { 1028, 9, 16, 11, 1, -16 },
  { 1046, 5, 20, 7, 2, -16 },
  { 1059, 8, 16, 8, 0, -16 },
  { 1075, 5, 20, 7, 1, -16 },
  { 1088, 10, 10, 12, 1, -16 },
  { 1101, 10, 1, 10, 0, 2 },
  { 1103, 5, 4, 7, 1, -17 },
  { 1106, 9, 12, 11, 1, -12 },
  { 1120, 9, 17, 12, 2, -17 },
  { 1140, 8, 12, 10, 1, -12 },
  { 1152, 10, 17, 12, 1, -17 },
  { 1174, 9, 12, 11, 1, -12 },
  { 1188, 8, 17, 7, 0, -17 },
  { 1205, 10, 17, 12, 1, -12 },
  { 1227, 9, 17, 13, 2, -17 },
  { 1247, 3, 16, 6, 1, -16 },
  { 1253, 5, 21, 6, -1, -16 },
  { 1267, 9, 17, 11, 2, -17 },
  { 1287, 2, 17, 6, 2, -17 },
  { 1292, 15, 12, 19, 2, -12 },
  { 1315, 9, 12, 13, 2, -12 },
  { 1329, 10, 12, 12, 1, -12 },
  { 1344, 9, 17, 12, 2, -12 },
  { 1364, 10, 17, 12, 1, -12 },
  { 1386, 6, 12, 8, 2, -12 },
  { 1395, 8, 12, 10, 1, -12 },
  { 1407, 7, 15, 8, 0, -15 },
  { 1421, 9, 12, 13, 2, -12 },
  { 1435, 10, 12, 11, 0, -12 },
  { 1450, 16, 12, 16, 0, -12 },
  { 1474, 10, 12, 11, 0, -12 },
  { 1489, 11, 17, 11, 0, -12 },
  { 1513, 8, 12, 9, 1, -12 },
  { 1525, 6, 20, 8, 1, -16 },
  { 1540, 1, 22, 11, 5, -17 },
  { 1543, 7, 20, 8, 1, -16 },
  { 1561, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Medium22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM22PT7B_H_
