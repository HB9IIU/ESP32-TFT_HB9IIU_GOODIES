#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium38pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDC, 0x00, 0x01, 0xCF, 0xFF, 0xDE, 0xF1, 0xFF, 0x0E, 0xF0, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x01, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF0, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x07,
  0xF0, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0xF9, 0x84, 0xF1, 0x80, 0xF1,
  0x80, 0xF1, 0x80, 0xF1, 0x80, 0x7D, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0x9F, 0x01, 0x8F, 0x01, 0x8F, 0x01,
  0x8F, 0x81, 0x8F, 0xF1, 0xBE, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xE0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x08, 0x00, 0x00, 0x07, 0xE0,
  0x07, 0x01, 0xFE, 0x01, 0xC0, 0x79, 0xC0, 0x38, 0x0E, 0x1C, 0x0E, 0x01,
  0xC3, 0x81, 0xC0, 0x38, 0x70, 0x78, 0x07, 0x0E, 0x0E, 0x00, 0xE1, 0xC3,
  0xC0, 0x1C, 0x38, 0x70, 0x03, 0x87, 0x1E, 0x00, 0x70, 0xE3, 0x87, 0x0E,
  0x1C, 0xF3, 0xF1, 0xC3, 0x9C, 0xFF, 0x1C, 0xE7, 0x9C, 0xF3, 0xFC, 0xE7,
  0x0E, 0x3F, 0x3C, 0xE1, 0xC1, 0x07, 0x1C, 0x3C, 0x01, 0xE3, 0x87, 0x80,
  0x38, 0x70, 0xF0, 0x07, 0x0E, 0x1E, 0x01, 0xC1, 0xC3, 0xC0, 0x38, 0x38,
  0x70, 0x0E, 0x07, 0x0E, 0x01, 0xC0, 0xF1, 0xC0, 0x70, 0x0F, 0x78, 0x0E,
  0x01, 0xFE, 0x03, 0x80, 0x1F, 0x80, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x0F,
  0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x79,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8,
  0x1E, 0x1F, 0xF8, 0x3C, 0x7C, 0xF0, 0x79, 0xF0, 0xF0, 0xF3, 0xC1, 0xF3,
  0xC7, 0x81, 0xF7, 0x8F, 0x01, 0xFE, 0x1E, 0x01, 0xFC, 0x3C, 0x01, 0xF0,
  0x7C, 0x07, 0xF0, 0xFC, 0x3F, 0xF0, 0xFF, 0xFD, 0xE0, 0xFF, 0xF3, 0xE0,
  0xFF, 0x83, 0xF0, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x07, 0x87, 0x07, 0x83,
  0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78,
  0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C,
  0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x8E,
  0x39, 0xFF, 0xFD, 0xFF, 0xFE, 0x3F, 0xFE, 0x81, 0xF0, 0x01, 0xDC, 0x01,
  0xEF, 0x00, 0xE7, 0x80, 0xF1, 0xE0, 0xF0, 0xF8, 0x08, 0x20, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x3C, 0xF3, 0xCE, 0x79, 0xE7, 0x1C, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x73, 0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x01, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0,
  0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3D, 0xFE, 0xFF, 0x3D, 0x8F, 0x43, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x01, 0x00,
  0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0x60, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x3F, 0xF0, 0xFF, 0xF8,
  0xFF, 0xFC, 0x70, 0x3E, 0x40, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1E, 0xC0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1D, 0xE0, 0x0E, 0x78, 0x03, 0x9E, 0x01, 0xC7,
  0x80, 0xF1, 0xE0, 0x38, 0x78, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xE1,
  0xE0, 0x78, 0x70, 0x1E, 0x38, 0x07, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F,
  0xE0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7D, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x80,
  0x1E, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x03, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC,
  0x3E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x3C, 0x3E, 0x3F, 0xFC, 0x1F,
  0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x00, 0x01, 0x80, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1E, 0xF0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x7C, 0x3E, 0x3E,
  0x7C, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xFC, 0x7C, 0x7E, 0xF8,
  0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0xF0, 0x0F, 0xE0, 0x3F,
  0xF8, 0x7F, 0xFC, 0x78, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0x7C,
  0x3F, 0x7F, 0xFF, 0x3F, 0xEF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x7F, 0xF0, 0x7F,
  0xE0, 0x7F, 0x80, 0x33, 0xFF, 0xF7, 0x90, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x73, 0xFF, 0xF7, 0x80, 0x18, 0xF7, 0xDF, 0x3C, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x79, 0xE7, 0x9C, 0x73,
  0x80, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x01, 0x00, 0x7F, 0xE3, 0xFF, 0xE3, 0xFF, 0xE7, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0xF0, 0x00,
  0x70, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xF1, 0xC0, 0x7E, 0x0E, 0x78,
  0x3F, 0xF1, 0xCE, 0x0F, 0xFE, 0x1D, 0xC3, 0xC3, 0xC3, 0xF8, 0x70, 0x70,
  0x7E, 0x1E, 0x0E, 0x0F, 0xC3, 0x81, 0xC1, 0xF8, 0x70, 0x38, 0x3F, 0x0E,
  0x07, 0x07, 0xE1, 0xC0, 0xE0, 0xFC, 0x38, 0x1C, 0x1F, 0x87, 0x87, 0x87,
  0x70, 0x70, 0xF8, 0xEF, 0x0F, 0xFF, 0xF8, 0xE0, 0xFE, 0x7E, 0x1C, 0x0F,
  0x07, 0x83, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x60, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07,
  0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0,
  0xF0, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xC0, 0xFC, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x03, 0xEF, 0x01, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x3F, 0xF0, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xF8, 0x1C, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x81, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0x07, 0xF8, 0xF0,
  0x0F, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x0F,
  0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBC,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x0E, 0x1F, 0x80,
  0x10, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0xE0, 0x0F,
  0x1F, 0xC0, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0x80, 0xFF, 0xFF, 0xF7, 0xF8, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x7F, 0xFE, 0xFF, 0x3F, 0x80, 0xF0, 0x03, 0xFE,
  0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x0F, 0x8F, 0x01, 0xE1, 0xE0, 0x78, 0x3C,
  0x1F, 0x07, 0x87, 0xC0, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x7B,
  0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xEF, 0x80, 0xF8,
  0xF0, 0x1E, 0x1F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xE1, 0xE0,
  0x3C, 0x3C, 0x07, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xFB, 0xC0,
  0x0F, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x70, 0x03,
  0xFF, 0xDC, 0x00, 0xEF, 0xF7, 0x80, 0x7B, 0xFC, 0xE0, 0x1E, 0xFF, 0x38,
  0x07, 0x3F, 0xCF, 0x03, 0xCF, 0xF1, 0xC0, 0xF3, 0xFC, 0x70, 0x38, 0xFF,
  0x1E, 0x1E, 0x3F, 0xC7, 0x87, 0x8F, 0xF0, 0xE1, 0xC3, 0xFC, 0x3C, 0xF0,
  0xFF, 0x0F, 0x3C, 0x3F, 0xC1, 0xCE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0x3F, 0x03, 0xFC,
  0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3C, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFE, 0xF0, 0x0F, 0xF3, 0xC0, 0x7F, 0x9E, 0x03, 0xFC, 0x78, 0x1F, 0xE3,
  0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x7C, 0x3F, 0xC1, 0xE1, 0xFE, 0x0F, 0x8F,
  0xF0, 0x3C, 0x7F, 0x80, 0xF3, 0xFC, 0x07, 0x9F, 0xE0, 0x1E, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x18, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0x07, 0xC0, 0x1F, 0x1F, 0x00,
  0x1E, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xE0, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1F,
  0x00, 0x7C, 0x1F, 0x83, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x7E, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x3F, 0x07, 0xC0,
  0x1F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x7B, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0x0F,
  0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F, 0x83, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC1, 0xFC, 0xF0, 0x1F, 0x3C, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x7C, 0xF0, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xF0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F,
  0x00, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3C, 0x00,
  0x80, 0x1F, 0xF8, 0xFF, 0xFB, 0xFF, 0xF7, 0xC1, 0xDF, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x7D, 0xFF, 0xFB,
  0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1E, 0xF0,
  0x07, 0xDF, 0x00, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01,
  0xE7, 0x80, 0x0F, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x1E,
  0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x78,
  0x07, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C,
  0x78, 0x00, 0xF3, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xBC, 0x01, 0xF0, 0x07, 0x9E, 0x00, 0xF8,
  0x03, 0xCF, 0x00, 0x7C, 0x01, 0xE7, 0x80, 0x7E, 0x01, 0xE1, 0xE0, 0x3F,
  0x80, 0xF0, 0xF0, 0x1D, 0xC0, 0x78, 0x78, 0x1E, 0xE0, 0x3C, 0x3C, 0x0F,
  0x70, 0x1C, 0x0E, 0x07, 0x3C, 0x1E, 0x07, 0x83, 0x9E, 0x0F, 0x03, 0xC3,
  0xC7, 0x07, 0x81, 0xE1, 0xE3, 0x83, 0xC0, 0xF0, 0xE1, 0xE3, 0xC0, 0x3C,
  0x70, 0xF1, 0xE0, 0x1E, 0x78, 0x38, 0xF0, 0x0F, 0x3C, 0x1E, 0x78, 0x07,
  0x9C, 0x0F, 0x78, 0x01, 0xCE, 0x07, 0xBC, 0x00, 0xF7, 0x01, 0xDE, 0x00,
  0x7F, 0x80, 0xEF, 0x00, 0x3F, 0x80, 0x77, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x03,
  0xC1, 0xE0, 0x3C, 0x1F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x8F, 0x00, 0x78,
  0xF0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0x7D, 0xE0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x01, 0xE7, 0x80, 0x1F, 0xF8, 0x00,
  0xF0, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xE3, 0xC0, 0x3C, 0x3C,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0x70,
  0x0E, 0x1C, 0x07, 0x07, 0x81, 0xC0, 0xE0, 0xF0, 0x3C, 0x38, 0x07, 0x1E,
  0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x07, 0x07, 0xE0, 0xFF, 0xF0, 0xFF, 0xF1,
  0xE3, 0xE2, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x3F,
  0xFC, 0xFF, 0xFB, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xBB, 0xFE, 0x73, 0xF8, 0xE0, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF1, 0xF0, 0x7B, 0xFC, 0x3F, 0xFF, 0x1F, 0xEF, 0xCF,
  0x81, 0xF7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3D, 0xE0,
  0x1E, 0xF8, 0x1F, 0x7E, 0x0F, 0x3F, 0xFF, 0x9C, 0xFF, 0x8E, 0x3F, 0x80,
  0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0xDE, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x23, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xC7, 0x8F, 0xF3, 0xCF, 0xFD,
  0xEF, 0xEF, 0xF7, 0xC1, 0xFB, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x1F, 0x78, 0x0F, 0xBE, 0x0F, 0xCF, 0xFF, 0xE7, 0xFE,
  0xF0, 0xFE, 0x78, 0x03, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3E, 0x3E, 0x78,
  0x1E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x7F,
  0x83, 0xFC, 0x3E, 0x21, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x07,
  0xFF, 0x3F, 0xF9, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0xC0, 0x0F,
  0xF3, 0xCF, 0xFD, 0xEF, 0xEF, 0xF7, 0xC1, 0xFB, 0xC0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0x78, 0x0F, 0xBE, 0x0F, 0xCF,
  0xFF, 0xE7, 0xFE, 0xF0, 0xFE, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x20, 0x07, 0x9C, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF,
  0x80, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xF0, 0xF7, 0xFC, 0xFF, 0xFE, 0xFF,
  0x7E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0xC7, 0xBF, 0xDF, 0xCF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xF0, 0xF3,
  0xE0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFB,
  0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x3C, 0xF0,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x3E, 0x1C,
  0xFF, 0x1F, 0xF3, 0xBF, 0xF7, 0xFF, 0x7F, 0x3F, 0xF7, 0xEF, 0x81, 0xF8,
  0x3F, 0xF0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0x80, 0xF0, 0x0F, 0xF0,
  0x1E, 0x01, 0xFE, 0x03, 0xC0, 0x3F, 0xC0, 0x78, 0x07, 0xF8, 0x0F, 0x00,
  0xFF, 0x01, 0xE0, 0x1F, 0xE0, 0x3C, 0x03, 0xFC, 0x07, 0x80, 0x7F, 0x80,
  0xF0, 0x0F, 0xF0, 0x1E, 0x01, 0xFE, 0x03, 0xC0, 0x3F, 0xC0, 0x78, 0x07,
  0xF8, 0x0F, 0x00, 0xFF, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0xE7, 0xFC, 0xEF,
  0xFE, 0xFF, 0x7E, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x87, 0xEF, 0xC7, 0xC1, 0xF3,
  0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0xF0, 0x1F, 0x78,
  0x0F, 0x3E, 0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xF0,
  0x73, 0xFC, 0x3B, 0xFF, 0x1F, 0xCF, 0xCF, 0x81, 0xF7, 0xC0, 0x7B, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3D, 0xE0, 0x1E, 0xF8, 0x1F, 0x7E, 0x1F,
  0x3F, 0xFF, 0x9E, 0xFF, 0x8F, 0x3F, 0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x0F, 0xF3, 0xCF, 0xFD, 0xEF, 0xEF, 0xF7, 0x81,
  0xFB, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0x78, 0x0F, 0xBE, 0x0F, 0xCF, 0xFF, 0xE7, 0xFE, 0xF0, 0xFE, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xFC, 0x7F, 0x9F, 0xF7, 0xFF,
  0xE1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x0F,
  0xC1, 0xFF, 0xDF, 0xFD, 0xF0, 0xEF, 0x01, 0x70, 0x03, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xE0,
  0x0F, 0x00, 0x7E, 0x07, 0xFF, 0xFD, 0xFF, 0xCF, 0xFC, 0x00, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0x07, 0xF8, 0xFF, 0x0F, 0xE0, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7F, 0xFF, 0x7F, 0xEF, 0x1F,
  0xC7, 0xF0, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x3C, 0x0F,
  0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x38, 0x1E, 0x1E, 0x07, 0x87, 0x80,
  0xE1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xCE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0xF7, 0x80, 0xF8, 0x0F, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E,
  0x78, 0x1F, 0x81, 0xE3, 0x81, 0xFC, 0x1C, 0x3C, 0x3D, 0xC3, 0xC3, 0xC3,
  0x9C, 0x3C, 0x3C, 0x39, 0xC3, 0xC1, 0xC3, 0x9E, 0x38, 0x1E, 0x78, 0xE7,
  0x81, 0xE7, 0x0E, 0x78, 0x1E, 0x70, 0xE7, 0x80, 0xE7, 0x0F, 0x70, 0x0E,
  0xF0, 0xF7, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x07, 0xCF, 0x03, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x0F, 0x1E, 0x03,
  0xEF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xEF, 0x00, 0xF1, 0xE0, 0x78, 0x78,
  0x1E, 0x0F, 0x0F, 0x03, 0xC7, 0xC0, 0x7B, 0xE0, 0x1F, 0xF8, 0x03, 0xDE,
  0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x3C, 0x0F, 0x0F, 0x03, 0xC1, 0xC0,
  0xF0, 0x78, 0x38, 0x1E, 0x1E, 0x03, 0x87, 0x80, 0xF1, 0xC0, 0x3C, 0xF0,
  0x07, 0x3C, 0x01, 0xEE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E,
  0x0F, 0xC0, 0xF0, 0x0F, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x07,
  0xF0, 0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0xC0, 0xFE, 0x01,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF0, 0x3F, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0xFE, 0x0F, 0xC0, 0xF0, 0x00, 0x7E, 0x01, 0xFF,
  0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0x80, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_Medium38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 27, 10, 2, -27 },
  { 18, 12, 10, 16, 2, -27 },
  { 33, 20, 27, 22, 1, -27 },
  { 101, 16, 31, 20, 2, -29 },
  { 163, 27, 28, 30, 2, -28 },
  { 258, 23, 28, 25, 2, -28 },
  { 339, 4, 10, 9, 2, -27 },
  { 344, 9, 33, 12, 2, -27 },
  { 382, 9, 33, 12, 1, -27 },
  { 420, 17, 16, 19, 1, -29 },
  { 454, 16, 19, 20, 2, -23 },
  { 492, 6, 9, 10, 1, -4 },
  { 499, 9, 4, 12, 1, -12 },
  { 504, 5, 5, 10, 2, -5 },
  { 508, 14, 27, 15, 0, -27 },
  { 556, 16, 28, 20, 2, -28 },
  { 612, 10, 27, 20, 3, -27 },
  { 646, 16, 28, 20, 2, -28 },
  { 702, 16, 28, 20, 2, -28 },
  { 758, 18, 27, 20, 1, -27 },
  { 819, 16, 27, 20, 2, -27 },
  { 873, 16, 27, 20, 2, -27 },
  { 927, 17, 27, 20, 1, -27 },
  { 985, 16, 28, 20, 2, -28 },
  { 1041, 16, 27, 20, 2, -27 },
  { 1095, 5, 21, 10, 2, -21 },
  { 1109, 6, 26, 10, 1, -21 },
  { 1129, 16, 19, 20, 2, -23 },
  { 1167, 16, 11, 20, 2, -19 },
  { 1189, 16, 19, 20, 2, -23 },
  { 1227, 15, 28, 15, 0, -28 },
  { 1280, 27, 30, 31, 2, -27 },
  { 1382, 22, 27, 22, 0, -27 },
  { 1457, 18, 27, 23, 3, -27 },
  { 1518, 19, 28, 22, 2, -28 },
  { 1585, 20, 27, 25, 3, -27 },
  { 1653, 14, 27, 19, 3, -27 },
  { 1701, 14, 27, 18, 3, -27 },
  { 1749, 21, 28, 25, 2, -28 },
  { 1823, 19, 27, 26, 3, -27 },
  { 1888, 10, 27, 13, 1, -27 },
  { 1922, 10, 34, 10, -3, -27 },
  { 1965, 19, 27, 22, 3, -27 },
  { 2030, 14, 27, 18, 3, -27 },
  { 2078, 26, 27, 32, 3, -27 },
  { 2166, 21, 27, 27, 3, -27 },
  { 2237, 23, 28, 27, 2, -28 },
  { 2318, 16, 27, 21, 3, -27 },
  { 2372, 23, 34, 27, 2, -28 },
  { 2470, 18, 27, 22, 3, -27 },
  { 2531, 15, 28, 19, 2, -28 },
  { 2584, 19, 27, 19, 0, -27 },
  { 2649, 19, 27, 25, 3, -27 },
  { 2714, 21, 27, 21, 0, -27 },
  { 2785, 33, 27, 33, 0, -27 },
  { 2897, 20, 27, 21, 0, -27 },
  { 2965, 20, 27, 20, 0, -27 },
  { 3033, 17, 27, 19, 1, -27 },
  { 3091, 8, 33, 12, 3, -27 },
  { 3124, 14, 27, 15, 0, -27 },
  { 3172, 9, 33, 12, 1, -27 },
  { 3210, 18, 16, 20, 1, -27 },
  { 3246, 16, 3, 16, 0, 3 },
  { 3252, 8, 6, 11, 2, -29 },
  { 3258, 15, 21, 20, 2, -21 },
  { 3298, 17, 29, 22, 3, -29 },
  { 3360, 14, 21, 17, 2, -21 },
  { 3397, 17, 29, 22, 2, -29 },
  { 3459, 16, 21, 20, 2, -21 },
  { 3501, 13, 29, 12, 1, -29 },
  { 3549, 17, 30, 22, 2, -21 },
  { 3613, 16, 29, 22, 3, -29 },
  { 3671, 4, 28, 10, 3, -28 },
  { 3685, 9, 37, 10, -2, -28 },
  { 3727, 16, 29, 19, 3, -29 },
  { 3785, 4, 29, 10, 3, -29 },
  { 3800, 27, 21, 33, 3, -21 },
  { 3871, 16, 21, 22, 3, -21 },
  { 3913, 17, 21, 21, 2, -21 },
  { 3958, 17, 30, 22, 3, -21 },
  { 4022, 17, 30, 22, 2, -21 },
  { 4086, 11, 21, 15, 3, -21 },
  { 4115, 13, 21, 17, 2, -21 },
  { 4150, 11, 25, 13, 1, -25 },
  { 4185, 16, 20, 22, 3, -20 },
  { 4225, 18, 20, 18, 0, -20 },
  { 4270, 28, 21, 28, 0, -21 },
  { 4344, 18, 20, 18, 0, -20 },
  { 4389, 18, 29, 18, 0, -20 },
  { 4455, 14, 20, 16, 1, -20 },
  { 4490, 12, 33, 14, 1, -27 },
  { 4540, 3, 38, 19, 8, -29 },
  { 4555, 12, 33, 14, 1, -27 },
  { 4605, 16, 5, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_Medium38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM38PT7B_H_
