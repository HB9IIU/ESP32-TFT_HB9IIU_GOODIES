#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM30PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0x66, 0x66, 0x66, 0x60, 0x06, 0xFF, 0xF0,
  0xE7, 0xF1, 0xF8, 0xFC, 0x6E, 0x37, 0x1B, 0x8C, 0x07, 0x1C, 0x07, 0x18,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0E, 0x38, 0x7F, 0xFF, 0x7F, 0xFF,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x18, 0x60, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xC0, 0x30, 0xC0,
  0x30, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x03, 0xFE, 0x7F, 0xFF, 0x6E, 0xE6,
  0x0C, 0x60, 0xE6, 0x0E, 0x60, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x06,
  0xF0, 0x67, 0x06, 0x70, 0x67, 0xC6, 0xFF, 0xFE, 0xFF, 0xC0, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x0E, 0x07, 0x70, 0x30,
  0x18, 0xC1, 0xC0, 0xE3, 0x86, 0x03, 0x8E, 0x38, 0x0E, 0x38, 0xC0, 0x38,
  0xE7, 0x00, 0xE3, 0x9C, 0x03, 0x8E, 0xE7, 0x86, 0x33, 0xBF, 0x1D, 0xCC,
  0xCE, 0x3E, 0x77, 0x18, 0x21, 0x9C, 0x60, 0x0E, 0x71, 0xC0, 0x31, 0xC7,
  0x01, 0xC7, 0x1C, 0x06, 0x1C, 0x60, 0x38, 0x71, 0x80, 0xC0, 0xCE, 0x07,
  0x03, 0xF8, 0x38, 0x07, 0xC0, 0x07, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x00, 0xE7, 0x00,
  0x1D, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC1, 0xC7, 0xBC, 0x38,
  0xE3, 0xC7, 0x3C, 0x3D, 0xE7, 0x03, 0xF8, 0xE0, 0x3F, 0x1E, 0x03, 0xC3,
  0xC0, 0xF8, 0x3E, 0xFF, 0x83, 0xFF, 0x78, 0x3F, 0x87, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0x70, 0xE1, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x0E, 0x1C,
  0xE0, 0xE0, 0xE1, 0xC3, 0x83, 0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x38, 0x61, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0,
  0x0D, 0x80, 0xEE, 0x0E, 0x38, 0x71, 0xC0, 0x88, 0x00, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7B, 0x9C,
  0xE6, 0x73, 0x80, 0xFF, 0xFC, 0x6F, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0xFE, 0x0F, 0xF8, 0x71, 0xE7, 0x07, 0x38, 0x1D,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0xDE, 0x1C, 0x7B, 0xE1, 0xFE,
  0x07, 0xE0, 0x07, 0x87, 0xCF, 0xEF, 0xFF, 0x7B, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x07, 0x01, 0xFF, 0x3F, 0xFC, 0xE1, 0xE2, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0x3F, 0xFC, 0xC1, 0xE4, 0x07, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x1F, 0x07, 0xE0, 0x3F, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x1F, 0xE3, 0xEF, 0xFE,
  0x3F, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0x70, 0x1D,
  0xC0, 0x67, 0x03, 0xBC, 0x1C, 0xF0, 0x73, 0xC3, 0x8F, 0x0C, 0x3C, 0x70,
  0xF3, 0x83, 0xCE, 0x0F, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x7F, 0xE7, 0xFE, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x8F, 0xFE, 0x63, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x0F, 0xE3, 0xEF, 0xFC, 0xFF,
  0x80, 0x01, 0xF0, 0x3F, 0x87, 0xFC, 0x3C, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x71, 0x83, 0x3F, 0x3B, 0xFD, 0xF0, 0xFF, 0x03, 0xF8, 0x1F,
  0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDE, 0x0E, 0x7D, 0xE1, 0xFF, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xFF, 0x0F, 0xFC, 0xF0, 0xF7, 0x03, 0xB8, 0x1D, 0xC0, 0xEE,
  0x0E, 0x38, 0xF0, 0xFF, 0x03, 0xF0, 0x3F, 0x83, 0xDF, 0x3C, 0x3D, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0E, 0xF0, 0xF3, 0xFF, 0x0F, 0xF0,
  0x07, 0x00, 0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x78, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x81, 0xDC, 0x1E, 0xF9, 0xF3, 0xFF, 0x8F, 0xDC, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x87, 0xC3, 0xFC, 0x1F, 0x80,
  0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x6F, 0xFF, 0x7B, 0xDE, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3D, 0xCE, 0x73, 0x39, 0x80, 0x00, 0x08, 0x01,
  0xC0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80,
  0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x00, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x00, 0x60, 0x00, 0x0E, 0x0F,
  0xFB, 0xFF, 0xB0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x78,
  0x1E, 0x03, 0x80, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30,
  0x0F, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3C, 0x03, 0x83, 0x80, 0x0E, 0x18, 0x00, 0x39, 0xC1, 0xF0, 0xCC,
  0x3F, 0xC6, 0xE3, 0xCE, 0x3E, 0x1C, 0x71, 0xF1, 0xC3, 0x87, 0x8E, 0x1C,
  0x3C, 0x70, 0xE3, 0xE3, 0x87, 0x1F, 0x1C, 0x38, 0xF8, 0xE1, 0xC6, 0xC3,
  0xBF, 0x77, 0x1F, 0x9F, 0x38, 0x18, 0x60, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0x70, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x87, 0x01, 0xE1, 0xC0,
  0x70, 0x70, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xE0, 0x1C, 0x78,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x7B, 0xC0, 0x0E, 0xE0, 0x03, 0xC0, 0xFF,
  0xC7, 0xFF, 0xB8, 0x3D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0E,
  0xE3, 0xE7, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x03, 0xFF, 0xFD, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xE0,
  0x3F, 0xF1, 0xFF, 0xCF, 0x82, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0x87, 0xE7, 0x03, 0xCE, 0x03, 0xDC, 0x03,
  0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC0, 0xF3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00,
  0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x3E, 0x06, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78, 0x07, 0x7C,
  0x07, 0x3F, 0xBF, 0x1F, 0xFF, 0x07, 0xFE, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0, 0xFF,
  0xFE, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0xFE, 0xFC, 0xF0, 0xE0,
  0x3F, 0x81, 0xEE, 0x0F, 0x38, 0x38, 0xE1, 0xC3, 0x8F, 0x0E, 0x78, 0x39,
  0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xF0, 0x3D, 0xC0, 0xE7, 0x83, 0x8F, 0x0E,
  0x1C, 0x38, 0x78, 0xE0, 0xE3, 0x83, 0xCE, 0x07, 0xB8, 0x0E, 0xE0, 0x3C,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFD, 0x80, 0x3F, 0xDC, 0x03, 0xFD, 0xC0, 0x77, 0xCC, 0x07, 0x7C, 0xE0,
  0x77, 0xCE, 0x0E, 0x7C, 0xE0, 0xE7, 0xC7, 0x0C, 0x7C, 0x71, 0xC7, 0xC7,
  0x1C, 0x7C, 0x39, 0x87, 0xC3, 0xB8, 0x7C, 0x3B, 0x87, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0E, 0x07, 0xC0, 0xE0, 0x70, 0xF0, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xDC, 0x07, 0xDE, 0x07, 0xCE, 0x07,
  0xCF, 0x07, 0xC7, 0x07, 0xC7, 0x87, 0xC3, 0x87, 0xC1, 0xC7, 0xC1, 0xE7,
  0xC0, 0xE7, 0xC0, 0xF7, 0xC0, 0x77, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x87, 0x83,
  0xC7, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xF0, 0x07, 0xB8, 0x03, 0x9E, 0x03, 0xC7, 0xEF, 0xC1, 0xFF,
  0xC0, 0x3F, 0x80, 0xFF, 0xCF, 0xFE, 0xE1, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0xEF, 0xFC, 0xFF, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x87, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x3B,
  0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xB8,
  0x03, 0x9E, 0x03, 0xC7, 0xEF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0xFF, 0xC3, 0xFF,
  0x8E, 0x3F, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0,
  0xF3, 0x87, 0x8F, 0xFC, 0x3F, 0xE0, 0xE3, 0x83, 0x8F, 0x0E, 0x1C, 0x38,
  0x78, 0xE0, 0xE3, 0x83, 0xCE, 0x07, 0xB8, 0x0E, 0xE0, 0x3C, 0x07, 0x80,
  0xFF, 0x8F, 0xFC, 0xF0, 0x67, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xE0, 0x1D, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x78, 0x1E, 0x3F, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0xE0, 0x07, 0xB8, 0x03,
  0x9C, 0x01, 0xCE, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x78,
  0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x73, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x60, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x1E, 0x03, 0xDC, 0x07, 0x80, 0xE7,
  0x01, 0xE0, 0x39, 0xC0, 0xF8, 0x0E, 0x70, 0x3F, 0x07, 0x8E, 0x0F, 0xC1,
  0xC3, 0x83, 0x70, 0x70, 0xE1, 0xCC, 0x1C, 0x38, 0x73, 0x8F, 0x07, 0x1C,
  0xE3, 0x81, 0xC6, 0x38, 0xE0, 0x73, 0x86, 0x38, 0x1C, 0xE1, 0xCE, 0x03,
  0x38, 0x77, 0x00, 0xEC, 0x1D, 0xC0, 0x3F, 0x03, 0x70, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x00, 0x78, 0x0F, 0x38, 0x1E, 0x3C, 0x1C, 0x1C, 0x3C, 0x1E, 0x38,
  0x0E, 0x70, 0x0F, 0x70, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x3C,
  0x38, 0x1C, 0x38, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x1E,
  0x78, 0x1C, 0x38, 0x1C, 0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0E, 0x70,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xFF, 0xFC, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0xC0, 0x33, 0x01, 0xCE, 0x06, 0x18, 0x38, 0x70, 0xC0, 0xC7,
  0x03, 0x98, 0x0E, 0xE0, 0x1F, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0xF0, 0xE0, 0xE0, 0xE0, 0x3F, 0xE3, 0xFF, 0x30, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x07, 0xF3, 0xFF, 0x7C, 0x77, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x77,
  0x1F, 0x7F, 0xB3, 0xF3, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x39, 0xF8, 0xEF, 0xF3, 0xE1, 0xCF, 0x03, 0xBC,
  0x0E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3B, 0xC0, 0xEF,
  0x03, 0xBC, 0x1E, 0xFC, 0xF3, 0xBF, 0xCE, 0x7E, 0x00, 0x0F, 0xE7, 0xFC,
  0xF1, 0xBC, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x78, 0xCF, 0xF8, 0x7F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC7, 0xE7, 0x3F, 0xDD, 0xF1,
  0xF7, 0x83, 0xDC, 0x0F, 0x70, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1D, 0xC0, 0x77, 0x03, 0xDE, 0x0F, 0x3C, 0xFC, 0xFF, 0x71, 0xF9, 0xC0,
  0x0F, 0xE1, 0xFF, 0x8E, 0x1C, 0xE0, 0x77, 0x03, 0xB8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x1C, 0x7F,
  0xE1, 0xFE, 0x07, 0xC1, 0xFC, 0x7F, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x03,
  0xFC, 0xFF, 0x83, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0x9C,
  0xFF, 0x73, 0xC7, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0x78, 0x3C, 0xF3, 0xF3, 0xFD,
  0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xD0, 0x0E, 0x7C, 0xF9, 0xFF,
  0xC3, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0xFC, 0xEF, 0xF7, 0xC3, 0xBC, 0x1F, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xE0, 0xEF, 0xE0, 0x00, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0x1C, 0x3C, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x3A, 0xF7, 0xEF, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xE0, 0xE7, 0x0F, 0x38, 0xF1,
  0xC7, 0x0E, 0x70, 0x77, 0x03, 0xFC, 0x1F, 0xE0, 0xF3, 0x87, 0x1E, 0x38,
  0x71, 0xC3, 0xCE, 0x0F, 0x70, 0x3B, 0x81, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xEF, 0xE7, 0xF3, 0xBF, 0xFF, 0xEF, 0x8F,
  0xC7, 0xBC, 0x1E, 0x0E, 0xF0, 0x78, 0x3F, 0x81, 0xE0, 0xFE, 0x07, 0x03,
  0xF8, 0x1C, 0x0F, 0xE0, 0x70, 0x3F, 0x81, 0xC0, 0xFE, 0x07, 0x03, 0xF8,
  0x1C, 0x0F, 0xE0, 0x70, 0x3F, 0x81, 0xC0, 0xFE, 0x07, 0x03, 0xF8, 0x1C,
  0x0F, 0xE7, 0xE7, 0x7F, 0xBE, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0x0F, 0xE0, 0xFF, 0xC3, 0xC7, 0x9E, 0x0E, 0x70, 0x1D,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07,
  0x78, 0x38, 0xF1, 0xE1, 0xFF, 0x03, 0xF8, 0xE7, 0xE3, 0xBF, 0xCF, 0x87,
  0x3C, 0x1E, 0xF0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80,
  0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x7B, 0xF3, 0xCE, 0xFF, 0x39, 0xF8, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00,
  0x1F, 0x9C, 0xFF, 0x73, 0x87, 0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x0F, 0x78, 0x3C, 0xF3,
  0xF3, 0xFD, 0xC7, 0xE7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0xE7, 0xF7, 0xFF, 0xBF, 0x0F, 0x07, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x3F,
  0xEF, 0xFB, 0xC3, 0x70, 0x0E, 0x00, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x0F, 0xC3, 0xFF, 0xF3, 0xFC, 0x18, 0x1C, 0x0E,
  0x07, 0x0F, 0xFF, 0xFD, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x38, 0x1E, 0x4F, 0xE3, 0xF0, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xBC, 0xFD, 0xFE, 0xE7, 0xE7, 0xE0, 0x1D,
  0xC0, 0x77, 0x03, 0x9C, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87, 0x07, 0x1C,
  0x1C, 0xE0, 0x73, 0x80, 0xCE, 0x03, 0xB0, 0x0F, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0xF0, 0x78, 0x1D, 0xC1, 0xE0, 0xF7, 0x07, 0xC3, 0x9C, 0x3F,
  0x0E, 0x78, 0xFC, 0x38, 0xE3, 0x31, 0xC3, 0x8C, 0xE7, 0x0E, 0x73, 0x9C,
  0x19, 0xCE, 0x70, 0x77, 0x19, 0x81, 0xD8, 0x6E, 0x07, 0x61, 0xF8, 0x0F,
  0x87, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x70, 0x3C,
  0xE0, 0xE3, 0xC7, 0x07, 0x3C, 0x1E, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xE0,
  0x07, 0xC0, 0x3F, 0x00, 0xEE, 0x07, 0x38, 0x1C, 0x70, 0xE1, 0xE7, 0x83,
  0xBC, 0x07, 0xF0, 0x1D, 0xC0, 0x77, 0x03, 0x9C, 0x0E, 0x38, 0x38, 0xE1,
  0xC3, 0x87, 0x07, 0x1C, 0x1C, 0xE0, 0x73, 0x80, 0xEE, 0x03, 0xB0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x9E, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0x01,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07,
  0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0x07, 0x87, 0xC7, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x1F, 0x0E, 0x07, 0xC0, 0xF0, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x7C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x81,
  0xF0, 0x38, 0x7C, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xF1, 0xF0, 0xF8, 0x60, 0x00, 0x38, 0x0B, 0xF8, 0x7F, 0xFF, 0x07, 0xF8,
  0x06, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 9, 7, 13, 2, -21 },
  { 20, 16, 21, 17, 1, -21 },
  { 62, 12, 25, 16, 2, -23 },
  { 100, 22, 22, 24, 1, -22 },
  { 161, 19, 22, 20, 1, -22 },
  { 214, 3, 7, 7, 2, -21 },
  { 217, 7, 26, 9, 1, -21 },
  { 240, 7, 26, 9, 1, -21 },
  { 263, 13, 13, 15, 1, -23 },
  { 285, 13, 15, 16, 1, -18 },
  { 310, 5, 7, 8, 1, -3 },
  { 315, 7, 2, 9, 1, -9 },
  { 317, 4, 4, 8, 2, -4 },
  { 319, 11, 22, 11, 0, -22 },
  { 350, 13, 22, 16, 1, -22 },
  { 386, 9, 21, 16, 2, -21 },
  { 410, 13, 22, 16, 1, -22 },
  { 446, 13, 22, 16, 1, -22 },
  { 482, 14, 22, 16, 1, -22 },
  { 521, 12, 21, 16, 2, -21 },
  { 553, 13, 22, 16, 1, -22 },
  { 589, 13, 21, 16, 1, -21 },
  { 624, 13, 22, 16, 1, -22 },
  { 660, 13, 22, 16, 1, -22 },
  { 696, 4, 16, 8, 2, -16 },
  { 704, 5, 20, 8, 1, -16 },
  { 717, 13, 14, 16, 1, -18 },
  { 740, 13, 9, 16, 1, -15 },
  { 755, 13, 14, 16, 1, -18 },
  { 778, 11, 22, 12, 0, -22 },
  { 809, 21, 25, 24, 2, -22 },
  { 875, 18, 21, 18, 0, -21 },
  { 923, 13, 21, 18, 3, -21 },
  { 958, 14, 22, 17, 2, -22 },
  { 997, 15, 21, 20, 3, -21 },
  { 1037, 10, 21, 15, 3, -21 },
  { 1064, 10, 21, 14, 3, -21 },
  { 1091, 16, 22, 20, 2, -22 },
  { 1135, 15, 21, 20, 3, -21 },
  { 1175, 8, 21, 10, 1, -21 },
  { 1196, 8, 27, 8, -2, -21 },
  { 1223, 14, 21, 17, 3, -21 },
  { 1260, 11, 21, 14, 3, -21 },
  { 1289, 20, 21, 26, 3, -21 },
  { 1342, 16, 21, 21, 3, -21 },
  { 1384, 17, 22, 21, 2, -22 },
  { 1431, 12, 21, 17, 3, -21 },
  { 1463, 17, 27, 21, 2, -22 },
  { 1521, 14, 21, 17, 3, -21 },
  { 1558, 13, 22, 15, 1, -22 },
  { 1594, 15, 21, 15, 0, -21 },
  { 1634, 16, 21, 20, 2, -21 },
  { 1676, 17, 21, 17, 0, -21 },
  { 1721, 26, 21, 26, 0, -21 },
  { 1790, 16, 21, 16, 0, -21 },
  { 1832, 16, 21, 16, 0, -21 },
  { 1874, 13, 21, 15, 1, -21 },
  { 1909, 7, 26, 10, 2, -21 },
  { 1932, 11, 22, 11, 0, -22 },
  { 1963, 7, 26, 10, 1, -21 },
  { 1986, 14, 14, 16, 1, -22 },
  { 2011, 13, 2, 13, 0, 3 },
  { 2015, 7, 5, 9, 1, -23 },
  { 2020, 12, 16, 16, 1, -16 },
  { 2044, 14, 23, 17, 2, -23 },
  { 2085, 11, 16, 13, 1, -16 },
  { 2107, 14, 23, 17, 1, -23 },
  { 2148, 13, 16, 16, 1, -16 },
  { 2174, 11, 23, 10, 0, -23 },
  { 2206, 14, 23, 17, 1, -16 },
  { 2247, 13, 23, 17, 2, -23 },
  { 2285, 4, 22, 8, 2, -22 },
  { 2296, 7, 29, 8, -1, -22 },
  { 2322, 13, 23, 15, 2, -23 },
  { 2360, 3, 23, 8, 2, -23 },
  { 2369, 22, 16, 26, 2, -16 },
  { 2413, 13, 16, 17, 2, -16 },
  { 2439, 14, 16, 17, 1, -16 },
  { 2467, 14, 23, 17, 2, -16 },
  { 2508, 14, 23, 17, 1, -16 },
  { 2549, 9, 16, 12, 2, -16 },
  { 2567, 11, 16, 13, 1, -16 },
  { 2589, 9, 20, 10, 1, -20 },
  { 2612, 13, 16, 17, 2, -16 },
  { 2638, 14, 16, 14, 0, -16 },
  { 2666, 22, 16, 22, 0, -16 },
  { 2710, 14, 16, 15, 0, -16 },
  { 2738, 14, 23, 14, 0, -16 },
  { 2779, 11, 16, 13, 1, -16 },
  { 2801, 9, 26, 11, 1, -21 },
  { 2831, 3, 30, 15, 6, -23 },
  { 2843, 9, 26, 11, 1, -21 },
  { 2873, 13, 5, 16, 1, -13 },
};

const GFXfont NotoSans_SemiCondensed_Medium30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium30pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM30PT7B_H_
