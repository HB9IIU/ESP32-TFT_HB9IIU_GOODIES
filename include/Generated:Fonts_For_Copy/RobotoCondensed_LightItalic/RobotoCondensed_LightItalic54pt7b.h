#ifndef _ROBOTOCONDENSED_LIGHTITALIC54PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x01, 0xC0, 0xF0, 0x1C,
  0x00, 0x00, 0x70, 0xDC, 0x77, 0x1D, 0xC7, 0x61, 0x98, 0x6E, 0x1B, 0x8E,
  0xE3, 0xB0, 0xCC, 0x33, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00,
  0x03, 0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01,
  0x80, 0x00, 0x60, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00,
  0x60, 0x30, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x01, 0x80, 0x00, 0x60, 0x30,
  0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC,
  0x01, 0xF1, 0xF0, 0x0F, 0x01, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x73, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0x87, 0x00,
  0x1E, 0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xFC, 0xFC, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x03, 0x00, 0x03,
  0x81, 0xC0, 0x21, 0x80, 0xE0, 0x19, 0xC0, 0x70, 0x18, 0xE0, 0x38, 0x1C,
  0x70, 0x1C, 0x1C, 0x38, 0x0E, 0x0C, 0x1C, 0x06, 0x0E, 0x0E, 0x03, 0x0E,
  0x07, 0x03, 0x86, 0x01, 0x81, 0x87, 0x00, 0xE1, 0xC7, 0x00, 0x3F, 0xC3,
  0x00, 0x0F, 0xC3, 0x00, 0x01, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC3, 0xF0, 0x00, 0xC3, 0xFC, 0x00,
  0xE3, 0x87, 0x00, 0xE3, 0x81, 0x80, 0x61, 0x80, 0xC0, 0x70, 0xC0, 0x70,
  0x70, 0xE0, 0x38, 0x30, 0x70, 0x1C, 0x38, 0x38, 0x0E, 0x38, 0x18, 0x07,
  0x38, 0x0C, 0x03, 0x18, 0x06, 0x01, 0x9C, 0x03, 0x81, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xF1,
  0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0xE0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x87, 0x80, 0x01, 0xDE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x3C, 0x07, 0x3C, 0x1C,
  0x06, 0x38, 0x1E, 0x06, 0x70, 0x0E, 0x0E, 0x70, 0x07, 0x0E, 0xE0, 0x07,
  0x0C, 0xE0, 0x03, 0x9C, 0xE0, 0x03, 0x98, 0xE0, 0x01, 0xF8, 0xE0, 0x01,
  0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0x70, 0x01, 0xF0, 0x78, 0x07,
  0xF8, 0x3E, 0x1F, 0x38, 0x1F, 0xFE, 0x1C, 0x0F, 0xF8, 0x1C, 0x00, 0x80,
  0x00, 0x39, 0x8C, 0x67, 0x39, 0xCC, 0x67, 0x39, 0xC0, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x0C, 0x06, 0x07, 0xFC, 0x71,
  0xFB, 0xFB, 0xBF, 0xC7, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0E, 0xE0, 0x00, 0xE3, 0x00, 0x0F, 0x1C, 0x00, 0xF0, 0x70,
  0x0F, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x00, 0x70, 0x08, 0x01, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x1C, 0x38, 0xF1, 0xC3, 0x8F, 0x1C, 0x78,
  0xE3, 0x82, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0x77, 0xFE, 0xE0, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xC3, 0xC0, 0x78, 0x0F, 0x03,
  0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0xC6, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xC0,
  0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00,
  0x0C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x0C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x3C, 0x1C, 0x01, 0xC0, 0xF0, 0x1C, 0x03, 0xC3, 0xE0, 0x1F,
  0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF1,
  0xFF, 0x7F, 0x7F, 0xC7, 0xE0, 0xE8, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xC0, 0x0F, 0x87, 0xC0, 0x3C, 0x03, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0x7C, 0x03, 0x80, 0x78, 0x1C,
  0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x70, 0x00,
  0x71, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x63, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x3C, 0x1E, 0x01, 0xE0,
  0x3E, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x87,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x03,
  0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x1F, 0x80, 0x06, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x3E, 0x07, 0x80, 0x70, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x30, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xE0, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0xFF, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x71, 0xFC, 0x0E, 0x7F, 0xC1, 0xBF, 0xFC, 0x7F, 0x03, 0xCF, 0x80,
  0x39, 0xE0, 0x07, 0xBC, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x03,
  0x8E, 0x00, 0xF0, 0xE0, 0x3C, 0x1F, 0x1F, 0x01, 0xFF, 0xC0, 0x1F, 0xF0,
  0x00, 0x20, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7C, 0x3C, 0x03,
  0xC0, 0x78, 0x0E, 0x00, 0xF0, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x07, 0x00, 0xF0, 0x0E,
  0x07, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3C, 0x1E,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xCE,
  0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x3C,
  0x1E, 0x01, 0xE0, 0x3E, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0xF8, 0xF8,
  0x0E, 0x03, 0xC1, 0xC0, 0x1E, 0x3C, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x01, 0xE7, 0x00, 0x1E, 0x70, 0x03, 0xE7, 0x80, 0x7C, 0x3C, 0x1F, 0xC3,
  0xFF, 0xDC, 0x1F, 0xF9, 0xC0, 0x7E, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x07, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x07, 0xC3, 0xE1, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x78, 0x3C, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x01, 0x00,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x08,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0x3E, 0x3C, 0x0E, 0x70, 0x0F,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0x06, 0x03, 0x80, 0x00, 0x00, 0x70, 0x70, 0x03,
  0xF0, 0x03, 0x07, 0x00, 0x7F, 0x80, 0x30, 0xE0, 0x0F, 0xFE, 0x03, 0x0E,
  0x01, 0xC0, 0xE0, 0x31, 0xC0, 0x38, 0x0E, 0x03, 0x1C, 0x07, 0x00, 0xE0,
  0x31, 0x80, 0x60, 0x0C, 0x03, 0x38, 0x0E, 0x00, 0xC0, 0x33, 0x00, 0xC0,
  0x1C, 0x03, 0x30, 0x1C, 0x01, 0xC0, 0x37, 0x01, 0xC0, 0x18, 0x03, 0x70,
  0x18, 0x01, 0x80, 0x36, 0x03, 0x80, 0x38, 0x03, 0x60, 0x38, 0x03, 0x80,
  0x3E, 0x03, 0x80, 0x38, 0x07, 0xE0, 0x30, 0x03, 0x00, 0x6E, 0x03, 0x00,
  0x30, 0x06, 0xE0, 0x30, 0x07, 0x00, 0x6C, 0x07, 0x00, 0x70, 0x0C, 0xC0,
  0x70, 0x06, 0x00, 0xCC, 0x07, 0x00, 0xE0, 0x0C, 0xC0, 0x70, 0x0E, 0x01,
  0x8C, 0x03, 0x01, 0xE0, 0x38, 0xC0, 0x38, 0x37, 0x03, 0x0C, 0x03, 0x87,
  0x70, 0xE0, 0xE0, 0x3F, 0xE3, 0xFC, 0x0E, 0x01, 0xF8, 0x1F, 0x80, 0xE0,
  0x02, 0x00, 0x40, 0x06, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xD8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70,
  0x60, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x01,
  0x80, 0x07, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0E,
  0x00, 0x1C, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38,
  0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x67, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03,
  0x80, 0x3E, 0x03, 0x80, 0x0F, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E,
  0x00, 0x3C, 0x1C, 0x00, 0x78, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x1C, 0x00, 0xF8, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x03, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x3C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x03, 0x80,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x0F, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xF1, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x7C, 0x0E, 0x00, 0x7E, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF1, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x01, 0xFF, 0xC7, 0x00, 0x7F, 0xF1, 0xC0, 0x1F, 0xFC,
  0x70, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x3C, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0,
  0x78, 0x03, 0xF0, 0x1F, 0xC7, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0x3F, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x07,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x78, 0x00, 0x38, 0x07, 0x80,
  0x03, 0x80, 0x78, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0xE7, 0xC0, 0x00, 0x07, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xF9, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x1D, 0xC0, 0xEC, 0x00, 0x00, 0xEC, 0x07, 0x70, 0x00,
  0x0E, 0xE0, 0x33, 0x80, 0x00, 0x77, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x1C,
  0xE0, 0x00, 0x39, 0xC0, 0xE7, 0x00, 0x03, 0x8E, 0x07, 0x18, 0x00, 0x1C,
  0xE0, 0x38, 0xE0, 0x01, 0xC7, 0x01, 0x87, 0x00, 0x0E, 0x38, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0xE1, 0xC0, 0x07, 0x0E, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x38, 0x30, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x0E, 0x0E, 0x01,
  0xC1, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x70, 0x38, 0x0E, 0x03, 0x07, 0x01,
  0xC0, 0xE0, 0x1C, 0x38, 0x0E, 0x07, 0x00, 0xE3, 0x80, 0x70, 0x38, 0x07,
  0x18, 0x03, 0x81, 0xC0, 0x39, 0xC0, 0x38, 0x0E, 0x00, 0xCC, 0x01, 0xC0,
  0x70, 0x06, 0xE0, 0x0E, 0x07, 0x00, 0x3E, 0x00, 0x70, 0x38, 0x01, 0xF0,
  0x03, 0x81, 0xC0, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x38, 0x1F,
  0x80, 0x00, 0xE0, 0x77, 0x00, 0x03, 0x81, 0xDC, 0x00, 0x1E, 0x07, 0x70,
  0x00, 0x70, 0x1C, 0xE0, 0x01, 0xC0, 0xF3, 0x80, 0x07, 0x03, 0x86, 0x00,
  0x1C, 0x0E, 0x1C, 0x00, 0x70, 0x38, 0x70, 0x03, 0x80, 0xE0, 0xE0, 0x0E,
  0x03, 0x83, 0x80, 0x38, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x1C, 0x03, 0x81,
  0xC0, 0x70, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x81, 0xC0, 0x70,
  0x0E, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x38, 0x01,
  0xC1, 0xC0, 0xE0, 0x03, 0x8E, 0x03, 0x80, 0x0E, 0x38, 0x1E, 0x00, 0x38,
  0xE0, 0x70, 0x00, 0x73, 0x81, 0xC0, 0x01, 0xCE, 0x07, 0x00, 0x07, 0x70,
  0x1C, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0x3F, 0x03, 0x80, 0x00, 0x7C, 0x0E,
  0x00, 0x01, 0xF0, 0x38, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x78,
  0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x8F, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0E,
  0x00, 0x3C, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1,
  0xC0, 0x01, 0xE0, 0x70, 0x01, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xF1, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x1F, 0x8F, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0x8E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0E, 0x00, 0x7C,
  0x07, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x07,
  0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0x80,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x38,
  0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x80, 0xF8, 0x03, 0xC0,
  0x1F, 0x87, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x07, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E,
  0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xC7,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x1C, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x07, 0x00,
  0x00, 0xC3, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80,
  0x01, 0xF8, 0x00, 0x1C, 0x00, 0x1E, 0xC0, 0x01, 0xE0, 0x00, 0xE7, 0x00,
  0x0F, 0x80, 0x07, 0x38, 0x00, 0xFC, 0x00, 0x71, 0xC0, 0x07, 0xE0, 0x03,
  0x8E, 0x00, 0x37, 0x00, 0x1C, 0x70, 0x03, 0xB8, 0x01, 0xC3, 0x80, 0x1D,
  0xC0, 0x0E, 0x1C, 0x01, 0xCE, 0x00, 0x70, 0xE0, 0x0E, 0x30, 0x07, 0x07,
  0x00, 0x61, 0x80, 0x38, 0x38, 0x07, 0x0C, 0x03, 0x81, 0xC0, 0x38, 0x60,
  0x1C, 0x0E, 0x03, 0x83, 0x00, 0xE0, 0x70, 0x1C, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x38,
  0x07, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x0E, 0x0E, 0x00, 0xC1, 0x80,
  0x70, 0xE0, 0x06, 0x1C, 0x01, 0x87, 0x00, 0x30, 0xE0, 0x0C, 0x30, 0x01,
  0x8E, 0x00, 0x63, 0x80, 0x0C, 0x70, 0x03, 0x1C, 0x00, 0x73, 0x00, 0x19,
  0xC0, 0x03, 0xB8, 0x00, 0xCE, 0x00, 0x1D, 0xC0, 0x06, 0x70, 0x00, 0xFC,
  0x00, 0x37, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0x9C, 0x00,
  0x03, 0xCE, 0x00, 0x01, 0xC7, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x3C, 0x00,
  0x38, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x30, 0x30, 0x38, 0x38, 0x38, 0x38, 0x38, 0x18, 0x18, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x06,
  0x06, 0x07, 0x07, 0x07, 0x07, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x36, 0x00, 0xEE, 0x03, 0x9C, 0x07, 0x38,
  0x1C, 0x30, 0x38, 0x60, 0xE0, 0xC1, 0xC1, 0xC7, 0x03, 0x8E, 0x07, 0x38,
  0x0E, 0x70, 0x0D, 0xC0, 0x1B, 0x80, 0x38, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0xE1, 0xC1, 0xC1, 0xC3, 0x83, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xC7, 0xC0, 0x78, 0x0F, 0x07,
  0x80, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC1, 0xFF, 0xBC, 0x1F, 0x00, 0xE1, 0xE0, 0x07, 0x1E, 0x00, 0x38,
  0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x63, 0x80, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x03, 0xC3, 0x80, 0x3E, 0x1C, 0x03, 0xF0, 0xFC, 0xFB, 0x83,
  0xFF, 0x9C, 0x0F, 0xF0, 0xE0, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x3F, 0xC0, 0x1D, 0xFF, 0xC0, 0x7F,
  0x1F, 0x03, 0xF0, 0x1E, 0x0F, 0x80, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0x01,
  0xC3, 0x80, 0x07, 0x0C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1E, 0x00, 0x38, 0x78,
  0x01, 0xE1, 0xB8, 0x0F, 0x0E, 0x78, 0xF8, 0x38, 0xFF, 0xC0, 0xE1, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0,
  0x7C, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0x73, 0x80, 0x07,
  0x38, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x78, 0x07, 0x03,
  0xE1, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x01, 0xFE,
  0x1C, 0x03, 0xFF, 0x1C, 0x07, 0xC7, 0x9C, 0x0F, 0x01, 0xF8, 0x1E, 0x00,
  0xF8, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x60, 0x00, 0x60, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x03,
  0xC0, 0x78, 0x0F, 0xC0, 0x3E, 0x3D, 0x80, 0x1F, 0xFB, 0x80, 0x0F, 0xF3,
  0x80, 0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x7C, 0x7C, 0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0x73, 0x80, 0x07,
  0x38, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x10, 0x78, 0x07, 0x83,
  0xE1, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x87, 0x00, 0xFF,
  0xC7, 0x01, 0xF1, 0xE7, 0x03, 0xC0, 0x7E, 0x07, 0x80, 0x3E, 0x07, 0x00,
  0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38, 0x00,
  0x70, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x1E, 0x03,
  0xF0, 0x0F, 0x8F, 0x60, 0x0F, 0xFE, 0xE0, 0x03, 0xFC, 0xE0, 0x00, 0x40,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x40, 0x03, 0x80, 0x60, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x71, 0xFC, 0x03, 0xBF, 0xF0, 0x1F, 0xC7, 0xC1, 0xF8,
  0x0E, 0x0F, 0x80, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70,
  0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80,
  0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x3C, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xC0, 0xE0, 0x0F, 0x01,
  0xC0, 0x3C, 0x07, 0x00, 0xF0, 0x0E, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x38,
  0x3C, 0x00, 0x70, 0xF0, 0x00, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x1C,
  0x00, 0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0,
  0x01, 0xF3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x70,
  0x01, 0xE0, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x73, 0xFC, 0x07, 0xF8, 0x06, 0x7F, 0xE0, 0xFF, 0xC0, 0xEF,
  0x1F, 0x1E, 0x3E, 0x0F, 0xC0, 0x73, 0x80, 0xE0, 0xF8, 0x07, 0xF0, 0x0E,
  0x0F, 0x00, 0x3E, 0x00, 0x70, 0xE0, 0x03, 0xC0, 0x07, 0x0E, 0x00, 0x3C,
  0x00, 0x71, 0xC0, 0x03, 0x80, 0x07, 0x1C, 0x00, 0x38, 0x00, 0x71, 0xC0,
  0x03, 0x80, 0x07, 0x1C, 0x00, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x00, 0x0E,
  0x1C, 0x00, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x0E, 0x38, 0x00, 0x70,
  0x00, 0xE3, 0x80, 0x07, 0x00, 0x0E, 0x38, 0x00, 0x70, 0x00, 0xE3, 0x80,
  0x0E, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x00, 0x1C,
  0x70, 0x00, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0xE0,
  0x01, 0xC7, 0x00, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0xFE, 0x01, 0xDF, 0xF8, 0x0D, 0xE3, 0xE0, 0xFC,
  0x07, 0x07, 0xC0, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0x60, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x71, 0xC0,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0x87, 0xC0, 0xF0, 0x0F, 0x07, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x80, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x07, 0x70, 0x00, 0x33, 0x80, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x01,
  0xC3, 0x80, 0x1E, 0x0E, 0x01, 0xE0, 0x7C, 0x3E, 0x01, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x80, 0x01, 0xCF, 0xF0, 0x01,
  0x9F, 0xFC, 0x01, 0xBC, 0x7C, 0x03, 0xF0, 0x1E, 0x03, 0xC0, 0x0E, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1F,
  0x00, 0xF0, 0x39, 0xC3, 0xE0, 0x39, 0xFF, 0xC0, 0x38, 0x7F, 0x80, 0x38,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07,
  0xF8, 0x70, 0x3F, 0xF1, 0xC1, 0xF0, 0xE7, 0x0F, 0x00, 0xF8, 0x78, 0x03,
  0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x38, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x80, 0x7C, 0x0F, 0x8F,
  0xE0, 0x1F, 0xFB, 0x80, 0x3F, 0xCE, 0x00, 0x10, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x3F, 0x07, 0x7F, 0x06, 0xFF, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0x3E, 0x07,
  0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0xC7, 0x00, 0x38, 0x78, 0x07, 0x83, 0xE3, 0xF0, 0x1F,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x03, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x90, 0x7F, 0x03,
  0xF0, 0x08, 0x00, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0x8E, 0x00, 0x1C, 0x70,
  0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x0F, 0x87, 0x80, 0xF8, 0x1F,
  0x1F, 0xC0, 0xFF, 0xEE, 0x01, 0xFE, 0x70, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x76, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x30, 0x07, 0x03, 0x00, 0x70, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x18, 0x01,
  0x83, 0x80, 0x18, 0x38, 0x01, 0x87, 0x00, 0x1C, 0x70, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0xCC, 0x00, 0x0D, 0xC0, 0x00, 0xD8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x03, 0x00, 0x1D, 0xC0, 0x0F, 0x00, 0x3B, 0x80, 0x1E, 0x00, 0xF7, 0x00,
  0x7C, 0x01, 0xCE, 0x00, 0xF8, 0x03, 0x9C, 0x01, 0xF0, 0x0E, 0x38, 0x07,
  0xE0, 0x1C, 0x70, 0x0D, 0xC0, 0x38, 0x60, 0x39, 0x80, 0xE0, 0xC0, 0x73,
  0x01, 0xC1, 0x81, 0xC6, 0x07, 0x03, 0x03, 0x8C, 0x0E, 0x07, 0x06, 0x18,
  0x1C, 0x0E, 0x1C, 0x38, 0x70, 0x1C, 0x30, 0x70, 0xE0, 0x38, 0xE0, 0xE3,
  0x80, 0x71, 0xC1, 0xC7, 0x00, 0xE7, 0x03, 0x8C, 0x01, 0xCE, 0x07, 0x38,
  0x03, 0x98, 0x06, 0x70, 0x07, 0x70, 0x0C, 0xC0, 0x0E, 0xC0, 0x1B, 0x80,
  0x1F, 0x80, 0x36, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x1E, 0x03, 0x80,
  0x3C, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0xF0, 0x01, 0xC0,
  0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x77,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xEE,
  0x00, 0x01, 0xC7, 0x00, 0x03, 0x87, 0x00, 0x07, 0x87, 0x00, 0x07, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x81, 0xC0,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C,
  0x00, 0xF0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x01, 0x80, 0x38, 0x00,
  0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xC3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x04, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xCF, 0xFC, 0x00,
  0xE7, 0x0F, 0x00, 0x77, 0x03, 0xC0, 0x33, 0x80, 0xF0, 0x3B, 0x80, 0x3C,
  0x39, 0xC0, 0x0F, 0xFC, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 10, 39, 11, 1, -38 },
  { 50, 10, 12, 15, 6, -41 },
  { 65, 27, 38, 27, 2, -38 },
  { 194, 22, 50, 25, 2, -44 },
  { 332, 25, 40, 33, 5, -39 },
  { 457, 24, 40, 28, 2, -39 },
  { 577, 5, 12, 9, 5, -41 },
  { 585, 15, 55, 15, 3, -43 },
  { 689, 15, 55, 16, -3, -43 },
  { 793, 21, 22, 22, 3, -38 },
  { 851, 22, 28, 26, 2, -32 },
  { 928, 7, 12, 10, -2, -5 },
  { 939, 11, 3, 14, 1, -19 },
  { 944, 5, 5, 13, 1, -4 },
  { 948, 23, 41, 19, -2, -38 },
  { 1066, 21, 40, 25, 3, -39 },
  { 1171, 12, 38, 25, 7, -38 },
  { 1228, 23, 39, 25, 1, -39 },
  { 1341, 22, 40, 25, 2, -39 },
  { 1451, 23, 38, 25, 1, -38 },
  { 1561, 23, 39, 25, 3, -38 },
  { 1674, 19, 39, 25, 3, -38 },
  { 1767, 22, 38, 25, 4, -38 },
  { 1872, 22, 40, 25, 2, -39 },
  { 1982, 20, 39, 25, 4, -39 },
  { 2080, 9, 29, 11, 1, -28 },
  { 2113, 11, 35, 10, -2, -28 },
  { 2162, 20, 23, 24, 2, -29 },
  { 2220, 20, 14, 25, 3, -25 },
  { 2255, 21, 23, 24, 1, -29 },
  { 2316, 16, 40, 21, 5, -39 },
  { 2396, 36, 50, 41, 2, -38 },
  { 2621, 27, 38, 29, -2, -38 },
  { 2750, 24, 38, 28, 2, -38 },
  { 2864, 26, 40, 30, 3, -39 },
  { 2994, 26, 38, 30, 2, -38 },
  { 3118, 26, 38, 26, 2, -38 },
  { 3242, 26, 38, 26, 2, -38 },
  { 3366, 26, 40, 31, 3, -39 },
  { 3496, 30, 38, 32, 2, -38 },
  { 3639, 10, 38, 13, 2, -38 },
  { 3687, 24, 39, 25, 1, -38 },
  { 3804, 29, 38, 29, 2, -38 },
  { 3942, 18, 38, 24, 2, -38 },
  { 4028, 37, 38, 39, 2, -38 },
  { 4204, 30, 38, 32, 2, -38 },
  { 4347, 26, 40, 31, 3, -39 },
  { 4477, 26, 38, 28, 2, -38 },
  { 4601, 26, 46, 31, 3, -39 },
  { 4751, 26, 38, 29, 2, -38 },
  { 4875, 26, 40, 27, 1, -39 },
  { 5005, 25, 38, 27, 5, -38 },
  { 5124, 27, 39, 30, 3, -38 },
  { 5256, 26, 38, 28, 5, -38 },
  { 5380, 37, 38, 40, 5, -38 },
  { 5556, 31, 38, 28, -1, -38 },
  { 5704, 25, 38, 27, 5, -38 },
  { 5823, 28, 38, 27, 0, -38 },
  { 5956, 16, 52, 12, 0, -44 },
  { 6060, 8, 41, 18, 6, -38 },
  { 6101, 15, 52, 12, -3, -44 },
  { 6199, 15, 19, 19, 3, -38 },
  { 6235, 20, 3, 20, -3, 0 },
  { 6243, 7, 7, 15, 7, -40 },
  { 6250, 21, 31, 25, 1, -30 },
  { 6332, 22, 42, 25, 1, -41 },
  { 6448, 20, 31, 24, 2, -30 },
  { 6526, 24, 42, 26, 2, -41 },
  { 6652, 20, 31, 24, 2, -30 },
  { 6730, 17, 42, 16, 3, -42 },
  { 6820, 24, 41, 26, 0, -30 },
  { 6943, 21, 41, 25, 1, -41 },
  { 7051, 10, 39, 11, 1, -39 },
  { 7100, 17, 50, 11, -6, -39 },
  { 7207, 23, 41, 23, 1, -41 },
  { 7325, 10, 41, 11, 1, -41 },
  { 7377, 36, 30, 40, 1, -30 },
  { 7512, 21, 30, 25, 1, -30 },
  { 7591, 21, 31, 26, 2, -30 },
  { 7673, 24, 41, 25, -1, -30 },
  { 7796, 22, 41, 26, 2, -30 },
  { 7909, 16, 30, 16, 1, -30 },
  { 7969, 20, 31, 23, 1, -30 },
  { 8047, 12, 37, 15, 3, -36 },
  { 8103, 21, 30, 25, 3, -29 },
  { 8182, 20, 29, 22, 3, -29 },
  { 8255, 31, 29, 34, 4, -29 },
  { 8368, 24, 29, 23, -1, -29 },
  { 8455, 25, 40, 22, -2, -29 },
  { 8580, 22, 29, 23, 0, -29 },
  { 8660, 17, 53, 16, 2, -42 },
  { 8773, 10, 45, 12, 1, -38 },
  { 8830, 17, 53, 16, -3, -42 },
  { 8943, 25, 10, 31, 3, -21 },
};

const GFXfont RobotoCondensed_LightItalic54pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic54pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic54pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC54PT7B_H_
