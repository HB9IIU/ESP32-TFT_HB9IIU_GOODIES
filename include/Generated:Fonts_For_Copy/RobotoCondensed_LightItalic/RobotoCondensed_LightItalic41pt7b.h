#ifndef _ROBOTOCONDENSED_LIGHTITALIC41PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x70, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1,
  0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x83, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x87, 0x0E, 0x00, 0x33, 0x63, 0x63, 0x63, 0x62, 0x66, 0x46, 0xC6, 0xC6,
  0x00, 0x18, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x30, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x80, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC3,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x83, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x06, 0x0C, 0x00, 0x30, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x00, 0x0C, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0,
  0x0C, 0xE0, 0x1C, 0x60, 0x38, 0x78, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x0C, 0x08, 0x19, 0x81, 0x83, 0x30, 0x20, 0xC6,
  0x04, 0x30, 0xC1, 0x86, 0x18, 0x31, 0x83, 0x06, 0x60, 0x71, 0x98, 0x07,
  0xE3, 0x00, 0x78, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x78, 0x01, 0x9F, 0x80,
  0x66, 0x18, 0x18, 0xC1, 0x03, 0x30, 0x20, 0xC6, 0x06, 0x30, 0xC0, 0xC6,
  0x18, 0x11, 0x83, 0x02, 0x60, 0x60, 0xC8, 0x0C, 0x18, 0x00, 0xC6, 0x00,
  0x1F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x38, 0xE0, 0x0C,
  0x1C, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x18, 0x18, 0x06, 0x0E,
  0x01, 0x87, 0x00, 0x73, 0x80, 0x0D, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00,
  0x7C, 0x00, 0x3B, 0x00, 0x1C, 0xE0, 0xCE, 0x18, 0x37, 0x03, 0x0D, 0x80,
  0xE3, 0x60, 0x19, 0xB8, 0x07, 0x6E, 0x00, 0xF3, 0x80, 0x3C, 0x60, 0x06,
  0x1C, 0x07, 0xC3, 0x83, 0xB0, 0x7F, 0xCE, 0x0F, 0xC1, 0x80, 0x6D, 0xB7,
  0xB6, 0xC0, 0x00, 0x20, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0x80, 0x02, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x10, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x60, 0xC3, 0xFD, 0x9F, 0x3F, 0xFC, 0x07, 0xE0, 0x03, 0x80, 0x06,
  0xC0, 0x0C, 0xE0, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x30, 0x20, 0x30, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x71, 0xC6, 0x18, 0xE7, 0x18, 0x40,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0x0E, 0x0E, 0x06, 0x1C, 0x07,
  0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03,
  0x60, 0x03, 0x60, 0x03, 0x60, 0x07, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06,
  0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C,
  0xC0, 0x18, 0x60, 0x38, 0x60, 0x30, 0x70, 0xF0, 0x3F, 0xE0, 0x1F, 0x80,
  0x00, 0xC0, 0xF1, 0xF9, 0xF6, 0xF1, 0xA0, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xE1, 0xC1, 0xC0, 0x60, 0xC0, 0x38,
  0xE0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x18, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1F, 0xFF,
  0xCF, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xE1, 0xC1, 0xC0, 0x60,
  0xC0, 0x38, 0xE0, 0x0C, 0x60, 0x06, 0x30, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x67,
  0x00, 0x33, 0x80, 0x19, 0xC0, 0x1C, 0x60, 0x0C, 0x38, 0x0E, 0x0E, 0x1E,
  0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xDC, 0x00, 0xCC, 0x00, 0xE6,
  0x00, 0x63, 0x00, 0x61, 0x80, 0x71, 0xC0, 0x30, 0xE0, 0x30, 0x60, 0x30,
  0x30, 0x38, 0x18, 0x18, 0x0C, 0x18, 0x0E, 0x1C, 0x06, 0x0C, 0x03, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xF0,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x9F, 0x00, 0x7F, 0xE0, 0x1E, 0x3C,
  0x0E, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x38, 0x03, 0x86, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x1C, 0x1C, 0x0E, 0x03, 0x87, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x1E, 0x01, 0xFC, 0x07, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xCF, 0xC1, 0xBF, 0xC6,
  0xE1, 0xCF, 0x01, 0x9C, 0x03, 0xB0, 0x03, 0x60, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xB8, 0x03, 0x30, 0x0E, 0x60, 0x18,
  0xE0, 0x70, 0xE1, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x38, 0x70, 0x1C, 0x0E, 0x0E, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x18, 0x70, 0x06, 0x1C, 0x01, 0x87, 0x00, 0x60, 0xC0, 0x30, 0x38,
  0x1C, 0x07, 0x0E, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x70, 0x70, 0x38, 0x0E,
  0x0C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x8E,
  0x00, 0x63, 0x80, 0x18, 0x60, 0x0C, 0x1C, 0x07, 0x03, 0x87, 0x80, 0x7F,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x78, 0xE1, 0xC0, 0xE3,
  0x00, 0xCE, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0x98, 0x07, 0x30, 0x1E, 0x78, 0xEC,
  0x7F, 0xB8, 0x3E, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1C,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x38, 0xE0, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x60, 0x20, 0x00, 0x00, 0x02, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x10, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0x10, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x0F,
  0x83, 0xFC, 0x78, 0xE6, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xC0, 0x00,
  0xC0, 0x18, 0x00, 0x06, 0x03, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x30, 0xC0, 0x3E, 0x03, 0x0C, 0x07, 0xF0, 0x31, 0x80, 0xC1,
  0x83, 0x18, 0x18, 0x18, 0x33, 0x03, 0x01, 0x83, 0x30, 0x30, 0x30, 0x33,
  0x06, 0x03, 0x03, 0x60, 0x60, 0x30, 0x36, 0x0E, 0x03, 0x03, 0x60, 0xC0,
  0x60, 0x36, 0x0C, 0x06, 0x02, 0x60, 0xC0, 0x60, 0x64, 0x0C, 0x0E, 0x06,
  0xC0, 0xC0, 0xC0, 0x4C, 0x0C, 0x1C, 0x0C, 0xC0, 0xC1, 0xC1, 0x8C, 0x0C,
  0x36, 0x38, 0x40, 0xFE, 0x7F, 0x06, 0x07, 0x83, 0xC0, 0x60, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0D, 0x80, 0x01, 0x98, 0x00, 0x19, 0x80, 0x03,
  0x18, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x00,
  0xC0, 0xC0, 0x1C, 0x0C, 0x01, 0x80, 0xC0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x0C, 0x06, 0x00, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xC0, 0x06,
  0x18, 0x00, 0x63, 0x80, 0x06, 0x30, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x18,
  0x0F, 0x03, 0x00, 0x60, 0x60, 0x0E, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0x60,
  0x03, 0x0C, 0x00, 0xE1, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xC1, 0x80,
  0x70, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00,
  0x63, 0x80, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x78, 0x7F, 0xFE,
  0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x70,
  0x0E, 0x0E, 0x00, 0xE0, 0xC0, 0x06, 0x18, 0x00, 0x61, 0x80, 0x07, 0x38,
  0x00, 0x73, 0x00, 0x07, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x1C, 0xE0, 0x01, 0x86, 0x00, 0x18, 0x60, 0x03,
  0x86, 0x00, 0x30, 0x70, 0x07, 0x03, 0x00, 0xE0, 0x3C, 0x1C, 0x01, 0xFF,
  0x80, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x06, 0x03, 0xC0,
  0x60, 0x0E, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0C, 0x00, 0x70, 0xC0, 0x03,
  0x0C, 0x00, 0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00,
  0x31, 0x80, 0x07, 0x18, 0x00, 0x71, 0x80, 0x06, 0x38, 0x00, 0x63, 0x80,
  0x06, 0x30, 0x00, 0x63, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x70,
  0x01, 0x87, 0x00, 0x38, 0x60, 0x07, 0x06, 0x00, 0xE0, 0x60, 0x3C, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8,
  0x03, 0xC1, 0xC0, 0x70, 0x0E, 0x0E, 0x00, 0x60, 0xC0, 0x07, 0x1C, 0x00,
  0x31, 0x80, 0x03, 0x38, 0x00, 0x33, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x03, 0xFE, 0x60,
  0x3F, 0xE6, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0xC6,
  0x00, 0x1C, 0x60, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0x83, 0x80, 0x78,
  0x1C, 0x1F, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x06, 0x0C,
  0x00, 0x0C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC1, 0xC0,
  0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0E, 0x0C, 0x00, 0x1C, 0x18, 0x00,
  0x30, 0x70, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x70, 0x00, 0x60,
  0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x07, 0x06, 0x00, 0x0C, 0x1C,
  0x00, 0x18, 0x38, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80,
  0x03, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x00, 0x06, 0x1C, 0x38, 0x60,
  0xC1, 0x83, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x61,
  0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x70, 0xC0, 0x18, 0x38, 0x0C, 0x07, 0x0F, 0x00, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0x60, 0x07,
  0x01, 0x80, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0xC0, 0x70, 0x03,
  0x03, 0x80, 0x0C, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C,
  0x00, 0x18, 0xE0, 0x00, 0x67, 0x00, 0x01, 0xBE, 0x00, 0x07, 0xD8, 0x00,
  0x3E, 0x70, 0x00, 0xF0, 0xC0, 0x03, 0x83, 0x80, 0x0C, 0x06, 0x00, 0x30,
  0x1C, 0x00, 0xC0, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x60, 0x07,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x38, 0x00, 0x60, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xF0, 0xD8, 0x00, 0x1E, 0x0D, 0x80, 0x03, 0x60, 0xD8, 0x00, 0x76, 0x0D,
  0xC0, 0x06, 0x60, 0xCC, 0x00, 0xE6, 0x1C, 0xC0, 0x0C, 0xE1, 0xCC, 0x01,
  0xCC, 0x18, 0xC0, 0x18, 0xC1, 0x8C, 0x03, 0x8C, 0x18, 0x60, 0x30, 0xC1,
  0x86, 0x07, 0x1C, 0x38, 0x60, 0x61, 0xC3, 0x86, 0x0E, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x1C, 0x18, 0x30, 0x31, 0x81, 0x83, 0x03, 0x38, 0x38,
  0x70, 0x33, 0x03, 0x07, 0x03, 0x70, 0x30, 0x60, 0x36, 0x03, 0x06, 0x03,
  0xE0, 0x30, 0x60, 0x1C, 0x07, 0x0E, 0x01, 0xC0, 0x70, 0xE0, 0x18, 0x06,
  0x00, 0x07, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x3C, 0x00,
  0x70, 0x78, 0x00, 0xC1, 0xF8, 0x01, 0x83, 0x30, 0x03, 0x06, 0x60, 0x06,
  0x0C, 0xE0, 0x1C, 0x18, 0xC0, 0x38, 0x71, 0x80, 0x60, 0xE1, 0x80, 0xC1,
  0x83, 0x01, 0x83, 0x06, 0x03, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x18, 0x38,
  0x1C, 0x30, 0x70, 0x18, 0x60, 0xC0, 0x30, 0xC1, 0x80, 0x73, 0x83, 0x00,
  0x67, 0x06, 0x00, 0xCC, 0x1C, 0x00, 0xD8, 0x38, 0x01, 0xB0, 0x60, 0x03,
  0x60, 0xC0, 0x03, 0xC1, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x0C,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x70, 0x0E, 0x0E,
  0x00, 0x61, 0xC0, 0x07, 0x18, 0x00, 0x71, 0x80, 0x03, 0x38, 0x00, 0x33,
  0x00, 0x03, 0x30, 0x00, 0x37, 0x00, 0x03, 0x70, 0x00, 0x76, 0x00, 0x07,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00,
  0xEE, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0x60, 0x01, 0x86, 0x00,
  0x38, 0x70, 0x03, 0x03, 0x00, 0x70, 0x3C, 0x1E, 0x01, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x06, 0x01, 0xE0, 0x60, 0x06,
  0x06, 0x00, 0x70, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03, 0x0C, 0x00,
  0x30, 0xC0, 0x03, 0x1C, 0x00, 0x71, 0xC0, 0x06, 0x18, 0x00, 0xE1, 0x80,
  0x1C, 0x18, 0x07, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xC3, 0xC0, 0x70,
  0x0E, 0x0E, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x73, 0x80, 0x03, 0x30,
  0x00, 0x33, 0x00, 0x03, 0x30, 0x00, 0x37, 0x00, 0x07, 0x70, 0x00, 0x76,
  0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0x60, 0x00, 0x6E, 0x00, 0x06,
  0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x00, 0xCE, 0x00, 0x1C, 0xE0, 0x01,
  0x86, 0x00, 0x38, 0x70, 0x03, 0x03, 0x00, 0xF0, 0x3C, 0x3E, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x20, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x06, 0x01, 0xC0,
  0x60, 0x0E, 0x0E, 0x00, 0x60, 0xE0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x07,
  0x0C, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x61, 0xC0, 0x0E, 0x18, 0x00,
  0xC1, 0x80, 0x1C, 0x18, 0x07, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0x81,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x00, 0x60, 0x70,
  0x06, 0x06, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x30, 0x60, 0x03, 0x8E,
  0x00, 0x38, 0xE0, 0x01, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xC3,
  0xC0, 0x70, 0x0C, 0x0E, 0x00, 0xE0, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0xC0,
  0x06, 0x1C, 0x00, 0x61, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x18,
  0xE0, 0x01, 0x8E, 0x00, 0x38, 0x60, 0x03, 0x07, 0x00, 0xF0, 0x3C, 0x3E,
  0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x38, 0x60, 0x01, 0xC7, 0x00, 0x0C, 0x38,
  0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00, 0x0C,
  0x38, 0x00, 0x61, 0xC0, 0x03, 0x0C, 0x00, 0x18, 0x60, 0x01, 0xC3, 0x00,
  0x0E, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC3,
  0x00, 0x0E, 0x18, 0x00, 0x70, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x70, 0x00,
  0xC3, 0x80, 0x0E, 0x0C, 0x00, 0x60, 0x60, 0x07, 0x03, 0x80, 0x70, 0x0F,
  0x0F, 0x00, 0x3F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0x60, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x18, 0x00,
  0xC3, 0x00, 0x38, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x38, 0x38, 0x06,
  0x07, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x0E, 0x01, 0x81, 0x80, 0x30, 0x70,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x1C, 0x60, 0x01, 0x8C, 0x00, 0x33, 0x00,
  0x06, 0x60, 0x00, 0xDC, 0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0xC0, 0x0E, 0x00, 0x6C, 0x00, 0xE0, 0x06, 0xE0, 0x1A, 0x00, 0xEE, 0x01,
  0xB0, 0x0C, 0xE0, 0x1B, 0x01, 0xCE, 0x03, 0x30, 0x18, 0xE0, 0x33, 0x01,
  0x86, 0x06, 0x30, 0x38, 0x60, 0x63, 0x03, 0x06, 0x06, 0x30, 0x30, 0x60,
  0xC3, 0x07, 0x06, 0x0C, 0x30, 0x60, 0x61, 0x83, 0x06, 0x06, 0x18, 0x30,
  0xE0, 0x61, 0x83, 0x0C, 0x06, 0x30, 0x10, 0xC0, 0x63, 0x01, 0x98, 0x06,
  0x60, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x60, 0x1B, 0x00, 0x6C, 0x01,
  0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x68, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x0E, 0x03, 0x00, 0x0E, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x38, 0x01,
  0xC0, 0x30, 0x01, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0xC0, 0x00,
  0x61, 0xC0, 0x00, 0x63, 0x80, 0x00, 0x73, 0x00, 0x00, 0x37, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC6, 0x00, 0x03,
  0x87, 0x00, 0x03, 0x03, 0x00, 0x07, 0x03, 0x80, 0x0E, 0x01, 0x80, 0x0C,
  0x01, 0x80, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x70, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0xC0, 0x00, 0xFC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC7,
  0x00, 0x70, 0xE0, 0x0E, 0x0C, 0x03, 0x81, 0x80, 0x60, 0x38, 0x1C, 0x03,
  0x07, 0x00, 0x60, 0xC0, 0x0C, 0x38, 0x01, 0xCE, 0x00, 0x19, 0x80, 0x03,
  0x70, 0x00, 0x6C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0F,
  0xC0, 0xFC, 0x00, 0xC1, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x80, 0x03, 0xE0, 0xFC, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC1, 0xF0, 0x3E,
  0x00, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xE0, 0x6C, 0x0D, 0x83, 0x30, 0x66,
  0x18, 0xC3, 0x08, 0xC1, 0x98, 0x36, 0x06, 0xC0, 0xF0, 0x18, 0xFF, 0xFF,
  0xFF, 0xFC, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0x01, 0xF0, 0x0F, 0xF8, 0x38,
  0x78, 0xE0, 0x31, 0x80, 0x67, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x0F, 0xFC, 0x7F, 0xF9, 0xE0, 0x67, 0x00, 0xCC, 0x01, 0xB8, 0x03, 0x60,
  0x06, 0xC0, 0x1D, 0x80, 0x73, 0x81, 0xE3, 0x8F, 0xC7, 0xF9, 0x83, 0xE3,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0xF8, 0x1D, 0xFE, 0x1F,
  0x0E, 0x1E, 0x07, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03, 0x60, 0x07, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0xF0, 0x1C, 0xDC, 0x38, 0xCF,
  0xF0, 0xC7, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x38,
  0x06, 0x30, 0x07, 0x30, 0x03, 0x70, 0x03, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x60,
  0x0C, 0x60, 0x1C, 0x70, 0x18, 0x38, 0x70, 0x3F, 0xE0, 0x0F, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x01, 0xF8, 0xC0, 0xFF, 0x30,
  0x70, 0xEC, 0x38, 0x0F, 0x0C, 0x03, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60,
  0x06, 0x38, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03,
  0x0C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x01, 0x83,
  0x80, 0xE0, 0x70, 0xF8, 0x1F, 0xF6, 0x01, 0xF3, 0x80, 0x01, 0xF0, 0x07,
  0xFC, 0x0E, 0x0E, 0x1C, 0x06, 0x18, 0x06, 0x30, 0x07, 0x30, 0x03, 0x70,
  0x03, 0x60, 0x07, 0x7F, 0xFE, 0x7F, 0xFE, 0x60, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x18, 0x38,
  0x78, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0xE0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x03, 0xFE, 0x1F, 0xF0, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x00, 0x01, 0xF8, 0xC0, 0xFF,
  0x30, 0x70, 0xEC, 0x38, 0x0F, 0x0C, 0x03, 0x86, 0x00, 0x61, 0x80, 0x18,
  0x60, 0x06, 0x38, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x30,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x30, 0x06, 0x0C, 0x01,
  0x83, 0x80, 0xE0, 0x70, 0xF8, 0x1F, 0xFE, 0x01, 0xF3, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x10, 0x06, 0x06, 0x03, 0x81, 0xC1, 0xC0, 0x3F,
  0xE0, 0x03, 0xE0, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0xF8,
  0x1D, 0xFC, 0x1B, 0x0E, 0x1E, 0x06, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07,
  0x30, 0x07, 0x30, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06,
  0x60, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C,
  0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x18, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83,
  0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x01,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x0F, 0xC0, 0x7C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x03, 0x87, 0x03, 0x83, 0x01,
  0x81, 0x81, 0x80, 0xC1, 0xC0, 0x61, 0xC0, 0x71, 0xC0, 0x31, 0xC0, 0x19,
  0xC0, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xCC, 0x01, 0xC7, 0x00,
  0xC1, 0x80, 0x60, 0xE0, 0x30, 0x30, 0x18, 0x1C, 0x1C, 0x06, 0x0C, 0x03,
  0x06, 0x01, 0xC3, 0x00, 0x60, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0,
  0x1C, 0xF8, 0x1F, 0x03, 0x3F, 0x87, 0xF8, 0x6C, 0x39, 0xC7, 0x0F, 0x03,
  0x60, 0x71, 0xC0, 0x78, 0x0E, 0x30, 0x0F, 0x00, 0xCE, 0x01, 0xC0, 0x19,
  0x80, 0x38, 0x03, 0x30, 0x06, 0x00, 0x66, 0x00, 0xC0, 0x1C, 0xC0, 0x18,
  0x03, 0x38, 0x03, 0x00, 0x67, 0x00, 0x60, 0x0C, 0xC0, 0x1C, 0x01, 0x98,
  0x03, 0x00, 0x33, 0x00, 0x60, 0x0E, 0x60, 0x0C, 0x01, 0x9C, 0x01, 0x80,
  0x33, 0x80, 0x30, 0x06, 0x60, 0x0E, 0x00, 0xCC, 0x01, 0x80, 0x19, 0x80,
  0x30, 0x07, 0x00, 0x1C, 0xF8, 0x19, 0xFC, 0x1B, 0x0E, 0x1E, 0x06, 0x1C,
  0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x70, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x18, 0x03,
  0xF0, 0x0F, 0xF8, 0x1E, 0x1C, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x06, 0x60,
  0x06, 0x60, 0x06, 0xE0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0x60,
  0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x07, 0x3E, 0x01, 0xBF, 0xE0,
  0x7C, 0x38, 0x1C, 0x07, 0x06, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x30,
  0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x1C, 0x00,
  0xC6, 0x00, 0x71, 0x80, 0x18, 0x60, 0x06, 0x18, 0x03, 0x86, 0x00, 0xC3,
  0xC0, 0x70, 0xD8, 0x38, 0x33, 0xFC, 0x0C, 0x7E, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x00, 0x07, 0xE3, 0x0F, 0xF3, 0x1C, 0x3B, 0x38, 0x0F, 0x30,
  0x06, 0x70, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0,
  0x18, 0xC0, 0x18, 0xE0, 0x38, 0x70, 0xF8, 0x7F, 0xF8, 0x1F, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x1C, 0xF1, 0xBF, 0x1B, 0x91, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x38, 0x70, 0xE0, 0x71, 0x80, 0x67, 0x00, 0xCE,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x80, 0xE3,
  0x83, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC7,
  0xFF, 0xFE, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x3E, 0x0F,
  0x00, 0x38, 0x03, 0x30, 0x03, 0x30, 0x07, 0x30, 0x06, 0x30, 0x06, 0x30,
  0x06, 0x70, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0xE0, 0x0C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xE0,
  0x38, 0xE0, 0x78, 0x70, 0xF8, 0x7F, 0xB0, 0x1F, 0x30, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00, 0xCE, 0x07, 0x18, 0x18, 0x60,
  0xE1, 0x83, 0x06, 0x1C, 0x18, 0x60, 0x61, 0x81, 0x8C, 0x03, 0x30, 0x0D,
  0x80, 0x36, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x1F, 0x00, 0xE0, 0x36, 0x03, 0xC0, 0x6C,
  0x07, 0x81, 0x9C, 0x1B, 0x03, 0x38, 0x36, 0x0E, 0x30, 0xEC, 0x18, 0x61,
  0x98, 0x30, 0xC3, 0x30, 0xC1, 0x8C, 0x61, 0x83, 0x18, 0x47, 0x06, 0x60,
  0xCC, 0x0C, 0xC1, 0x98, 0x1B, 0x83, 0x60, 0x36, 0x06, 0xC0, 0x6C, 0x0F,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC1, 0x80, 0xE0, 0x60, 0x30, 0x1C,
  0x1C, 0x03, 0x0E, 0x00, 0xC3, 0x00, 0x19, 0xC0, 0x06, 0xE0, 0x01, 0xB0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x73, 0x00, 0x18, 0xC0, 0x0E, 0x18, 0x07, 0x06, 0x01, 0x81, 0xC0, 0xE0,
  0x30, 0x70, 0x0C, 0x18, 0x03, 0x80, 0x06, 0x00, 0x60, 0x60, 0x0E, 0x06,
  0x00, 0xC0, 0x60, 0x1C, 0x06, 0x01, 0x80, 0x70, 0x18, 0x07, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x07, 0x00, 0x30, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xC0,
  0x03, 0x1C, 0x00, 0x39, 0x80, 0x01, 0xB8, 0x00, 0x1B, 0x00, 0x01, 0xB0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x87,
  0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x18, 0x01, 0xC0,
  0x1C, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x0E, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x40, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x80, 0x02, 0x00, 0x38, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x10, 0x00,
  0x0F, 0x00, 0x67, 0xF0, 0x0D, 0xC7, 0x01, 0xB0, 0x70, 0x66, 0x07, 0x9D,
  0x80, 0x7F, 0x00, 0x03, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 29, 9, 1, -29 },
  { 27, 8, 9, 11, 4, -31 },
  { 36, 21, 29, 20, 1, -29 },
  { 113, 16, 37, 19, 2, -33 },
  { 187, 19, 29, 25, 4, -29 },
  { 256, 18, 29, 21, 1, -29 },
  { 322, 3, 9, 7, 4, -31 },
  { 326, 12, 42, 12, 2, -33 },
  { 389, 11, 42, 12, -2, -33 },
  { 447, 16, 16, 17, 2, -29 },
  { 479, 16, 21, 20, 2, -24 },
  { 521, 6, 9, 8, -2, -4 },
  { 528, 8, 2, 10, 1, -14 },
  { 530, 3, 3, 9, 1, -3 },
  { 532, 18, 31, 14, -2, -29 },
  { 602, 16, 29, 19, 2, -29 },
  { 660, 10, 29, 19, 5, -29 },
  { 697, 17, 29, 19, 1, -29 },
  { 759, 17, 29, 19, 1, -29 },
  { 821, 17, 29, 19, 1, -29 },
  { 883, 18, 29, 19, 2, -29 },
  { 949, 15, 29, 19, 2, -29 },
  { 1004, 17, 29, 19, 3, -29 },
  { 1066, 18, 29, 19, 1, -29 },
  { 1132, 15, 29, 19, 3, -29 },
  { 1187, 6, 21, 8, 1, -21 },
  { 1203, 9, 26, 8, -2, -21 },
  { 1233, 15, 17, 18, 2, -22 },
  { 1265, 16, 10, 19, 2, -19 },
  { 1285, 16, 17, 18, 1, -22 },
  { 1319, 12, 29, 16, 4, -29 },
  { 1363, 28, 37, 31, 1, -28 },
  { 1493, 20, 29, 22, -1, -29 },
  { 1566, 19, 29, 21, 1, -29 },
  { 1635, 20, 29, 22, 2, -29 },
  { 1708, 20, 29, 23, 1, -29 },
  { 1781, 20, 29, 20, 1, -29 },
  { 1854, 20, 29, 20, 1, -29 },
  { 1927, 20, 29, 24, 2, -29 },
  { 2000, 23, 29, 24, 1, -29 },
  { 2084, 7, 29, 10, 2, -29 },
  { 2110, 18, 29, 19, 1, -29 },
  { 2176, 22, 29, 22, 1, -29 },
  { 2256, 15, 29, 18, 1, -29 },
  { 2311, 28, 29, 30, 1, -29 },
  { 2413, 23, 29, 25, 1, -29 },
  { 2497, 20, 29, 23, 2, -29 },
  { 2570, 20, 29, 21, 1, -29 },
  { 2643, 20, 34, 23, 2, -29 },
  { 2728, 20, 29, 22, 1, -29 },
  { 2801, 20, 29, 21, 1, -29 },
  { 2874, 19, 29, 21, 4, -29 },
  { 2943, 21, 29, 23, 2, -29 },
  { 3020, 19, 29, 22, 4, -29 },
  { 3089, 28, 29, 31, 4, -29 },
  { 3191, 24, 29, 21, -1, -29 },
  { 3278, 19, 29, 21, 4, -29 },
  { 3347, 21, 29, 21, 0, -29 },
  { 3424, 12, 39, 9, 0, -33 },
  { 3483, 7, 31, 14, 4, -29 },
  { 3511, 11, 39, 9, -2, -33 },
  { 3565, 11, 15, 15, 2, -29 },
  { 3586, 15, 2, 15, -2, 0 },
  { 3590, 6, 6, 11, 5, -31 },
  { 3595, 15, 22, 19, 1, -22 },
  { 3637, 16, 31, 19, 1, -31 },
  { 3699, 16, 22, 18, 1, -22 },
  { 3743, 18, 31, 19, 2, -31 },
  { 3813, 16, 22, 18, 1, -22 },
  { 3857, 13, 31, 12, 2, -31 },
  { 3908, 18, 30, 19, 0, -22 },
  { 3976, 16, 31, 19, 1, -31 },
  { 4038, 7, 30, 8, 1, -30 },
  { 4065, 13, 38, 8, -5, -30 },
  { 4127, 17, 31, 17, 1, -31 },
  { 4193, 8, 31, 8, 1, -31 },
  { 4224, 27, 22, 30, 1, -22 },
  { 4299, 16, 22, 19, 1, -22 },
  { 4343, 16, 22, 20, 2, -22 },
  { 4387, 18, 30, 19, -1, -22 },
  { 4455, 16, 30, 19, 2, -22 },
  { 4515, 12, 22, 12, 1, -22 },
  { 4548, 15, 22, 18, 1, -22 },
  { 4590, 9, 27, 12, 2, -27 },
  { 4621, 16, 22, 19, 2, -22 },
  { 4665, 14, 22, 17, 3, -22 },
  { 4704, 23, 22, 26, 3, -22 },
  { 4768, 18, 22, 17, -1, -22 },
  { 4818, 20, 30, 17, -2, -22 },
  { 4893, 17, 22, 17, 0, -22 },
  { 4940, 13, 40, 12, 1, -32 },
  { 5005, 7, 34, 9, 1, -29 },
  { 5035, 13, 40, 12, -2, -32 },
  { 5100, 19, 7, 24, 2, -15 },
};

const GFXfont RobotoCondensed_LightItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC41PT7B_H_
