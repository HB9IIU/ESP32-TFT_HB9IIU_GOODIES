#ifndef _ROBOTOCONDENSED_LIGHTITALIC28PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x23, 0x18, 0xC4, 0x21, 0x18, 0xC6, 0x21, 0x00, 0x00,
  0x31, 0x80, 0x4A, 0x53, 0xB9, 0xC8, 0x01, 0x08, 0x04, 0x60, 0x31, 0x00,
  0x84, 0x02, 0x30, 0x18, 0x83, 0xFF, 0xC1, 0x18, 0x04, 0x40, 0x21, 0x00,
  0x8C, 0x02, 0x20, 0x10, 0x83, 0xFF, 0xC1, 0x10, 0x0C, 0x40, 0x21, 0x00,
  0x88, 0x06, 0x20, 0x10, 0x80, 0x01, 0x80, 0x18, 0x01, 0x00, 0x78, 0x0E,
  0xE1, 0x86, 0x10, 0x23, 0x02, 0x30, 0x33, 0x00, 0x30, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x4C, 0x04, 0xC0, 0x4C, 0x0C, 0x41,
  0x87, 0xF8, 0x3E, 0x00, 0x80, 0x08, 0x01, 0x80, 0x38, 0x04, 0xC0, 0xC4,
  0x08, 0x42, 0x84, 0x68, 0x44, 0x8C, 0x8C, 0x90, 0x73, 0x00, 0x20, 0x04,
  0x00, 0xCE, 0x09, 0xB1, 0x31, 0x32, 0x16, 0x21, 0x42, 0x18, 0x21, 0x03,
  0x20, 0x1C, 0x07, 0x80, 0xEC, 0x08, 0x41, 0x84, 0x18, 0x41, 0x0C, 0x19,
  0x81, 0xB0, 0x0E, 0x00, 0xC0, 0x3E, 0x06, 0x61, 0x63, 0x1C, 0x13, 0xC1,
  0xA8, 0x0E, 0xC0, 0xCC, 0x0C, 0x77, 0x63, 0xE2, 0x7E, 0xA0, 0x01, 0x03,
  0x06, 0x04, 0x08, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x08, 0x10, 0x10, 0x20, 0x60, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20,
  0xC3, 0x04, 0x00, 0x06, 0x01, 0x00, 0x42, 0x11, 0xED, 0xCF, 0xC1, 0xC0,
  0xD0, 0x66, 0x10, 0xC4, 0x20, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0xFF, 0xFF, 0xFE, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x08, 0x00, 0x32, 0x26, 0xC8, 0xF8, 0xF0, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x81, 0x98, 0x61, 0x98, 0x13,
  0x02, 0x40, 0x58, 0x0B, 0x01, 0x60, 0x28, 0x0D, 0x01, 0xA0, 0x34, 0x07,
  0x80, 0xB0, 0x16, 0x06, 0x40, 0x8C, 0x31, 0xDC, 0x1F, 0x00, 0x04, 0xFE,
  0xE3, 0x08, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0xC3, 0x08, 0x20, 0x86,
  0x18, 0x03, 0xC0, 0xEE, 0x08, 0x31, 0x81, 0x10, 0x13, 0x01, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x60, 0x07, 0xFE, 0x07, 0x83, 0x98, 0x41, 0x98,
  0x12, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0xC0, 0x70, 0x3C, 0x00, 0xC0,
  0x0C, 0x00, 0xA0, 0x14, 0x06, 0xC0, 0xC8, 0x31, 0xDC, 0x1F, 0x00, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x0A, 0x01, 0xA0, 0x12, 0x02, 0x60, 0x66, 0x0C,
  0x60, 0x84, 0x18, 0x43, 0x04, 0x20, 0xC6, 0x0C, 0x7F, 0xF0, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x1F, 0xE3, 0xFC, 0x40, 0x18, 0x03, 0x00,
  0x40, 0x08, 0x03, 0x78, 0x7F, 0x8C, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0xA0, 0x34, 0x04, 0x81, 0x98, 0x21, 0xDC, 0x1E, 0x00, 0x01, 0xC0, 0xF8,
  0x38, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x01, 0x7C, 0x7D, 0xCE, 0x19, 0x81,
  0x20, 0x34, 0x07, 0x80, 0xD0, 0x12, 0x02, 0x40, 0xCC, 0x30, 0xEC, 0x0F,
  0x00, 0x7F, 0xF0, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x07, 0xC0, 0xEE, 0x18, 0x63,
  0x02, 0x30, 0x33, 0x02, 0x30, 0x23, 0x06, 0x1D, 0xC1, 0xF0, 0x31, 0x86,
  0x0C, 0xC0, 0x4C, 0x04, 0x80, 0x48, 0x0C, 0xC0, 0xCC, 0x18, 0x77, 0x03,
  0xE0, 0x0F, 0x0E, 0xE2, 0x0D, 0x83, 0x40, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0xF0, 0x34, 0x1D, 0xDE, 0x3C, 0x80, 0x60, 0x18, 0x0C, 0x02, 0x01, 0x87,
  0xC3, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0x80,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x82, 0x18,
  0x42, 0x00, 0x00, 0x40, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x40, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x20, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30,
  0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x02, 0x00, 0x1E, 0x1F, 0x98, 0x68, 0x3C,
  0x18, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x02, 0x03, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x7E, 0x00, 0x38, 0xE0, 0x1C,
  0x02, 0x06, 0x00, 0x20, 0x80, 0x04, 0x30, 0x00, 0xCC, 0x1E, 0x09, 0x06,
  0x61, 0x61, 0x84, 0x28, 0x61, 0x85, 0x08, 0x20, 0xA1, 0x04, 0x3C, 0x60,
  0x87, 0x08, 0x30, 0xA1, 0x04, 0x14, 0x21, 0x86, 0x84, 0x30, 0x90, 0xCB,
  0x22, 0x0E, 0x38, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0xC3, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00,
  0x3C, 0x00, 0xB0, 0x06, 0x40, 0x11, 0x00, 0xC4, 0x02, 0x10, 0x18, 0x40,
  0x41, 0x83, 0x06, 0x08, 0x18, 0x7F, 0xE1, 0x00, 0x8C, 0x02, 0x20, 0x09,
  0x80, 0x36, 0x00, 0xF0, 0x03, 0x1F, 0xC0, 0xC7, 0x84, 0x04, 0x20, 0x31,
  0x01, 0x98, 0x0C, 0xC0, 0x46, 0x06, 0x21, 0xE1, 0xFE, 0x18, 0x18, 0xC0,
  0x46, 0x02, 0x30, 0x19, 0x00, 0xC8, 0x04, 0xC0, 0x66, 0x06, 0x30, 0xF1,
  0xFE, 0x00, 0x07, 0xC0, 0x77, 0x06, 0x0C, 0x60, 0x26, 0x01, 0xB0, 0x0D,
  0x00, 0x78, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x12, 0x00, 0x90, 0x0C, 0xC0, 0x46, 0x06, 0x1C, 0xE0, 0x7C, 0x00, 0x1F,
  0xC0, 0x63, 0xC1, 0x03, 0x04, 0x06, 0x10, 0x08, 0xC0, 0x23, 0x00, 0x8C,
  0x02, 0x20, 0x08, 0x80, 0x26, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x44,
  0x03, 0x10, 0x0C, 0xC0, 0x63, 0x03, 0x0C, 0x78, 0x3F, 0x80, 0x1F, 0xF8,
  0xC0, 0x04, 0x00, 0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20,
  0x01, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0xC0, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0xFF, 0x1F,
  0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x77, 0x86, 0x04, 0x60, 0x36, 0x01,
  0xB0, 0x05, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x87, 0xE8,
  0x03, 0x40, 0x1A, 0x00, 0xD8, 0x04, 0xC0, 0x23, 0x03, 0x1E, 0xF0, 0x3E,
  0x00, 0x18, 0x02, 0x30, 0x04, 0x40, 0x18, 0x80, 0x31, 0x00, 0x66, 0x00,
  0xCC, 0x01, 0x18, 0x02, 0x20, 0x0C, 0x7F, 0xF9, 0x80, 0x33, 0x00, 0x46,
  0x00, 0x8C, 0x01, 0x10, 0x06, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x23, 0x00,
  0x46, 0x00, 0x80, 0x18, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x88, 0x46, 0x31,
  0x88, 0x42, 0x31, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x31, 0x01, 0x08, 0x08, 0x40, 0xC3, 0x0C, 0x0F, 0xC0, 0x3C,
  0x00, 0x18, 0x0C, 0x30, 0x38, 0x40, 0x60, 0x81, 0x81, 0x06, 0x06, 0x18,
  0x0C, 0x60, 0x19, 0x80, 0x26, 0x00, 0x5C, 0x01, 0xE8, 0x03, 0x98, 0x06,
  0x10, 0x0C, 0x30, 0x10, 0x60, 0x20, 0x60, 0xC0, 0xC1, 0x80, 0xC3, 0x01,
  0x86, 0x01, 0x80, 0x18, 0x06, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0xFE, 0x18, 0x00, 0x63, 0x80, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0xE1, 0x40, 0x14, 0x68, 0x06, 0x8D, 0x00, 0xB1, 0xB0, 0x36, 0x26,
  0x04, 0xC4, 0xC1, 0x91, 0x88, 0x22, 0x31, 0x0C, 0x46, 0x21, 0x18, 0xC4,
  0x63, 0x10, 0xC8, 0x62, 0x1B, 0x08, 0xC1, 0x41, 0x18, 0x38, 0x63, 0x06,
  0x0C, 0x60, 0xC1, 0x80, 0x18, 0x02, 0x18, 0x02, 0x1C, 0x06, 0x14, 0x06,
  0x14, 0x06, 0x36, 0x06, 0x32, 0x04, 0x33, 0x04, 0x23, 0x0C, 0x21, 0x0C,
  0x61, 0x8C, 0x61, 0x8C, 0x60, 0x88, 0x60, 0xC8, 0x40, 0x58, 0x40, 0x58,
  0xC0, 0x78, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0x07, 0xC0, 0x7F, 0x86,
  0x0C, 0x60, 0x36, 0x01, 0xB0, 0x0D, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x28, 0x01, 0x40, 0x1A, 0x00, 0xD0, 0x04, 0xC0, 0x66,
  0x06, 0x1E, 0xE0, 0x7C, 0x00, 0x1F, 0xE0, 0x61, 0xC1, 0x01, 0x84, 0x02,
  0x10, 0x08, 0xC0, 0x23, 0x00, 0x8C, 0x06, 0x20, 0x18, 0x80, 0xC6, 0x0E,
  0x1F, 0xF0, 0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xC1, 0x86, 0x03, 0x30,
  0x0C, 0xC0, 0x32, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80, 0x36, 0x00, 0x90,
  0x02, 0x40, 0x09, 0x00, 0x64, 0x01, 0x90, 0x04, 0x60, 0x31, 0x81, 0x83,
  0xFC, 0x07, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x1F, 0xE0, 0xC3,
  0x84, 0x06, 0x20, 0x33, 0x00, 0x98, 0x04, 0xC0, 0x66, 0x03, 0x20, 0x11,
  0x01, 0x98, 0x78, 0xFF, 0x06, 0x08, 0x30, 0x41, 0x03, 0x08, 0x18, 0xC0,
  0x46, 0x03, 0x30, 0x19, 0x00, 0x40, 0x07, 0xC0, 0x77, 0x86, 0x0C, 0x60,
  0x33, 0x01, 0x90, 0x0C, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0x80, 0x06, 0x00, 0x12, 0x00, 0x90, 0x04, 0xC0, 0x66, 0x06, 0x1E,
  0xE0, 0x3E, 0x00, 0xFF, 0xF0, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x04, 0x20,
  0x08, 0x40, 0x11, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x02, 0x10, 0x04,
  0x20, 0x08, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x10,
  0x0C, 0x20, 0x18, 0x40, 0x20, 0xC0, 0xC0, 0xE7, 0x00, 0xF8, 0x00, 0x40,
  0x0D, 0x00, 0x24, 0x01, 0x98, 0x04, 0x60, 0x31, 0x80, 0x86, 0x06, 0x08,
  0x18, 0x20, 0xC0, 0x83, 0x02, 0x08, 0x0C, 0x60, 0x31, 0x00, 0xCC, 0x01,
  0x20, 0x05, 0x80, 0x14, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x80, 0xC0,
  0x70, 0x18, 0x0A, 0x03, 0x03, 0x40, 0xE0, 0x6C, 0x14, 0x09, 0x82, 0x83,
  0x30, 0xD8, 0x66, 0x13, 0x08, 0xC6, 0x63, 0x18, 0x8C, 0x63, 0x10, 0x88,
  0x66, 0x13, 0x0C, 0x82, 0x41, 0xB0, 0x48, 0x34, 0x0B, 0x02, 0x81, 0x40,
  0x70, 0x28, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x00, 0x18, 0x06,
  0x30, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x43, 0x00, 0xC6, 0x01, 0x98, 0x01,
  0x60, 0x03, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x68, 0x01, 0x98,
  0x06, 0x10, 0x0C, 0x30, 0x30, 0x60, 0xC0, 0x41, 0x80, 0xC6, 0x01, 0x80,
  0x80, 0x16, 0x01, 0xB0, 0x18, 0x80, 0xC4, 0x0C, 0x30, 0xC1, 0x86, 0x04,
  0x60, 0x32, 0x01, 0xB0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x1F, 0xFE, 0x00,
  0x08, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40, 0x40, 0xC0,
  0xC0, 0xF0, 0x88, 0xCC, 0xC4, 0x44, 0x46, 0x66, 0x22, 0x22, 0x33, 0x31,
  0x11, 0x0F, 0x01, 0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18,
  0x18, 0x18, 0x10, 0xF0, 0x06, 0x06, 0x0E, 0x0A, 0x1A, 0x12, 0x33, 0x23,
  0x61, 0x41, 0xFF, 0xC0, 0x66, 0x21, 0x0F, 0x06, 0xF3, 0x0D, 0x81, 0x00,
  0x40, 0x31, 0xFD, 0xC3, 0xC0, 0xB0, 0x28, 0x0A, 0x06, 0x83, 0xBF, 0xE7,
  0x98, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0D, 0xE1, 0x6E,
  0x30, 0x44, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0x80, 0xD0, 0x1E, 0x02, 0xC0,
  0x58, 0x1B, 0x06, 0x5F, 0xC9, 0xE0, 0x0F, 0x87, 0x38, 0xC3, 0x30, 0x24,
  0x05, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x02, 0x60, 0x4C, 0x18,
  0xEE, 0x0F, 0x80, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x3C, 0x87, 0xF4, 0x30, 0xE3, 0x03, 0x10, 0x18, 0x80, 0xCC, 0x04,
  0x60, 0x23, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x04, 0x30, 0x60, 0xED, 0x03,
  0xD8, 0x00, 0x0F, 0x06, 0x63, 0x0D, 0x81, 0x40, 0x70, 0x1C, 0x07, 0xFF,
  0xC0, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x9C, 0xC3, 0xE0, 0x03, 0x83, 0xC3,
  0x01, 0x01, 0x80, 0xC1, 0xF8, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x00, 0x07, 0x91, 0xFD,
  0x18, 0x73, 0x03, 0x20, 0x32, 0x03, 0x60, 0x26, 0x02, 0x60, 0x66, 0x06,
  0x60, 0x66, 0x06, 0x60, 0xC3, 0xB4, 0x1E, 0xC0, 0x0C, 0x00, 0xC0, 0x08,
  0xC1, 0x87, 0x70, 0x3E, 0x00, 0x18, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x78, 0xB7, 0x30, 0x48, 0x16, 0x05, 0x81, 0x60, 0x50, 0x34, 0x0F,
  0x03, 0xC0, 0xF0, 0x28, 0x0A, 0x06, 0x81, 0x80, 0x18, 0xC0, 0x00, 0x18,
  0xC4, 0x23, 0x18, 0xC4, 0x21, 0x18, 0xC6, 0x21, 0x00, 0x01, 0x80, 0x80,
  0x00, 0x00, 0x00, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20,
  0xF0, 0x70, 0x00, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C,
  0x19, 0x06, 0x21, 0x84, 0x61, 0x98, 0x36, 0x07, 0x80, 0xF8, 0x1B, 0x06,
  0x20, 0xC6, 0x18, 0x42, 0x0C, 0x40, 0x88, 0x18, 0x18, 0xC4, 0x21, 0x18,
  0xC6, 0x21, 0x08, 0xC6, 0x31, 0x08, 0xC6, 0x31, 0x08, 0x00, 0x13, 0xC3,
  0xC2, 0xDD, 0xDC, 0x61, 0xA1, 0x98, 0x18, 0x13, 0x03, 0x02, 0x60, 0x40,
  0xC8, 0x08, 0x19, 0x03, 0x03, 0x20, 0x60, 0x6C, 0x0C, 0x09, 0x81, 0x01,
  0x30, 0x20, 0x64, 0x04, 0x0C, 0x81, 0x81, 0x90, 0x30, 0x30, 0x27, 0x8B,
  0x73, 0x04, 0x81, 0x60, 0x58, 0x16, 0x05, 0x03, 0x40, 0xF0, 0x3C, 0x0F,
  0x02, 0x80, 0xA0, 0x68, 0x18, 0x0F, 0x83, 0xB8, 0xC1, 0x30, 0x34, 0x06,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0B, 0x01, 0x60, 0x64, 0x18, 0xE6,
  0x0F, 0x80, 0x13, 0xC1, 0x6E, 0x18, 0x23, 0x03, 0x30, 0x33, 0x03, 0x30,
  0x32, 0x03, 0x20, 0x26, 0x02, 0x60, 0x66, 0x06, 0x60, 0xC5, 0x9C, 0x4F,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x0F, 0x27,
  0x34, 0xC1, 0xB0, 0x34, 0x06, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0xD8, 0x1B,
  0x03, 0x60, 0x4C, 0x18, 0xED, 0x0F, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04,
  0x00, 0x80, 0x30, 0x37, 0x2F, 0x30, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x0F, 0x0E, 0xE2, 0x0D, 0x83, 0x60,
  0x08, 0x03, 0x80, 0x38, 0x03, 0x00, 0x60, 0x1A, 0x06, 0xC1, 0x3F, 0xC3,
  0xC0, 0x18, 0x30, 0x60, 0x87, 0xE2, 0x0C, 0x18, 0x30, 0x40, 0x81, 0x06,
  0x0C, 0x18, 0x20, 0x40, 0xF0, 0xE0, 0x20, 0x24, 0x04, 0x81, 0xB0, 0x36,
  0x06, 0xC0, 0x90, 0x12, 0x06, 0x40, 0xD8, 0x1B, 0x02, 0x60, 0x44, 0x18,
  0xEF, 0x0F, 0x60, 0x80, 0xE0, 0x2C, 0x1B, 0x04, 0xC3, 0x10, 0x84, 0x61,
  0x18, 0x44, 0x13, 0x06, 0x81, 0xE0, 0x30, 0x0C, 0x02, 0x00, 0xC1, 0x83,
  0xC1, 0x82, 0xC3, 0x86, 0xC2, 0x86, 0xC6, 0x84, 0xC4, 0x8C, 0xC4, 0x88,
  0x4C, 0x98, 0x48, 0x90, 0x58, 0x90, 0x50, 0xB0, 0x70, 0xE0, 0x60, 0xE0,
  0x60, 0xC0, 0x60, 0x40, 0x18, 0x10, 0x41, 0x83, 0x18, 0x18, 0x80, 0x4C,
  0x03, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x68, 0x02, 0x60, 0x31, 0x03,
  0x0C, 0x30, 0x61, 0x81, 0x00, 0x10, 0x18, 0xC0, 0x86, 0x0C, 0x30, 0x41,
  0x86, 0x0C, 0x20, 0x23, 0x01, 0x18, 0x08, 0x80, 0x4C, 0x03, 0x40, 0x1E,
  0x00, 0xE0, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0x3F, 0xE0, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x3F,
  0xE0, 0x01, 0x01, 0x81, 0x81, 0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C,
  0x04, 0x06, 0x0E, 0x06, 0x01, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x06, 0x00, 0x08, 0x20, 0x82, 0x18,
  0x61, 0x84, 0x10, 0x41, 0x0C, 0x30, 0xC2, 0x08, 0x21, 0x86, 0x18, 0x41,
  0x04, 0x10, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x30, 0x0C, 0x06, 0x04, 0x04, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x18, 0x18, 0x08, 0x00, 0x38, 0x13,
  0xE0, 0xB1, 0x8D, 0x07, 0xC8, 0x1C, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 20, 6, 1, -20 },
  { 14, 5, 6, 8, 3, -21 },
  { 18, 14, 20, 14, 1, -20 },
  { 53, 12, 26, 13, 1, -23 },
  { 92, 12, 20, 17, 3, -20 },
  { 122, 12, 20, 15, 1, -20 },
  { 152, 2, 6, 5, 3, -21 },
  { 154, 8, 28, 8, 1, -22 },
  { 182, 7, 28, 8, -1, -22 },
  { 207, 10, 11, 12, 2, -20 },
  { 221, 12, 15, 13, 1, -17 },
  { 244, 4, 6, 5, -1, -3 },
  { 247, 5, 1, 7, 1, -9 },
  { 248, 2, 2, 6, 1, -2 },
  { 249, 12, 22, 10, -1, -20 },
  { 282, 11, 20, 13, 1, -20 },
  { 310, 6, 20, 13, 4, -20 },
  { 325, 12, 20, 13, 0, -20 },
  { 355, 11, 20, 13, 1, -20 },
  { 383, 12, 20, 13, 0, -20 },
  { 413, 11, 20, 13, 2, -20 },
  { 441, 11, 20, 13, 1, -20 },
  { 469, 12, 20, 13, 2, -20 },
  { 499, 12, 20, 13, 1, -20 },
  { 529, 10, 20, 13, 2, -20 },
  { 554, 5, 15, 6, 0, -15 },
  { 564, 6, 18, 5, -1, -15 },
  { 578, 11, 12, 12, 1, -15 },
  { 595, 11, 6, 13, 1, -12 },
  { 604, 10, 12, 12, 1, -15 },
  { 619, 9, 20, 11, 2, -20 },
  { 642, 19, 25, 21, 1, -19 },
  { 702, 14, 20, 15, -1, -20 },
  { 737, 13, 20, 15, 1, -20 },
  { 770, 13, 20, 15, 2, -20 },
  { 803, 14, 20, 15, 1, -20 },
  { 838, 13, 20, 14, 1, -20 },
  { 871, 13, 20, 13, 1, -20 },
  { 904, 13, 20, 16, 2, -20 },
  { 937, 15, 20, 17, 1, -20 },
  { 975, 5, 20, 7, 1, -20 },
  { 988, 13, 20, 13, 0, -20 },
  { 1021, 15, 20, 15, 1, -20 },
  { 1059, 10, 20, 13, 1, -20 },
  { 1084, 19, 20, 20, 1, -20 },
  { 1132, 16, 20, 17, 1, -20 },
  { 1172, 13, 20, 16, 2, -20 },
  { 1205, 14, 20, 15, 1, -20 },
  { 1240, 14, 23, 16, 1, -20 },
  { 1281, 13, 20, 15, 1, -20 },
  { 1314, 13, 20, 14, 1, -20 },
  { 1347, 12, 20, 14, 3, -20 },
  { 1377, 15, 20, 15, 1, -20 },
  { 1415, 14, 20, 15, 2, -20 },
  { 1450, 19, 20, 21, 3, -20 },
  { 1498, 15, 20, 15, 0, -20 },
  { 1536, 13, 20, 14, 3, -20 },
  { 1569, 15, 20, 14, 0, -20 },
  { 1607, 8, 27, 6, 0, -23 },
  { 1634, 4, 22, 10, 3, -20 },
  { 1645, 8, 27, 6, -2, -23 },
  { 1672, 8, 10, 10, 1, -20 },
  { 1682, 10, 1, 10, -1, 0 },
  { 1684, 4, 4, 8, 3, -21 },
  { 1686, 10, 15, 13, 1, -15 },
  { 1705, 11, 21, 13, 1, -21 },
  { 1734, 11, 15, 12, 1, -15 },
  { 1755, 13, 21, 13, 1, -21 },
  { 1790, 10, 15, 12, 1, -15 },
  { 1809, 9, 21, 8, 1, -21 },
  { 1833, 12, 21, 13, 0, -15 },
  { 1865, 10, 21, 13, 1, -21 },
  { 1892, 5, 20, 6, 1, -20 },
  { 1905, 9, 26, 6, -3, -20 },
  { 1935, 11, 21, 12, 1, -21 },
  { 1964, 5, 21, 6, 1, -21 },
  { 1978, 19, 15, 21, 0, -15 },
  { 2014, 10, 15, 13, 1, -15 },
  { 2033, 11, 15, 13, 1, -15 },
  { 2054, 12, 21, 13, 0, -15 },
  { 2086, 11, 21, 13, 1, -15 },
  { 2115, 8, 15, 8, 1, -15 },
  { 2130, 10, 15, 12, 1, -15 },
  { 2149, 7, 19, 8, 1, -19 },
  { 2166, 11, 15, 13, 1, -15 },
  { 2187, 10, 15, 12, 2, -15 },
  { 2206, 16, 15, 18, 2, -15 },
  { 2236, 13, 15, 12, -1, -15 },
  { 2261, 13, 21, 11, -1, -15 },
  { 2296, 11, 15, 12, 0, -15 },
  { 2317, 9, 27, 8, 1, -22 },
  { 2348, 6, 24, 6, 0, -20 },
  { 2366, 9, 28, 8, -2, -22 },
  { 2398, 13, 5, 16, 2, -11 },
};

const GFXfont RobotoCondensed_LightItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC28PT7B_H_
