#ifndef _ROBOTOCONDENSED_LIGHTITALIC71PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0x60, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xCF,
  0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x39, 0xE1, 0xE7,
  0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x06, 0x38, 0x38, 0x00, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0x80,
  0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x1C, 0xF0,
  0x07, 0x00, 0x3C, 0xE0, 0x07, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x70, 0xE0,
  0x07, 0x00, 0xF0, 0xE0, 0x07, 0x00, 0xE0, 0xE0, 0x07, 0x01, 0xC0, 0xE0,
  0x07, 0x03, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0xE0, 0x0F, 0x07, 0x00, 0xE0,
  0x0E, 0x0F, 0x00, 0xE0, 0x1E, 0x1E, 0x00, 0x70, 0x1C, 0x1C, 0x00, 0x78,
  0x3C, 0x38, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x0F,
  0xE0, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x07, 0xF0, 0x00,
  0x0E, 0x0F, 0xF8, 0x00, 0x1E, 0x1F, 0xFC, 0x00, 0x3C, 0x3C, 0x1E, 0x00,
  0x38, 0x38, 0x0E, 0x00, 0x70, 0x70, 0x0F, 0x00, 0xF0, 0x70, 0x07, 0x00,
  0xE0, 0xE0, 0x07, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0xE0, 0x07, 0x03,
  0x80, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x07, 0x0F, 0x01, 0xE0, 0x07, 0x1E,
  0x01, 0xE0, 0x07, 0x1C, 0x01, 0xE0, 0x0F, 0x3C, 0x01, 0xE0, 0x0E, 0x78,
  0x00, 0xE0, 0x0E, 0x30, 0x00, 0xE0, 0x1E, 0x10, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x7E, 0x00, 0x00,
  0x78, 0xFC, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03,
  0xE3, 0xC0, 0x0F, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x81, 0xE0, 0x0E, 0x1F,
  0x01, 0xF0, 0x0E, 0x3E, 0x00, 0xF0, 0x1E, 0x3C, 0x00, 0x78, 0x1E, 0x7C,
  0x00, 0x78, 0x1C, 0x78, 0x00, 0x3C, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x78,
  0x00, 0x1E, 0x78, 0xF0, 0x00, 0x1F, 0x78, 0xF0, 0x00, 0x0F, 0xF0, 0xF0,
  0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x0F, 0xE0, 0x3E,
  0x00, 0x3E, 0xF0, 0x1F, 0x80, 0xFC, 0xF0, 0x0F, 0xFF, 0xF8, 0x78, 0x07,
  0xFF, 0xE0, 0x7C, 0x03, 0xFF, 0xC0, 0x3C, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0xF3, 0x8E, 0x39, 0xE7, 0x9E, 0x71, 0xC7, 0x3C, 0xE3, 0x8E, 0x38, 0x00,
  0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0xE0, 0x0D, 0xF0, 0x3C, 0x0F, 0xFF, 0x87, 0x8F, 0xF7, 0xFE, 0xE7,
  0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xC0,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x7C,
  0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x01, 0xE0,
  0x0C, 0x00, 0x38, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0,
  0xF0, 0x7C, 0x1E, 0x07, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xEF, 0xFE, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C,
  0x78, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0x00, 0x07, 0x80,
  0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF9, 0xFE, 0x38, 0xFC, 0x1C,
  0xF8, 0x1E, 0x60, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x7C, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xF0, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03,
  0x80, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0xFE, 0x00, 0x01, 0xCF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xF8, 0x01, 0xC7, 0xFF,
  0x80, 0xF3, 0xFF, 0xF0, 0x3D, 0xFF, 0xFE, 0x0F, 0xF0, 0x0F, 0x83, 0xF8,
  0x01, 0xF1, 0xFC, 0x00, 0x3C, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x7C, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFC,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xF0, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F,
  0x70, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xE7, 0x80, 0x01, 0xF8,
  0xF0, 0x00, 0xFE, 0x3E, 0x00, 0x77, 0x07, 0xC0, 0x7F, 0xC1, 0xFF, 0xFE,
  0xF0, 0x3F, 0xFF, 0x3C, 0x07, 0xFF, 0x0E, 0x00, 0x7F, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0x78, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x00, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xC1, 0xF0, 0x7C, 0x03, 0xE3,
  0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0x01, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0x80, 0xE0, 0x01, 0xF8,
  0xFC, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x60, 0x70, 0x01, 0xE0,
  0x07, 0x00, 0x30, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x18, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x06, 0x1E, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x0E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x87, 0x00, 0x38,
  0x00, 0x78, 0x01, 0xC3, 0x80, 0x3C, 0x00, 0x38, 0x00, 0xE3, 0xC0, 0x1E,
  0x00, 0x1C, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0x1C, 0x70, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x78, 0x03,
  0x80, 0x03, 0x80, 0x06, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x1C, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0x8E, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC7, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xC3, 0x80, 0x3C, 0x00, 0x38, 0x00, 0xE1, 0xC0,
  0x1C, 0x00, 0x3C, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x1E, 0x00, 0x30, 0x70,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x38, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x3C,
  0x01, 0xC0, 0x0F, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x0F, 0xC0, 0x1E, 0x07,
  0x00, 0x78, 0x0E, 0xF0, 0x0E, 0x03, 0x80, 0x1E, 0x0F, 0x38, 0x0E, 0x01,
  0xC0, 0x0F, 0xFF, 0x1E, 0x1E, 0x00, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x70, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00,
  0x70, 0x7C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x7E, 0x03, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFC, 0x78, 0x00,
  0x7F, 0xFF, 0x1E, 0x00, 0x1F, 0xFF, 0xC7, 0x80, 0x07, 0xFF, 0xF1, 0xE0,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x07,
  0xE0, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x7C, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x00, 0x78, 0xF8, 0x00,
  0x00, 0x01, 0xE7, 0xF0, 0x00, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0x00, 0x3D,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x9E, 0x00, 0x00, 0x03, 0xFC, 0x7C, 0x00,
  0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x01, 0xEE, 0x00, 0x00, 0x01, 0xEE, 0x00, 0xF7, 0x80, 0x00, 0x00, 0xF7,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x00, 0x00, 0x7B,
  0xC0, 0x1C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x0E, 0x38, 0x00, 0x00, 0x3C,
  0xF0, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0x70, 0x07, 0x8F, 0x00, 0x00, 0x1E,
  0x78, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x00, 0x0F,
  0x1E, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x87, 0x00, 0x78, 0x38, 0x00, 0x07, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xE0, 0x00,
  0xE0, 0x78, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x38, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x03,
  0x87, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x00, 0x78, 0x00,
  0xE3, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x3D, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0xF0, 0x01, 0xE0, 0x0F, 0x00,
  0x07, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x78, 0x03, 0xC0,
  0x01, 0xF8, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0xFE, 0x00, 0x00, 0x1E,
  0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x01, 0xEF,
  0x00, 0x00, 0x3C, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0x01, 0xE7, 0x80, 0x00,
  0x3C, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x01,
  0xE3, 0xC0, 0x00, 0x38, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x03, 0xC1, 0xC0,
  0x00, 0x78, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0x03, 0x83,
  0xC0, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0x03, 0xC3, 0x80, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x3C, 0x00, 0x00, 0xF7, 0x80,
  0x78, 0x00, 0x00, 0x7F, 0x00, 0x78, 0x00, 0x00, 0x7F, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x00, 0x3F,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x01, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0x80, 0x00, 0x7E, 0x01, 0xE0,
  0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03,
  0xCF, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xC0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x0F,
  0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xDF, 0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x07, 0xC7, 0x80, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x3C, 0x1C, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x9C, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0x8E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC7, 0x00,
  0x07, 0x81, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xE1, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x78,
  0x01, 0xE0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x1E,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x07, 0x80,
  0x38, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x1C, 0x07, 0x80, 0x0F, 0x01, 0xC0,
  0x0E, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0,
  0x03, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x78,
  0x00, 0xF0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x3C,
  0x00, 0x3C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE7,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x7B,
  0x80, 0x00, 0x73, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x38, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3B, 0x80, 0x07, 0xB8, 0x00, 0x73, 0x80, 0x0F, 0x3C, 0x00,
  0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0,
  0x78, 0x1E, 0x07, 0x01, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xE1, 0xE0, 0x0E,
  0x1E, 0x00, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00,
  0x70, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x03,
  0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFE, 0x03, 0xC0, 0xFC, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0x83, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x3F, 0x07, 0x80, 0x07,
  0xF0, 0x7C, 0x00, 0xFF, 0x03, 0xF0, 0x7E, 0xF0, 0x3F, 0xFF, 0xCF, 0x01,
  0xFF, 0xF8, 0xF0, 0x07, 0xFE, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x7F, 0xE0, 0x01, 0xE7, 0xFF, 0xC0,
  0x0E, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x3F,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0x1E,
  0x0F, 0xE0, 0x01, 0xF0, 0x7B, 0x80, 0x1F, 0x03, 0xDF, 0x03, 0xF0, 0x1C,
  0x7F, 0xFF, 0x80, 0xE1, 0xFF, 0xF0, 0x0F, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x70, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x3F, 0xF0, 0x3C, 0x00, 0xFF, 0xF8, 0xF0, 0x07,
  0xFF, 0xF9, 0xE0, 0x1F, 0xC0, 0xF3, 0xC0, 0x3E, 0x00, 0x77, 0x80, 0xF8,
  0x00, 0x6F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0xFE, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0x70, 0x00, 0xFF,
  0xFC, 0xE0, 0x00, 0xFF, 0xE3, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x04, 0x07, 0x80, 0x01, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x1C, 0x00, 0x7F, 0xFC, 0x38, 0x03, 0xFF, 0xFC, 0xF0, 0x0F,
  0xE0, 0x79, 0xE0, 0x1F, 0x00, 0x3B, 0xC0, 0x7C, 0x00, 0x37, 0x80, 0xF0,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x07, 0xC0, 0x1E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0x3F,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xB8, 0x00, 0x7F, 0xFE, 0xF0, 0x00, 0x7F,
  0xF1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x04, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3E,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x7C, 0x00, 0x1E, 0x3F, 0xF0, 0x01, 0xE7, 0xFF, 0x80, 0x1C, 0xFF, 0xFC,
  0x03, 0xDE, 0x07, 0xE0, 0x3F, 0xC0, 0x1E, 0x03, 0xF0, 0x01, 0xE0, 0x3E,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x20, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0x00, 0x0F, 0xC0, 0x3C, 0x00,
  0x7E, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x7C,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x07,
  0x0F, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0xF0,
  0x00, 0x07, 0xF3, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x1E, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x03, 0xE0, 0x00,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x01,
  0xE0, 0x1C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xC3, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xC7, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xDF, 0xFF, 0xC1, 0xFF, 0xFC,
  0x03, 0xDE, 0x07, 0xE3, 0xE0, 0x7C, 0x03, 0xF8, 0x03, 0xE7, 0x80, 0x3E,
  0x03, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x1C, 0x3F,
  0xF0, 0x01, 0xC7, 0xFF, 0x80, 0x3C, 0xFF, 0xFC, 0x03, 0xDE, 0x07, 0xE0,
  0x3F, 0xC0, 0x1E, 0x03, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0,
  0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x1E, 0x3E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x38, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xE1, 0xFF, 0x80, 0x01, 0xCF, 0xFF, 0xC0, 0x07, 0xBF, 0xFF, 0xC0, 0x0F,
  0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1F,
  0x80, 0x01, 0xE0, 0x3F, 0x00, 0x07, 0xC0, 0x7B, 0x80, 0x1F, 0x00, 0xF7,
  0x80, 0xFC, 0x01, 0xE7, 0xFF, 0xF0, 0x03, 0x87, 0xFF, 0xC0, 0x0F, 0x07,
  0xFF, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xFE, 0x07, 0x01, 0xFF, 0xF8, 0x70, 0x3F, 0xFF, 0xCF, 0x07,
  0xF0, 0x3E, 0xF0, 0x7C, 0x00, 0xEF, 0x0F, 0x80, 0x07, 0xE0, 0xF0, 0x00,
  0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0xFE, 0x03,
  0xE0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFB, 0xC0, 0x07, 0xFE,
  0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x1F, 0xC0, 0x73, 0xFE, 0x07,
  0xBF, 0xF0, 0x3F, 0xF0, 0x81, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x3E, 0x00,
  0x1F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0x80, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x3E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0xC0,
  0x3E, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x3C, 0x00, 0xFF,
  0xE3, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x0E,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x01,
  0xE0, 0x07, 0x00, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x70, 0x00, 0x7C, 0x00, 0x1E, 0x70,
  0x00, 0xFC, 0x00, 0x3C, 0x70, 0x00, 0xFC, 0x00, 0x3C, 0x70, 0x01, 0xFC,
  0x00, 0x78, 0x70, 0x01, 0xFE, 0x00, 0x78, 0x78, 0x01, 0xDE, 0x00, 0x78,
  0x78, 0x03, 0xDE, 0x00, 0xF0, 0x78, 0x03, 0x9E, 0x00, 0xF0, 0x78, 0x07,
  0x9E, 0x00, 0xE0, 0x78, 0x07, 0x0E, 0x01, 0xE0, 0x78, 0x0F, 0x0E, 0x01,
  0xE0, 0x78, 0x0F, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x0E, 0x03, 0xC0, 0x78,
  0x1E, 0x0E, 0x03, 0x80, 0x78, 0x1C, 0x0E, 0x07, 0x80, 0x78, 0x3C, 0x0E,
  0x07, 0x80, 0x38, 0x38, 0x0F, 0x0F, 0x00, 0x38, 0x78, 0x0F, 0x0F, 0x00,
  0x38, 0x78, 0x0F, 0x0E, 0x00, 0x38, 0x70, 0x0F, 0x1E, 0x00, 0x38, 0xF0,
  0x07, 0x1C, 0x00, 0x38, 0xE0, 0x07, 0x3C, 0x00, 0x39, 0xE0, 0x07, 0x3C,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x3F, 0xC0, 0x07, 0x78, 0x00, 0x3F,
  0xC0, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x40, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xC3, 0xFF, 0x80, 0x00, 0xE3, 0xFF, 0xE0, 0x00, 0xE3, 0xE0, 0xF8, 0x00,
  0x71, 0xE0, 0x3E, 0x00, 0x39, 0xE0, 0x0F, 0x80, 0x3C, 0xF0, 0x03, 0xE0,
  0x3C, 0x70, 0x00, 0xF8, 0x3E, 0x78, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0x0F,
  0xFE, 0x1C, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 12, 51, 15, 2, -50 },
  { 78, 14, 16, 20, 7, -53 },
  { 106, 36, 50, 35, 2, -50 },
  { 331, 29, 65, 33, 3, -58 },
  { 567, 32, 52, 44, 7, -51 },
  { 775, 32, 52, 37, 2, -51 },
  { 983, 6, 16, 12, 7, -53 },
  { 995, 20, 73, 20, 4, -57 },
  { 1178, 20, 73, 20, -4, -57 },
  { 1361, 27, 29, 29, 4, -50 },
  { 1459, 29, 37, 34, 3, -42 },
  { 1594, 10, 16, 13, -3, -7 },
  { 1614, 14, 4, 18, 2, -24 },
  { 1621, 6, 6, 16, 2, -5 },
  { 1626, 30, 54, 24, -3, -50 },
  { 1829, 28, 52, 33, 4, -51 },
  { 2011, 17, 50, 33, 9, -50 },
  { 2118, 30, 51, 33, 1, -51 },
  { 2310, 29, 52, 33, 2, -51 },
  { 2499, 30, 50, 33, 1, -50 },
  { 2687, 30, 51, 33, 4, -50 },
  { 2879, 26, 51, 33, 4, -50 },
  { 3045, 30, 50, 33, 5, -50 },
  { 3233, 30, 52, 33, 2, -51 },
  { 3428, 26, 51, 33, 5, -51 },
  { 3594, 12, 38, 14, 1, -37 },
  { 3651, 15, 46, 13, -3, -37 },
  { 3738, 26, 30, 31, 3, -38 },
  { 3836, 27, 19, 33, 4, -33 },
  { 3901, 27, 30, 31, 2, -38 },
  { 4003, 22, 52, 28, 6, -51 },
  { 4146, 49, 65, 54, 2, -49 },
  { 4545, 35, 50, 38, -2, -50 },
  { 4764, 33, 50, 37, 2, -50 },
  { 4971, 34, 52, 39, 4, -51 },
  { 5192, 35, 50, 39, 2, -50 },
  { 5411, 35, 50, 34, 2, -50 },
  { 5630, 34, 50, 34, 2, -50 },
  { 5843, 34, 52, 41, 4, -51 },
  { 6064, 40, 50, 42, 2, -50 },
  { 6314, 13, 50, 17, 3, -50 },
  { 6396, 32, 51, 33, 1, -50 },
  { 6600, 38, 50, 38, 2, -50 },
  { 6838, 25, 50, 32, 2, -50 },
  { 6995, 49, 50, 51, 2, -50 },
  { 7302, 40, 50, 42, 2, -50 },
  { 7552, 34, 52, 41, 4, -51 },
  { 7773, 35, 50, 37, 2, -50 },
  { 7992, 34, 60, 41, 4, -51 },
  { 8247, 34, 50, 38, 2, -50 },
  { 8460, 34, 52, 36, 2, -51 },
  { 8681, 32, 50, 36, 7, -50 },
  { 8881, 35, 51, 39, 4, -50 },
  { 9105, 35, 50, 37, 6, -50 },
  { 9324, 49, 50, 53, 7, -50 },
  { 9631, 40, 50, 37, -1, -50 },
  { 9881, 33, 50, 36, 7, -50 },
  { 10088, 37, 50, 36, 0, -50 },
  { 10320, 21, 69, 16, 0, -58 },
  { 10502, 11, 54, 24, 7, -50 },
  { 10577, 20, 69, 16, -4, -58 },
  { 10750, 20, 25, 25, 3, -50 },
  { 10813, 26, 4, 27, -4, 0 },
  { 10826, 9, 10, 20, 9, -54 },
  { 10838, 28, 40, 32, 1, -39 },
  { 10978, 29, 54, 33, 1, -53 },
  { 11174, 27, 40, 31, 2, -39 },
  { 11309, 31, 54, 34, 3, -53 },
  { 11519, 27, 40, 32, 2, -39 },
  { 11654, 22, 54, 21, 4, -54 },
  { 11803, 31, 53, 34, 0, -39 },
  { 12009, 28, 53, 33, 1, -53 },
  { 12195, 13, 52, 15, 2, -52 },
  { 12280, 23, 66, 15, -8, -52 },
  { 12470, 30, 53, 30, 1, -53 },
  { 12669, 13, 53, 15, 2, -53 },
  { 12756, 48, 39, 53, 1, -39 },
  { 12990, 28, 39, 33, 1, -39 },
  { 13127, 28, 40, 34, 3, -39 },
  { 13267, 31, 53, 33, -1, -39 },
  { 13473, 28, 53, 34, 3, -39 },
  { 13659, 21, 39, 21, 1, -39 },
  { 13762, 27, 40, 31, 1, -39 },
  { 13897, 16, 48, 20, 4, -47 },
  { 13993, 28, 39, 33, 3, -38 },
  { 14130, 26, 38, 29, 4, -38 },
  { 14254, 40, 38, 45, 5, -38 },
  { 14444, 31, 38, 30, -1, -38 },
  { 14592, 33, 52, 29, -3, -38 },
  { 14807, 29, 38, 30, 0, -38 },
  { 14945, 22, 70, 21, 2, -56 },
  { 15138, 13, 59, 15, 1, -50 },
  { 15234, 22, 69, 21, -4, -55 },
  { 15424, 33, 13, 41, 4, -28 },
};

const GFXfont RobotoCondensed_LightItalic71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC71PT7B_H_
