#ifndef _ROBOTOCONDENSED_LIGHTITALIC63PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0x80, 0x00, 0x38, 0x73, 0x87, 0x70, 0xE7, 0x0E, 0x70,
  0xE7, 0x0E, 0x70, 0xE6, 0x0E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xC1,
  0x8C, 0x18, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x60, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x1E,
  0x01, 0xE0, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x1E,
  0x00, 0x0F, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x03, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x03, 0x0E, 0x01,
  0xC0, 0x1C, 0xE0, 0x0E, 0x01, 0xC7, 0x00, 0x70, 0x1C, 0x38, 0x03, 0x80,
  0xE1, 0xC0, 0x1C, 0x0E, 0x0E, 0x00, 0xC0, 0xE0, 0x70, 0x06, 0x07, 0x03,
  0x80, 0x70, 0x70, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0x38, 0x38, 0x03, 0x81,
  0xC3, 0x80, 0x1E, 0x3C, 0x38, 0x00, 0x7F, 0xC1, 0xC0, 0x01, 0xFC, 0x1C,
  0x00, 0x01, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x10, 0x00, 0x07, 0x07, 0xF0, 0x00,
  0x70, 0xFF, 0xC0, 0x07, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x38, 0x03, 0x87,
  0x01, 0xC0, 0x38, 0x38, 0x06, 0x01, 0xC1, 0x80, 0x38, 0x1C, 0x1C, 0x01,
  0xC1, 0xC0, 0xE0, 0x0E, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x38, 0x03, 0x8E,
  0x01, 0xC0, 0x18, 0x70, 0x0E, 0x01, 0xC7, 0x00, 0x70, 0x0E, 0x70, 0x03,
  0x80, 0x70, 0x80, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0F,
  0x00, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x01,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x01,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x71, 0xF0,
  0x78, 0x07, 0x1E, 0x07, 0x80, 0xF3, 0xC0, 0x3C, 0x0E, 0x78, 0x01, 0xC0,
  0xE7, 0x80, 0x1E, 0x0E, 0x70, 0x00, 0xE1, 0xCF, 0x00, 0x0F, 0x1C, 0xF0,
  0x00, 0x73, 0xCF, 0x00, 0x07, 0xB8, 0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x03,
  0xF0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x3F, 0x07,
  0x80, 0x07, 0xF0, 0x3E, 0x01, 0xF7, 0x81, 0xFC, 0xFE, 0x38, 0x0F, 0xFF,
  0x83, 0xC0, 0x7F, 0xF0, 0x1C, 0x00, 0xF8, 0x00, 0x00, 0x39, 0xCE, 0x73,
  0xB9, 0xCE, 0x73, 0xB9, 0xCE, 0x70, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x78,
  0x0E, 0x07, 0xBF, 0x07, 0x0F, 0xFF, 0xE7, 0x3F, 0xE3, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x30, 0x01,
  0xC0, 0x08, 0x00, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x1E, 0x0E,
  0x0F, 0x0F, 0x07, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x31, 0xE7,
  0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x0F,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xE1,
  0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCE, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xE0, 0x00,
  0x1C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x9C, 0x00,
  0x03, 0x8E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x73, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x3C,
  0x00, 0x0F, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC1,
  0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x1C, 0x01, 0xF0,
  0x0F, 0x81, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xE1,
  0xFF, 0xCF, 0xF7, 0xBF, 0x8F, 0x78, 0x1C, 0xC0, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x3E,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1C, 0xF0,
  0x00, 0x07, 0x9C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1C,
  0x01, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x03, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x3F, 0x00, 0x03, 0xBF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0x9F, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x40, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x0F,
  0x01, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x1F, 0x80, 0x38, 0xFF, 0xC0, 0xF7, 0xFF, 0xC1, 0xDF,
  0x0F, 0xC3, 0xF8, 0x07, 0xC7, 0xE0, 0x07, 0x9F, 0x80, 0x07, 0x3E, 0x00,
  0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE7,
  0x00, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C,
  0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0x80,
  0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0E,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xC0,
  0xF0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x03, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x0F, 0x07, 0x80,
  0x0E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x39, 0xE0, 0x00,
  0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x78,
  0x00, 0x3E, 0x70, 0x00, 0xF8, 0xF0, 0x03, 0xF1, 0xF0, 0x0E, 0xE1, 0xF8,
  0xFB, 0xC1, 0xFF, 0xE7, 0x01, 0xFF, 0x8E, 0x00, 0xFC, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x08,
  0x00, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0x40, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x08,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x80, 0xFF, 0xFC, 0x1F, 0x03, 0xC1, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0x80,
  0x0E, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0xE0, 0x01, 0x80, 0xE0, 0x03, 0xFF, 0x00, 0x30,
  0x3C, 0x00, 0xFF, 0xF0, 0x07, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0xE0, 0xE0,
  0x0F, 0x00, 0xE0, 0x1C, 0x38, 0x03, 0xC0, 0x1C, 0x03, 0x87, 0x00, 0x70,
  0x07, 0x00, 0x71, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC7, 0x00, 0xE0, 0x03, 0x80, 0x39, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x38, 0x07, 0x80, 0x1C, 0x00, 0xE7, 0x00, 0xE0, 0x03, 0x80, 0x19, 0xC0,
  0x1C, 0x00, 0x70, 0x03, 0x38, 0x03, 0x80, 0x0C, 0x00, 0x67, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x9C, 0x03, 0x80, 0x0E,
  0x00, 0x73, 0x00, 0x70, 0x01, 0xC0, 0x0C, 0xE0, 0x0E, 0x00, 0x70, 0x01,
  0x9C, 0x03, 0x80, 0x0E, 0x00, 0x73, 0x80, 0x70, 0x01, 0xC0, 0x0E, 0x70,
  0x0E, 0x00, 0x78, 0x01, 0x8E, 0x01, 0xC0, 0x0F, 0x00, 0x71, 0xC0, 0x38,
  0x03, 0xE0, 0x0C, 0x38, 0x07, 0x00, 0x7C, 0x03, 0x87, 0x00, 0x70, 0x1B,
  0x80, 0xE0, 0xE0, 0x0E, 0x07, 0x70, 0x1C, 0x1C, 0x01, 0xF3, 0xCF, 0x0F,
  0x01, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x38, 0x03, 0xFC, 0x0F, 0xF0, 0x07,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07,
  0x8E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0xE0, 0x0F,
  0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x0E, 0x00,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xC0, 0x1F,
  0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xC0, 0x03,
  0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0,
  0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xE0, 0x70,
  0x00, 0x3E, 0x03, 0x80, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0x7C, 0x00, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x3C, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0xFF, 0xC7, 0x00, 0x1F, 0xFF, 0x3C, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x38, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0xF8, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x00,
  0xF0, 0x03, 0xE0, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xC1, 0xF0,
  0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x03, 0x9F, 0xC0, 0x00, 0x00, 0xEF, 0xF0, 0x00, 0x00, 0x3F,
  0xDE, 0x00, 0x00, 0x1F, 0xE7, 0x80, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x01,
  0xF8, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xEE, 0x03, 0xBC, 0x00, 0x00,
  0x3F, 0xC0, 0x77, 0x80, 0x00, 0x07, 0x78, 0x0E, 0x70, 0x00, 0x01, 0xEE,
  0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x39, 0xC0, 0x00, 0x0F, 0x38, 0x0F,
  0x38, 0x00, 0x01, 0xCF, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x38, 0xF0,
  0x00, 0x0E, 0x38, 0x07, 0x0E, 0x00, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0xE0, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x07, 0x87, 0x00, 0x03, 0x87,
  0x80, 0xF0, 0xE0, 0x00, 0xF0, 0xF0, 0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x03,
  0x81, 0xC0, 0x07, 0x83, 0x80, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x1E, 0x07,
  0x00, 0x3C, 0x1E, 0x03, 0xC0, 0xE0, 0x07, 0x03, 0xC0, 0x78, 0x1C, 0x01,
  0xE0, 0x78, 0x0E, 0x03, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x00, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x1C, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x83, 0x80, 0x3C, 0x07, 0x00,
  0x78, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE3,
  0x80, 0x1C, 0x07, 0x80, 0x1C, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0x9C, 0x00,
  0xF0, 0x1E, 0x00, 0x77, 0x00, 0x1E, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0x80,
  0x70, 0x00, 0xF8, 0x00, 0x70, 0x0E, 0x00, 0x1F, 0x00, 0x1E, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3E, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00,
  0x1C, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x7E, 0x00, 0x00, 0xF0, 0x1F, 0xE0,
  0x00, 0x1E, 0x03, 0xDC, 0x00, 0x03, 0xC0, 0x7B, 0xC0, 0x00, 0x70, 0x0E,
  0x38, 0x00, 0x0E, 0x01, 0xC7, 0x00, 0x01, 0xC0, 0x38, 0xF0, 0x00, 0x78,
  0x0F, 0x0E, 0x00, 0x0F, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0x3C, 0x3C, 0x00,
  0x38, 0x07, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x3C, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x80, 0x70,
  0x1E, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x78, 0x01, 0xE0,
  0x78, 0x0E, 0x00, 0x1C, 0x0E, 0x01, 0xC0, 0x03, 0x81, 0xC0, 0x38, 0x00,
  0x78, 0x38, 0x0F, 0x00, 0x07, 0x0F, 0x01, 0xE0, 0x00, 0xF1, 0xE0, 0x3C,
  0x00, 0x1E, 0x3C, 0x07, 0x00, 0x01, 0xC7, 0x00, 0xE0, 0x00, 0x3C, 0xE0,
  0x1C, 0x00, 0x03, 0x9C, 0x07, 0x80, 0x00, 0x77, 0x80, 0xF0, 0x00, 0x0F,
  0xF0, 0x1E, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x70, 0x00,
  0x03, 0xF0, 0x0E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x1E, 0x38, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x0E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x3F, 0x80, 0x1C, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E,
  0x03, 0x80, 0x01, 0xF8, 0x07, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x02, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x78, 0x03, 0xF8, 0x01, 0xC0, 0x01, 0xF0, 0x07, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x1F, 0x00, 0xE0,
  0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x1E,
  0x00, 0x03, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x1C, 0x0F, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x3C, 0x0E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x38, 0x1E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x78, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xF0,
  0x00, 0x3C, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0xC0, 0x00,
  0xE3, 0x80, 0x03, 0xB8, 0x00, 0x3C, 0x70, 0x00, 0x77, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x9C, 0x00, 0x3C, 0x38, 0x00,
  0x73, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x8E,
  0x00, 0x3C, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x01,
  0xE0, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x70, 0x07, 0x01,
  0xE0, 0x1C, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x81, 0xC0, 0x38, 0x07, 0x80,
  0xE0, 0x38, 0x07, 0x00, 0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x1E, 0x07, 0x80,
  0xE0, 0x38, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0x78, 0x1C, 0x03, 0x81,
  0xE0, 0x07, 0x07, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0, 0x06, 0x0F, 0x00,
  0x1C, 0x1C, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x03, 0x8F, 0x00, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xCF, 0x00, 0x07, 0x38, 0x00, 0x39,
  0xC0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x01,
  0xDE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xDC, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0,
  0x07, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x38, 0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xCE,
  0x00, 0x71, 0x80, 0x38, 0x70, 0x1E, 0x1C, 0x07, 0x07, 0x03, 0xC1, 0xC0,
  0xE0, 0x70, 0x78, 0x1C, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x39, 0xE0,
  0x0E, 0x70, 0x03, 0xBC, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x0E, 0x0E, 0x07,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0x1E, 0x1F, 0x00, 0x1E,
  0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x3C,
  0x70, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x70, 0x00, 0xF8, 0x78, 0x03, 0xF8, 0x7C, 0x07, 0xF8, 0x3F, 0xFF, 0x78,
  0x1F, 0xFE, 0x78, 0x0F, 0xF8, 0x78, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x7F, 0x80, 0x0E, 0x7F,
  0xF8, 0x03, 0xBF, 0xFF, 0x01, 0xFE, 0x07, 0xC0, 0x7E, 0x00, 0x78, 0x1F,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00,
  0x3C, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x7C, 0x00, 0x1E, 0x1F, 0x00,
  0x0F, 0x07, 0x60, 0x07, 0xC1, 0xDE, 0x03, 0xE0, 0x73, 0xFF, 0xF0, 0x3C,
  0x7F, 0xF8, 0x0E, 0x0F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0x3C,
  0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0x78, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xC3, 0xC0, 0x1F,
  0xFE, 0x3C, 0x03, 0xFF, 0xF3, 0x80, 0x7E, 0x07, 0xB8, 0x07, 0x80, 0x1B,
  0x80, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x1C,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x01, 0xF8,
  0x03, 0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xE7, 0x00, 0x07,
  0xFC, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xC0, 0x3C, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E,
  0x38, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x70, 0x00, 0x0E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x20, 0x3C, 0x00, 0xF0,
  0x3E, 0x01, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x07, 0x00, 0x7F,
  0xF8, 0xF0, 0x0F, 0xFF, 0xCF, 0x01, 0xF8, 0x1E, 0xE0, 0x1E, 0x00, 0x6E,
  0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x70,
  0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00,
  0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xE0,
  0x0F, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x9E, 0x00, 0x1F,
  0xF1, 0xC0, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x20,
  0x00, 0x70, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x1F, 0xE0, 0x07,
  0x3F, 0xFC, 0x03, 0xBF, 0xFE, 0x03, 0xFC, 0x0F, 0x81, 0xFC, 0x03, 0xC0,
  0xF8, 0x00, 0xE0, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x1C,
  0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC3,
  0xC0, 0x00, 0xE0, 0x00, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x8F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x7C, 0x0E, 0x00, 0x3E, 0x03, 0x80,
  0x1F, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x07,
  0x00, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x39, 0xE0,
  0x00, 0x1E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7E,
  0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x38,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x20, 0x00, 0xE1, 0xFE, 0x00, 0xFF, 0x00, 0x39, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1E, 0xFF, 0xF8, 0x7F, 0xFC, 0x07, 0xF8, 0x1F, 0x3C, 0x0F, 0x81, 0xF8,
  0x03, 0xDE, 0x01, 0xE0, 0x7C, 0x00, 0x77, 0x00, 0x3C, 0x1E, 0x00, 0x1F,
  0x80, 0x0F, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x87, 0x00, 0x03, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x8F, 0x00,
  0x03, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x87, 0x00, 0x03,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0xFC, 0x00, 0xE7, 0xFF, 0x80, 0x77, 0xFF, 0xC0, 0x7F, 0x81, 0xF0, 0x3F,
  0x80, 0x78, 0x1F, 0x00, 0x1C, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x38, 0x00,
  0x1E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x80,
  0x03, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x38, 0x78, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x3C, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8,
  0x00, 0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E,
  0x38, 0x00, 0x0F, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x07,
  0x81, 0xE0, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x3F, 0xE0, 0x00, 0xE7, 0xFF, 0x80, 0x0E, 0xFF, 0xFC, 0x01, 0xFE,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xE0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x01, 0xD8, 0x01, 0xF0, 0x1D, 0xC0, 0x3E, 0x01, 0xCF, 0xFF, 0xC0,
  0x3C, 0x7F, 0xF8, 0x03, 0xC3, 0xFE, 0x00, 0x3C, 0x03, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x70,
  0x1F, 0xFE, 0x3C, 0x0F, 0xFF, 0xCE, 0x07, 0xE0, 0x7B, 0x83, 0xE0, 0x06,
  0xE0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x78, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x3F, 0x80, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x70, 0x01, 0xFF, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x80, 0x71, 0xFC, 0x0E, 0x7F, 0x81, 0xDF, 0xE0,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03,
  0xE0, 0x3E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x08, 0x00, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x87,
  0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07,
  0x0F, 0x00, 0x07, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x38, 0x00,
  0x1E, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x80,
  0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x3E, 0x07, 0x80, 0x3F, 0x03,
  0xE0, 0x7F, 0x00, 0xFF, 0xFB, 0x80, 0x7F, 0xF9, 0xC0, 0x0F, 0xF8, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x3C,
  0x38, 0x00, 0x70, 0x70, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x0F, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C,
  0x07, 0x80, 0x38, 0x0E, 0x00, 0x78, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE1,
  0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x3F,
  0x80, 0x07, 0x80, 0x07, 0x70, 0x01, 0xF0, 0x01, 0xEE, 0x00, 0x3E, 0x00,
  0x39, 0xC0, 0x0F, 0xC0, 0x07, 0x38, 0x01, 0xF8, 0x01, 0xE7, 0x00, 0x3F,
  0x00, 0x38, 0xE0, 0x0E, 0xF0, 0x0F, 0x1E, 0x01, 0xCE, 0x01, 0xC3, 0xC0,
  0x79, 0xC0, 0x38, 0x78, 0x0E, 0x38, 0x0F, 0x0F, 0x03, 0xC7, 0x01, 0xC0,
  0xE0, 0x70, 0xE0, 0x78, 0x1C, 0x0E, 0x1C, 0x0E, 0x03, 0x83, 0x83, 0x81,
  0xC0, 0x70, 0x70, 0x70, 0x70, 0x0E, 0x1C, 0x0E, 0x0E, 0x01, 0xC3, 0x81,
  0xC3, 0xC0, 0x38, 0xF0, 0x18, 0x70, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xDE, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x01,
  0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x01,
  0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x78, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x0E,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0,
  0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70, 0x0F,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x80,
  0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0E, 0x00, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0x40, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x71, 0xFF, 0xE0, 0x01, 0x87, 0xDF,
  0xC0, 0x0E, 0x3C, 0x0F, 0x80, 0x38, 0xE0, 0x1E, 0x01, 0xE7, 0x80, 0x3C,
  0x0F, 0x1C, 0x00, 0x7E, 0xF8, 0x70, 0x00, 0xFF, 0xE1, 0xC0, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 11, 46, 13, 2, -45 },
  { 65, 12, 14, 18, 7, -47 },
  { 86, 31, 45, 31, 2, -45 },
  { 261, 26, 59, 30, 2, -52 },
  { 453, 29, 47, 39, 6, -46 },
  { 624, 28, 47, 33, 2, -46 },
  { 789, 5, 14, 10, 6, -47 },
  { 798, 18, 64, 18, 3, -50 },
  { 942, 17, 64, 18, -3, -50 },
  { 1078, 25, 25, 26, 3, -45 },
  { 1157, 25, 33, 30, 3, -37 },
  { 1261, 9, 14, 12, -3, -6 },
  { 1277, 12, 3, 16, 2, -21 },
  { 1282, 6, 6, 15, 1, -5 },
  { 1287, 27, 49, 22, -3, -45 },
  { 1453, 25, 47, 30, 3, -46 },
  { 1600, 15, 45, 30, 8, -45 },
  { 1685, 27, 46, 30, 1, -46 },
  { 1841, 26, 47, 30, 2, -46 },
  { 1994, 27, 45, 30, 1, -45 },
  { 2146, 26, 46, 30, 4, -45 },
  { 2296, 23, 46, 30, 3, -45 },
  { 2429, 26, 45, 30, 5, -45 },
  { 2576, 26, 47, 30, 2, -46 },
  { 2729, 23, 46, 30, 5, -46 },
  { 2862, 10, 34, 13, 1, -33 },
  { 2905, 13, 41, 12, -2, -33 },
  { 2972, 23, 27, 27, 3, -34 },
  { 3050, 24, 15, 30, 3, -28 },
  { 3095, 24, 26, 28, 2, -33 },
  { 3173, 20, 47, 25, 5, -46 },
  { 3291, 43, 58, 48, 2, -44 },
  { 3603, 31, 45, 34, -2, -45 },
  { 3778, 29, 45, 33, 2, -45 },
  { 3942, 30, 47, 35, 4, -46 },
  { 4119, 31, 45, 35, 2, -45 },
  { 4294, 30, 45, 30, 2, -45 },
  { 4463, 30, 45, 30, 2, -45 },
  { 4632, 30, 47, 36, 4, -46 },
  { 4809, 35, 45, 38, 2, -45 },
  { 5006, 11, 45, 15, 3, -45 },
  { 5068, 28, 46, 29, 1, -45 },
  { 5229, 34, 45, 34, 2, -45 },
  { 5421, 22, 45, 28, 2, -45 },
  { 5545, 43, 45, 46, 2, -45 },
  { 5787, 35, 45, 38, 2, -45 },
  { 5984, 31, 47, 36, 3, -46 },
  { 6167, 31, 45, 33, 2, -45 },
  { 6342, 31, 54, 36, 3, -46 },
  { 6552, 30, 45, 34, 2, -45 },
  { 6721, 30, 47, 32, 2, -46 },
  { 6898, 29, 45, 32, 6, -45 },
  { 7062, 32, 46, 35, 3, -45 },
  { 7246, 30, 45, 33, 6, -45 },
  { 7415, 43, 45, 47, 6, -45 },
  { 7657, 36, 45, 33, -1, -45 },
  { 7860, 29, 45, 32, 6, -45 },
  { 8024, 33, 45, 32, 0, -45 },
  { 8210, 18, 61, 14, 0, -51 },
  { 8348, 10, 49, 22, 6, -45 },
  { 8410, 18, 61, 14, -4, -51 },
  { 8548, 18, 22, 23, 3, -45 },
  { 8598, 23, 3, 24, -3, 0 },
  { 8607, 8, 9, 17, 8, -48 },
  { 8616, 24, 35, 29, 1, -34 },
  { 8721, 26, 48, 30, 1, -47 },
  { 8877, 24, 35, 28, 2, -34 },
  { 8982, 28, 48, 30, 2, -47 },
  { 9150, 24, 35, 28, 2, -34 },
  { 9255, 20, 48, 18, 3, -48 },
  { 9375, 28, 47, 30, 0, -34 },
  { 9540, 25, 47, 29, 1, -47 },
  { 9687, 11, 45, 13, 2, -45 },
  { 9749, 20, 58, 13, -7, -45 },
  { 9894, 26, 47, 27, 1, -47 },
  { 10047, 11, 47, 13, 2, -47 },
  { 10112, 42, 34, 47, 1, -34 },
  { 10291, 25, 34, 29, 1, -34 },
  { 10398, 25, 35, 30, 2, -34 },
  { 10508, 28, 47, 30, -1, -34 },
  { 10673, 26, 47, 30, 2, -34 },
  { 10826, 19, 34, 18, 1, -34 },
  { 10907, 24, 35, 27, 1, -34 },
  { 11012, 15, 43, 18, 3, -42 },
  { 11093, 25, 34, 29, 3, -33 },
  { 11200, 23, 33, 26, 4, -33 },
  { 11295, 35, 33, 40, 5, -33 },
  { 11440, 28, 33, 26, -1, -33 },
  { 11556, 30, 46, 26, -3, -33 },
  { 11729, 26, 33, 26, 0, -33 },
  { 11837, 20, 61, 18, 2, -49 },
  { 11990, 12, 53, 14, 1, -45 },
  { 12070, 19, 61, 18, -3, -49 },
  { 12215, 30, 11, 36, 3, -24 },
};

const GFXfont RobotoCondensed_LightItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC63PT7B_H_
