#ifndef _ROBOTOCONDENSED_LIGHTITALIC6PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x60, 0x40, 0x0F, 0x80, 0x55, 0x1E, 0x00, 0xED, 0x4A, 0xF0, 0x00,
  0x1A, 0xA0, 0x7C, 0xE8, 0x09, 0x00, 0x80, 0x00, 0x00, 0x18, 0xF6, 0xE0,
  0xF0, 0x25, 0x40, 0x2C, 0x60, 0x0B, 0x00, 0x48, 0xF0, 0x0A, 0xE0, 0x29,
  0x00, 0xFE, 0xF0, 0xF5, 0x20, 0x00, 0x20, 0x60, 0x78, 0x70, 0xC0, 0x7B,
  0xFF, 0xC0, 0x4B, 0x90, 0xF6, 0xE0, 0xD2, 0x70, 0x36, 0xE0, 0x12, 0x40,
  0x12, 0x40, 0x52, 0x70, 0x09, 0xA8, 0x70, 0x24, 0xE0, 0x2A, 0x50, 0x2A,
  0x15, 0xFD, 0x4D, 0xAA, 0xF6, 0xF0, 0xF6, 0x40, 0xF6, 0xF2, 0xF6, 0x50,
  0xC8, 0xF0, 0x28, 0x16, 0xF0, 0x3A, 0x4E, 0xA0, 0x29, 0x40, 0x68, 0x29,
  0x60, 0x2A, 0x80, 0x60, 0x7C, 0x60, 0x00, 0x00, 0x78, 0x1A, 0xDC, 0xA8,
  0x0E, 0xDC, 0xF8, 0x5A, 0x80, 0xF7, 0x20, 0x2F, 0x80, 0x30, 0x05, 0x00,
  0x13, 0x4C, 0x78, 0xBB, 0x90, 0xF8, 0xF7, 0x00, 0xF7, 0x00, 0xF7, 0x00,
  0xA8, 0x9C, 0x2A, 0x36, 0x00, 0x89, 0x00, 0x96, 0x20, 0x0B, 0x00, 0x89,
  0x00, 0x58, 0x12, 0x80, 0x70, 0x10, 0xA0, 0xE0,
};

const GFXglyph RobotoCondensed_LightItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 2, 2, 1, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 2, 4, 4, 1, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 2, 1, 0, -5 },
  { 12, 2, 6, 2, 0, -5 },
  { 14, 1, 6, 2, 0, -5 },
  { 15, 3, 2, 2, 0, -4 },
  { 16, 3, 4, 3, 0, -4 },
  { 18, 1, 2, 1, 0, -1 },
  { 19, 1, 1, 2, 0, -2 },
  { 20, 1, 1, 1, 0, -1 },
  { 21, 2, 4, 2, 0, -4 },
  { 22, 3, 4, 3, 0, -4 },
  { 24, 1, 4, 3, 1, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 1, 3, 1, 0, -3 },
  { 42, 1, 4, 1, 0, -3 },
  { 43, 2, 2, 3, 0, -3 },
  { 44, 3, 2, 3, 0, -3 },
  { 45, 2, 2, 3, 0, -3 },
  { 46, 1, 4, 2, 1, -4 },
  { 47, 4, 5, 5, 0, -4 },
  { 50, 3, 4, 3, 0, -4 },
  { 52, 3, 4, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 4, 4, 4, 0, -4 },
  { 66, 1, 4, 1, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 2, 4, 3, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 4, 4, 4, 0, -4 },
  { 76, 3, 4, 3, 0, -4 },
  { 78, 3, 4, 3, 0, -4 },
  { 80, 3, 5, 3, 0, -4 },
  { 82, 3, 4, 3, 0, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 2, 4, 3, 1, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 2, 4, 3, 1, -4 },
  { 90, 4, 4, 4, 1, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 2, 4, 3, 1, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 2, 6, 1, 0, -5 },
  { 99, 1, 4, 2, 1, -4 },
  { 100, 1, 6, 1, 0, -5 },
  { 101, 2, 2, 2, 0, -4 },
  { 102, 2, 1, 2, 0, 0 },
  { 103, 1, 1, 2, 1, -5 },
  { 104, 2, 3, 3, 0, -3 },
  { 105, 3, 5, 3, 0, -5 },
  { 107, 2, 3, 3, 0, -3 },
  { 108, 3, 5, 3, 0, -5 },
  { 110, 2, 3, 3, 0, -3 },
  { 111, 2, 5, 2, 0, -5 },
  { 113, 3, 4, 3, 0, -3 },
  { 115, 2, 5, 3, 0, -5 },
  { 117, 1, 4, 1, 0, -4 },
  { 118, 2, 5, 1, -1, -4 },
  { 120, 3, 5, 3, 0, -5 },
  { 122, 1, 5, 1, 0, -5 },
  { 123, 4, 3, 4, 0, -3 },
  { 125, 2, 3, 3, 0, -3 },
  { 126, 3, 3, 3, 0, -3 },
  { 128, 3, 4, 3, 0, -3 },
  { 130, 3, 4, 3, 0, -3 },
  { 132, 2, 3, 2, 0, -3 },
  { 133, 2, 3, 3, 0, -3 },
  { 134, 2, 4, 2, 0, -4 },
  { 135, 3, 3, 3, 0, -3 },
  { 137, 3, 3, 2, 0, -3 },
  { 139, 4, 3, 4, 0, -3 },
  { 141, 3, 3, 3, 0, -3 },
  { 143, 3, 4, 2, 0, -3 },
  { 145, 2, 3, 3, 0, -3 },
  { 146, 2, 6, 2, 0, -5 },
  { 148, 1, 5, 1, 0, -4 },
  { 149, 2, 6, 2, 0, -5 },
  { 151, 3, 1, 3, 0, -2 },
};

const GFXfont RobotoCondensed_LightItalic6pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic6pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC6PT7B_H_
