#ifndef _ROBOTOCONDENSED_LIGHTITALIC65PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x18, 0x00, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87,
  0x70, 0x77, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xCE, 0x1C,
  0xE1, 0xCC, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x18, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x06, 0x00, 0x00,
  0x30, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x70, 0x0C, 0x00, 0x00,
  0x60, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x87,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x06, 0x1C, 0x01, 0x80, 0x1C,
  0x70, 0x06, 0x00, 0xE3, 0x80, 0x18, 0x07, 0x0E, 0x00, 0x60, 0x1C, 0x38,
  0x03, 0x80, 0xE0, 0xE0, 0x0E, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x0E, 0x00,
  0xE0, 0xE0, 0x38, 0x03, 0x87, 0x00, 0x60, 0x1C, 0x1C, 0x01, 0xC0, 0x70,
  0xE0, 0x07, 0x83, 0x87, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0x1F, 0xF0, 0xE0,
  0x00, 0x3F, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0xFC, 0x00,
  0x07, 0x07, 0xF8, 0x00, 0x38, 0x3F, 0xF0, 0x00, 0xE1, 0xC1, 0xE0, 0x07,
  0x0E, 0x03, 0x80, 0x38, 0x38, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x07, 0x07,
  0x00, 0x70, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x70, 0x07, 0x07, 0x01, 0xC0,
  0x1C, 0x38, 0x06, 0x00, 0x71, 0xE0, 0x38, 0x01, 0x87, 0x00, 0x60, 0x0E,
  0x38, 0x01, 0x80, 0x38, 0xE0, 0x07, 0x00, 0xE1, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xC0,
  0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x1C, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x0E, 0x1E, 0x0F, 0x00, 0x71,
  0xE0, 0x3C, 0x07, 0x1F, 0x01, 0xE0, 0x38, 0xF0, 0x07, 0x81, 0xCF, 0x00,
  0x3C, 0x1E, 0x78, 0x00, 0xF0, 0xE3, 0x80, 0x07, 0x87, 0x3C, 0x00, 0x1E,
  0x79, 0xE0, 0x00, 0xF3, 0x8F, 0x00, 0x03, 0xFC, 0x78, 0x00, 0x0F, 0xC3,
  0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1F, 0x03, 0xC0,
  0x01, 0xFC, 0x1F, 0x00, 0x1F, 0xE0, 0x7C, 0x03, 0xE7, 0x81, 0xFF, 0xFE,
  0x3C, 0x07, 0xFF, 0xE0, 0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x3C, 0xE3, 0x8E, 0x38, 0xE7, 0x9C, 0x71, 0xC7, 0x18, 0xE3, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x18, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x60,
  0x1C, 0x03, 0x7C, 0x0E, 0x0F, 0xFF, 0xC7, 0x1F, 0xEF, 0xFB, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x38, 0x01, 0xC0, 0x08, 0x00, 0x40, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07,
  0x87, 0x83, 0x80, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x11, 0xF7, 0xDF,
  0x78, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xF0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x07,
  0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x38, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x70, 0x00,
  0x0F, 0x1C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x8F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x0F,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x3C, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xE7, 0xFB, 0x9F, 0xC7, 0x3C, 0x0E,
  0xE0, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0x80, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x07,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC3, 0xF0, 0x00, 0x3B, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x20, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x3E,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x1F, 0xC0, 0x1C, 0x7F, 0xF0,
  0x1C, 0xFF, 0xF8, 0x3D, 0xF1, 0xFC, 0x3F, 0xC0, 0x3C, 0x3F, 0x00, 0x1E,
  0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1C,
  0x78, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0,
  0x1F, 0x01, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x1E,
  0x01, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x1C, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C,
  0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x07,
  0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0x81,
  0xE0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x70,
  0x00, 0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x70, 0x00, 0x7C, 0xF0, 0x01, 0xF9,
  0xE0, 0x07, 0xF1, 0xE0, 0x1F, 0xE3, 0xF9, 0xFB, 0x83, 0xFF, 0xE7, 0x03,
  0xFF, 0x9E, 0x01, 0xFC, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x78, 0x1F, 0x83, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xC0, 0x00, 0x00, 0x18, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1E, 0x03, 0xC3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0xF0, 0x00,
  0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x60, 0x1C, 0x00, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xF8, 0x00,
  0x70, 0x38, 0x00, 0x7F, 0xE0, 0x07, 0x07, 0x80, 0x0F, 0xFF, 0x00, 0x70,
  0x70, 0x03, 0xE0, 0xF8, 0x03, 0x0F, 0x00, 0x3C, 0x03, 0x80, 0x30, 0xE0,
  0x07, 0x80, 0x38, 0x03, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x31, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x31, 0xC0, 0x1C, 0x00,
  0x70, 0x07, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0x73, 0x80, 0x38, 0x00, 0xE0,
  0x07, 0x38, 0x03, 0x80, 0x0E, 0x00, 0x77, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0x70, 0x07, 0x00, 0x1C, 0x00, 0x77, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x70,
  0x0F, 0x00, 0x1C, 0x00, 0xE7, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x70, 0x0E,
  0x00, 0x1C, 0x00, 0xE6, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0xE0, 0x0E, 0x00,
  0x38, 0x01, 0xCE, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0xE0, 0x0E, 0x00, 0x78,
  0x01, 0x8E, 0x00, 0xE0, 0x07, 0x80, 0x38, 0xE0, 0x0E, 0x00, 0xF0, 0x03,
  0x8E, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0xE0, 0x0E, 0x01, 0xB8, 0x0E, 0x0E,
  0x00, 0xF0, 0x33, 0x80, 0xE0, 0x60, 0x0F, 0xDF, 0x3C, 0x3C, 0x07, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x70, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x78, 0xE0, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x78, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x78, 0x07, 0xFC, 0x01, 0xE0,
  0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xF0, 0x0F, 0x00,
  0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x81, 0xC0, 0x00, 0xFC, 0x07, 0x00, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x1F, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x7C, 0x01, 0xC0,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x70, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF,
  0xF1, 0xC0, 0x07, 0xFF, 0xE3, 0x80, 0x0F, 0xFF, 0xCF, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x1E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x70, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x78, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x03, 0xE0, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x0F, 0x80, 0x00, 0x38, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x1C, 0x1F, 0x00, 0x00, 0x03,
  0x87, 0xC0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x1E, 0x7E, 0x00, 0x00,
  0x03, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0x80,
  0x00, 0x01, 0xFC, 0x78, 0x00, 0x00, 0x7F, 0x0F, 0x00, 0x00, 0x0F, 0xC0,
  0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x01, 0xDC, 0x00, 0x00,
  0x1E, 0xE0, 0x1E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0xF7, 0x00, 0x00, 0x0F,
  0x78, 0x07, 0x38, 0x00, 0x00, 0x7B, 0xC0, 0x39, 0xE0, 0x00, 0x07, 0x9C,
  0x01, 0xCF, 0x00, 0x00, 0x3C, 0xE0, 0x1E, 0x38, 0x00, 0x03, 0xC7, 0x00,
  0xF1, 0xC0, 0x00, 0x1E, 0x78, 0x07, 0x8E, 0x00, 0x01, 0xE3, 0xC0, 0x38,
  0x70, 0x00, 0x0E, 0x1E, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x0E, 0x1E,
  0x00, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x07, 0x83, 0x80,
  0x03, 0x83, 0xC0, 0x3C, 0x1C, 0x00, 0x3C, 0x1E, 0x01, 0xC0, 0xE0, 0x01,
  0xC0, 0xE0, 0x0E, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x70, 0x3C, 0x00, 0xE0,
  0x38, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x00, 0x70, 0x1E,
  0x01, 0xE0, 0x38, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x70, 0x0F, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0x3C,
  0x01, 0xC1, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0xF0, 0x07, 0x80, 0x70, 0x03, 0x87, 0x00, 0x38, 0x03, 0x80, 0x1E,
  0x78, 0x01, 0xC0, 0x3C, 0x00, 0x73, 0x80, 0x1E, 0x01, 0xE0, 0x03, 0xBC,
  0x00, 0xF0, 0x0F, 0x00, 0x1D, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xFE, 0x00,
  0x3C, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x3F, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0x01, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x00, 0x0E, 0x01, 0xFC, 0x00,
  0x00, 0xE0, 0x1D, 0xC0, 0x00, 0x1E, 0x01, 0xDE, 0x00, 0x01, 0xE0, 0x3D,
  0xE0, 0x00, 0x1E, 0x03, 0xCE, 0x00, 0x01, 0xC0, 0x3C, 0xF0, 0x00, 0x1C,
  0x03, 0x87, 0x00, 0x01, 0xC0, 0x38, 0x70, 0x00, 0x3C, 0x07, 0x87, 0x80,
  0x03, 0xC0, 0x78, 0x38, 0x00, 0x3C, 0x07, 0x83, 0xC0, 0x03, 0x80, 0x78,
  0x3C, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x1E, 0x00, 0x78,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x07, 0x80, 0xF0, 0x1E, 0x00, 0x38, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0,
  0x1E, 0x00, 0x3C, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x1C, 0x00, 0x1E,
  0x1E, 0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0x0E, 0x1E, 0x03, 0xC0,
  0x00, 0xF1, 0xC0, 0x3C, 0x00, 0x07, 0x1C, 0x03, 0x80, 0x00, 0x71, 0xC0,
  0x38, 0x00, 0x07, 0xBC, 0x07, 0x80, 0x00, 0x3B, 0xC0, 0x78, 0x00, 0x03,
  0xFC, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x01, 0xF8, 0x07, 0x00,
  0x00, 0x1F, 0x80, 0x70, 0x00, 0x01, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38,
  0x3C, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x80,
  0xF8, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xF0, 0x0F,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C, 0x01,
  0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1C, 0x78,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0x00, 0x7F, 0x80, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x70,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E,
  0x03, 0xC0, 0x01, 0xF8, 0x07, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x38, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x78, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x07, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C,
  0x38, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xF8,
  0x00, 0x0E, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0xF1, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0x8E, 0x00, 0x07, 0x70, 0x00, 0x38, 0x70, 0x00, 0x3B, 0x80, 0x03,
  0xC3, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0xE0,
  0xF0, 0x00, 0xE7, 0x00, 0x0F, 0x07, 0x80, 0x0E, 0x38, 0x00, 0x70, 0x3C,
  0x00, 0x71, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0x0F, 0x00,
  0x38, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xC1, 0xC0, 0x1E, 0x03, 0xC0, 0x1C,
  0x0E, 0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x03,
  0x80, 0x78, 0x07, 0x80, 0x70, 0x1C, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x00, 0x38, 0x1E, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x80,
  0x0E, 0x07, 0x00, 0x70, 0x38, 0x00, 0x70, 0x78, 0x03, 0x83, 0xC0, 0x03,
  0x83, 0x80, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x03, 0x8F, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xF0,
  0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x38, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xB8,
  0x00, 0x07, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1E,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x0E, 0x7C, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x7C, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1F, 0x07, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03,
  0xC0, 0x70, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0x60,
  0x03, 0x9C, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x07,
  0x87, 0x01, 0xC0, 0xE0, 0xF0, 0x38, 0x38, 0x0E, 0x1E, 0x03, 0x87, 0x00,
  0xE3, 0xC0, 0x38, 0xE0, 0x0F, 0x78, 0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x01, 0xF0,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xF8, 0x03, 0xC3, 0xF0, 0x01, 0xC3, 0xE0,
  0x00, 0xE1, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x70,
  0x00, 0x1E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87,
  0x00, 0x07, 0xC3, 0x80, 0x07, 0xE1, 0xE0, 0x07, 0xF0, 0xF8, 0x0F, 0x78,
  0x3F, 0xFF, 0xBC, 0x0F, 0xFF, 0x1E, 0x03, 0xFF, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x1E, 0x3F, 0xE0, 0x03, 0x9F, 0xFF, 0x00, 0x77,
  0xFF, 0xE0, 0x0F, 0xE0, 0x3E, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0xF0, 0x00,
  0x0E, 0x1E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0F, 0x0E,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE1, 0xF0,
  0x00, 0x38, 0x3F, 0x00, 0x0F, 0x07, 0x70, 0x03, 0xC0, 0xEF, 0x00, 0xF8,
  0x1C, 0xFF, 0xFE, 0x07, 0x8F, 0xFF, 0x80, 0xF0, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x0E, 0x3C,
  0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0,
  0xF0, 0x03, 0xC0, 0x7C, 0x03, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x03, 0xC0,
  0x0F, 0xFC, 0x3C, 0x03, 0xFF, 0xE3, 0x80, 0x7F, 0xFF, 0x38, 0x0F, 0xC0,
  0x73, 0x80, 0xF0, 0x03, 0xF8, 0x1E, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0xF8,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x80, 0x78, 0x01, 0xF8, 0x07, 0xC0, 0x7F, 0x00,
  0x3F, 0xFF, 0x70, 0x01, 0xFF, 0xE7, 0x00, 0x0F, 0xFC, 0x70, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xE0, 0x00,
  0x1C, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x80,
  0xF0, 0x01, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xC3, 0xC0, 0x1F, 0xFF, 0x1E, 0x01, 0xFF, 0xFC, 0xE0, 0x1F, 0x80,
  0xF7, 0x00, 0xF0, 0x03, 0xB8, 0x0F, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x3E,
  0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0xFC, 0x01,
  0xF0, 0x1F, 0xC0, 0x07, 0xFF, 0xEE, 0x00, 0x1F, 0xFE, 0x70, 0x00, 0x7F,
  0xE7, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x01,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xF0,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x1F, 0x00, 0x0F, 0x1F, 0xF0, 0x03, 0x9F, 0xFE, 0x00, 0xEF, 0xFF, 0xC0,
  0x3B, 0x80, 0xF8, 0x1F, 0xC0, 0x1E, 0x07, 0xE0, 0x07, 0x81, 0xF0, 0x00,
  0xE0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x0D, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x03, 0x80, 0x07, 0xC0, 0x70,
  0x01, 0xF0, 0x0E, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0xC0,
  0x0F, 0x01, 0xF0, 0x01, 0xC0, 0x7C, 0x00, 0x38, 0x1F, 0x00, 0x0F, 0x07,
  0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x1F, 0x00, 0x00,
  0xE7, 0xC0, 0x00, 0x1D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xDC, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0,
  0x01, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0xF0,
  0x1C, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x70, 0xFF, 0x80, 0x7F, 0xE0,
  0x0E, 0x7F, 0xF8, 0x1F, 0xFE, 0x01, 0xDF, 0xFF, 0x87, 0xFF, 0xE0, 0x7F,
  0x80, 0xF9, 0xE0, 0x3C, 0x0F, 0xC0, 0x0F, 0x70, 0x03, 0xC1, 0xF0, 0x01,
  0xFC, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0x7C, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x87, 0x80, 0x01, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE1, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0xE1, 0xFF, 0x00, 0x39, 0xFF, 0xE0, 0x0E, 0xFF, 0xFC, 0x03,
  0xB8, 0x0F, 0x81, 0xFC, 0x01, 0xE0, 0x7E, 0x00, 0x78, 0x1F, 0x00, 0x0E,
  0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x38,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07,
  0x9C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x0F, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x07, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x3F, 0xF0, 0x00, 0xE7, 0xFF, 0xC0,
  0x0E, 0xFF, 0xFC, 0x00, 0xFE, 0x03, 0xE0, 0x1F, 0x80, 0x1E, 0x01, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x3C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00,
  0x70, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x78, 0x1F, 0x80,
  0x0F, 0x01, 0xDE, 0x03, 0xF0, 0x1C, 0xFF, 0xFE, 0x03, 0xC7, 0xFF, 0xC0,
  0x3C, 0x3F, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x3C, 0x07, 0xFF, 0xC7, 0x81,
  0xFF, 0xFC, 0xE0, 0x7E, 0x03, 0xDC, 0x0F, 0x00, 0x1B, 0x83, 0xC0, 0x03,
  0xF0, 0x78, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0xF0,
  0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x70, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x3F, 0x01, 0xF0, 0x0F,
  0xC0, 0x1F, 0xFF, 0xB8, 0x01, 0xFF, 0xE7, 0x00, 0x1F, 0xF9, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x79, 0xFC,
  0x0E, 0x7F, 0x81, 0xDF, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3E, 0x03, 0xE0, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07,
  0x80, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00,
  0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0x70, 0x01, 0xF8, 0x1E, 0x00, 0xFC,
  0x07, 0xC0, 0x7F, 0x00, 0xFF, 0xFD, 0xC0, 0x3F, 0xFE, 0xF0, 0x03, 0xFE,
  0x3C, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x78, 0x70,
  0x00, 0x78, 0x70, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x38,
  0x01, 0xE0, 0x38, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x3C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1C,
  0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C,
  0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x80, 0x07, 0xB8, 0x00, 0x7C, 0x00,
  0x3D, 0xC0, 0x03, 0xE0, 0x03, 0xCF, 0x00, 0x1F, 0x00, 0x1E, 0x78, 0x01,
  0xF8, 0x00, 0xE3, 0xC0, 0x0F, 0xC0, 0x0F, 0x1E, 0x00, 0xFE, 0x00, 0x70,
  0xF0, 0x07, 0x70, 0x07, 0x87, 0x80, 0x7B, 0x80, 0x3C, 0x3C, 0x03, 0x9C,
  0x01, 0xC0, 0xE0, 0x1C, 0xF0, 0x1E, 0x07, 0x01, 0xC3, 0x80, 0xE0, 0x38,
  0x0E, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0xE0, 0x78, 0x0E, 0x07, 0x07, 0x03,
  0x80, 0x70, 0x78, 0x38, 0x3C, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0x1C, 0x1C,
  0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x70, 0xF0, 0x07, 0x0E, 0x03, 0x87, 0x00,
  0x38, 0xE0, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x0F, 0x78, 0x03,
  0x9C, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x03, 0xFC, 0x00, 0xEE, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xE0,
  0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x1F, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x38, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0xF8, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00,
  0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x02, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x20, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x71, 0xFF, 0xC0, 0x01,
  0xCF, 0xFF, 0x80, 0x0E, 0x38, 0x1F, 0x00, 0x39, 0xE0, 0x3E, 0x00, 0xE7,
  0x00, 0x78, 0x07, 0x3C, 0x00, 0xF0, 0x3C, 0xE0, 0x01, 0xFF, 0xE3, 0x80,
  0x03, 0xFF, 0x0E, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
};

const GFXglyph RobotoCondensed_LightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 47, 14, 2, -46 },
  { 66, 12, 14, 18, 7, -49 },
  { 87, 32, 46, 32, 2, -46 },
  { 271, 27, 60, 31, 2, -53 },
  { 474, 30, 48, 40, 6, -47 },
  { 654, 29, 48, 34, 2, -47 },
  { 828, 6, 14, 11, 6, -49 },
  { 839, 19, 67, 18, 3, -52 },
  { 999, 18, 67, 19, -3, -52 },
  { 1150, 25, 26, 27, 4, -46 },
  { 1232, 26, 34, 31, 3, -39 },
  { 1343, 9, 15, 12, -3, -6 },
  { 1360, 13, 3, 16, 2, -22 },
  { 1365, 6, 6, 15, 1, -5 },
  { 1370, 28, 50, 22, -3, -46 },
  { 1545, 26, 48, 31, 3, -47 },
  { 1701, 15, 46, 31, 8, -46 },
  { 1788, 28, 47, 31, 1, -47 },
  { 1953, 27, 48, 31, 2, -47 },
  { 2115, 27, 46, 31, 1, -46 },
  { 2271, 27, 47, 31, 4, -46 },
  { 2430, 24, 47, 31, 3, -46 },
  { 2571, 27, 46, 31, 5, -46 },
  { 2727, 27, 48, 31, 2, -47 },
  { 2889, 23, 47, 31, 5, -47 },
  { 3025, 11, 35, 13, 1, -34 },
  { 3074, 14, 43, 12, -3, -34 },
  { 3150, 24, 28, 28, 3, -35 },
  { 3234, 25, 15, 30, 3, -29 },
  { 3281, 24, 27, 29, 2, -34 },
  { 3362, 20, 48, 25, 6, -47 },
  { 3482, 44, 59, 49, 2, -45 },
  { 3807, 32, 46, 35, -2, -46 },
  { 3991, 30, 46, 34, 2, -46 },
  { 4164, 31, 48, 36, 4, -47 },
  { 4350, 32, 46, 36, 2, -46 },
  { 4534, 31, 46, 31, 2, -46 },
  { 4713, 31, 46, 31, 2, -46 },
  { 4892, 31, 48, 37, 4, -47 },
  { 5078, 36, 46, 39, 2, -46 },
  { 5285, 11, 46, 15, 3, -46 },
  { 5349, 29, 47, 30, 1, -46 },
  { 5520, 35, 46, 35, 2, -46 },
  { 5722, 23, 46, 29, 2, -46 },
  { 5855, 45, 46, 47, 2, -46 },
  { 6114, 36, 46, 39, 2, -46 },
  { 6321, 31, 48, 37, 4, -47 },
  { 6507, 32, 46, 34, 2, -46 },
  { 6691, 32, 55, 37, 3, -47 },
  { 6911, 31, 46, 35, 2, -46 },
  { 7090, 31, 48, 33, 2, -47 },
  { 7276, 30, 46, 33, 6, -46 },
  { 7449, 33, 47, 36, 3, -46 },
  { 7643, 31, 46, 34, 6, -46 },
  { 7822, 45, 46, 49, 6, -46 },
  { 8081, 37, 46, 34, -1, -46 },
  { 8294, 31, 46, 33, 6, -46 },
  { 8473, 34, 46, 33, 0, -46 },
  { 8669, 19, 63, 14, 0, -53 },
  { 8819, 10, 50, 22, 7, -46 },
  { 8882, 19, 63, 14, -4, -53 },
  { 9032, 18, 23, 23, 3, -46 },
  { 9084, 23, 3, 24, -3, 0 },
  { 9093, 9, 9, 18, 8, -49 },
  { 9104, 25, 36, 30, 1, -35 },
  { 9217, 27, 50, 31, 1, -49 },
  { 9386, 25, 36, 29, 2, -35 },
  { 9499, 28, 50, 31, 3, -49 },
  { 9674, 25, 36, 29, 2, -35 },
  { 9787, 21, 50, 19, 3, -50 },
  { 9919, 29, 48, 31, 0, -35 },
  { 10093, 26, 49, 30, 1, -49 },
  { 10253, 11, 46, 13, 2, -46 },
  { 10317, 20, 59, 13, -7, -46 },
  { 10465, 27, 49, 27, 1, -49 },
  { 10631, 12, 49, 13, 2, -49 },
  { 10705, 43, 35, 48, 1, -35 },
  { 10894, 26, 35, 30, 1, -35 },
  { 11008, 26, 36, 31, 2, -35 },
  { 11125, 28, 48, 31, -1, -35 },
  { 11293, 27, 48, 31, 2, -35 },
  { 11455, 19, 35, 19, 1, -35 },
  { 11539, 25, 36, 28, 1, -35 },
  { 11652, 15, 44, 18, 3, -43 },
  { 11735, 26, 35, 30, 3, -34 },
  { 11849, 24, 34, 27, 4, -34 },
  { 11951, 37, 34, 41, 5, -34 },
  { 12109, 28, 34, 27, -1, -34 },
  { 12228, 31, 47, 26, -3, -34 },
  { 12411, 27, 34, 27, 0, -34 },
  { 12526, 20, 64, 19, 2, -51 },
  { 12686, 12, 55, 14, 1, -46 },
  { 12769, 21, 64, 19, -4, -51 },
  { 12937, 30, 12, 37, 4, -25 },
};

const GFXfont RobotoCondensed_LightItalic65pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic65pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic65pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC65PT7B_H_
