#ifndef _ROBOTOCONDENSED_LIGHTITALIC58PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x38,
  0x67, 0x1C, 0xE3, 0x98, 0x77, 0x0E, 0xE1, 0x9C, 0x33, 0x8E, 0x61, 0xCC,
  0x3B, 0x86, 0x70, 0xCC, 0x18, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0C, 0x07,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x30, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x01, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x18,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x0C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x70,
  0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0x18, 0x0E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x1E, 0x03, 0xC0,
  0x0E, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0x70, 0x00,
  0x78, 0x70, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x3C, 0x03,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x38, 0x02,
  0x1C, 0x07, 0x00, 0x63, 0x80, 0x60, 0x1C, 0x60, 0x0C, 0x07, 0x0C, 0x01,
  0x80, 0xC1, 0x80, 0x70, 0x38, 0x70, 0x0E, 0x0E, 0x06, 0x01, 0xC1, 0x80,
  0xC0, 0x30, 0x70, 0x18, 0x0E, 0x1C, 0x03, 0x81, 0xC7, 0x00, 0x38, 0x70,
  0xE0, 0x07, 0xFC, 0x38, 0x00, 0x7F, 0x0E, 0x00, 0x01, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x3F, 0x00, 0x06, 0x1F, 0xF0, 0x01, 0xC3, 0x87, 0x00,
  0x70, 0xE0, 0x60, 0x1C, 0x38, 0x0E, 0x03, 0x87, 0x01, 0xC0, 0xE0, 0xC0,
  0x38, 0x38, 0x18, 0x07, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0xE0, 0x1C, 0x70,
  0x1C, 0x03, 0x8E, 0x03, 0x80, 0x63, 0x80, 0x70, 0x0C, 0x60, 0x06, 0x03,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70,
  0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0x70, 0x07,
  0x1E, 0x1E, 0x01, 0x87, 0x03, 0x80, 0xE3, 0xC0, 0xF0, 0x39, 0xE0, 0x1E,
  0x0E, 0x70, 0x03, 0x87, 0x3C, 0x00, 0xF1, 0xCF, 0x00, 0x1C, 0x73, 0x80,
  0x07, 0xB8, 0xE0, 0x00, 0xEE, 0x38, 0x00, 0x3F, 0x0E, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x3F, 0x07, 0xC0, 0x3D,
  0xC0, 0xFE, 0x7E, 0x38, 0x1F, 0xFF, 0x0F, 0x01, 0xFF, 0x01, 0xC0, 0x04,
  0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xCE, 0x73, 0x98, 0xCE, 0x00, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x30, 0x0C, 0x06, 0x7C, 0x38, 0x3D, 0xFE, 0x73, 0xFC,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xEE, 0x00, 0x07, 0x8E, 0x00, 0x1E, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x04, 0x00,
  0x40, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0E, 0x0E, 0x0E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0xE0, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7B, 0xFE, 0xF2, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0,
  0x0F, 0xCF, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xC0, 0x07, 0x07,
  0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x0F, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x73, 0x80, 0x00,
  0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1C,
  0xF0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x80, 0x0E, 0x07, 0x00,
  0x3C, 0x0E, 0x00, 0x70, 0x1E, 0x03, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x1F,
  0x81, 0xFE, 0x3F, 0xF9, 0xFC, 0xE7, 0x83, 0x98, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x01, 0xE0, 0x0E,
  0x00, 0x78, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFD, 0xF8, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x78, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0x9F, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xEE, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xDE, 0x00, 0x03, 0x9C, 0x00, 0x07,
  0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x38, 0x00,
  0xE0, 0x78, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x7E, 0x00, 0x0E, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0xC0, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x71, 0xFC, 0x07, 0x3F,
  0xF0, 0x3B, 0xFF, 0xC1, 0xFC, 0x0F, 0x0F, 0xC0, 0x3C, 0xF8, 0x00, 0xE7,
  0xC0, 0x07, 0x3C, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xF0, 0x00, 0x73, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xF0, 0x03, 0xC3, 0x80, 0x3C, 0x1E, 0x03, 0xC0, 0x7E,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFC,
  0xFC, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x07, 0x00,
  0x1E, 0x07, 0x00, 0x1C, 0x07, 0x80, 0x38, 0x03, 0xC0, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x83, 0xE0, 0x1E, 0x00,
  0xF0, 0x3C, 0x00, 0x70, 0x38, 0x00, 0x78, 0x78, 0x00, 0x38, 0x70, 0x00,
  0x38, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0x9F,
  0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0xF8, 0x1F, 0x07,
  0x00, 0x78, 0x78, 0x01, 0xC3, 0x80, 0x0F, 0x38, 0x00, 0x39, 0xC0, 0x01,
  0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1E,
  0xE0, 0x00, 0xF7, 0x00, 0x0F, 0xB8, 0x00, 0x79, 0xE0, 0x07, 0xC7, 0x80,
  0x7E, 0x3E, 0x0F, 0x70, 0xFF, 0xF7, 0x83, 0xFF, 0x38, 0x07, 0xE1, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0x0F, 0x87, 0x80, 0x00,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x10, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3E, 0x07, 0x8F, 0x00, 0xE7, 0x80, 0x39, 0xC0, 0x0F, 0x70, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x18, 0x07, 0x00, 0x00, 0x00, 0x30, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x38, 0x00, 0xFC, 0x00, 0xE0, 0xE0, 0x07, 0xFC, 0x00,
  0xC1, 0xC0, 0x1F, 0xFE, 0x01, 0x87, 0x00, 0x78, 0x1C, 0x03, 0x0E, 0x01,
  0xE0, 0x38, 0x06, 0x38, 0x03, 0x80, 0x70, 0x0C, 0x70, 0x0E, 0x00, 0xE0,
  0x18, 0xC0, 0x38, 0x01, 0x80, 0x33, 0x80, 0x70, 0x07, 0x00, 0x67, 0x00,
  0xC0, 0x0E, 0x00, 0xCC, 0x03, 0x80, 0x1C, 0x01, 0xB8, 0x07, 0x00, 0x30,
  0x07, 0x70, 0x0C, 0x00, 0xE0, 0x0E, 0xE0, 0x38, 0x01, 0xC0, 0x1D, 0x80,
  0x70, 0x03, 0x80, 0x33, 0x00, 0xE0, 0x06, 0x00, 0x6E, 0x01, 0x80, 0x1C,
  0x00, 0xDC, 0x07, 0x00, 0x38, 0x03, 0xB8, 0x0E, 0x00, 0x70, 0x06, 0x70,
  0x1C, 0x00, 0xC0, 0x0C, 0xE0, 0x38, 0x03, 0x80, 0x39, 0xC0, 0x70, 0x07,
  0x00, 0x63, 0x80, 0xE0, 0x1E, 0x01, 0xC7, 0x01, 0xC0, 0x6C, 0x03, 0x0E,
  0x01, 0xC1, 0xDC, 0x0E, 0x1C, 0x03, 0xC7, 0x38, 0x78, 0x38, 0x07, 0xFC,
  0x3F, 0xE0, 0x70, 0x07, 0xF0, 0x7F, 0x80, 0x60, 0x01, 0x00, 0x10, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x38, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x70, 0x0C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x38, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0x00, 0x7E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x1F, 0x03,
  0x80, 0x1F, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x07, 0x00, 0x1F, 0x01, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x3C,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0xF0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00,
  0x3C, 0x01, 0xF8, 0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x03, 0x80,
  0x01, 0xC0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x1E, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x07, 0xC0, 0x70, 0x00, 0xF8, 0x0F, 0x00,
  0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xE7, 0x80, 0x3F, 0xFC, 0xE0, 0x07,
  0xFF, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x79, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x38, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x38,
  0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x3F,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07,
  0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x0E, 0x01, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF8, 0x07, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x00, 0x39,
  0xF0, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFD,
  0xC0, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xF0,
  0x01, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xC0,
  0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x07, 0x38, 0x00, 0x03,
  0xDC, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x07, 0x38, 0x00, 0x07, 0x9C, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x07, 0x38, 0x00, 0x0F, 0x38, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x0E, 0x1C, 0x00, 0x1E, 0x38, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x0E, 0x1C, 0x00, 0x3C, 0x78, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x0E, 0x1C,
  0x00, 0x78, 0x70, 0x1E, 0x1C, 0x00, 0x70, 0x70, 0x1C, 0x0E, 0x00, 0xE0,
  0x70, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C,
  0x0E, 0x01, 0xC0, 0xE0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x78, 0x07,
  0x1C, 0x01, 0xC0, 0x70, 0x07, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0xB8, 0x03,
  0xC0, 0x70, 0x03, 0xB8, 0x03, 0xC0, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x70,
  0x03, 0xF0, 0x03, 0x80, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xE0,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x07,
  0x03, 0xE0, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0x0E, 0x03, 0xF0, 0x00, 0x0E,
  0x03, 0xF0, 0x00, 0x0E, 0x03, 0xB8, 0x00, 0x0E, 0x07, 0xB8, 0x00, 0x1E,
  0x07, 0xBC, 0x00, 0x1E, 0x07, 0x1C, 0x00, 0x1C, 0x07, 0x1C, 0x00, 0x1C,
  0x07, 0x1E, 0x00, 0x1C, 0x07, 0x0E, 0x00, 0x1C, 0x0F, 0x0E, 0x00, 0x3C,
  0x0E, 0x07, 0x00, 0x38, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x07, 0x00, 0x38,
  0x0E, 0x03, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x38, 0x1E, 0x03, 0xC0, 0x78,
  0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0xE0, 0x70,
  0x1C, 0x00, 0xE0, 0x70, 0x3C, 0x00, 0xE0, 0x70, 0x3C, 0x00, 0x70, 0xF0,
  0x38, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x70, 0xE0, 0x38, 0x00, 0x38, 0xE0,
  0x38, 0x00, 0x38, 0xE0, 0x78, 0x00, 0x3D, 0xE0, 0x78, 0x00, 0x1D, 0xE0,
  0x70, 0x00, 0x1D, 0xC0, 0x70, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0x0F, 0xC0,
  0x70, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x3C, 0x00, 0x7C, 0x03, 0x80, 0x03, 0xE0, 0x38, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x78,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0xC0, 0xE0, 0x00,
  0xF8, 0x1E, 0x00, 0x3F, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x01, 0xCF, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x1C,
  0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x31, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x80, 0x03,
  0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x00, 0x70,
  0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0x70,
  0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0,
  0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x38, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x3C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x1C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x1F,
  0x00, 0x78, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x03, 0xC7,
  0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0,
  0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x03, 0xC0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x38,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0xE0, 0x00, 0xFC, 0x00, 0x38, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0xE0, 0x01,
  0xDC, 0x00, 0x70, 0xE0, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x03, 0x9C, 0x00,
  0xF0, 0xE0, 0x03, 0x9C, 0x00, 0xE0, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0xF0,
  0x07, 0x1C, 0x01, 0xE0, 0xF0, 0x0E, 0x1C, 0x01, 0xC0, 0x70, 0x0E, 0x0C,
  0x01, 0xC0, 0x70, 0x0E, 0x0C, 0x03, 0xC0, 0x70, 0x1C, 0x0C, 0x03, 0x80,
  0x70, 0x1C, 0x0C, 0x03, 0x80, 0x70, 0x38, 0x0E, 0x07, 0x00, 0x70, 0x38,
  0x0E, 0x07, 0x00, 0x70, 0x38, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x0E,
  0x00, 0x70, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x0E, 0x1E, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x0E,
  0x3C, 0x00, 0x71, 0xC0, 0x06, 0x38, 0x00, 0x71, 0x80, 0x06, 0x38, 0x00,
  0x73, 0x80, 0x06, 0x70, 0x00, 0x73, 0x80, 0x06, 0x70, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x00, 0x36, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0x80,
  0x07, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0xC0,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x0E, 0x78,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xE0, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x07, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03,
  0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xD8, 0x01, 0xDC, 0x01, 0x9C, 0x03, 0x9C, 0x03, 0x1C, 0x07, 0x0C, 0x07,
  0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38,
  0x06, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFE, 0xFE, 0x03, 0xC0,
  0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x78, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7E, 0x00,
  0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xC7,
  0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0x8F, 0x00,
  0x1E, 0x1C, 0x00, 0xF8, 0x78, 0x0F, 0xE0, 0xFF, 0xFB, 0x83, 0xFF, 0xCE,
  0x03, 0xFC, 0x38, 0x01, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x1F, 0xF0,
  0x07, 0x3F, 0xF8, 0x07, 0x7F, 0xFC, 0x07, 0xE0, 0x3C, 0x07, 0xC0, 0x1E,
  0x0F, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x38,
  0x78, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0x76, 0x01, 0xE0, 0x77, 0xFF, 0xE0,
  0xE3, 0xFF, 0xC0, 0xE0, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x04, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFC, 0xFC, 0x07, 0x80, 0x78, 0x3C,
  0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xDC, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x07,
  0x38, 0x00, 0x3C, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1E,
  0x00, 0xF0, 0x3C, 0x07, 0x80, 0xFE, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x3F,
  0xC3, 0xC0, 0x3F, 0xFC, 0xE0, 0x1F, 0xFF, 0x38, 0x0F, 0x80, 0xEE, 0x03,
  0xC0, 0x1F, 0x81, 0xE0, 0x03, 0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xC0, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x01, 0xE0,
  0x0F, 0x80, 0x3C, 0x07, 0xE0, 0x0F, 0xEF, 0xB8, 0x01, 0xFF, 0xCE, 0x00,
  0x3F, 0xE3, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFC, 0xFC, 0x07, 0x80, 0xF0, 0x3C, 0x01, 0xE1,
  0xE0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xF7, 0x80,
  0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x30,
  0x3C, 0x03, 0xC0, 0xFF, 0x7F, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x70, 0x0F, 0xFF, 0x38, 0x07, 0xFF, 0xCE, 0x03, 0xE0, 0x3B,
  0x80, 0xF0, 0x07, 0xE0, 0x78, 0x00, 0xF8, 0x1C, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00,
  0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x07, 0x80,
  0x78, 0x03, 0xE0, 0x0F, 0x01, 0xF8, 0x03, 0xFF, 0xEE, 0x00, 0x7F, 0xF3,
  0x80, 0x0F, 0xF9, 0xE0, 0x00, 0x20, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x06,
  0x00, 0x1C, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE1, 0xFE, 0x01,
  0xCF, 0xFE, 0x03, 0xBE, 0xFC, 0x07, 0xE0, 0x3C, 0x0F, 0x80, 0x38, 0x3E,
  0x00, 0x70, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80,
  0x07, 0x87, 0x00, 0x0F, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x8F, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x87, 0x00,
  0x07, 0x00, 0x00, 0x40, 0x3C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x1E, 0x07, 0x00,
  0x3C, 0x07, 0x00, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x0E, 0x03,
  0xC0, 0x0E, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x1D, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x38, 0x00, 0x3E, 0x38, 0x00, 0x3C, 0x3C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0F,
  0x00, 0x78, 0x07, 0x00, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03,
  0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0E, 0x3F, 0xE0, 0x3F, 0xC0,
  0x1C, 0xFF, 0xE0, 0xFF, 0xE0, 0x3B, 0xEF, 0xC3, 0xEF, 0xC0, 0x7E, 0x03,
  0xCE, 0x03, 0xC0, 0xF8, 0x03, 0xB8, 0x03, 0x83, 0xE0, 0x07, 0xE0, 0x07,
  0x07, 0x80, 0x0F, 0x80, 0x0E, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0x00,
  0xE1, 0xE0, 0x01, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x78, 0x00, 0x78, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xC0,
  0x01, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x80, 0x03, 0x87, 0x00, 0x07, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x70,
  0x00, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x80, 0x03, 0x87, 0x00, 0x07, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x1F, 0xE0, 0x1C, 0xFF, 0xE0, 0x3B,
  0xEF, 0xC0, 0x7E, 0x03, 0xC0, 0xF8, 0x03, 0x83, 0xE0, 0x07, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70, 0x00,
  0xF1, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x78,
  0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0x9F, 0x80, 0x78, 0x07,
  0x81, 0xE0, 0x07, 0x03, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C,
  0x70, 0x00, 0x3C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0xB8, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xE0, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x03, 0xF3, 0xF0,
  0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x71, 0xFF, 0x00, 0x1C, 0xFF, 0xE0, 0x07, 0x7D, 0xFC, 0x01, 0xF8,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E,
  0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x01,
  0xC0, 0x7C, 0x00, 0xF0, 0x1F, 0x80, 0x78, 0x07, 0x7C, 0xFC, 0x03, 0xCF,
  0xFE, 0x00, 0xE1, 0xFF, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x07, 0x03, 0xFF, 0xCE, 0x07, 0xF7, 0xEE, 0x0F, 0x80, 0xEE, 0x0F,
  0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70,
  0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0x70,
  0x00, 0xF0, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x07, 0xE0, 0x3F,
  0xBE, 0xE0, 0x1F, 0xFD, 0xE0, 0x0F, 0xF9, 0xC0, 0x00, 0x81, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x8F,
  0xC1, 0xCF, 0xE0, 0xEF, 0xF0, 0x7F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFE, 0xFC, 0x07, 0xC0, 0x78, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0xF0, 0x00,
  0xE3, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1E, 0x00, 0x70, 0x7C, 0x07, 0xC0,
  0xFE, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xFE, 0x03, 0xF0, 0x0F,
  0x80, 0x10, 0x00, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7,
  0x00, 0x07, 0x1C, 0x00, 0x1C, 0xF0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x9E, 0x00, 0x1C,
  0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70,
  0x00, 0xF3, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x1E, 0x03, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xEE, 0x01, 0xFE, 0x38, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xE1, 0xC0,
  0x0F, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x01, 0xC0,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x0F, 0x00, 0xE0, 0x70, 0x07, 0x03,
  0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x01,
  0x8E, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xE0,
  0x03, 0xF8, 0x00, 0xF0, 0x01, 0xCE, 0x00, 0x78, 0x01, 0xE7, 0x00, 0x7C,
  0x00, 0xE3, 0x80, 0x3E, 0x00, 0x71, 0xC0, 0x3B, 0x00, 0x70, 0xE0, 0x1D,
  0xC0, 0x38, 0x70, 0x0E, 0xE0, 0x3C, 0x38, 0x0E, 0x70, 0x1C, 0x1C, 0x07,
  0x38, 0x0E, 0x0E, 0x07, 0x1C, 0x0E, 0x07, 0x03, 0x8E, 0x07, 0x03, 0x83,
  0x87, 0x03, 0x81, 0xC1, 0xC3, 0x83, 0x80, 0xE0, 0xE1, 0xC1, 0xC0, 0x70,
  0xE0, 0x61, 0xC0, 0x38, 0x70, 0x30, 0xE0, 0x1C, 0x70, 0x18, 0x70, 0x06,
  0x38, 0x0E, 0x70, 0x03, 0x18, 0x07, 0x38, 0x01, 0xDC, 0x03, 0xB8, 0x00,
  0xEE, 0x01, 0xDC, 0x00, 0x7E, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0x38,
  0x03, 0xC0, 0x1C, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0x81, 0xE0, 0x01,
  0xC1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1C, 0xF0, 0x00,
  0x07, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x1E, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x07, 0x80, 0x1C, 0x03, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0x83, 0xC0,
  0x01, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0F,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x0C, 0x7F, 0xE0, 0x03, 0x9E, 0x1E,
  0x00, 0x77, 0x81, 0xE0, 0x1C, 0xE0, 0x1E, 0x03, 0x9C, 0x01, 0xF1, 0xE7,
  0x00, 0x1F, 0xFC, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_LightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 42, 12, 1, -41 },
  { 59, 11, 13, 16, 6, -44 },
  { 77, 29, 41, 29, 2, -41 },
  { 226, 24, 54, 27, 2, -48 },
  { 388, 27, 43, 36, 5, -42 },
  { 534, 26, 43, 30, 2, -42 },
  { 674, 5, 13, 10, 5, -44 },
  { 683, 16, 59, 16, 3, -46 },
  { 801, 16, 59, 17, -3, -46 },
  { 919, 23, 23, 24, 3, -41 },
  { 986, 24, 30, 28, 2, -34 },
  { 1076, 8, 13, 11, -2, -5 },
  { 1089, 11, 3, 15, 2, -20 },
  { 1094, 5, 5, 13, 1, -4 },
  { 1098, 25, 45, 20, -3, -41 },
  { 1239, 23, 43, 27, 3, -42 },
  { 1363, 14, 41, 27, 7, -41 },
  { 1435, 25, 42, 27, 1, -42 },
  { 1567, 24, 43, 27, 2, -42 },
  { 1696, 24, 41, 27, 1, -41 },
  { 1819, 25, 42, 27, 3, -41 },
  { 1951, 21, 42, 27, 3, -41 },
  { 2062, 24, 41, 27, 4, -41 },
  { 2185, 24, 43, 27, 2, -42 },
  { 2314, 21, 42, 27, 4, -42 },
  { 2425, 9, 31, 12, 1, -30 },
  { 2460, 12, 38, 11, -2, -30 },
  { 2517, 22, 24, 25, 2, -31 },
  { 2583, 22, 14, 27, 3, -26 },
  { 2622, 22, 25, 26, 2, -31 },
  { 2691, 18, 43, 23, 5, -42 },
  { 2788, 39, 53, 44, 2, -40 },
  { 3047, 29, 41, 31, -2, -41 },
  { 3196, 26, 41, 30, 2, -41 },
  { 3330, 28, 43, 32, 3, -42 },
  { 3481, 28, 41, 32, 2, -41 },
  { 3625, 28, 41, 28, 2, -41 },
  { 3769, 28, 41, 28, 2, -41 },
  { 3913, 27, 43, 33, 4, -42 },
  { 4059, 32, 41, 35, 2, -41 },
  { 4223, 11, 41, 14, 2, -41 },
  { 4280, 26, 42, 27, 1, -41 },
  { 4417, 31, 41, 31, 2, -41 },
  { 4576, 20, 41, 26, 2, -41 },
  { 4679, 40, 41, 42, 2, -41 },
  { 4884, 32, 41, 35, 2, -41 },
  { 5048, 28, 43, 33, 3, -42 },
  { 5199, 28, 41, 30, 2, -41 },
  { 5343, 28, 49, 33, 3, -42 },
  { 5515, 28, 41, 31, 2, -41 },
  { 5659, 28, 43, 29, 1, -42 },
  { 5810, 27, 41, 29, 5, -41 },
  { 5949, 29, 42, 32, 3, -41 },
  { 6102, 28, 41, 30, 5, -41 },
  { 6246, 40, 41, 43, 6, -41 },
  { 6451, 33, 41, 30, -1, -41 },
  { 6621, 28, 41, 29, 5, -41 },
  { 6765, 30, 41, 29, 0, -41 },
  { 6919, 17, 56, 13, 0, -47 },
  { 7038, 9, 45, 20, 6, -41 },
  { 7089, 16, 56, 13, -3, -47 },
  { 7201, 16, 21, 21, 3, -41 },
  { 7243, 21, 3, 22, -3, 0 },
  { 7251, 8, 8, 16, 7, -44 },
  { 7259, 22, 33, 27, 1, -32 },
  { 7350, 24, 45, 27, 1, -44 },
  { 7485, 22, 33, 26, 2, -32 },
  { 7576, 26, 45, 27, 2, -44 },
  { 7723, 22, 33, 26, 2, -32 },
  { 7814, 18, 45, 17, 3, -45 },
  { 7916, 26, 44, 27, 0, -32 },
  { 8059, 23, 44, 27, 1, -44 },
  { 8186, 11, 43, 12, 1, -43 },
  { 8246, 19, 55, 12, -7, -43 },
  { 8377, 24, 44, 24, 1, -44 },
  { 8509, 11, 44, 12, 1, -44 },
  { 8570, 39, 32, 43, 1, -32 },
  { 8726, 23, 32, 27, 1, -32 },
  { 8818, 23, 33, 28, 2, -32 },
  { 8913, 26, 44, 27, -1, -32 },
  { 9056, 24, 44, 28, 2, -32 },
  { 9188, 17, 32, 17, 1, -32 },
  { 9256, 22, 33, 25, 1, -32 },
  { 9347, 13, 39, 16, 3, -38 },
  { 9411, 22, 32, 27, 3, -31 },
  { 9499, 21, 31, 24, 4, -31 },
  { 9581, 33, 31, 37, 4, -31 },
  { 9709, 25, 31, 24, -1, -31 },
  { 9806, 27, 43, 24, -2, -31 },
  { 9952, 24, 31, 24, 0, -31 },
  { 10045, 18, 56, 17, 2, -45 },
  { 10171, 11, 49, 12, 1, -41 },
  { 10239, 18, 57, 17, -3, -45 },
  { 10368, 27, 10, 33, 3, -22 },
};

const GFXfont RobotoCondensed_LightItalic58pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic58pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic58pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC58PT7B_H_
