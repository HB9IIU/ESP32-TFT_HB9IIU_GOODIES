#ifndef _ROBOTOCONDENSED_LIGHTITALIC46PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x60, 0x73, 0xB1,
  0xD8, 0xCC, 0x66, 0x33, 0x1B, 0x1D, 0x8C, 0xC6, 0x63, 0x00, 0x00, 0x0E,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0x81,
  0x80, 0x03, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x70,
  0x00, 0x60, 0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x06, 0x0C, 0x00,
  0x18, 0x18, 0x00, 0x30, 0x70, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03,
  0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60,
  0xC0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x06, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00,
  0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0x7C, 0x07, 0x03, 0xC1, 0xC0, 0x38, 0x38, 0x03, 0x06,
  0x00, 0x61, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xC7, 0x00,
  0x38, 0xE0, 0x07, 0x0C, 0x01, 0xC1, 0xC0, 0x78, 0x1F, 0x7E, 0x01, 0xFF,
  0x80, 0x1F, 0x80, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0E, 0x30, 0x00, 0xE0, 0xC0, 0x06,
  0x06, 0x02, 0x30, 0x30, 0x39, 0x81, 0x81, 0x9C, 0x0C, 0x18, 0xC0, 0x61,
  0xC6, 0x03, 0x0C, 0x18, 0x30, 0xC0, 0xC1, 0x8C, 0x07, 0x1C, 0x60, 0x1F,
  0xC6, 0x00, 0x78, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x38, 0xF8, 0x01, 0x8F, 0xE0, 0x18, 0xE3, 0x81, 0xC6, 0x0C, 0x0C,
  0x60, 0x60, 0xC3, 0x03, 0x0C, 0x18, 0x18, 0xE0, 0xC0, 0xC6, 0x06, 0x06,
  0x60, 0x30, 0x37, 0x01, 0x81, 0x90, 0x0C, 0x18, 0x00, 0x71, 0xC0, 0x01,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x79, 0xE0,
  0x03, 0x83, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0C, 0x07, 0x00, 0x60,
  0x38, 0x03, 0x01, 0x80, 0x18, 0x1C, 0x00, 0xC1, 0xC0, 0x07, 0x1C, 0x00,
  0x39, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x3B, 0x80, 0x03, 0x9C, 0x06, 0x38, 0x70, 0x73, 0x83, 0x83, 0x38,
  0x0E, 0x19, 0xC0, 0x31, 0xCC, 0x01, 0xCC, 0x60, 0x06, 0x63, 0x00, 0x3E,
  0x18, 0x00, 0xF0, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1C, 0x07, 0xE0, 0xF8,
  0xF3, 0x83, 0xFF, 0x1C, 0x07, 0xE0, 0x70, 0x33, 0x37, 0x76, 0x66, 0x6C,
  0x00, 0x08, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x01, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x07, 0xC3, 0x0F, 0xF9, 0xBF, 0x3F, 0xFE, 0x03, 0xF8, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xEE, 0x00, 0xE3, 0x80, 0xE0, 0xC0, 0xE0, 0x70, 0x60, 0x18,
  0x10, 0x08, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00,
  0x0C, 0x71, 0xC7, 0x1C, 0xE3, 0x9C, 0xE1, 0x00, 0xFF, 0xBF, 0xE0, 0x6F,
  0xF6, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x3C, 0x78, 0x1C, 0x0E, 0x0E, 0x01, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x70,
  0x03, 0x18, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x37, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xD8, 0x00, 0x66,
  0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80,
  0x0C, 0xE0, 0x03, 0x38, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x38, 0x70, 0x0C,
  0x1C, 0x07, 0x03, 0xC7, 0x80, 0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x60,
  0x38, 0x3F, 0x1F, 0xEF, 0x9D, 0xC3, 0xA0, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xF0, 0x0F, 0x9F, 0x03, 0xC0, 0xE0, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x00,
  0x18, 0xE0, 0x03, 0x1C, 0x00, 0x63, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFC,
  0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0x9F, 0x03, 0xC0,
  0xE0, 0x70, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x1C, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0xE0, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x0E, 0x30, 0x01, 0x87, 0x00, 0x70,
  0x70, 0x1C, 0x0F, 0x8F, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x6C, 0x00, 0x1F,
  0x80, 0x03, 0x70, 0x00, 0xCE, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0x86,
  0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xC0, 0x38, 0x18,
  0x06, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0C, 0x03, 0x83, 0x80, 0x60,
  0xE0, 0x0C, 0x18, 0x01, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x9F, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xE0, 0x70, 0x10, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x18, 0x70, 0x07, 0x0E,
  0x01, 0xC0, 0xE0, 0x78, 0x0F, 0x1E, 0x00, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x1F, 0x03, 0xBF, 0xE1, 0xBC, 0xF0, 0xF0, 0x1C, 0xF0, 0x06, 0x70, 0x03,
  0xB8, 0x01, 0xD8, 0x00, 0xEC, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0xCE, 0x00, 0xC7,
  0x00, 0xE1, 0xC0, 0xE0, 0x79, 0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x01,
  0xE3, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x06, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xE0, 0x0E,
  0x0E, 0x01, 0xC0, 0x70, 0x3C, 0x03, 0xC7, 0x80, 0x1F, 0xE0, 0x07, 0xFE,
  0x00, 0xE0, 0xF0, 0x1C, 0x03, 0x03, 0x80, 0x38, 0x30, 0x01, 0x87, 0x00,
  0x18, 0x60, 0x01, 0xC6, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0x60,
  0x03, 0x86, 0x00, 0x38, 0x70, 0x07, 0x03, 0x80, 0xE0, 0x3E, 0x3C, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xE7, 0x83,
  0xC0, 0xE1, 0xC0, 0x31, 0xC0, 0x1C, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3E, 0x00, 0x3B, 0x00, 0x1D, 0x80,
  0x0E, 0xC0, 0x0F, 0x60, 0x07, 0x38, 0x07, 0x8E, 0x06, 0xC7, 0xCF, 0xE1,
  0xFE, 0x70, 0x7E, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x78, 0x00, 0x00, 0x0C, 0x1C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x38,
  0x78, 0xE0, 0x01, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x70, 0x38, 0x04, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xEF, 0x8E,
  0x0E, 0x70, 0x1D, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x03, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x07,
  0x00, 0x00, 0x0C, 0x1C, 0x00, 0x00, 0x18, 0x30, 0x07, 0xC0, 0x10, 0xE0,
  0x1F, 0xE0, 0x31, 0x80, 0xF1, 0xE0, 0x67, 0x01, 0x81, 0xC0, 0xCC, 0x06,
  0x03, 0x01, 0x98, 0x1C, 0x06, 0x03, 0x60, 0x30, 0x0C, 0x06, 0xC0, 0xE0,
  0x38, 0x0D, 0x81, 0x80, 0x60, 0x17, 0x03, 0x00, 0xC0, 0x6C, 0x0E, 0x01,
  0x80, 0xD8, 0x1C, 0x07, 0x01, 0xB0, 0x30, 0x0C, 0x03, 0x60, 0x60, 0x18,
  0x04, 0xC0, 0xC0, 0x30, 0x19, 0x81, 0x80, 0xE0, 0x33, 0x03, 0x01, 0xC0,
  0xC6, 0x06, 0x07, 0x81, 0x8C, 0x0C, 0x1B, 0x06, 0x18, 0x1C, 0x66, 0x18,
  0x30, 0x1F, 0x8F, 0xE0, 0x60, 0x1E, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x10, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1B, 0x00, 0x00, 0xEE, 0x00, 0x03, 0x38, 0x00, 0x1C, 0x60,
  0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x0C, 0x18, 0x00, 0x70, 0x60, 0x01,
  0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x30, 0x07, 0x00,
  0xC0, 0x38, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xE0,
  0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0C, 0x00, 0x18, 0x70, 0x00, 0x61, 0x80,
  0x01, 0x8E, 0x00, 0x06, 0x30, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x30, 0x3F, 0x01, 0xC0, 0x1E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0x60, 0x70,
  0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x38, 0x00, 0x60, 0xE0, 0x03,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x30, 0x03, 0x80, 0xC0, 0x7C, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x70, 0x07, 0x01, 0x80, 0x0E, 0x06, 0x00,
  0x18, 0x18, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x30, 0x00, 0x70, 0xC0, 0x01, 0x83, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x01, 0xC1, 0xC0, 0x0E, 0x06, 0x01, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0xF8, 0x0F, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x00, 0x03, 0x38, 0x00,
  0x19, 0x80, 0x00, 0xCC, 0x00, 0x06, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x01, 0x98, 0x00, 0x1C, 0xC0, 0x00, 0xE7, 0x00, 0x06, 0x38, 0x00, 0x71,
  0xC0, 0x07, 0x07, 0x00, 0x38, 0x3C, 0x03, 0x80, 0xF8, 0xF8, 0x03, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0C, 0x0F,
  0xC0, 0x38, 0x03, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xC0, 0x00, 0xE1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0E,
  0x00, 0x06, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x60, 0x00, 0x70, 0xC0,
  0x00, 0xE1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x3C, 0x0E, 0x00, 0xF0, 0x18, 0x0F, 0xC0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0x3F, 0x01, 0xE0, 0x1C,
  0x0F, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x01, 0xC6, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xFF, 0x38, 0x07, 0xFC, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x63, 0x80, 0x03,
  0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xE0, 0xE0, 0x0F, 0x01,
  0xF3, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0xC0, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x06, 0x07, 0x00, 0x01,
  0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x06, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0C,
  0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x70, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00,
  0x38, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0,
  0x00, 0x70, 0x30, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x60, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x03,
  0x81, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x00, 0x07, 0x07, 0x07, 0x06,
  0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18,
  0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60,
  0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xE0, 0x06,
  0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x07, 0x03, 0xC0, 0x3E, 0xF8, 0x03, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x07, 0x81, 0x80, 0x07, 0x80, 0xC0,
  0x07, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x0C, 0x03, 0x80, 0x06, 0x03, 0x80, 0x07, 0x03, 0x80, 0x03,
  0x83, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3, 0xC0, 0x00, 0x63, 0xC0, 0x00,
  0x33, 0xC0, 0x00, 0x3B, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xDC, 0x00,
  0x07, 0xCE, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0xE0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x30, 0x07, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x06, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0,
  0x00, 0x3E, 0x06, 0xC0, 0x00, 0x36, 0x06, 0xC0, 0x00, 0x7E, 0x06, 0xE0,
  0x00, 0x6E, 0x06, 0xE0, 0x00, 0xEE, 0x0E, 0xE0, 0x00, 0xCC, 0x0E, 0x60,
  0x01, 0xCC, 0x0E, 0x60, 0x01, 0x8C, 0x0C, 0x60, 0x03, 0x9C, 0x0C, 0x70,
  0x03, 0x1C, 0x0C, 0x70, 0x07, 0x18, 0x1C, 0x70, 0x06, 0x18, 0x1C, 0x30,
  0x0E, 0x18, 0x1C, 0x30, 0x0C, 0x38, 0x18, 0x30, 0x1C, 0x38, 0x18, 0x30,
  0x18, 0x38, 0x18, 0x38, 0x38, 0x30, 0x38, 0x38, 0x30, 0x30, 0x38, 0x18,
  0x70, 0x30, 0x38, 0x18, 0x60, 0x70, 0x30, 0x18, 0xE0, 0x70, 0x30, 0x18,
  0xC0, 0x70, 0x30, 0x1D, 0xC0, 0x60, 0x70, 0x1D, 0x80, 0x60, 0x70, 0x0F,
  0x80, 0x60, 0x70, 0x0F, 0x00, 0xE0, 0x60, 0x0F, 0x00, 0xE0, 0x60, 0x0E,
  0x00, 0xE0, 0xE0, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x38, 0x00, 0x1C, 0x1F, 0x00, 0x07, 0x07, 0xC0, 0x01, 0x81, 0xF8,
  0x00, 0x60, 0x7E, 0x00, 0x38, 0x19, 0x80, 0x0E, 0x06, 0x70, 0x03, 0x83,
  0x9C, 0x00, 0xC0, 0xE3, 0x00, 0x30, 0x38, 0xE0, 0x0C, 0x0E, 0x18, 0x07,
  0x03, 0x06, 0x01, 0xC0, 0xC1, 0xC0, 0x70, 0x70, 0x30, 0x18, 0x1C, 0x0E,
  0x06, 0x07, 0x03, 0x81, 0x81, 0x80, 0x60, 0xE0, 0x60, 0x1C, 0x38, 0x18,
  0x07, 0x0E, 0x0E, 0x00, 0xC3, 0x03, 0x80, 0x38, 0xC0, 0xE0, 0x06, 0x70,
  0x30, 0x01, 0x9C, 0x0C, 0x00, 0x77, 0x03, 0x00, 0x0D, 0xC1, 0xC0, 0x03,
  0x60, 0x70, 0x00, 0xF8, 0x1C, 0x00, 0x1E, 0x06, 0x00, 0x07, 0x81, 0x80,
  0x01, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0x7E, 0x01, 0xE0, 0x1C, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0,
  0x01, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x1C, 0xC0, 0x00, 0x77, 0x00, 0x01,
  0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98,
  0x00, 0x06, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB0, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x1C,
  0xC0, 0x00, 0x63, 0x00, 0x03, 0x8E, 0x00, 0x0C, 0x38, 0x00, 0x70, 0x70,
  0x03, 0x81, 0xE0, 0x1C, 0x03, 0xF3, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0C, 0x07, 0xE0, 0x38, 0x01,
  0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x83, 0x00, 0x07,
  0x06, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60,
  0xE0, 0x01, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0xF0, 0x38, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x1E, 0x03, 0xC0,
  0x70, 0x01, 0x81, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x06, 0x1C,
  0x00, 0x0E, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x00,
  0x00, 0xC6, 0x00, 0x01, 0x8C, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x70, 0x00,
  0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x00, 0x00, 0xC6, 0x00, 0x01,
  0x8C, 0x00, 0x07, 0x18, 0x00, 0x0E, 0x30, 0x00, 0x18, 0x60, 0x00, 0x30,
  0xC0, 0x00, 0xE1, 0xC0, 0x01, 0x83, 0x80, 0x07, 0x03, 0x80, 0x1C, 0x07,
  0x80, 0x70, 0x07, 0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x20, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x30,
  0x1F, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60, 0x01,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0xC0, 0x07, 0x07, 0x00,
  0x3C, 0x1C, 0x07, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x06, 0x01, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x0E, 0x00, 0xE0, 0x30,
  0x03, 0x80, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0E, 0x18, 0x00, 0x38, 0xE0, 0x00, 0x60,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0x3F, 0x00, 0xF0, 0x1C, 0x07,
  0x00, 0x38, 0x18, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00,
  0x1C, 0x30, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x06, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x80, 0x03, 0x86,
  0x00, 0x0E, 0x1C, 0x00, 0x30, 0x70, 0x01, 0xC0, 0xE0, 0x1E, 0x01, 0xF1,
  0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00,
  0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x0E, 0x0C, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x0C, 0x00, 0x0C, 0x1C, 0x00, 0x0C, 0x1C, 0x00,
  0x0C, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x18, 0x00,
  0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x30, 0x00,
  0x38, 0x30, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00, 0x70, 0x60, 0x00,
  0x60, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x1F, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0x98, 0x00, 0x0E,
  0x60, 0x00, 0x71, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0xC1, 0xC0, 0x07, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xE0, 0x30, 0x03,
  0x80, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x38, 0x0E, 0x00,
  0x60, 0x30, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x18, 0x38, 0x00, 0x70,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x80,
  0x00, 0xCC, 0x00, 0x03, 0x70, 0x00, 0x0D, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x0F,
  0x80, 0x07, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x36, 0x00, 0x3C, 0x00, 0xEC,
  0x00, 0xF8, 0x01, 0xD8, 0x01, 0xB0, 0x03, 0x30, 0x03, 0x60, 0x0E, 0x60,
  0x0E, 0xC0, 0x18, 0xC0, 0x19, 0x80, 0x71, 0x80, 0x73, 0x00, 0xE3, 0x80,
  0xC6, 0x01, 0x87, 0x01, 0x8C, 0x07, 0x0E, 0x07, 0x18, 0x0E, 0x1C, 0x0C,
  0x30, 0x18, 0x38, 0x18, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0,
  0xC1, 0x81, 0xC3, 0x81, 0x87, 0x03, 0x86, 0x03, 0x0C, 0x03, 0x0C, 0x06,
  0x18, 0x06, 0x38, 0x0C, 0x70, 0x0C, 0x60, 0x18, 0xC0, 0x19, 0xC0, 0x31,
  0x80, 0x33, 0x00, 0x67, 0x00, 0x66, 0x00, 0xCC, 0x00, 0xDC, 0x01, 0x98,
  0x01, 0xB0, 0x03, 0x70, 0x03, 0x60, 0x06, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x78, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x07, 0x80,
  0x0E, 0x01, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x38, 0xE0, 0x00, 0x0E, 0x18, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x01, 0xE0, 0x30, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3D, 0x80, 0x00, 0xE7, 0x00, 0x07,
  0x1C, 0x00, 0x1C, 0x30, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x03, 0x03,
  0x80, 0x0C, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0x9C, 0x00,
  0x06, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0xC1, 0x83, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x87, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x70, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x01, 0xF8,
  0x0F, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xC0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x36, 0x01, 0xB0, 0x19, 0x80, 0xCE, 0x0C,
  0x30, 0x61, 0x86, 0x0C, 0x30, 0x63, 0x03, 0x18, 0x1D, 0x80, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x87, 0x0C, 0x18, 0x70, 0x00, 0xFC, 0x01,
  0xFF, 0x81, 0xE3, 0xC1, 0xC0, 0x71, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0xFF, 0xE1, 0xFF, 0xF1, 0xF0,
  0x31, 0xC0, 0x19, 0xC0, 0x0D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8,
  0x03, 0x9C, 0x03, 0xCE, 0x03, 0xE3, 0xEF, 0xF0, 0xFF, 0x38, 0x3F, 0x1C,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x31, 0xF8, 0x0C, 0xFF, 0x03, 0x73, 0xE1, 0xF0, 0x1C, 0x78, 0x07,
  0x1C, 0x00, 0xC6, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x03, 0x38, 0x00, 0xCE,
  0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x01, 0xDC, 0x00, 0x77, 0x00,
  0x1D, 0xC0, 0x06, 0x60, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x73, 0xE0, 0x3C,
  0xEF, 0x3E, 0x39, 0xFF, 0x0C, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03,
  0xC7, 0x83, 0x80, 0xE3, 0x80, 0x31, 0x80, 0x1D, 0xC0, 0x0E, 0xC0, 0x07,
  0x60, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x9C,
  0x03, 0x87, 0x03, 0xC3, 0xE7, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x3F, 0x0C, 0x07, 0xF8, 0xC0, 0xF9, 0xDC, 0x1C, 0x07, 0xC3,
  0x80, 0x3C, 0x30, 0x01, 0x87, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x38,
  0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x0E, 0x00, 0x30, 0xC0, 0x07,
  0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0E, 0x00,
  0x60, 0xE0, 0x0E, 0x07, 0x01, 0xE0, 0x7C, 0xFE, 0x03, 0xFE, 0xC0, 0x1F,
  0x8C, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x78, 0xF0, 0x38, 0x0E, 0x1C,
  0x01, 0x86, 0x00, 0x73, 0x80, 0x1C, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00,
  0x77, 0xFF, 0xF9, 0xFF, 0xFE, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x0E, 0x0F, 0x8F, 0x81, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xFC,
  0x07, 0xD0, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x00, 0x00, 0xFC, 0x30, 0x1F, 0xE3, 0x03, 0xE7, 0x30, 0x70, 0x1F,
  0x0E, 0x00, 0xF0, 0xC0, 0x0E, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00,
  0xE1, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x00,
  0x0C, 0x30, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0xC3, 0x00, 0x18, 0x38,
  0x01, 0x83, 0x80, 0x38, 0x1C, 0x0F, 0x81, 0xF3, 0xF8, 0x0F, 0xFB, 0x00,
  0x7E, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x40, 0x0E, 0x0E, 0x01, 0xC0, 0x7C, 0x78, 0x03, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0xF8, 0x0C, 0xFF, 0x03, 0x71, 0xE1, 0xF0, 0x38, 0x78,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0x80, 0x1C, 0x60, 0x07, 0x38, 0x01,
  0xCE, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x31, 0xC0, 0x0C, 0x70, 0x03, 0x18, 0x01, 0xC6, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x06, 0x38, 0x01, 0x8C, 0x00, 0x60, 0x03, 0x03, 0x81, 0xC0,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x27, 0x80, 0xFC, 0x03, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0xF0, 0xC0, 0x3C, 0x18, 0x0F, 0x07, 0x03, 0xC0,
  0xE0, 0xF0, 0x1C, 0x3C, 0x03, 0x0F, 0x00, 0x63, 0xC0, 0x0C, 0xF0, 0x03,
  0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x38, 0xC0, 0x06,
  0x1C, 0x01, 0xC1, 0x80, 0x38, 0x38, 0x07, 0x03, 0x00, 0xC0, 0x70, 0x18,
  0x06, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0x00,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0,
  0x60, 0x70, 0x38, 0x00, 0x0C, 0x7E, 0x03, 0xE0, 0x33, 0xFC, 0x3F, 0xE0,
  0xDC, 0xF9, 0xE7, 0x87, 0xC0, 0xEE, 0x07, 0x1E, 0x01, 0xF0, 0x1C, 0x70,
  0x07, 0x80, 0x31, 0xC0, 0x1E, 0x00, 0xC6, 0x00, 0x70, 0x03, 0x18, 0x01,
  0xC0, 0x0C, 0xE0, 0x06, 0x00, 0x33, 0x80, 0x18, 0x01, 0xCE, 0x00, 0x60,
  0x07, 0x30, 0x03, 0x80, 0x1C, 0xC0, 0x0E, 0x00, 0x67, 0x00, 0x38, 0x01,
  0x9C, 0x00, 0xC0, 0x06, 0x70, 0x03, 0x00, 0x39, 0x80, 0x0C, 0x00, 0xE6,
  0x00, 0x70, 0x03, 0x98, 0x01, 0xC0, 0x0C, 0xE0, 0x07, 0x00, 0x33, 0x80,
  0x18, 0x00, 0xCE, 0x00, 0x60, 0x07, 0x30, 0x01, 0x80, 0x1C, 0x0C, 0x3E,
  0x03, 0x3F, 0xC0, 0xDC, 0x78, 0x7C, 0x0E, 0x1E, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x60, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x18, 0xE0,
  0x06, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0C, 0x70, 0x03,
  0x1C, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0x8E,
  0x00, 0x63, 0x00, 0x18, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xF9, 0xF0, 0x78,
  0x1E, 0x38, 0x03, 0x8E, 0x00, 0x67, 0x00, 0x19, 0xC0, 0x07, 0x60, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0, 0x01, 0xB0, 0x00, 0x6C,
  0x00, 0x3B, 0x00, 0x0E, 0xC0, 0x03, 0x38, 0x01, 0xCE, 0x00, 0x71, 0x80,
  0x38, 0x70, 0x1C, 0x0F, 0x1E, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0x1F,
  0x80, 0x33, 0xFC, 0x03, 0xF3, 0xE0, 0x7C, 0x07, 0x07, 0x80, 0x70, 0x70,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0E,
  0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x07, 0x0C, 0x00, 0x71,
  0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x00, 0xE1, 0xC0, 0x1C,
  0x3E, 0x03, 0x83, 0xB8, 0xF8, 0x39, 0xFF, 0x03, 0x0F, 0xC0, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0xC1,
  0xFF, 0x30, 0xF1, 0xCC, 0x70, 0x1F, 0x38, 0x03, 0xCC, 0x00, 0x67, 0x00,
  0x19, 0xC0, 0x06, 0x60, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0C,
  0xE0, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x06, 0x30,
  0x01, 0x8E, 0x00, 0x63, 0x80, 0x38, 0x70, 0x1E, 0x1F, 0x3F, 0x83, 0xFE,
  0xC0, 0x7E, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x78, 0x6F, 0xC3, 0x7E, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xE7, 0xC1, 0xC0, 0xE1,
  0xC0, 0x38, 0xC0, 0x1C, 0x60, 0x06, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x06, 0x70, 0x03, 0x38, 0x01, 0x9C, 0x01, 0xC7, 0x01, 0xC3,
  0xE7, 0xE0, 0xFF, 0xC0, 0x1F, 0x80, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x83, 0xFF, 0xFF, 0xE1, 0x80, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xA0, 0x7C, 0x07,
  0x80, 0x18, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01,
  0x8E, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0xC7,
  0x00, 0x31, 0xC0, 0x0C, 0x60, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x18, 0xE0, 0x06, 0x38, 0x03, 0x8E, 0x00, 0xE1, 0x80, 0x78, 0x70, 0x3C,
  0x1F, 0x7F, 0x03, 0xFE, 0xC0, 0x7E, 0x00, 0xC0, 0x03, 0x60, 0x03, 0xB8,
  0x01, 0x9C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x70, 0xC0, 0x30,
  0x60, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x06, 0x0C, 0x03, 0x0E, 0x01, 0x86,
  0x00, 0xC7, 0x00, 0x63, 0x00, 0x39, 0x80, 0x1D, 0x80, 0x06, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x0C,
  0x00, 0xD8, 0x03, 0x80, 0x76, 0x01, 0xE0, 0x19, 0x80, 0x78, 0x0E, 0x60,
  0x3E, 0x03, 0x98, 0x0D, 0x80, 0xC6, 0x07, 0x60, 0x71, 0x81, 0x98, 0x18,
  0x60, 0x66, 0x0E, 0x18, 0x31, 0x83, 0x06, 0x0C, 0x60, 0xC1, 0x87, 0x18,
  0x70, 0x71, 0x86, 0x18, 0x1C, 0xE1, 0xCE, 0x07, 0x30, 0x73, 0x01, 0xDC,
  0x0C, 0xC0, 0x76, 0x03, 0x70, 0x0D, 0x80, 0xD8, 0x03, 0xC0, 0x3E, 0x00,
  0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38,
  0x00, 0xC0, 0x0E, 0x00, 0x06, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0,
  0x30, 0x1C, 0x03, 0x83, 0x80, 0x18, 0x70, 0x01, 0x87, 0x00, 0x1C, 0xE0,
  0x00, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x39, 0x80, 0x03, 0x1C, 0x00, 0x70,
  0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xE0, 0x1C, 0x06, 0x03, 0x80, 0x70, 0x70,
  0x07, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x70, 0x03,
  0x01, 0xC0, 0x1C, 0x03, 0x00, 0x70, 0x0C, 0x03, 0x80, 0x30, 0x0E, 0x00,
  0xC0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x60,
  0xC0, 0x01, 0x87, 0x00, 0x06, 0x18, 0x00, 0x18, 0xE0, 0x00, 0x63, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x09, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x10, 0x00, 0x03, 0x03, 0x07,
  0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x80, 0x03, 0x80, 0x1F, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x04, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0xDF, 0xF8, 0x0E, 0xC1, 0xC0, 0x6E,
  0x07, 0x07, 0x60, 0x1F, 0xF3, 0x00, 0x7F, 0x00, 0x01, 0xF0,
};

const GFXglyph RobotoCondensed_LightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 33, 10, 1, -33 },
  { 34, 9, 10, 13, 5, -35 },
  { 46, 23, 33, 23, 1, -33 },
  { 141, 19, 42, 22, 2, -38 },
  { 241, 21, 33, 29, 4, -33 },
  { 328, 21, 33, 24, 1, -33 },
  { 415, 4, 10, 8, 4, -35 },
  { 420, 13, 48, 13, 2, -37 },
  { 498, 13, 48, 13, -2, -37 },
  { 576, 17, 18, 19, 3, -33 },
  { 615, 19, 24, 22, 2, -27 },
  { 672, 6, 10, 9, -2, -4 },
  { 680, 10, 2, 12, 1, -15 },
  { 683, 4, 4, 11, 1, -4 },
  { 685, 20, 36, 16, -2, -33 },
  { 775, 18, 33, 22, 2, -33 },
  { 850, 11, 33, 22, 6, -33 },
  { 896, 19, 33, 22, 1, -33 },
  { 975, 19, 33, 22, 1, -33 },
  { 1054, 19, 33, 22, 1, -33 },
  { 1133, 19, 33, 22, 3, -33 },
  { 1212, 17, 33, 22, 2, -33 },
  { 1283, 19, 33, 22, 3, -33 },
  { 1362, 20, 33, 22, 1, -33 },
  { 1445, 17, 33, 22, 3, -33 },
  { 1516, 7, 25, 9, 1, -25 },
  { 1538, 10, 31, 9, -2, -25 },
  { 1577, 17, 19, 20, 2, -24 },
  { 1618, 18, 11, 22, 2, -21 },
  { 1643, 18, 19, 20, 1, -24 },
  { 1686, 14, 33, 18, 4, -33 },
  { 1744, 31, 42, 35, 2, -32 },
  { 1907, 22, 33, 24, -1, -33 },
  { 1998, 22, 33, 24, 1, -33 },
  { 2089, 21, 33, 25, 3, -33 },
  { 2176, 23, 33, 25, 1, -33 },
  { 2271, 23, 33, 22, 1, -33 },
  { 2366, 23, 33, 22, 1, -33 },
  { 2461, 22, 33, 27, 3, -33 },
  { 2552, 26, 33, 27, 1, -33 },
  { 2660, 8, 33, 11, 2, -33 },
  { 2693, 20, 33, 22, 1, -33 },
  { 2776, 25, 33, 24, 1, -33 },
  { 2880, 16, 33, 21, 1, -33 },
  { 2946, 32, 33, 33, 1, -33 },
  { 3078, 26, 33, 28, 1, -33 },
  { 3186, 22, 33, 26, 3, -33 },
  { 3277, 23, 33, 24, 1, -33 },
  { 3372, 23, 39, 26, 2, -33 },
  { 3485, 22, 33, 25, 1, -33 },
  { 3576, 22, 33, 23, 1, -33 },
  { 3667, 21, 33, 23, 4, -33 },
  { 3754, 24, 33, 25, 2, -33 },
  { 3853, 22, 33, 24, 4, -33 },
  { 3944, 31, 33, 34, 5, -33 },
  { 4072, 26, 33, 24, -1, -33 },
  { 4180, 22, 33, 23, 4, -33 },
  { 4271, 24, 33, 23, 0, -33 },
  { 4370, 13, 44, 10, 0, -37 },
  { 4442, 7, 36, 16, 5, -33 },
  { 4474, 13, 44, 10, -3, -37 },
  { 4546, 13, 16, 16, 2, -33 },
  { 4572, 16, 2, 17, -2, 0 },
  { 4576, 6, 6, 13, 6, -34 },
  { 4581, 17, 24, 21, 1, -24 },
  { 4632, 18, 35, 22, 1, -35 },
  { 4711, 17, 24, 20, 2, -24 },
  { 4762, 20, 35, 22, 2, -35 },
  { 4850, 18, 24, 20, 1, -24 },
  { 4904, 15, 35, 13, 2, -35 },
  { 4970, 20, 33, 22, 0, -24 },
  { 5053, 18, 35, 21, 1, -35 },
  { 5132, 9, 33, 9, 1, -33 },
  { 5170, 14, 42, 10, -5, -33 },
  { 5244, 19, 35, 19, 1, -35 },
  { 5328, 9, 35, 9, 1, -35 },
  { 5368, 30, 24, 34, 1, -24 },
  { 5458, 18, 24, 22, 1, -24 },
  { 5512, 18, 24, 22, 2, -24 },
  { 5566, 20, 33, 22, -1, -24 },
  { 5649, 18, 33, 22, 2, -24 },
  { 5724, 13, 24, 14, 1, -24 },
  { 5763, 17, 24, 20, 1, -24 },
  { 5814, 11, 31, 13, 2, -31 },
  { 5857, 18, 24, 21, 2, -24 },
  { 5911, 17, 24, 19, 3, -24 },
  { 5962, 26, 24, 29, 3, -24 },
  { 6040, 20, 24, 19, -1, -24 },
  { 6100, 22, 33, 19, -2, -24 },
  { 6191, 19, 24, 19, 0, -24 },
  { 6248, 15, 45, 13, 1, -36 },
  { 6333, 8, 39, 10, 1, -33 },
  { 6372, 15, 45, 13, -3, -36 },
  { 6457, 21, 8, 27, 3, -17 },
};

const GFXfont RobotoCondensed_LightItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC46PT7B_H_
