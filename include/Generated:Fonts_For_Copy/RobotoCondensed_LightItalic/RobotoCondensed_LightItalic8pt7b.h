#ifndef _ROBOTOCONDENSED_LIGHTITALIC8PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x20, 0x00, 0x23, 0x56, 0x70, 0x22, 0x54, 0x2A, 0xA4, 0x9E,
  0xBE, 0xC0, 0x25, 0x65, 0xBE, 0x00, 0x0A, 0x49, 0x20, 0x15, 0x58, 0x03,
  0x42, 0x02, 0xF0, 0x80, 0xC0, 0x80, 0x05, 0x29, 0x00, 0x25, 0x99, 0xAE,
  0x55, 0x80, 0x61, 0x12, 0x4C, 0x61, 0x16, 0xAE, 0x02, 0x6A, 0xE2, 0x74,
  0x61, 0x9E, 0x29, 0xDB, 0xC0, 0xE5, 0x28, 0x00, 0x25, 0x5A, 0xAE, 0xD6,
  0xE5, 0x00, 0x10, 0x10, 0x71, 0x80, 0x68, 0x47, 0x00, 0xD6, 0x00, 0x39,
  0x15, 0x69, 0xD7, 0xE8, 0x18, 0x22, 0x65, 0x91, 0x65, 0x5B, 0x9E, 0x34,
  0x88, 0x96, 0x65, 0x59, 0x9E, 0x74, 0x48, 0x88, 0x74, 0x48, 0x88, 0x34,
  0x8B, 0x97, 0x4A, 0x53, 0x69, 0x48, 0x56, 0xA0, 0x11, 0x12, 0xAE, 0x42,
  0x98, 0x8A, 0x40, 0x49, 0x49, 0x00, 0x45, 0x14, 0xAE, 0xAA, 0xA0, 0x4A,
  0x53, 0x6B, 0x48, 0x35, 0x99, 0x96, 0x75, 0x56, 0x88, 0x35, 0x99, 0x96,
  0x10, 0x65, 0x56, 0xA8, 0x24, 0x42, 0x9E, 0xE9, 0x29, 0x00, 0x45, 0x59,
  0x9E, 0x0A, 0xAC, 0xC8, 0x25, 0x7B, 0x69, 0x40, 0x05, 0x22, 0x68, 0x0A,
  0xC4, 0x88, 0x71, 0x24, 0x4C, 0x56, 0xAA, 0x78, 0x55, 0xAA, 0x08, 0x80,
  0x40, 0x80, 0x2E, 0xF0, 0x4A, 0xDB, 0xC0, 0xD2, 0x70, 0x11, 0xEA, 0xAA,
  0xF6, 0x70, 0x49, 0x28, 0x00, 0xEA, 0xAA, 0x24, 0x4A, 0xDB, 0x40, 0x42,
  0xA0, 0x20, 0x24, 0x94, 0x4A, 0xAD, 0x40, 0x56, 0xA0, 0x7D, 0x6B, 0x40,
  0x76, 0xD0, 0x76, 0xD0, 0x76, 0xF8, 0x00, 0xEA, 0xAA, 0x22, 0x92, 0x40,
  0xE8, 0xF0, 0x56, 0x00, 0x0A, 0xAE, 0x15, 0x20, 0x5D, 0xA2, 0x29, 0x50,
  0x15, 0x25, 0x00, 0x29, 0x60, 0x09, 0x41, 0x22, 0x56, 0xA8, 0x55, 0x28,
  0x60,
};

const GFXglyph RobotoCondensed_LightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 1, 2, 2, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 3, 6, 5, 1, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 1, 1, -6 },
  { 18, 3, 8, 2, 0, -6 },
  { 21, 2, 8, 2, 0, -6 },
  { 23, 4, 4, 3, 0, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 2, 1, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 3, 6, 4, 0, -6 },
  { 53, 3, 6, 4, 1, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 3, 6, 4, 1, -6 },
  { 62, 1, 4, 2, 0, -4 },
  { 63, 1, 5, 1, 0, -4 },
  { 64, 3, 3, 3, 0, -4 },
  { 66, 3, 2, 4, 0, -4 },
  { 67, 3, 3, 4, 0, -4 },
  { 69, 2, 6, 3, 1, -6 },
  { 71, 6, 8, 6, 0, -6 },
  { 77, 4, 6, 4, 0, -6 },
  { 80, 4, 6, 4, 0, -6 },
  { 83, 4, 6, 4, 0, -6 },
  { 86, 4, 6, 4, 0, -6 },
  { 89, 4, 6, 4, 0, -6 },
  { 92, 4, 6, 4, 0, -6 },
  { 95, 4, 6, 5, 0, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 2, 6, 2, 0, -6 },
  { 104, 4, 6, 4, 0, -6 },
  { 107, 5, 6, 4, 0, -6 },
  { 111, 3, 6, 4, 0, -6 },
  { 114, 6, 6, 6, 0, -6 },
  { 119, 5, 6, 5, 0, -6 },
  { 123, 4, 6, 5, 0, -6 },
  { 126, 4, 6, 4, 0, -6 },
  { 129, 4, 7, 5, 0, -6 },
  { 133, 4, 6, 4, 0, -6 },
  { 136, 4, 6, 4, 0, -6 },
  { 139, 3, 6, 4, 1, -6 },
  { 142, 4, 6, 4, 0, -6 },
  { 145, 4, 6, 4, 1, -6 },
  { 148, 5, 6, 6, 1, -6 },
  { 152, 4, 6, 4, 0, -6 },
  { 155, 4, 6, 4, 1, -6 },
  { 158, 4, 6, 4, 0, -6 },
  { 161, 2, 8, 2, 0, -7 },
  { 163, 1, 6, 3, 1, -6 },
  { 164, 2, 8, 2, 0, -7 },
  { 166, 3, 3, 3, 0, -6 },
  { 168, 3, 1, 3, 0, 0 },
  { 169, 1, 1, 2, 1, -6 },
  { 170, 3, 4, 4, 0, -4 },
  { 172, 3, 6, 4, 0, -6 },
  { 175, 3, 4, 4, 0, -4 },
  { 177, 4, 6, 4, 0, -6 },
  { 180, 3, 4, 4, 0, -4 },
  { 182, 3, 6, 2, 0, -6 },
  { 185, 4, 6, 4, 0, -4 },
  { 188, 3, 6, 4, 0, -6 },
  { 191, 2, 6, 2, 0, -6 },
  { 193, 3, 8, 2, -1, -6 },
  { 196, 3, 6, 3, 0, -6 },
  { 199, 2, 6, 2, 0, -6 },
  { 201, 5, 4, 6, 0, -4 },
  { 204, 3, 4, 4, 0, -4 },
  { 206, 3, 4, 4, 0, -4 },
  { 208, 3, 6, 4, 0, -4 },
  { 211, 4, 6, 4, 0, -4 },
  { 214, 3, 4, 2, 0, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 2, 5, 2, 0, -5 },
  { 220, 4, 4, 4, 0, -4 },
  { 222, 3, 4, 3, 0, -4 },
  { 224, 4, 4, 5, 1, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 3, 6, 3, 0, -4 },
  { 231, 3, 4, 3, 0, -4 },
  { 233, 3, 8, 2, 0, -6 },
  { 236, 2, 7, 2, 0, -6 },
  { 238, 2, 8, 2, 0, -6 },
  { 240, 4, 1, 5, 0, -3 },
};

const GFXfont RobotoCondensed_LightItalic8pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic8pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic8pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC8PT7B_H_
