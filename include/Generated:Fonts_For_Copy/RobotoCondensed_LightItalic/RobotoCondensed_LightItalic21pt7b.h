#ifndef _ROBOTOCONDENSED_LIGHTITALIC21PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB4, 0x92, 0x50, 0x01, 0x20, 0x55, 0x59, 0x90, 0x04, 0x81,
  0x20, 0x88, 0x22, 0x7F, 0xC4, 0x41, 0x10, 0x48, 0x22, 0x08, 0x8F, 0xF1,
  0x10, 0x44, 0x12, 0x08, 0x80, 0x04, 0x04, 0x1E, 0x33, 0x21, 0x61, 0x41,
  0x20, 0x30, 0x1C, 0x06, 0x02, 0x82, 0x82, 0x82, 0x44, 0x78, 0x10, 0x20,
  0x70, 0x12, 0x08, 0x8A, 0x24, 0x8A, 0x24, 0x87, 0x40, 0x20, 0x0B, 0x85,
  0x22, 0x45, 0x11, 0x44, 0x81, 0x20, 0x70, 0x0E, 0x09, 0x08, 0x44, 0x42,
  0x21, 0xA0, 0x60, 0x70, 0x48, 0xE6, 0x61, 0x50, 0xE8, 0x26, 0x39, 0xE4,
  0x5A, 0x80, 0x04, 0x21, 0x04, 0x20, 0x86, 0x10, 0x41, 0x0C, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x04, 0x10, 0x40, 0x80, 0x10, 0x20, 0x82, 0x04, 0x10,
  0x41, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x84, 0x10, 0x42, 0x18, 0x42, 0x00,
  0x08, 0x08, 0x08, 0x7F, 0x18, 0x38, 0x64, 0x44, 0x0C, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x18, 0x10, 0x10, 0x10, 0x10, 0x25, 0xA8, 0xF0, 0x50, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04,
  0x02, 0x02, 0x01, 0x01, 0x00, 0x1E, 0x33, 0x21, 0x41, 0x41, 0x41, 0x41,
  0xC1, 0x81, 0x81, 0x82, 0x82, 0x82, 0x44, 0x78, 0x13, 0xA4, 0x21, 0x08,
  0x84, 0x21, 0x08, 0xC4, 0x21, 0x00, 0x0F, 0x08, 0xC8, 0x24, 0x10, 0x08,
  0x04, 0x04, 0x06, 0x06, 0x06, 0x02, 0x02, 0x02, 0x02, 0x03, 0xFC, 0x1E,
  0x33, 0x61, 0x41, 0x01, 0x01, 0x02, 0x1C, 0x06, 0x02, 0x02, 0x82, 0x82,
  0xC4, 0x78, 0x01, 0x80, 0xC0, 0xA0, 0xA0, 0x50, 0x48, 0x44, 0x62, 0x23,
  0x21, 0x3F, 0xE0, 0x40, 0x20, 0x10, 0x18, 0x1F, 0x88, 0x08, 0x04, 0x02,
  0x01, 0xE1, 0x88, 0x06, 0x01, 0x00, 0x80, 0x50, 0x4C, 0x22, 0x30, 0xE0,
  0x07, 0x18, 0x30, 0x20, 0x40, 0x5C, 0x62, 0xC3, 0x81, 0x81, 0x83, 0x82,
  0xC2, 0x44, 0x38, 0xFF, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x30, 0x20, 0x60, 0x40, 0xC0, 0x80, 0x1E, 0x19, 0x88, 0x4C, 0x24, 0x13,
  0x08, 0x88, 0x78, 0x42, 0x41, 0x20, 0x90, 0x48, 0x26, 0x21, 0xE0, 0x3C,
  0xCF, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0xCA, 0xE8, 0x10, 0x60, 0x86, 0x38,
  0x00, 0x33, 0x00, 0x00, 0x00, 0x04, 0xC0, 0x10, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0x08, 0xC4, 0x40, 0x01, 0x06, 0x18, 0x60, 0x80, 0x60, 0x30, 0x0C,
  0x04, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x40, 0x70, 0x18, 0x06, 0x02, 0x0C,
  0x30, 0xC0, 0x80, 0x39, 0x18, 0x61, 0x04, 0x30, 0x84, 0x21, 0x84, 0x00,
  0x01, 0x0C, 0x00, 0x03, 0xE0, 0x30, 0x41, 0x80, 0x84, 0x01, 0x23, 0xC5,
  0x19, 0x14, 0x44, 0x52, 0x11, 0x88, 0x46, 0x22, 0x18, 0x88, 0x64, 0x22,
  0x90, 0x8A, 0x26, 0x48, 0xEE, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x10,
  0x07, 0x80, 0x01, 0x80, 0x30, 0x0A, 0x01, 0x40, 0x68, 0x09, 0x03, 0x30,
  0x42, 0x18, 0x42, 0x08, 0x7F, 0x10, 0x22, 0x04, 0x80, 0x90, 0x18, 0x3F,
  0x10, 0xC8, 0x24, 0x16, 0x0A, 0x05, 0x0C, 0xFC, 0x41, 0x20, 0xB0, 0x50,
  0x28, 0x14, 0x13, 0xF0, 0x0F, 0x06, 0x22, 0x04, 0x81, 0x40, 0x50, 0x04,
  0x01, 0x00, 0xC0, 0x20, 0x08, 0x0B, 0x02, 0x41, 0x18, 0xC3, 0xC0, 0x3F,
  0x08, 0x62, 0x08, 0x83, 0x60, 0x50, 0x14, 0x05, 0x03, 0x40, 0x90, 0x2C,
  0x0A, 0x06, 0x81, 0x21, 0x8F, 0xC0, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x60,
  0x10, 0x04, 0x01, 0xFC, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x0F,
  0xE0, 0x3F, 0xC8, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x01, 0xFC, 0x40,
  0x10, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x08, 0x00, 0x0F, 0x86, 0x32, 0x04,
  0x81, 0x40, 0x10, 0x04, 0x01, 0x00, 0x47, 0xF0, 0x2C, 0x0B, 0x02, 0x40,
  0x98, 0xC3, 0xE0, 0x20, 0x24, 0x04, 0x80, 0x90, 0x16, 0x06, 0x80, 0x90,
  0x13, 0xFE, 0x40, 0x48, 0x0B, 0x03, 0x40, 0x48, 0x09, 0x01, 0x20, 0x20,
  0x32, 0x22, 0x26, 0x44, 0x44, 0x4C, 0x88, 0x80, 0x00, 0xC0, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x01, 0x00, 0x40, 0x13, 0x0C, 0xC2,
  0x11, 0x83, 0xC0, 0x20, 0x44, 0x18, 0x86, 0x11, 0x86, 0x60, 0x98, 0x16,
  0x03, 0xC0, 0x6C, 0x08, 0x83, 0x10, 0x41, 0x08, 0x21, 0x02, 0x20, 0x40,
  0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x08, 0x10,
  0x3F, 0x80, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x4C, 0x06, 0x70, 0x29, 0x20,
  0xA4, 0x84, 0x92, 0x12, 0x48, 0x99, 0x22, 0x4C, 0x91, 0x21, 0x44, 0x86,
  0x12, 0x18, 0x48, 0x43, 0x00, 0x30, 0x26, 0x04, 0xC0, 0x94, 0x16, 0x86,
  0x90, 0x91, 0x12, 0x22, 0x44, 0x48, 0x4B, 0x0B, 0x41, 0xC8, 0x19, 0x03,
  0x20, 0x60, 0x0F, 0x06, 0x22, 0x05, 0x81, 0x40, 0x50, 0x14, 0x05, 0x01,
  0xC0, 0x60, 0x38, 0x0A, 0x02, 0x41, 0x18, 0xC3, 0xC0, 0x3F, 0x08, 0x22,
  0x0C, 0x81, 0x60, 0x50, 0x34, 0x09, 0x06, 0x7E, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x81, 0x40, 0x50, 0x14,
  0x07, 0x01, 0xC0, 0x60, 0x38, 0x0A, 0x02, 0xC1, 0x18, 0xC3, 0xC0, 0x08,
  0x03, 0x00, 0x40, 0x3F, 0x08, 0x62, 0x08, 0x83, 0x60, 0xD0, 0x24, 0x09,
  0x04, 0x7E, 0x11, 0x8C, 0x22, 0x08, 0x83, 0x20, 0x48, 0x10, 0x0F, 0x0C,
  0x62, 0x09, 0x02, 0x40, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x48, 0x12,
  0x04, 0x81, 0x31, 0x83, 0xC0, 0xFF, 0x82, 0x00, 0x80, 0x20, 0x18, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x20, 0x64, 0x08, 0x81, 0x30, 0x24, 0x04, 0x80, 0x90, 0x32, 0x04, 0x40,
  0x98, 0x12, 0x02, 0x40, 0xCC, 0x10, 0x86, 0x0F, 0x00, 0x80, 0xE0, 0x28,
  0x0B, 0x04, 0x41, 0x10, 0x84, 0x21, 0x18, 0x44, 0x13, 0x04, 0x80, 0xA0,
  0x30, 0x0C, 0x02, 0x00, 0x81, 0x06, 0x0C, 0x18, 0x30, 0xE1, 0x42, 0x85,
  0x0A, 0x14, 0x6C, 0x91, 0x32, 0x44, 0x51, 0x21, 0x42, 0x85, 0x0A, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x04, 0x08, 0x00, 0x30, 0x21, 0x06, 0x10, 0xC0,
  0x88, 0x09, 0x00, 0xF0, 0x06, 0x00, 0x40, 0x0E, 0x01, 0xA0, 0x13, 0x03,
  0x10, 0x61, 0x04, 0x18, 0x80, 0x80, 0x80, 0xB0, 0x64, 0x11, 0x0C, 0x42,
  0x09, 0x02, 0xC0, 0xA0, 0x30, 0x04, 0x03, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x1F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20,
  0x08, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x3F, 0xE0, 0x1C, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x82, 0x18, 0x41, 0x04, 0x10, 0x43, 0x08,
  0x38, 0x93, 0x24, 0x92, 0x4C, 0x92, 0x49, 0x1C, 0x30, 0x82, 0x08, 0x20,
  0x86, 0x10, 0x41, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x82, 0x38, 0x08, 0x63,
  0x8A, 0x49, 0x18, 0x40, 0xFF, 0xB4, 0x1E, 0x31, 0x21, 0x01, 0x01, 0x1F,
  0x61, 0x43, 0xC2, 0x46, 0x7A, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x78,
  0xC6, 0x41, 0x20, 0x90, 0x50, 0x28, 0x34, 0x12, 0x09, 0x89, 0xB8, 0x3C,
  0x62, 0x42, 0x83, 0x80, 0x80, 0x80, 0x82, 0x84, 0xC4, 0x78, 0x00, 0x80,
  0x40, 0x20, 0x30, 0x11, 0xE9, 0x8C, 0x82, 0xC1, 0x41, 0xA0, 0x90, 0x48,
  0x24, 0x13, 0x18, 0xF8, 0x3C, 0x62, 0x42, 0x83, 0x83, 0xFE, 0x80, 0x80,
  0x80, 0xC4, 0x78, 0x0E, 0x20, 0xC1, 0x02, 0x1F, 0x08, 0x10, 0x60, 0x81,
  0x02, 0x04, 0x08, 0x30, 0x40, 0x1E, 0x98, 0xC8, 0x2C, 0x14, 0x1A, 0x09,
  0x04, 0x82, 0x41, 0x31, 0x8F, 0x80, 0x40, 0x26, 0x21, 0xE0, 0x10, 0x08,
  0x04, 0x02, 0x02, 0x01, 0x78, 0xC4, 0x43, 0x21, 0x90, 0x90, 0x48, 0x24,
  0x12, 0x09, 0x0D, 0x84, 0x24, 0x06, 0x92, 0x5A, 0x49, 0x20, 0x04, 0x10,
  0x00, 0x08, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x41, 0x0C, 0x20, 0x8C,
  0x00, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01, 0x0C, 0x8C, 0x4C, 0x2C, 0x1C,
  0x1E, 0x0D, 0x04, 0x42, 0x21, 0x09, 0x84, 0x24, 0x96, 0x92, 0x4B, 0x49,
  0x24, 0x2F, 0x38, 0xC5, 0x12, 0x18, 0x48, 0x61, 0x61, 0x05, 0x04, 0x14,
  0x10, 0x50, 0x41, 0x41, 0x0D, 0x0C, 0x2C, 0x20, 0x80, 0x2F, 0x18, 0x88,
  0x64, 0x32, 0x13, 0x09, 0x04, 0x82, 0x41, 0x21, 0xB0, 0x80, 0x1C, 0x62,
  0x41, 0xC1, 0x81, 0x81, 0x81, 0x82, 0x82, 0xC4, 0x78, 0x2F, 0x18, 0xC8,
  0x24, 0x12, 0x0A, 0x05, 0x06, 0x82, 0x41, 0x31, 0x37, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x3D, 0x63, 0x41, 0xC1, 0x83, 0x82, 0x82, 0x82, 0x82, 0xC6,
  0x7C, 0x04, 0x04, 0x04, 0x04, 0x2E, 0x60, 0x81, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x83, 0x00, 0x1E, 0x33, 0x21, 0x20, 0x30, 0x0C, 0x06, 0x02, 0x42,
  0x46, 0x3C, 0x21, 0x09, 0xF2, 0x31, 0x08, 0x42, 0x11, 0x84, 0x30, 0x41,
  0x41, 0x41, 0x43, 0x42, 0x82, 0x82, 0x82, 0x86, 0xCE, 0x74, 0x83, 0x42,
  0x42, 0x44, 0x44, 0x48, 0x48, 0x50, 0x30, 0x30, 0x20, 0x84, 0x31, 0x86,
  0x31, 0x4A, 0x29, 0x4D, 0x29, 0x29, 0x25, 0x18, 0xC3, 0x18, 0x42, 0x08,
  0x00, 0x21, 0x11, 0x84, 0x82, 0x81, 0xC0, 0x40, 0x60, 0x48, 0x64, 0x23,
  0x20, 0x80, 0x30, 0xC4, 0x21, 0x08, 0x44, 0x11, 0x04, 0x81, 0x20, 0x50,
  0x0C, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x0E, 0x00, 0x3F, 0x00, 0x80,
  0x80, 0x80, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x60, 0x3F, 0x80, 0x04, 0x21,
  0x04, 0x10, 0xC2, 0x08, 0x21, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x08, 0x11, 0x11, 0x22, 0x22, 0x22, 0x24, 0x44, 0x44, 0x48, 0x10, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x84, 0x10, 0x41, 0x0C, 0x20, 0x84,
  0x20, 0x30, 0x52, 0x18, 0x4A, 0x0C,
};

const GFXglyph RobotoCondensed_LightItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 15, 4, 1, -15 },
  { 7, 4, 5, 6, 2, -16 },
  { 10, 10, 15, 10, 1, -15 },
  { 29, 8, 19, 10, 1, -17 },
  { 48, 10, 15, 13, 2, -15 },
  { 67, 9, 15, 11, 1, -15 },
  { 84, 2, 5, 3, 2, -16 },
  { 86, 6, 22, 6, 1, -17 },
  { 103, 6, 22, 6, -1, -17 },
  { 120, 8, 8, 9, 1, -15 },
  { 128, 8, 11, 10, 1, -12 },
  { 139, 3, 5, 4, -1, -2 },
  { 141, 4, 1, 5, 1, -7 },
  { 142, 2, 2, 5, 0, -2 },
  { 143, 9, 16, 7, -1, -15 },
  { 161, 8, 15, 10, 1, -15 },
  { 176, 5, 15, 10, 3, -15 },
  { 186, 9, 15, 10, 0, -15 },
  { 203, 8, 15, 10, 1, -15 },
  { 218, 9, 15, 10, 0, -15 },
  { 235, 9, 15, 10, 1, -15 },
  { 252, 8, 15, 10, 1, -15 },
  { 267, 8, 15, 10, 2, -15 },
  { 282, 9, 15, 10, 1, -15 },
  { 299, 7, 15, 10, 2, -15 },
  { 313, 4, 11, 4, 0, -11 },
  { 319, 5, 14, 4, -1, -11 },
  { 328, 8, 9, 9, 1, -11 },
  { 337, 8, 5, 10, 1, -9 },
  { 342, 8, 9, 9, 1, -11 },
  { 351, 6, 15, 8, 2, -15 },
  { 363, 14, 20, 16, 1, -15 },
  { 398, 11, 15, 11, -1, -15 },
  { 419, 9, 15, 11, 1, -15 },
  { 436, 10, 15, 12, 1, -15 },
  { 455, 10, 15, 12, 1, -15 },
  { 474, 10, 15, 10, 1, -15 },
  { 493, 10, 15, 10, 1, -15 },
  { 512, 10, 15, 12, 1, -15 },
  { 531, 11, 15, 13, 1, -15 },
  { 552, 4, 15, 5, 1, -15 },
  { 560, 10, 15, 10, 0, -15 },
  { 579, 11, 15, 11, 1, -15 },
  { 600, 7, 15, 9, 1, -15 },
  { 614, 14, 15, 15, 1, -15 },
  { 641, 11, 15, 13, 1, -15 },
  { 662, 10, 15, 12, 1, -15 },
  { 681, 10, 15, 11, 1, -15 },
  { 700, 10, 18, 12, 1, -15 },
  { 723, 10, 15, 11, 1, -15 },
  { 742, 10, 15, 11, 1, -15 },
  { 761, 10, 15, 11, 2, -15 },
  { 780, 11, 15, 12, 1, -15 },
  { 801, 10, 15, 11, 2, -15 },
  { 820, 14, 15, 16, 2, -15 },
  { 847, 12, 15, 11, 0, -15 },
  { 870, 10, 15, 11, 2, -15 },
  { 889, 11, 15, 11, 0, -15 },
  { 910, 6, 20, 5, 0, -17 },
  { 925, 3, 16, 7, 2, -15 },
  { 931, 6, 20, 5, -1, -17 },
  { 946, 6, 7, 8, 1, -15 },
  { 952, 8, 1, 8, -1, 0 },
  { 953, 2, 3, 6, 3, -16 },
  { 954, 8, 11, 10, 0, -11 },
  { 965, 9, 16, 10, 0, -16 },
  { 983, 8, 11, 9, 1, -11 },
  { 994, 9, 16, 10, 1, -16 },
  { 1012, 8, 11, 9, 1, -11 },
  { 1023, 7, 16, 6, 1, -16 },
  { 1037, 9, 15, 10, 0, -11 },
  { 1054, 9, 16, 10, 0, -16 },
  { 1072, 3, 15, 4, 1, -15 },
  { 1078, 6, 19, 4, -2, -15 },
  { 1093, 9, 16, 9, 0, -16 },
  { 1111, 3, 16, 4, 1, -16 },
  { 1117, 14, 11, 16, 0, -11 },
  { 1137, 9, 11, 10, 0, -11 },
  { 1150, 8, 11, 10, 1, -11 },
  { 1161, 9, 15, 10, 0, -11 },
  { 1178, 8, 15, 10, 1, -11 },
  { 1193, 7, 11, 6, 0, -11 },
  { 1203, 8, 11, 9, 0, -11 },
  { 1214, 5, 14, 6, 1, -14 },
  { 1223, 8, 11, 10, 1, -11 },
  { 1234, 8, 11, 9, 1, -11 },
  { 1245, 11, 11, 13, 2, -11 },
  { 1261, 9, 11, 9, 0, -11 },
  { 1274, 10, 15, 9, -1, -11 },
  { 1293, 9, 11, 9, 0, -11 },
  { 1306, 6, 20, 6, 1, -16 },
  { 1321, 4, 18, 5, 0, -15 },
  { 1330, 6, 20, 6, -1, -16 },
  { 1345, 10, 4, 12, 1, -8 },
};

const GFXfont RobotoCondensed_LightItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC21PT7B_H_
