#ifndef _ROBOTOCONDENSED_LIGHTITALIC59PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x73, 0x86, 0x38, 0xE3, 0x8E, 0x30, 0xE7, 0x0E, 0x70, 0xE7,
  0x0C, 0x61, 0xC6, 0x1C, 0x61, 0xCE, 0x18, 0xE1, 0x80, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x0C, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xE0, 0x30, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x18, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0C, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x06, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x18, 0x01, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x80, 0x0C, 0x07,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0x18, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x60, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x1C,
  0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x03,
  0x80, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE3, 0x80, 0x00,
  0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x0C, 0x01, 0x87, 0x00,
  0xC0, 0x18, 0x70, 0x0C, 0x03, 0x86, 0x00, 0xC0, 0x70, 0x60, 0x0C, 0x06,
  0x06, 0x00, 0xC0, 0xE0, 0x60, 0x0C, 0x1C, 0x06, 0x01, 0xC3, 0x80, 0x60,
  0x1C, 0x38, 0x07, 0x03, 0x87, 0x00, 0x70, 0x38, 0xE0, 0x03, 0x87, 0x0E,
  0x00, 0x3F, 0xE1, 0xC0, 0x01, 0xFC, 0x38, 0x00, 0x02, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x3F, 0x80, 0x03, 0x87, 0xFC, 0x00, 0x30, 0xF1, 0xC0, 0x07, 0x1C, 0x0E,
  0x00, 0xE1, 0xC0, 0x60, 0x1C, 0x38, 0x06, 0x01, 0xC3, 0x80, 0x60, 0x38,
  0x38, 0x06, 0x07, 0x03, 0x00, 0x60, 0x70, 0x30, 0x06, 0x0E, 0x03, 0x00,
  0x61, 0xC0, 0x30, 0x06, 0x1C, 0x03, 0x00, 0xE3, 0x80, 0x30, 0x0E, 0x10,
  0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x38, 0x07, 0x00, 0x1E, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0,
  0x1C, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x03,
  0xC0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x0F, 0x80,
  0x01, 0xE7, 0xC0, 0x00, 0x3B, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1E,
  0x70, 0x00, 0x0F, 0x1E, 0x01, 0xC7, 0x83, 0x80, 0x73, 0xC0, 0xF0, 0x1C,
  0xE0, 0x1E, 0x0E, 0x78, 0x03, 0x83, 0x9C, 0x00, 0xF0, 0xEF, 0x00, 0x1C,
  0x73, 0x80, 0x07, 0x9C, 0xE0, 0x00, 0xEF, 0x38, 0x00, 0x3F, 0x8E, 0x00,
  0x07, 0xC3, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x1F, 0x07,
  0x80, 0x0F, 0xC0, 0xF0, 0x0F, 0xF8, 0x3F, 0xFF, 0x8F, 0x07, 0xFF, 0xC1,
  0xC0, 0x7F, 0xC0, 0x78, 0x01, 0x00, 0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xE3,
  0x1C, 0x71, 0xC7, 0x18, 0x60, 0x00, 0x01, 0x00, 0x01, 0x80, 0x01, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x01,
  0x78, 0x1C, 0x1E, 0xFC, 0x31, 0xFD, 0xFF, 0xEF, 0xF0, 0x7F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xCE, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0,
  0x38, 0x07, 0x80, 0x78, 0x0E, 0x00, 0x70, 0x08, 0x00, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x0E, 0x0E, 0x0E,
  0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0xF0, 0xE0, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7B, 0xFE, 0xF2, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3E, 0x03, 0xC0, 0x70, 0x07, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0F, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0,
  0x00, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xF7, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1D,
  0xE0, 0x00, 0x7B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0,
  0x00, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x1E, 0x0E, 0x00,
  0x38, 0x1E, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x3F, 0x3F, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0xF0, 0x0F,
  0xC1, 0xFF, 0x1F, 0xFD, 0xFC, 0xE7, 0xC3, 0x98, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0F,
  0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0xE3, 0xC0, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x38, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x0F, 0x00, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x7E, 0x00, 0x0E, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0xFC, 0x03,
  0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x0F, 0xC0, 0x38,
  0xFF, 0xC0, 0xEF, 0xFF, 0x83, 0xFC, 0x1F, 0x0F, 0xC0, 0x3C, 0x7E, 0x00,
  0x79, 0xF0, 0x01, 0xE7, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xF0, 0x00, 0x73, 0xC0, 0x01,
  0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x78, 0x01, 0xE0, 0xE0, 0x0F, 0x03,
  0xC0, 0x7C, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x3C, 0x00,
  0x1C, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0E,
  0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x07,
  0x81, 0xE0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0x80, 0xF0, 0x3C, 0x01,
  0xC1, 0xE0, 0x07, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0xDE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xE7, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x79, 0xC0, 0x01, 0xE7, 0x80, 0x0F, 0x9E,
  0x00, 0x7E, 0x3C, 0x03, 0xF0, 0xF8, 0x3D, 0xC1, 0xFF, 0xE7, 0x03, 0xFF,
  0x3C, 0x03, 0xF0, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF8, 0x3E, 0x0F, 0x00, 0x80, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x10, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x1E,
  0x07, 0x8F, 0x00, 0xE7, 0x80, 0x3D, 0xC0, 0x07, 0x70, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x06, 0x03, 0x80, 0x0F, 0xC0, 0x06, 0x03, 0x80,
  0x1F, 0xF0, 0x07, 0x07, 0x00, 0x7F, 0xF8, 0x07, 0x0E, 0x00, 0xF0, 0x3C,
  0x07, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x38, 0x07, 0x00,
  0x38, 0x07, 0x38, 0x07, 0x00, 0x30, 0x07, 0x38, 0x06, 0x00, 0x70, 0x07,
  0x30, 0x0E, 0x00, 0x70, 0x07, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x70, 0x0E,
  0x00, 0x60, 0x06, 0x70, 0x1C, 0x00, 0xE0, 0x06, 0x60, 0x1C, 0x00, 0xE0,
  0x06, 0x60, 0x1C, 0x00, 0xE0, 0x0E, 0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0xE0,
  0x1C, 0x00, 0xC0, 0x0C, 0xE0, 0x18, 0x01, 0xC0, 0x0C, 0xE0, 0x38, 0x01,
  0xC0, 0x1C, 0xE0, 0x38, 0x03, 0xC0, 0x18, 0xE0, 0x38, 0x03, 0xC0, 0x38,
  0xE0, 0x18, 0x07, 0xC0, 0x30, 0xE0, 0x1C, 0x0F, 0xC0, 0x70, 0xE0, 0x1C,
  0x1D, 0xC0, 0xE0, 0xE0, 0x1F, 0x38, 0xE1, 0xC0, 0xE0, 0x0F, 0xF0, 0xFF,
  0x80, 0x60, 0x0F, 0xE0, 0x7F, 0x00, 0x60, 0x01, 0x00, 0x18, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x02, 0x00, 0x00, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x38, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0xC0, 0x3C, 0x00,
  0x7C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x03,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x38, 0x01, 0xF8,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0x70, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0F,
  0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xC0,
  0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x7C, 0x03, 0xC0, 0x1F,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFC, 0xF0, 0x03, 0xFF, 0xCF, 0x00,
  0x7F, 0xFC, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x70, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F,
  0x00, 0x0F, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x7C, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x01,
  0xE0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x03, 0x80, 0x0F,
  0x80, 0x03, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x07, 0x00, 0xF8, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x0E, 0x7C, 0x00,
  0x00, 0x0E, 0xFE, 0x00, 0x00, 0x1F, 0xEE, 0x00, 0x00, 0x1F, 0xCF, 0x00,
  0x00, 0x1F, 0x87, 0x00, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x00, 0xEE, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x07,
  0x38, 0x00, 0x01, 0xCE, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x07, 0x38, 0x00,
  0x03, 0x9C, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x07, 0x38, 0x00, 0x07, 0x1C,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x0F, 0x1C, 0x00, 0x0E, 0x3C, 0x0E, 0x1C,
  0x00, 0x0E, 0x38, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x0E, 0x1C, 0x00, 0x1C,
  0x38, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x0E, 0x0E, 0x00, 0x78, 0x78, 0x1E,
  0x0E, 0x00, 0x70, 0x78, 0x1C, 0x0E, 0x00, 0xF0, 0x70, 0x1C, 0x0E, 0x00,
  0xE0, 0x70, 0x1C, 0x0E, 0x01, 0xE0, 0x70, 0x1C, 0x0E, 0x01, 0xC0, 0x70,
  0x3C, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x03, 0x80, 0xF0, 0x38, 0x07,
  0x07, 0x80, 0xE0, 0x38, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x0F, 0x00,
  0xE0, 0x38, 0x07, 0x0E, 0x00, 0xE0, 0x78, 0x03, 0x9E, 0x01, 0xE0, 0x78,
  0x03, 0x9C, 0x01, 0xC0, 0x70, 0x03, 0xBC, 0x01, 0xC0, 0x70, 0x03, 0xB8,
  0x01, 0xC0, 0x70, 0x03, 0xF8, 0x01, 0xC0, 0x70, 0x03, 0xF0, 0x03, 0xC0,
  0xF0, 0x01, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0xE0, 0x01,
  0xE0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x00,
  0xE0, 0x3F, 0x00, 0x00, 0x70, 0x1F, 0x80, 0x00, 0x38, 0x0F, 0xE0, 0x00,
  0x3C, 0x07, 0x70, 0x00, 0x1C, 0x03, 0xB8, 0x00, 0x0E, 0x03, 0xCE, 0x00,
  0x07, 0x01, 0xE7, 0x00, 0x03, 0x80, 0xE3, 0x80, 0x03, 0xC0, 0x70, 0xE0,
  0x01, 0xE0, 0x38, 0x70, 0x00, 0xE0, 0x1C, 0x3C, 0x00, 0x70, 0x1E, 0x0E,
  0x00, 0x38, 0x0F, 0x07, 0x00, 0x1C, 0x07, 0x03, 0xC0, 0x1E, 0x03, 0x80,
  0xE0, 0x0F, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0,
  0x0E, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xF0, 0x1C,
  0x00, 0xE0, 0x78, 0x0E, 0x00, 0x78, 0x38, 0x0F, 0x00, 0x1C, 0x1C, 0x07,
  0x80, 0x0E, 0x0E, 0x03, 0x80, 0x07, 0x87, 0x01, 0xC0, 0x01, 0xC7, 0x80,
  0xE0, 0x00, 0xE3, 0x80, 0x70, 0x00, 0x39, 0xC0, 0x78, 0x00, 0x1C, 0xE0,
  0x3C, 0x00, 0x0E, 0x70, 0x1C, 0x00, 0x03, 0xB8, 0x0E, 0x00, 0x01, 0xFC,
  0x07, 0x00, 0x00, 0xFC, 0x03, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x78,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F,
  0x38, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x38, 0x70, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF8, 0x0F, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0,
  0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x63, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0xFC, 0x03, 0xC0, 0x03, 0xC0, 0x38,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xC0, 0x0E, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x03, 0x80,
  0x07, 0x00, 0x38, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00, 0x38,
  0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0x80, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x80,
  0x07, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xE0,
  0x00, 0x3C, 0x00, 0x0E, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0xE0, 0x00, 0x7C,
  0x00, 0x1E, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0xE0, 0x00, 0xFC, 0x00, 0x1C,
  0xE0, 0x00, 0xFC, 0x00, 0x3C, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0xF0, 0x01,
  0xCC, 0x00, 0x38, 0xF0, 0x03, 0x8C, 0x00, 0x78, 0xF0, 0x03, 0x8C, 0x00,
  0x70, 0xF0, 0x03, 0x8E, 0x00, 0xF0, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0x70,
  0x07, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x0E, 0x01, 0xE0, 0x70, 0x0E, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0xC0,
  0x70, 0x1C, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0x70, 0x38,
  0x0E, 0x07, 0x80, 0x70, 0x38, 0x06, 0x07, 0x00, 0x70, 0x70, 0x06, 0x07,
  0x00, 0x70, 0x70, 0x06, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0xC0, 0x07, 0x3C, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0x33, 0x00,
  0x07, 0x70, 0x00, 0x37, 0x00, 0x07, 0x70, 0x00, 0x37, 0x00, 0x03, 0x60,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xE0,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00,
  0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xDC, 0x01, 0xDC, 0x03, 0x8C, 0x03, 0x8C, 0x07, 0x0E, 0x07, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x0E, 0x1C, 0x06, 0x38, 0x06, 0x38, 0x07,
  0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x80, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3C,
  0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0x1E, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0x00, 0x70, 0xF8, 0x00, 0xE1, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x8E,
  0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xE0,
  0x01, 0xE3, 0xC0, 0x07, 0xC3, 0x80, 0x1F, 0x87, 0x80, 0xFF, 0x07, 0xFF,
  0xDE, 0x0F, 0xFF, 0x3C, 0x07, 0xF8, 0x78, 0x01, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x8F, 0xF0, 0x07, 0x3F, 0xF8, 0x07, 0x7F, 0xFC, 0x07, 0xE0,
  0x3E, 0x07, 0xC0, 0x1E, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x1C, 0x00,
  0x0F, 0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x38, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0x77, 0x01,
  0xF0, 0x77, 0xFF, 0xE0, 0xE3, 0xFF, 0xC0, 0xE0, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0x80, 0x78, 0x3C, 0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x00, 0x07, 0x3C,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDE, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x03,
  0x87, 0x00, 0x1E, 0x1E, 0x00, 0x70, 0x3C, 0x07, 0x80, 0xFE, 0xFE, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x3F, 0xE1, 0xC0, 0x1F, 0xFC, 0x70, 0x1F, 0xFF, 0x9C,
  0x07, 0x80, 0xEF, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x03, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x0F, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x07, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xCE, 0x00, 0x3F, 0xE3, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFE, 0xFC, 0x07, 0x80,
  0x78, 0x3C, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0F, 0x3C, 0x00, 0x1C,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x04, 0x1E, 0x00, 0x30, 0x3C, 0x03, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x70,
  0x07, 0xFF, 0x1C, 0x07, 0xFF, 0xE7, 0x01, 0xE0, 0x3B, 0xC0, 0xF0, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x01, 0xF0,
  0x0F, 0x01, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xF3, 0x80, 0x0F, 0xF8,
  0xE0, 0x00, 0x20, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x06, 0x00, 0x1E, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x08, 0x00, 0xF1, 0xFE, 0x01, 0xCF, 0xFE, 0x03,
  0xBF, 0xFE, 0x07, 0xF0, 0x3C, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x7C,
  0x00, 0x70, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x1E, 0x00, 0x1E,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC7,
  0x80, 0x03, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x80, 0x00,
  0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x78,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x78,
  0x00, 0xE0, 0x78, 0x00, 0x70, 0x78, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x78,
  0x00, 0x0E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x7C, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xF9, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0x38, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x07,
  0x00, 0xE0, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x3C, 0x00, 0x38,
  0x1C, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x0E, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1C, 0xFF, 0xE0, 0xFF, 0xE0, 0x3B, 0xFF, 0xE3, 0xFF,
  0xE0, 0x7E, 0x03, 0xCF, 0x03, 0xC0, 0xF8, 0x03, 0xF8, 0x03, 0xC3, 0xE0,
  0x07, 0xE0, 0x03, 0x87, 0x80, 0x07, 0xC0, 0x07, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0xC0,
  0x01, 0xC7, 0x00, 0x07, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x00, 0x0F, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x00, 0x38, 0xF0, 0x00, 0xF0,
  0x00, 0x71, 0xC0, 0x01, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x80, 0x03, 0xC7,
  0x00, 0x07, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x78, 0x00, 0x78, 0x00, 0x38, 0xE0, 0x00, 0xF0, 0x00, 0x71,
  0xC0, 0x01, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0x80, 0x03, 0xC7, 0x00, 0x07,
  0x00, 0x07, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x80, 0x0F, 0x1F, 0xE0, 0x1C,
  0xFF, 0xE0, 0x3B, 0xFF, 0xE0, 0x7F, 0x03, 0xC0, 0xF8, 0x03, 0xC1, 0xE0,
  0x07, 0x87, 0xC0, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0x71,
  0xE0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x7C, 0x07, 0x81, 0xE0, 0x07, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0F,
  0x1C, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x77,
  0x80, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xEF, 0x00,
  0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x78, 0xE0, 0x00, 0xE1, 0xE0, 0x03, 0xC1, 0xC0, 0x0F, 0x03, 0xC0, 0x3C,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x71, 0xFF, 0x00, 0x1C, 0xFF, 0xE0, 0x07, 0x7F,
  0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x0F,
  0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xF0,
  0x00, 0x38, 0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0x81, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x1D, 0x80, 0x7C, 0x07, 0x7E,
  0xFE, 0x03, 0xCF, 0xFF, 0x00, 0xE0, 0xFF, 0x00, 0x38, 0x06, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x87, 0x03, 0xFF, 0xC7, 0x07, 0xFF, 0xE7, 0x07,
  0x80, 0x7F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C,
  0x00, 0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70,
  0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0,
  0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x3C,
  0x07, 0xE0, 0x3F, 0xBF, 0xE0, 0x1F, 0xFE, 0xE0, 0x0F, 0xF8, 0xE0, 0x00,
  0x81, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0x01, 0xE7, 0xE0, 0x73, 0xF8, 0x1D, 0xFE, 0x07, 0xF0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0,
  0x78, 0x1C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0xC0, 0x03, 0xC7, 0x00,
  0x0E, 0x1E, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x80, 0x1E,
  0x00, 0x0E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0,
  0x01, 0xC7, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03,
  0x8E, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71,
  0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xE1, 0xE0,
  0x07, 0x83, 0xC0, 0x1F, 0x03, 0xC0, 0x7E, 0x07, 0xFF, 0xDC, 0x07, 0xFF,
  0x38, 0x07, 0xFC, 0xF0, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x78, 0x00, 0xF1, 0xC0,
  0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xC0,
  0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x03,
  0x80, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x30, 0xE0, 0x01,
  0xC7, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0x70,
  0x00, 0xE7, 0x00, 0x3E, 0x00, 0x79, 0xC0, 0x0F, 0x80, 0x1C, 0x70, 0x03,
  0xE0, 0x07, 0x1C, 0x01, 0xF8, 0x03, 0x87, 0x00, 0x7E, 0x00, 0xE1, 0xC0,
  0x3B, 0x80, 0x78, 0x70, 0x0E, 0xE0, 0x1C, 0x1C, 0x07, 0x38, 0x07, 0x07,
  0x01, 0xCE, 0x03, 0x81, 0xC0, 0x73, 0x80, 0xE0, 0x70, 0x38, 0x60, 0x78,
  0x1C, 0x0E, 0x18, 0x1C, 0x07, 0x07, 0x07, 0x07, 0x01, 0xC1, 0xC1, 0xC3,
  0x80, 0x70, 0xE0, 0x70, 0xE0, 0x1C, 0x38, 0x1C, 0x78, 0x03, 0x0E, 0x07,
  0x1C, 0x00, 0xE7, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x73, 0x80, 0x0E, 0xE0,
  0x1C, 0xE0, 0x03, 0xB8, 0x07, 0x70, 0x00, 0xFC, 0x00, 0xDC, 0x00, 0x3F,
  0x00, 0x37, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x78, 0x0F,
  0x00, 0x0E, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C,
  0x78, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x0F,
  0x01, 0xC0, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x03, 0xC0,
  0x3C, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x01, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0,
  0x3C, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03,
  0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x1F,
  0xF8, 0x00, 0x63, 0xE3, 0xC0, 0x0E, 0x38, 0x1E, 0x00, 0xE7, 0x00, 0xF0,
  0x0E, 0x70, 0x07, 0x81, 0xC7, 0x00, 0x3C, 0x3C, 0xE0, 0x01, 0xFF, 0x8E,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 11, 43, 12, 1, -42 },
  { 61, 12, 13, 16, 6, -44 },
  { 81, 29, 42, 29, 2, -42 },
  { 234, 25, 55, 28, 2, -49 },
  { 406, 28, 44, 37, 5, -43 },
  { 560, 26, 44, 31, 2, -43 },
  { 703, 6, 13, 10, 5, -44 },
  { 713, 17, 61, 17, 3, -47 },
  { 843, 17, 61, 17, -3, -47 },
  { 973, 23, 24, 24, 3, -42 },
  { 1042, 25, 30, 28, 2, -34 },
  { 1136, 8, 13, 11, -2, -6 },
  { 1149, 11, 3, 15, 2, -20 },
  { 1154, 5, 5, 14, 1, -4 },
  { 1158, 26, 46, 20, -3, -42 },
  { 1308, 23, 44, 28, 3, -43 },
  { 1435, 14, 42, 28, 7, -42 },
  { 1509, 25, 43, 28, 1, -43 },
  { 1644, 24, 44, 28, 2, -43 },
  { 1776, 25, 42, 28, 1, -42 },
  { 1908, 25, 43, 28, 3, -42 },
  { 2043, 22, 43, 28, 3, -42 },
  { 2162, 25, 42, 28, 4, -42 },
  { 2294, 25, 44, 28, 2, -43 },
  { 2432, 22, 43, 28, 4, -43 },
  { 2551, 10, 32, 12, 1, -31 },
  { 2591, 12, 38, 11, -2, -31 },
  { 2648, 22, 24, 26, 2, -31 },
  { 2714, 22, 15, 28, 3, -27 },
  { 2756, 22, 24, 26, 2, -31 },
  { 2822, 18, 44, 23, 5, -43 },
  { 2921, 40, 54, 45, 2, -41 },
  { 3191, 29, 42, 31, -2, -42 },
  { 3344, 27, 42, 31, 2, -42 },
  { 3486, 28, 44, 32, 3, -43 },
  { 3640, 29, 42, 33, 2, -42 },
  { 3793, 28, 42, 28, 2, -42 },
  { 3940, 28, 42, 28, 2, -42 },
  { 4087, 28, 44, 34, 4, -43 },
  { 4241, 33, 42, 35, 2, -42 },
  { 4415, 11, 42, 14, 2, -42 },
  { 4473, 26, 43, 28, 1, -42 },
  { 4613, 32, 42, 31, 2, -42 },
  { 4781, 20, 42, 27, 2, -42 },
  { 4886, 40, 42, 43, 2, -42 },
  { 5096, 33, 42, 35, 2, -42 },
  { 5270, 29, 44, 34, 3, -43 },
  { 5430, 29, 42, 31, 2, -42 },
  { 5583, 29, 50, 34, 3, -43 },
  { 5765, 28, 42, 31, 2, -42 },
  { 5912, 29, 44, 30, 1, -43 },
  { 6072, 27, 42, 30, 5, -42 },
  { 6214, 30, 43, 33, 3, -42 },
  { 6376, 29, 42, 31, 5, -42 },
  { 6529, 40, 42, 44, 6, -42 },
  { 6739, 34, 42, 31, -1, -42 },
  { 6918, 28, 42, 30, 5, -42 },
  { 7065, 31, 42, 30, 0, -42 },
  { 7228, 17, 57, 13, 0, -48 },
  { 7350, 9, 46, 20, 6, -42 },
  { 7402, 17, 57, 13, -4, -48 },
  { 7524, 16, 21, 21, 3, -42 },
  { 7566, 22, 3, 22, -3, 0 },
  { 7575, 8, 8, 16, 7, -44 },
  { 7583, 23, 33, 27, 1, -32 },
  { 7678, 24, 45, 28, 1, -44 },
  { 7813, 22, 33, 26, 2, -32 },
  { 7904, 26, 45, 28, 2, -44 },
  { 8051, 22, 33, 26, 2, -32 },
  { 8142, 19, 45, 17, 3, -45 },
  { 8249, 26, 44, 28, 0, -32 },
  { 8392, 23, 44, 28, 1, -44 },
  { 8519, 11, 43, 12, 1, -43 },
  { 8579, 19, 55, 12, -7, -43 },
  { 8710, 25, 44, 25, 1, -44 },
  { 8848, 11, 44, 12, 1, -44 },
  { 8909, 39, 32, 44, 1, -32 },
  { 9065, 23, 32, 28, 1, -32 },
  { 9157, 23, 33, 28, 2, -32 },
  { 9252, 26, 44, 28, -1, -32 },
  { 9395, 24, 44, 28, 2, -32 },
  { 9527, 18, 32, 17, 1, -32 },
  { 9599, 22, 33, 26, 1, -32 },
  { 9690, 13, 40, 17, 3, -39 },
  { 9755, 23, 32, 28, 3, -31 },
  { 9847, 21, 31, 24, 4, -31 },
  { 9929, 34, 31, 37, 4, -31 },
  { 10061, 26, 31, 25, -1, -31 },
  { 10162, 27, 43, 24, -2, -31 },
  { 10308, 24, 31, 25, 0, -31 },
  { 10401, 18, 58, 17, 2, -46 },
  { 10532, 11, 50, 13, 1, -42 },
  { 10601, 18, 58, 17, -3, -46 },
  { 10732, 28, 11, 34, 3, -23 },
};

const GFXfont RobotoCondensed_LightItalic59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC59PT7B_H_
