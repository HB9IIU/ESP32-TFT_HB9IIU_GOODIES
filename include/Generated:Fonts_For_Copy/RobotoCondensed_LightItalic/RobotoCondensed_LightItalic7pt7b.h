#ifndef _ROBOTOCONDENSED_LIGHTITALIC7PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0x00, 0x07, 0x6E, 0x00, 0x0A, 0x23, 0xC0, 0x99, 0x76, 0x6D,
  0x5E, 0x00, 0x1A, 0xA8, 0x15, 0x68, 0x0A, 0x00, 0x1D, 0x20, 0x80, 0x00,
  0x80, 0x09, 0x48, 0x76, 0xDE, 0x9A, 0x80, 0x24, 0xAC, 0x25, 0x1E, 0x25,
  0xF0, 0x48, 0x96, 0x52, 0xDE, 0x56, 0x00, 0x75, 0x5E, 0xFD, 0x80, 0x10,
  0x10, 0x39, 0x00, 0x1C, 0x07, 0x00, 0x58, 0x00, 0x33, 0x67, 0xBD, 0x41,
  0x00, 0x2D, 0xF0, 0x6D, 0xDE, 0x79, 0x88, 0xE0, 0x25, 0x99, 0xE0, 0x24,
  0x68, 0xC0, 0x24, 0x68, 0x80, 0x78, 0x88, 0xE0, 0x05, 0x79, 0x80, 0x1A,
  0x80, 0x04, 0x9E, 0x16, 0x4A, 0x80, 0x0A, 0x4C, 0x4A, 0x77, 0xDA, 0x00,
  0x45, 0xBB, 0x90, 0x79, 0x99, 0xE0, 0x75, 0xA8, 0x80, 0x79, 0x99, 0xE2,
  0x79, 0xAA, 0x80, 0x48, 0x42, 0xE0, 0x4A, 0x48, 0x19, 0x99, 0xE0, 0x37,
  0x48, 0x06, 0xAD, 0x4A, 0x00, 0x16, 0x46, 0xA0, 0x3A, 0x48, 0x32, 0x44,
  0xC0, 0x5A, 0xA0, 0x78, 0x56, 0xA8, 0x58, 0x00, 0x80, 0x66, 0xC0, 0x0E,
  0xDE, 0x72, 0x60, 0x0E, 0xDA, 0x77, 0x40, 0x5A, 0x48, 0x56, 0xD4, 0x0E,
  0xDA, 0x38, 0x05, 0x50, 0x15, 0x68, 0x78, 0x7D, 0x6B, 0x40, 0x76, 0xD0,
  0x76, 0xD0, 0x76, 0xF0, 0x56, 0xD0, 0x6A, 0x51, 0xF0, 0x3A, 0x80, 0x16,
  0xF0, 0xB7, 0x20, 0x5E, 0x80, 0x29, 0x40, 0xB7, 0x28, 0x00, 0x69, 0x40,
  0x50, 0x80, 0x7C, 0x10, 0xA0, 0x52,
};

const GFXglyph RobotoCondensed_LightItalic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 5, 1, 0, -5 },
  { 2, 1, 1, 2, 1, -5 },
  { 3, 4, 5, 3, 0, -5 },
  { 6, 3, 7, 3, 0, -6 },
  { 9, 3, 5, 4, 1, -5 },
  { 11, 3, 5, 4, 0, -5 },
  { 13, 1, 1, 1, 0, -5 },
  { 14, 2, 8, 2, 0, -6 },
  { 16, 2, 8, 2, 0, -6 },
  { 18, 3, 3, 3, 0, -5 },
  { 20, 3, 4, 3, 0, -4 },
  { 22, 1, 2, 1, 0, -1 },
  { 23, 2, 1, 2, 0, -3 },
  { 24, 1, 1, 2, 0, -1 },
  { 25, 3, 5, 2, 0, -5 },
  { 27, 3, 5, 3, 0, -5 },
  { 29, 2, 5, 3, 1, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 2, 5, 3, 1, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 2, 5, 3, 1, -5 },
  { 47, 1, 4, 1, 0, -4 },
  { 48, 1, 5, 1, 0, -4 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 3, 2, 3, 0, -3 },
  { 52, 3, 3, 3, 0, -4 },
  { 54, 2, 5, 3, 1, -5 },
  { 56, 5, 7, 5, 0, -5 },
  { 61, 3, 5, 4, 0, -5 },
  { 63, 3, 5, 4, 0, -5 },
  { 65, 4, 5, 4, 0, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 3, 0, -5 },
  { 74, 4, 5, 3, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 2, 5, 2, 0, -5 },
  { 85, 3, 5, 3, 0, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 3, 5, 3, 0, -5 },
  { 92, 5, 5, 5, 0, -5 },
  { 96, 4, 5, 4, 0, -5 },
  { 99, 4, 5, 4, 0, -5 },
  { 102, 4, 5, 4, 0, -5 },
  { 105, 4, 6, 4, 0, -5 },
  { 108, 4, 5, 4, 0, -5 },
  { 111, 4, 5, 4, 0, -5 },
  { 114, 3, 5, 4, 1, -5 },
  { 116, 4, 5, 4, 0, -5 },
  { 119, 3, 5, 4, 1, -5 },
  { 121, 5, 5, 5, 1, -5 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 3, 5, 4, 1, -5 },
  { 130, 4, 5, 4, 0, -5 },
  { 133, 2, 7, 2, 0, -6 },
  { 135, 1, 5, 2, 1, -5 },
  { 136, 2, 7, 2, 0, -6 },
  { 138, 2, 3, 3, 0, -5 },
  { 139, 2, 1, 3, 0, 0 },
  { 140, 1, 1, 2, 1, -5 },
  { 141, 3, 4, 3, 0, -4 },
  { 143, 3, 5, 3, 0, -5 },
  { 145, 3, 4, 3, 0, -4 },
  { 147, 3, 5, 3, 0, -5 },
  { 149, 3, 4, 3, 0, -4 },
  { 151, 3, 5, 2, 0, -5 },
  { 153, 3, 5, 3, 0, -4 },
  { 155, 3, 5, 3, 0, -5 },
  { 157, 1, 5, 1, 0, -5 },
  { 158, 2, 7, 1, -1, -5 },
  { 160, 3, 5, 3, 0, -5 },
  { 162, 1, 5, 1, 0, -5 },
  { 163, 5, 4, 5, 0, -4 },
  { 166, 3, 4, 3, 0, -4 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 3, 5, 3, 0, -4 },
  { 172, 3, 5, 3, 0, -4 },
  { 174, 2, 4, 2, 0, -4 },
  { 175, 3, 4, 3, 0, -4 },
  { 177, 2, 5, 2, 0, -5 },
  { 179, 3, 4, 3, 0, -4 },
  { 181, 3, 4, 3, 0, -4 },
  { 183, 3, 4, 4, 1, -4 },
  { 185, 3, 4, 3, 0, -4 },
  { 187, 3, 6, 3, 0, -4 },
  { 190, 3, 4, 3, 0, -4 },
  { 192, 2, 6, 2, 0, -5 },
  { 194, 1, 6, 2, 0, -5 },
  { 195, 2, 6, 2, 0, -5 },
  { 197, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoCondensed_LightItalic7pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic7pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic7pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC7PT7B_H_
