#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &RobotoCondensed_LightItalic6pt7b, 6, "RobotoCondensed_LightItalic6pt7b" },
  { &RobotoCondensed_LightItalic7pt7b, 7, "RobotoCondensed_LightItalic7pt7b" },
  { &RobotoCondensed_LightItalic8pt7b, 8, "RobotoCondensed_LightItalic8pt7b" },
  { &RobotoCondensed_LightItalic9pt7b, 9, "RobotoCondensed_LightItalic9pt7b" },
  { &RobotoCondensed_LightItalic10pt7b, 10, "RobotoCondensed_LightItalic10pt7b" },
  { &RobotoCondensed_LightItalic11pt7b, 11, "RobotoCondensed_LightItalic11pt7b" },
  { &RobotoCondensed_LightItalic12pt7b, 12, "RobotoCondensed_LightItalic12pt7b" },
  { &RobotoCondensed_LightItalic13pt7b, 13, "RobotoCondensed_LightItalic13pt7b" },
  { &RobotoCondensed_LightItalic14pt7b, 14, "RobotoCondensed_LightItalic14pt7b" },
  { &RobotoCondensed_LightItalic15pt7b, 15, "RobotoCondensed_LightItalic15pt7b" },
  { &RobotoCondensed_LightItalic16pt7b, 16, "RobotoCondensed_LightItalic16pt7b" },
  { &RobotoCondensed_LightItalic17pt7b, 17, "RobotoCondensed_LightItalic17pt7b" },
  { &RobotoCondensed_LightItalic18pt7b, 18, "RobotoCondensed_LightItalic18pt7b" },
  { &RobotoCondensed_LightItalic19pt7b, 19, "RobotoCondensed_LightItalic19pt7b" },
  { &RobotoCondensed_LightItalic20pt7b, 20, "RobotoCondensed_LightItalic20pt7b" },
  { &RobotoCondensed_LightItalic21pt7b, 21, "RobotoCondensed_LightItalic21pt7b" },
  { &RobotoCondensed_LightItalic22pt7b, 22, "RobotoCondensed_LightItalic22pt7b" },
  { &RobotoCondensed_LightItalic23pt7b, 23, "RobotoCondensed_LightItalic23pt7b" },
  { &RobotoCondensed_LightItalic24pt7b, 24, "RobotoCondensed_LightItalic24pt7b" },
  { &RobotoCondensed_LightItalic25pt7b, 25, "RobotoCondensed_LightItalic25pt7b" },
  { &RobotoCondensed_LightItalic26pt7b, 26, "RobotoCondensed_LightItalic26pt7b" },
  { &RobotoCondensed_LightItalic27pt7b, 27, "RobotoCondensed_LightItalic27pt7b" },
  { &RobotoCondensed_LightItalic28pt7b, 28, "RobotoCondensed_LightItalic28pt7b" },
  { &RobotoCondensed_LightItalic29pt7b, 29, "RobotoCondensed_LightItalic29pt7b" },
  { &RobotoCondensed_LightItalic30pt7b, 30, "RobotoCondensed_LightItalic30pt7b" },
  { &RobotoCondensed_LightItalic31pt7b, 31, "RobotoCondensed_LightItalic31pt7b" },
  { &RobotoCondensed_LightItalic32pt7b, 32, "RobotoCondensed_LightItalic32pt7b" },
  { &RobotoCondensed_LightItalic33pt7b, 33, "RobotoCondensed_LightItalic33pt7b" },
  { &RobotoCondensed_LightItalic34pt7b, 34, "RobotoCondensed_LightItalic34pt7b" },
  { &RobotoCondensed_LightItalic35pt7b, 35, "RobotoCondensed_LightItalic35pt7b" },
  { &RobotoCondensed_LightItalic36pt7b, 36, "RobotoCondensed_LightItalic36pt7b" },
  { &RobotoCondensed_LightItalic37pt7b, 37, "RobotoCondensed_LightItalic37pt7b" },
  { &RobotoCondensed_LightItalic38pt7b, 38, "RobotoCondensed_LightItalic38pt7b" },
  { &RobotoCondensed_LightItalic39pt7b, 39, "RobotoCondensed_LightItalic39pt7b" },
  { &RobotoCondensed_LightItalic40pt7b, 40, "RobotoCondensed_LightItalic40pt7b" },
  { &RobotoCondensed_LightItalic41pt7b, 41, "RobotoCondensed_LightItalic41pt7b" },
  { &RobotoCondensed_LightItalic42pt7b, 42, "RobotoCondensed_LightItalic42pt7b" },
  { &RobotoCondensed_LightItalic43pt7b, 43, "RobotoCondensed_LightItalic43pt7b" },
  { &RobotoCondensed_LightItalic44pt7b, 44, "RobotoCondensed_LightItalic44pt7b" },
  { &RobotoCondensed_LightItalic45pt7b, 45, "RobotoCondensed_LightItalic45pt7b" },
  { &RobotoCondensed_LightItalic46pt7b, 46, "RobotoCondensed_LightItalic46pt7b" },
  { &RobotoCondensed_LightItalic47pt7b, 47, "RobotoCondensed_LightItalic47pt7b" },
  { &RobotoCondensed_LightItalic48pt7b, 48, "RobotoCondensed_LightItalic48pt7b" },
  { &RobotoCondensed_LightItalic49pt7b, 49, "RobotoCondensed_LightItalic49pt7b" },
  { &RobotoCondensed_LightItalic50pt7b, 50, "RobotoCondensed_LightItalic50pt7b" },
  { &RobotoCondensed_LightItalic51pt7b, 51, "RobotoCondensed_LightItalic51pt7b" },
  { &RobotoCondensed_LightItalic52pt7b, 52, "RobotoCondensed_LightItalic52pt7b" },
  { &RobotoCondensed_LightItalic53pt7b, 53, "RobotoCondensed_LightItalic53pt7b" },
  { &RobotoCondensed_LightItalic54pt7b, 54, "RobotoCondensed_LightItalic54pt7b" },
  { &RobotoCondensed_LightItalic55pt7b, 55, "RobotoCondensed_LightItalic55pt7b" },
  { &RobotoCondensed_LightItalic56pt7b, 56, "RobotoCondensed_LightItalic56pt7b" },
  { &RobotoCondensed_LightItalic57pt7b, 57, "RobotoCondensed_LightItalic57pt7b" },
  { &RobotoCondensed_LightItalic58pt7b, 58, "RobotoCondensed_LightItalic58pt7b" },
  { &RobotoCondensed_LightItalic59pt7b, 59, "RobotoCondensed_LightItalic59pt7b" },
  { &RobotoCondensed_LightItalic60pt7b, 60, "RobotoCondensed_LightItalic60pt7b" },
  { &RobotoCondensed_LightItalic61pt7b, 61, "RobotoCondensed_LightItalic61pt7b" },
  { &RobotoCondensed_LightItalic62pt7b, 62, "RobotoCondensed_LightItalic62pt7b" },
  { &RobotoCondensed_LightItalic63pt7b, 63, "RobotoCondensed_LightItalic63pt7b" },
  { &RobotoCondensed_LightItalic64pt7b, 64, "RobotoCondensed_LightItalic64pt7b" },
  { &RobotoCondensed_LightItalic65pt7b, 65, "RobotoCondensed_LightItalic65pt7b" },
  { &RobotoCondensed_LightItalic66pt7b, 66, "RobotoCondensed_LightItalic66pt7b" },
  { &RobotoCondensed_LightItalic67pt7b, 67, "RobotoCondensed_LightItalic67pt7b" },
  { &RobotoCondensed_LightItalic68pt7b, 68, "RobotoCondensed_LightItalic68pt7b" },
  { &RobotoCondensed_LightItalic69pt7b, 69, "RobotoCondensed_LightItalic69pt7b" },
  { &RobotoCondensed_LightItalic70pt7b, 70, "RobotoCondensed_LightItalic70pt7b" },
  { &RobotoCondensed_LightItalic71pt7b, 71, "RobotoCondensed_LightItalic71pt7b" },
  { &RobotoCondensed_LightItalic72pt7b, 72, "RobotoCondensed_LightItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
