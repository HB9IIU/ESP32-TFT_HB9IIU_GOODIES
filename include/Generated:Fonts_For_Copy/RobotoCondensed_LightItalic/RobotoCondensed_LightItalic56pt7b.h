#ifndef _ROBOTOCONDENSED_LIGHTITALIC56PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x0F, 0x01, 0xC0, 0x00, 0x00, 0x30, 0xE6, 0x1D, 0xC3, 0x38, 0xE7, 0x1C,
  0xE3, 0x98, 0x73, 0x0C, 0xE1, 0x9C, 0x73, 0x0E, 0x61, 0x80, 0x00, 0x03,
  0x80, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x18,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x1C, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00,
  0x30, 0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x06, 0x03,
  0x80, 0x00, 0x60, 0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x70, 0x00,
  0x0C, 0x06, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x38, 0x0C, 0x00, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x38, 0x00, 0x06, 0x03, 0x00, 0x00, 0xE0,
  0x30, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x1C, 0x06, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xF0, 0x07,
  0x80, 0xF0, 0x1E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x3E,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xF0, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x87, 0x01,
  0x80, 0x31, 0x80, 0x60, 0x1C, 0x60, 0x18, 0x0E, 0x38, 0x06, 0x03, 0x0E,
  0x01, 0x81, 0xC3, 0x80, 0x60, 0xE0, 0xE0, 0x18, 0x30, 0x38, 0x0E, 0x1C,
  0x06, 0x03, 0x0E, 0x01, 0xC1, 0xC7, 0x00, 0x70, 0xE1, 0xC0, 0x0F, 0xF8,
  0xE0, 0x01, 0xF8, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xE1, 0xF8, 0x00, 0x70, 0xFF,
  0x00, 0x18, 0x70, 0xE0, 0x0E, 0x38, 0x18, 0x07, 0x0C, 0x07, 0x01, 0x87,
  0x01, 0xC0, 0xE1, 0xC0, 0x70, 0x70, 0x60, 0x1C, 0x18, 0x18, 0x07, 0x0E,
  0x06, 0x01, 0xC7, 0x01, 0x80, 0x73, 0x80, 0x60, 0x18, 0xE0, 0x18, 0x06,
  0x30, 0x06, 0x03, 0x80, 0x01, 0xC0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0E, 0x07, 0x00,
  0x0F, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0x38, 0x07, 0x1C,
  0x1E, 0x03, 0x1E, 0x07, 0x03, 0x9E, 0x03, 0xC1, 0xCE, 0x00, 0xE0, 0xEF,
  0x00, 0x78, 0xE7, 0x00, 0x1C, 0x73, 0x80, 0x0F, 0x39, 0xC0, 0x03, 0xB8,
  0xE0, 0x00, 0xFC, 0x70, 0x00, 0x7C, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x1F,
  0x07, 0x00, 0x1F, 0x83, 0xC0, 0x1F, 0xE0, 0xFC, 0x7E, 0x70, 0x3F, 0xFC,
  0x3C, 0x0F, 0xFC, 0x0E, 0x00, 0x60, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x39,
  0xCE, 0x63, 0x39, 0xC0, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x1C, 0x0E, 0x07, 0xFC, 0x38, 0xFD, 0xFE, 0xDF, 0xF0,
  0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3D,
  0xC0, 0x01, 0xE7, 0x00, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x40, 0x08, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x1C, 0x38,
  0x71, 0xE3, 0x87, 0x1E, 0x38, 0xF3, 0xC7, 0x04, 0x00, 0x7F, 0xF7, 0xFF,
  0x7F, 0xE0, 0x73, 0xFE, 0xE2, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x7C, 0x03, 0xC0, 0x70,
  0x1E, 0x00, 0xE0, 0x70, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0xE7,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00,
  0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x1C, 0x00,
  0xE0, 0x70, 0x07, 0x81, 0xE0, 0x3C, 0x03, 0xE3, 0xE0, 0x07, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x1F,
  0xF3, 0xFF, 0x3F, 0x3B, 0xC1, 0xD8, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xF8, 0xFC, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x0F,
  0xCF, 0xC0, 0x3C, 0x03, 0x80, 0xF0, 0x07, 0x81, 0xC0, 0x07, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x71, 0xC0, 0x01, 0xE3, 0x80, 0x03, 0x87, 0x80, 0x0F, 0x07, 0x80, 0x3C,
  0x0F, 0x80, 0xF0, 0x0F, 0xC7, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xDC,
  0x00, 0x01, 0xDC, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x38,
  0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x78, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0x70, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x7E, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0x83, 0xE0, 0x1E, 0x01, 0xE0,
  0x0C, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0x38, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x1F, 0x1F, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x7E, 0x03, 0x9F, 0xF8, 0x3B, 0xFF,
  0xC3, 0x78, 0x3E, 0x7E, 0x01, 0xE7, 0xC0, 0x0E, 0x78, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xF0, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x80, 0x38,
  0x3C, 0x07, 0x81, 0xF3, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x80,
  0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xC7, 0xC0, 0x1E, 0x03, 0xC0, 0x78,
  0x03, 0x81, 0xE0, 0x07, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03,
  0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x38, 0x0F, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0xF0, 0x00, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x1E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03,
  0x87, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0xF8, 0x0F, 0xC7, 0xE0,
  0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0x9F, 0x80, 0xF0, 0x1E, 0x0F, 0x00,
  0x70, 0x70, 0x03, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x73, 0xC0, 0x03, 0x9C,
  0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x78, 0x00, 0x3B, 0x80, 0x01,
  0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x01, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0xF1, 0xC0, 0x0F, 0x87, 0x00, 0xFC,
  0x3C, 0x0E, 0xE0, 0xFF, 0xE7, 0x03, 0xFE, 0x70, 0x0F, 0xC3, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x03, 0xC3,
  0xE0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x3C, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x08, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0xF7,
  0xC3, 0xC0, 0xF3, 0xC0, 0x39, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x00, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x06, 0x07, 0x00, 0x1F, 0x80, 0x18,
  0x1C, 0x01, 0xFF, 0x00, 0x70, 0xE0, 0x0F, 0xFF, 0x01, 0xC3, 0x80, 0x78,
  0x1C, 0x03, 0x1C, 0x03, 0xC0, 0x70, 0x0C, 0x70, 0x0E, 0x01, 0xC0, 0x31,
  0x80, 0x70, 0x06, 0x00, 0xCE, 0x01, 0xC0, 0x18, 0x07, 0x38, 0x0E, 0x00,
  0xE0, 0x1C, 0xC0, 0x38, 0x03, 0x80, 0x77, 0x00, 0xC0, 0x0C, 0x01, 0xDC,
  0x07, 0x00, 0x30, 0x06, 0x60, 0x1C, 0x01, 0xC0, 0x19, 0x80, 0x60, 0x07,
  0x00, 0x6E, 0x03, 0x80, 0x1C, 0x01, 0xB8, 0x0E, 0x00, 0x60, 0x0E, 0xE0,
  0x38, 0x03, 0x80, 0x33, 0x80, 0xE0, 0x0E, 0x00, 0xCE, 0x03, 0x80, 0x38,
  0x07, 0x38, 0x0C, 0x01, 0xC0, 0x18, 0xC0, 0x30, 0x07, 0x00, 0x63, 0x00,
  0xE0, 0x3C, 0x03, 0x8C, 0x03, 0x80, 0xF0, 0x0C, 0x38, 0x0E, 0x06, 0xE0,
  0x60, 0xE0, 0x3C, 0x73, 0x87, 0x83, 0x80, 0x7F, 0x87, 0xFC, 0x0E, 0x00,
  0xFC, 0x0F, 0xC0, 0x18, 0x00, 0x80, 0x08, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x40, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x38, 0x70, 0x00, 0x07, 0x87, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x30, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00,
  0x38, 0x03, 0x80, 0x07, 0x00, 0x38, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xC0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E,
  0x1C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x70, 0x03, 0xE0, 0x38, 0x00,
  0x70, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x38, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E,
  0x00, 0x1E, 0x07, 0x00, 0x3E, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x38,
  0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x3C, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x1E, 0x00,
  0x1F, 0x0E, 0x00, 0x3F, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x07, 0x00, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38,
  0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E, 0x38, 0x00,
  0x01, 0xCE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0xF3,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xC0,
  0x1F, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00,
  0x38, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0xF8, 0x0E, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0xFF, 0xE3, 0x80, 0x1F, 0xFC, 0x70, 0x03, 0xFF, 0x8E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0xC0,
  0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0x80,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF8, 0x03, 0x80, 0x03, 0xC0,
  0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x39, 0xF0, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x07, 0x3F, 0x00, 0x00, 0x1D, 0xFC, 0x00, 0x00,
  0x7F, 0x78, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3E,
  0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x37, 0x00, 0x00, 0x1F, 0x81, 0xDC, 0x00, 0x00, 0xEE,
  0x07, 0x70, 0x00, 0x03, 0xB8, 0x1D, 0xC0, 0x00, 0x1C, 0xE0, 0x77, 0x00,
  0x00, 0x77, 0x01, 0xCC, 0x00, 0x03, 0x9C, 0x0E, 0x38, 0x00, 0x0E, 0x70,
  0x38, 0xE0, 0x00, 0x71, 0xC0, 0xE3, 0x80, 0x01, 0xC7, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x38, 0x60, 0x01, 0xC3, 0x81,
  0xC1, 0xC0, 0x07, 0x0E, 0x07, 0x07, 0x00, 0x38, 0x38, 0x1C, 0x1C, 0x00,
  0xE0, 0xE0, 0x70, 0x70, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x07,
  0x03, 0x00, 0xE0, 0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0x38,
  0x0E, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x70, 0x0E, 0x07, 0x00, 0x71, 0xC0,
  0x38, 0x1C, 0x01, 0xCE, 0x00, 0xE0, 0x70, 0x07, 0x38, 0x07, 0x81, 0xC0,
  0x1D, 0xC0, 0x1C, 0x07, 0x00, 0x77, 0x00, 0x70, 0x3C, 0x00, 0xF8, 0x01,
  0xC0, 0xE0, 0x03, 0xE0, 0x07, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x0E, 0x00,
  0x3C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0xE0,
  0x3E, 0x00, 0x01, 0xC0, 0x7E, 0x00, 0x03, 0x81, 0xFC, 0x00, 0x07, 0x03,
  0xB8, 0x00, 0x0E, 0x07, 0x38, 0x00, 0x3C, 0x0E, 0x70, 0x00, 0x70, 0x1C,
  0xE0, 0x00, 0xE0, 0x38, 0xE0, 0x01, 0xC0, 0xF1, 0xC0, 0x03, 0x81, 0xC1,
  0xC0, 0x07, 0x03, 0x83, 0x80, 0x1E, 0x07, 0x07, 0x00, 0x38, 0x0E, 0x07,
  0x00, 0x70, 0x1C, 0x0E, 0x00, 0xE0, 0x78, 0x1C, 0x01, 0xC0, 0xE0, 0x1C,
  0x03, 0x81, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x00, 0x70,
  0x38, 0x0E, 0x00, 0xE0, 0x70, 0x3C, 0x01, 0xE0, 0xE0, 0x70, 0x01, 0xC3,
  0xC0, 0xE0, 0x03, 0x87, 0x01, 0xC0, 0x03, 0x8E, 0x03, 0x80, 0x07, 0x1C,
  0x07, 0x00, 0x0E, 0x38, 0x1E, 0x00, 0x0E, 0x70, 0x38, 0x00, 0x1D, 0xE0,
  0x70, 0x00, 0x3B, 0x80, 0xE0, 0x00, 0x3F, 0x01, 0xC0, 0x00, 0x7E, 0x07,
  0x80, 0x00, 0xFC, 0x0E, 0x00, 0x00, 0xF8, 0x1C, 0x00, 0x01, 0xF0, 0x38,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0x00, 0xF8,
  0x07, 0x80, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0F, 0x00,
  0x01, 0xE1, 0xC0, 0x00, 0x1C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0F,
  0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80,
  0x3C, 0x03, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xC0, 0x07, 0xC0, 0x38, 0x00, 0x3C, 0x07, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xF0, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x07,
  0x81, 0xC0, 0x03, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0F,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07,
  0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x0E, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x06, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xC0, 0x07, 0x80, 0x38, 0x00, 0x78, 0x07, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1C, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x3E, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x87, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0,
  0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x01,
  0xF0, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x1E,
  0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0x38, 0x38,
  0x00, 0x03, 0x87, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0xF0,
  0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00,
  0x38, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x33, 0xC0,
  0x00, 0x06, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x01, 0xC0,
  0x00, 0xEE, 0x00, 0x0F, 0x00, 0x03, 0xB8, 0x00, 0x3C, 0x00, 0x1E, 0xE0,
  0x00, 0xF0, 0x00, 0x73, 0x80, 0x07, 0xE0, 0x01, 0xCE, 0x00, 0x1F, 0x80,
  0x0F, 0x38, 0x00, 0xEE, 0x00, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0xE3, 0x80,
  0x0C, 0xE0, 0x07, 0x8E, 0x00, 0x73, 0x80, 0x1C, 0x38, 0x01, 0xCE, 0x00,
  0x70, 0xE0, 0x0E, 0x38, 0x03, 0x83, 0x80, 0x38, 0x60, 0x0E, 0x0E, 0x00,
  0xE1, 0x80, 0x38, 0x38, 0x07, 0x06, 0x01, 0xC0, 0xE0, 0x1C, 0x18, 0x07,
  0x03, 0x80, 0x60, 0x60, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x18, 0x0E,
  0x07, 0x03, 0x80, 0x70, 0x70, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x70,
  0x07, 0x06, 0x01, 0xC1, 0xC0, 0x1C, 0x38, 0x07, 0x0F, 0x00, 0x70, 0xE0,
  0x1C, 0x38, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0xC7, 0x00,
  0x1C, 0x60, 0x03, 0x1C, 0x00, 0x73, 0x80, 0x0C, 0x70, 0x01, 0xCE, 0x00,
  0x33, 0x80, 0x07, 0x70, 0x00, 0xCE, 0x00, 0x1D, 0xC0, 0x03, 0x38, 0x00,
  0x76, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x70, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80,
  0x1E, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00, 0xF0, 0x70,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x1E, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80,
  0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80,
  0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x66, 0x01, 0xCC, 0x03, 0x18, 0x0E, 0x38, 0x38, 0x70,
  0x70, 0xE1, 0xC1, 0xC3, 0x81, 0x8E, 0x03, 0x1C, 0x07, 0x70, 0x0E, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x70, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFC, 0xF0, 0xE1, 0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0xFC, 0x07, 0x80, 0x78, 0x3C, 0x00,
  0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07,
  0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x87, 0x00, 0x7E, 0x1E, 0x03,
  0xF8, 0x7F, 0xFD, 0xE0, 0xFF, 0xE7, 0x81, 0xFE, 0x1E, 0x00, 0x40, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x71,
  0xFE, 0x00, 0xEF, 0xFE, 0x01, 0xFE, 0x7E, 0x03, 0xE0, 0x1E, 0x0F, 0x80,
  0x1C, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xC7,
  0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x71, 0xC0, 0x00, 0xE3, 0xC0, 0x03, 0x87, 0x80, 0x07, 0x0F, 0x80,
  0x1C, 0x1F, 0x80, 0x78, 0x73, 0xE7, 0xE0, 0xE3, 0xFF, 0x81, 0xC3, 0xFE,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xC7, 0xC0, 0xF0, 0x0F, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80,
  0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0xE0, 0xF0, 0x0F, 0x03, 0xF1, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0xE0, 0x1F, 0xFC, 0x70,
  0x1F, 0x9F, 0x70, 0x1E, 0x01, 0xB8, 0x0E, 0x00, 0x7C, 0x0E, 0x00, 0x1E,
  0x07, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x03,
  0x80, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0x7E, 0x7F, 0x80, 0x1F, 0xFD, 0xC0,
  0x07, 0xF8, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xC7, 0xC0, 0xF0, 0x0F, 0x07, 0x00, 0x38, 0x70,
  0x01, 0xC7, 0x80, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x60, 0x78, 0x07, 0x83, 0xF1, 0xF8, 0x0F,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xB0, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x03, 0xFF,
  0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xC0, 0x3F, 0xF8,
  0xE0, 0x3F, 0x3E, 0xE0, 0x3C, 0x03, 0x70, 0x1C, 0x00, 0xF8, 0x1C, 0x00,
  0x3C, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x3C,
  0x07, 0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x00, 0xFC, 0xFF, 0x00, 0x3F, 0xFB,
  0x80, 0x0F, 0xF1, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x3E, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x40,
  0x07, 0x1F, 0xE0, 0x1C, 0xFF, 0xC0, 0x77, 0x9F, 0x81, 0xF8, 0x1E, 0x0F,
  0xC0, 0x38, 0x3E, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0,
  0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87,
  0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x07, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x01,
  0xE0, 0xE0, 0x07, 0x81, 0xC0, 0x1E, 0x03, 0x80, 0x78, 0x07, 0x01, 0xE0,
  0x1C, 0x07, 0x80, 0x38, 0x1E, 0x00, 0x70, 0x78, 0x00, 0xE1, 0xE0, 0x01,
  0xC7, 0x80, 0x07, 0x1E, 0x00, 0x0E, 0x78, 0x00, 0x1D, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFB, 0x80, 0x03, 0xE7, 0x80, 0x07, 0x87,
  0x00, 0x0E, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x1C, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0xC0,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x01,
  0x00, 0x02, 0x00, 0x38, 0xFF, 0x01, 0xFE, 0x01, 0xDF, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF3, 0xF1, 0xE7, 0xE0, 0xEC, 0x07, 0x9C, 0x07, 0x07, 0xC0, 0x1D,
  0xC0, 0x3C, 0x3C, 0x00, 0xFC, 0x00, 0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x0E,
  0x00, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x01, 0xC7, 0x80, 0x07, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x80, 0x03, 0x8E, 0x00,
  0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x00, 0x0E,
  0x3C, 0x00, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC0, 0x03, 0x8E, 0x00, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x07, 0x1C,
  0x00, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x00,
  0x1C, 0x70, 0x00, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x07, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0xE0, 0x01, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x00, 0x1C,
  0x70, 0x00, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x00, 0x07, 0x00, 0x00, 0x01,
  0x00, 0x1C, 0x7F, 0x80, 0x73, 0xFF, 0x01, 0xDE, 0x7E, 0x07, 0xE0, 0x78,
  0x3F, 0x00, 0xE0, 0xF8, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x70, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80,
  0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x03, 0x87, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0xFC, 0x07,
  0x80, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D,
  0xC0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01,
  0xEE, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87,
  0x80, 0x1C, 0x0F, 0x01, 0xE0, 0x1F, 0x1F, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xFC, 0x00, 0x77,
  0xFF, 0x00, 0x3F, 0xCF, 0xC0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F,
  0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x78, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x0F, 0x00,
  0x1E, 0x07, 0xC0, 0x0E, 0x03, 0xF0, 0x0F, 0x03, 0x9E, 0x3F, 0x01, 0xC7,
  0xFF, 0x00, 0xE1, 0xFE, 0x00, 0x70, 0x18, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x1C, 0x0F, 0xFE,
  0x38, 0x3F, 0x1E, 0xE0, 0xF0, 0x0F, 0xC1, 0xC0, 0x0F, 0x87, 0x00, 0x0F,
  0x0E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE3,
  0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00,
  0x03, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x0F, 0x03, 0xC0, 0x3E,
  0x03, 0xF3, 0xFC, 0x03, 0xFF, 0xB8, 0x03, 0xFC, 0x70, 0x00, 0xC1, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x9F, 0x81, 0xDF, 0xC0,
  0xFF, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xE7, 0xE0, 0x78, 0x0F,
  0x07, 0x80, 0x3C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x1C, 0xE0, 0x01, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xF0, 0x0F,
  0x03, 0xF1, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x10, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF,
  0xFF, 0xF7, 0xFF, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0x40, 0x7E, 0x03, 0xF0, 0x02,
  0x00, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x07, 0x83, 0xC0, 0x3E,
  0x07, 0x01, 0xF8, 0x1F, 0xBF, 0xE0, 0x3F, 0xFB, 0x80, 0x7F, 0x8E, 0x00,
  0x20, 0x00, 0x00, 0x70, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xE0,
  0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x06, 0x00, 0x70,
  0x38, 0x03, 0x81, 0xC0, 0x3C, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0x60, 0x70, 0x03, 0x03, 0x80, 0x1C, 0x38, 0x00,
  0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x06, 0x70,
  0x00, 0x33, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0xE0, 0x07, 0x80, 0x0E, 0xE0, 0x07,
  0x80, 0x1C, 0xE0, 0x07, 0xC0, 0x1C, 0xE0, 0x0F, 0xC0, 0x3C, 0x60, 0x0F,
  0xC0, 0x38, 0x70, 0x1D, 0xC0, 0x38, 0x70, 0x1D, 0xC0, 0x70, 0x70, 0x19,
  0xC0, 0x70, 0x70, 0x39, 0xC0, 0x70, 0x70, 0x39, 0xC0, 0xE0, 0x70, 0x70,
  0xC0, 0xE0, 0x70, 0x70, 0xC1, 0xC0, 0x70, 0xE0, 0xC1, 0xC0, 0x70, 0xE0,
  0xC1, 0xC0, 0x70, 0xC0, 0xE3, 0x80, 0x71, 0xC0, 0xE3, 0x80, 0x71, 0xC0,
  0xE7, 0x00, 0x73, 0x80, 0xE7, 0x00, 0x73, 0x80, 0xE7, 0x00, 0x77, 0x00,
  0xEE, 0x00, 0x37, 0x00, 0xEE, 0x00, 0x36, 0x00, 0x6C, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1C,
  0x03, 0x80, 0x0E, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0xE1, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x07,
  0x80, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x01, 0xC0,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x01, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x0C, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x06, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x07, 0x80, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x31, 0xFF, 0x80, 0x1C, 0xF1, 0xF0, 0x07, 0x70, 0x1E, 0x01, 0x9C, 0x03,
  0xC0, 0xE6, 0x00, 0xF8, 0x73, 0x80, 0x1F, 0xFC, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_LightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 41, 12, 1, -40 },
  { 53, 11, 12, 16, 6, -42 },
  { 70, 28, 40, 28, 2, -40 },
  { 210, 23, 53, 26, 2, -47 },
  { 363, 26, 42, 35, 5, -41 },
  { 500, 25, 42, 29, 2, -41 },
  { 632, 5, 12, 9, 5, -42 },
  { 640, 16, 58, 16, 3, -45 },
  { 756, 16, 58, 16, -3, -45 },
  { 872, 22, 22, 23, 3, -40 },
  { 933, 23, 29, 27, 2, -33 },
  { 1017, 7, 13, 10, -2, -5 },
  { 1029, 12, 3, 14, 1, -19 },
  { 1034, 5, 5, 13, 1, -4 },
  { 1038, 23, 43, 19, -2, -40 },
  { 1162, 22, 42, 26, 3, -41 },
  { 1278, 13, 40, 26, 7, -40 },
  { 1343, 24, 41, 26, 1, -41 },
  { 1466, 23, 42, 26, 2, -41 },
  { 1587, 24, 40, 26, 1, -40 },
  { 1707, 24, 41, 26, 3, -40 },
  { 1830, 20, 41, 26, 3, -40 },
  { 1933, 23, 40, 26, 4, -40 },
  { 2048, 23, 42, 26, 2, -41 },
  { 2169, 21, 41, 26, 4, -41 },
  { 2277, 9, 30, 11, 1, -29 },
  { 2311, 12, 37, 10, -2, -29 },
  { 2367, 21, 24, 24, 2, -30 },
  { 2430, 21, 15, 26, 3, -26 },
  { 2470, 22, 24, 25, 1, -30 },
  { 2536, 17, 42, 22, 5, -41 },
  { 2626, 38, 51, 43, 2, -39 },
  { 2869, 28, 40, 30, -2, -40 },
  { 3009, 25, 40, 29, 2, -40 },
  { 3134, 27, 42, 31, 3, -41 },
  { 3276, 27, 40, 31, 2, -40 },
  { 3411, 27, 40, 27, 2, -40 },
  { 3546, 27, 40, 27, 2, -40 },
  { 3681, 27, 42, 32, 3, -41 },
  { 3823, 31, 40, 33, 2, -40 },
  { 3978, 10, 40, 13, 2, -40 },
  { 4028, 25, 41, 26, 1, -40 },
  { 4157, 30, 40, 30, 2, -40 },
  { 4307, 19, 40, 25, 2, -40 },
  { 4402, 38, 40, 41, 2, -40 },
  { 4592, 31, 40, 34, 2, -40 },
  { 4747, 27, 42, 32, 3, -41 },
  { 4889, 27, 40, 29, 2, -40 },
  { 5024, 27, 48, 32, 3, -41 },
  { 5186, 27, 40, 30, 2, -40 },
  { 5321, 27, 42, 28, 1, -41 },
  { 5463, 26, 40, 28, 5, -40 },
  { 5593, 28, 41, 31, 3, -40 },
  { 5737, 27, 40, 29, 5, -40 },
  { 5872, 38, 40, 42, 6, -40 },
  { 6062, 32, 40, 29, -1, -40 },
  { 6222, 27, 40, 28, 5, -40 },
  { 6357, 29, 40, 28, 0, -40 },
  { 6502, 16, 55, 12, 0, -46 },
  { 6612, 9, 43, 19, 6, -40 },
  { 6661, 16, 55, 12, -3, -46 },
  { 6771, 15, 20, 20, 3, -40 },
  { 6809, 21, 3, 21, -3, 0 },
  { 6817, 7, 8, 16, 7, -42 },
  { 6824, 22, 32, 26, 1, -31 },
  { 6912, 23, 43, 26, 1, -42 },
  { 7036, 21, 32, 25, 2, -31 },
  { 7120, 25, 43, 27, 2, -42 },
  { 7255, 21, 32, 25, 2, -31 },
  { 7339, 17, 43, 16, 3, -43 },
  { 7431, 25, 42, 26, 0, -31 },
  { 7563, 22, 42, 26, 1, -42 },
  { 7679, 11, 41, 11, 1, -41 },
  { 7736, 17, 52, 12, -6, -41 },
  { 7847, 23, 42, 24, 1, -42 },
  { 7968, 11, 42, 11, 1, -42 },
  { 8026, 37, 31, 41, 1, -31 },
  { 8170, 22, 31, 26, 1, -31 },
  { 8256, 22, 32, 27, 2, -31 },
  { 8344, 25, 42, 26, -1, -31 },
  { 8476, 23, 42, 27, 2, -31 },
  { 8597, 17, 31, 16, 1, -31 },
  { 8663, 21, 32, 24, 1, -31 },
  { 8747, 13, 38, 16, 3, -37 },
  { 8809, 22, 31, 26, 3, -30 },
  { 8895, 21, 30, 23, 3, -30 },
  { 8974, 32, 30, 35, 4, -30 },
  { 9094, 25, 30, 23, -1, -30 },
  { 9188, 26, 41, 23, -2, -30 },
  { 9322, 23, 30, 23, 0, -30 },
  { 9409, 17, 55, 16, 2, -44 },
  { 9526, 10, 47, 12, 1, -40 },
  { 9585, 17, 55, 16, -3, -44 },
  { 9702, 26, 10, 32, 3, -22 },
};

const GFXfont RobotoCondensed_LightItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC56PT7B_H_
