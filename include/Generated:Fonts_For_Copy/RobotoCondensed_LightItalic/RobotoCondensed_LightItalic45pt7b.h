#ifndef _ROBOTOCONDENSED_LIGHTITALIC45PT7B_H_
#define _ROBOTOCONDENSED_LIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-LightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_LightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0xE0, 0xE0, 0x60, 0x63, 0x63, 0x63,
  0x63, 0x63, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0x00, 0x0C, 0x1C, 0x00, 0x18,
  0x30, 0x00, 0x70, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x07, 0x06,
  0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0x30, 0x60, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0C,
  0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60,
  0x00, 0xC0, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x3C, 0xF8, 0x1C, 0x0E, 0x0E, 0x01, 0xC3,
  0x00, 0x71, 0xC0, 0x0C, 0x70, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x31, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0xCE, 0x00,
  0x61, 0x80, 0x38, 0x70, 0x1C, 0x0F, 0xBE, 0x01, 0xFF, 0x00, 0x3F, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x00, 0x0E, 0x30, 0x00, 0xE1, 0x80, 0x06, 0x06, 0x02, 0x30, 0x30,
  0x33, 0x01, 0x83, 0x18, 0x0C, 0x38, 0xC0, 0x61, 0x86, 0x06, 0x18, 0x30,
  0x31, 0xC0, 0xC1, 0x8C, 0x06, 0x18, 0xC0, 0x1F, 0x8C, 0x00, 0x78, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x1E, 0x00, 0x31, 0xF8, 0x03,
  0x18, 0x60, 0x31, 0x83, 0x01, 0x8C, 0x0C, 0x18, 0x60, 0x61, 0x86, 0x03,
  0x1C, 0x30, 0x18, 0xC1, 0x80, 0xCC, 0x0C, 0x0C, 0xE0, 0x60, 0x62, 0x01,
  0x83, 0x00, 0x0C, 0x30, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xF0, 0x01, 0xE7, 0x80, 0x18, 0x38, 0x03, 0x81, 0x80, 0x30, 0x18,
  0x03, 0x01, 0x80, 0x70, 0x18, 0x07, 0x03, 0x80, 0x70, 0x70, 0x03, 0x0E,
  0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xE7, 0x03, 0x1C, 0x70, 0x33, 0x83, 0x83, 0x30,
  0x18, 0x77, 0x01, 0xC6, 0x60, 0x0C, 0x66, 0x00, 0xEE, 0x60, 0x06, 0xC6,
  0x00, 0x78, 0x60, 0x03, 0x87, 0x00, 0x78, 0x78, 0x0F, 0xC3, 0xC3, 0xDC,
  0x1F, 0xF8, 0xE0, 0x7E, 0x06, 0x33, 0x77, 0x66, 0x66, 0xEC, 0x00, 0x08,
  0x00, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x02,
  0x00, 0x01, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x08, 0x00, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x10, 0x18, 0x17,
  0x0E, 0x3D, 0xFB, 0x3F, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0x70, 0x03, 0x8C, 0x01, 0xC3, 0x80, 0xE0, 0x60, 0x30, 0x1C,
  0x04, 0x02, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x71, 0xC7,
  0x18, 0xE3, 0x9C, 0xE1, 0x00, 0xFF, 0xFF, 0xC0, 0x6F, 0xF6, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xC0, 0x3C, 0x70, 0x1C, 0x0E, 0x0E, 0x01, 0x83, 0x00, 0x71,
  0xC0, 0x1C, 0x60, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x1C, 0xC0,
  0x07, 0x30, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x06, 0x60, 0x01,
  0x98, 0x00, 0x66, 0x00, 0x39, 0x80, 0x0E, 0xE0, 0x03, 0x38, 0x00, 0xCE,
  0x00, 0x33, 0x80, 0x1C, 0xE0, 0x06, 0x38, 0x01, 0x86, 0x00, 0xE1, 0x80,
  0x70, 0x70, 0x38, 0x0F, 0x1E, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x40,
  0xF0, 0xFD, 0xFF, 0xF9, 0xB0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0x1E, 0x03, 0x80, 0xE0,
  0x60, 0x0C, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x07, 0x18, 0x00, 0xE3,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F,
  0x1E, 0x03, 0x80, 0xE0, 0x60, 0x0C, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0,
  0x07, 0x1C, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x8C, 0x00, 0x61, 0x80, 0x1C, 0x38, 0x03,
  0x83, 0x80, 0xE0, 0x7C, 0x78, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1B,
  0x80, 0x07, 0x60, 0x01, 0xCC, 0x00, 0x31, 0x80, 0x0E, 0x70, 0x03, 0x8E,
  0x00, 0x61, 0x80, 0x18, 0x30, 0x07, 0x06, 0x00, 0xC1, 0xC0, 0x30, 0x38,
  0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x1C, 0x03, 0x07, 0x00, 0xE0,
  0xC0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8, 0x0E,
  0x03, 0x80, 0x80, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC6, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x01, 0xC3, 0x00, 0x30, 0x70, 0x0E, 0x07, 0x03, 0x80, 0xF9,
  0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x3F, 0x03, 0x3F, 0xC1, 0xB8, 0xF1,
  0xF0, 0x1C, 0xF0, 0x0E, 0x70, 0x03, 0x38, 0x01, 0x98, 0x00, 0xEC, 0x00,
  0x76, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0D, 0xC0, 0x06, 0x60, 0x07, 0x30,
  0x03, 0x98, 0x03, 0x8E, 0x01, 0xC3, 0x81, 0xC1, 0xF3, 0xC0, 0x7F, 0xC0,
  0x0F, 0x80, 0x3F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x0F,
  0x8F, 0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x0C, 0x01, 0xC3, 0x80, 0x18, 0x70,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x60, 0xE0,
  0x1C, 0x0E, 0x07, 0x00, 0xE3, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xC1,
  0xC0, 0x70, 0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x03, 0x18, 0x00,
  0x63, 0x00, 0x0C, 0xE0, 0x03, 0x8C, 0x00, 0x71, 0x80, 0x0C, 0x38, 0x03,
  0x87, 0x00, 0xE0, 0x78, 0x78, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x03, 0xFE, 0x03, 0xC7, 0x83, 0x80, 0xC1, 0x80, 0x71, 0xC0, 0x18, 0xC0,
  0x0C, 0xE0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0xD8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x37, 0x00, 0x19, 0x80, 0x1C, 0xC0, 0x0E, 0x70, 0x0F, 0x38, 0x0F,
  0x8F, 0x1D, 0x83, 0xFC, 0xC0, 0xFC, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x0C, 0x3C, 0x78, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x1C, 0x38, 0x70, 0x01, 0x80, 0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0x60, 0x10, 0x00, 0x00, 0x01, 0x00, 0x01, 0x80, 0x03, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x10, 0x00, 0x0E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x20, 0x00,
  0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xCF, 0x9E, 0x0E, 0x70, 0x1B, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x01, 0x81,
  0xC0, 0x00, 0x06, 0x06, 0x00, 0x00, 0x08, 0x38, 0x07, 0xC0, 0x30, 0xC0,
  0x7F, 0x80, 0xC6, 0x03, 0x87, 0x03, 0x18, 0x1C, 0x0C, 0x0C, 0xC0, 0x60,
  0x30, 0x33, 0x03, 0x01, 0xC0, 0xDC, 0x0C, 0x06, 0x03, 0x60, 0x60, 0x18,
  0x0D, 0x81, 0x80, 0x60, 0x36, 0x06, 0x01, 0x80, 0xF0, 0x30, 0x0C, 0x03,
  0xC0, 0xC0, 0x30, 0x1B, 0x03, 0x00, 0xC0, 0x6C, 0x0C, 0x03, 0x01, 0xB0,
  0x30, 0x18, 0x06, 0xC1, 0xC0, 0x60, 0x33, 0x07, 0x03, 0x80, 0xCC, 0x0C,
  0x0E, 0x06, 0x30, 0x30, 0x78, 0x18, 0xC0, 0xE3, 0x71, 0xC3, 0x03, 0xF8,
  0xFE, 0x0C, 0x07, 0xC1, 0xE0, 0x30, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x06, 0xC0, 0x00, 0x3B, 0x00,
  0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x18, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x06, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x0E, 0x06,
  0x00, 0x30, 0x18, 0x01, 0xC0, 0x70, 0x06, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0xC0, 0x0C, 0x07, 0x00, 0x30, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x60, 0x00, 0xE3, 0x80, 0x01, 0x8C, 0x00, 0x06,
  0x70, 0x00, 0x19, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xC0, 0xF8, 0x0E, 0x00, 0xE0, 0x70, 0x03,
  0x83, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x70,
  0x70, 0x1F, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xC0, 0x1E, 0x06, 0x00,
  0x30, 0x30, 0x01, 0xC3, 0x80, 0x06, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x86,
  0x00, 0x0C, 0x30, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03,
  0x86, 0x00, 0x38, 0x30, 0x0F, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0xF8, 0x0E, 0x01, 0xE0, 0xE0, 0x07,
  0x0E, 0x00, 0x18, 0x70, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0x80,
  0x01, 0xDC, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x03, 0x98,
  0x00, 0x18, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE0, 0xE0, 0x07,
  0x07, 0x00, 0xF0, 0x1F, 0x1F, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x70, 0x3E, 0x01, 0xC0, 0x1C, 0x07, 0x00,
  0x38, 0x18, 0x00, 0x60, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x0C,
  0x38, 0x00, 0x30, 0xE0, 0x00, 0xC3, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x30,
  0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x18, 0x60, 0x00,
  0x61, 0x80, 0x01, 0x86, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x61, 0xC0, 0x03, 0x87, 0x00,
  0x1C, 0x1C, 0x00, 0xF0, 0x60, 0x07, 0x81, 0x80, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xF8, 0xF8, 0x0E, 0x00, 0xE0, 0xE0, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x00, 0x63, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xFF, 0xB8, 0x0F,
  0xFD, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x03, 0x98,
  0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x18, 0x00, 0x30, 0xE0, 0x03,
  0x83, 0x80, 0x7C, 0x1F, 0x9F, 0x80, 0x7F, 0xF8, 0x00, 0xFE, 0x00, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x30, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x06,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0x80, 0x00,
  0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x38, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0C, 0x00, 0x06, 0x06, 0x00, 0x03, 0x03, 0x00,
  0x01, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x60,
  0x00, 0x30, 0x30, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC1,
  0xC0, 0x00, 0xE0, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x70, 0xC0,
  0x06, 0x0C, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC0, 0x70, 0x3C, 0x07,
  0xCF, 0x80, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0x00, 0x07, 0x01, 0x80,
  0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x07, 0x00, 0x18, 0x07, 0x80, 0x0C, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x07,
  0x07, 0x80, 0x03, 0x87, 0x80, 0x01, 0x83, 0x80, 0x00, 0xC3, 0x80, 0x00,
  0x63, 0x80, 0x00, 0x73, 0x80, 0x00, 0x3B, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0x9C, 0x00, 0x07, 0x8E, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x38, 0x06, 0x00,
  0x1C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x3C, 0x1F,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0xD8,
  0x00, 0x0F, 0x81, 0xB0, 0x00, 0x1B, 0x03, 0x60, 0x00, 0x76, 0x0E, 0xE0,
  0x00, 0xDC, 0x1D, 0xC0, 0x03, 0xB8, 0x33, 0x80, 0x06, 0x60, 0x63, 0x00,
  0x1C, 0xC0, 0xC6, 0x00, 0x31, 0x81, 0x8C, 0x00, 0xE7, 0x07, 0x18, 0x01,
  0x8E, 0x0E, 0x38, 0x07, 0x1C, 0x1C, 0x30, 0x0C, 0x30, 0x30, 0x60, 0x38,
  0x60, 0x60, 0xC0, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x83, 0x83, 0x07, 0x07,
  0x07, 0x07, 0x0C, 0x0E, 0x0E, 0x06, 0x38, 0x18, 0x18, 0x0C, 0x60, 0x30,
  0x30, 0x19, 0xC0, 0xE0, 0xE0, 0x33, 0x01, 0xC1, 0xC0, 0x6E, 0x03, 0x83,
  0x80, 0xF8, 0x06, 0x06, 0x00, 0xF0, 0x0C, 0x0C, 0x01, 0xC0, 0x18, 0x18,
  0x03, 0x80, 0x70, 0x70, 0x06, 0x00, 0xE0, 0x03, 0x80, 0x01, 0x80, 0xE0,
  0x00, 0x60, 0x78, 0x00, 0x18, 0x1F, 0x00, 0x0E, 0x07, 0xC0, 0x03, 0x81,
  0xF0, 0x00, 0xE0, 0x6E, 0x00, 0x30, 0x19, 0x80, 0x0C, 0x0E, 0x60, 0x03,
  0x03, 0x9C, 0x01, 0xC0, 0xE3, 0x00, 0x70, 0x30, 0xE0, 0x1C, 0x0C, 0x38,
  0x06, 0x03, 0x06, 0x01, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C,
  0x0C, 0x0E, 0x06, 0x03, 0x83, 0x01, 0x80, 0x60, 0xC0, 0x60, 0x18, 0x30,
  0x38, 0x07, 0x1C, 0x0E, 0x00, 0xC7, 0x03, 0x80, 0x39, 0xC0, 0xC0, 0x0E,
  0x60, 0x30, 0x01, 0x98, 0x1C, 0x00, 0x76, 0x07, 0x00, 0x0F, 0x81, 0xC0,
  0x03, 0xE0, 0x70, 0x00, 0xF8, 0x18, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0x3F, 0x00,
  0xE0, 0x1E, 0x07, 0x00, 0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x18, 0x00, 0x0C, 0x60, 0x00, 0x33, 0x80, 0x00, 0xCE, 0x00, 0x03,
  0x30, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x70,
  0x00, 0x19, 0xC0, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x0E, 0x60, 0x00,
  0x39, 0x80, 0x00, 0xC6, 0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x61,
  0xC0, 0x03, 0x87, 0x00, 0x0C, 0x0E, 0x00, 0x70, 0x38, 0x07, 0x80, 0x7C,
  0x7C, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x70, 0x1F, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x70,
  0x60, 0x00, 0xC1, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0,
  0x01, 0xC3, 0x00, 0x07, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0xE1, 0xC0, 0x07,
  0x87, 0x00, 0x3C, 0x1C, 0x03, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0x3F, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0x38, 0x38, 0x00, 0x60, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x18, 0x00, 0x0C,
  0xE0, 0x00, 0x33, 0x80, 0x00, 0xCC, 0x00, 0x07, 0x30, 0x00, 0x1C, 0xC0,
  0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x06, 0x70, 0x00, 0x19, 0xC0, 0x00,
  0x66, 0x00, 0x03, 0x98, 0x00, 0x0E, 0x60, 0x00, 0x3B, 0x80, 0x00, 0xCE,
  0x00, 0x03, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x61, 0x80, 0x03, 0x87, 0x00,
  0x0C, 0x0C, 0x00, 0x70, 0x38, 0x07, 0x80, 0x7C, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x70, 0x1F, 0x01, 0xC0, 0x1E, 0x07, 0x00, 0x38, 0x18, 0x00,
  0x60, 0x60, 0x01, 0xC1, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0,
  0x07, 0x07, 0x00, 0x38, 0x1C, 0x07, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0E, 0x01, 0x80, 0x38, 0x06, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x70, 0x0C,
  0x00, 0xC0, 0x30, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x18, 0x1C, 0x00,
  0x70, 0x60, 0x01, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0x3E, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0x30, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0x80, 0x03, 0x87,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x38, 0x07, 0x80, 0x7C, 0x7C, 0x00, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x60, 0x00, 0x60, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60,
  0xC0, 0x00, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x30, 0x00,
  0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x78, 0x07, 0xE3, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0xE0, 0x00, 0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0x60,
  0x00, 0x71, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x1C, 0x00, 0x30, 0x70, 0x01,
  0xC1, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x0C, 0x00, 0xC0, 0x30, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x60,
  0x70, 0x01, 0x81, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x30, 0x00, 0x61, 0xC0,
  0x01, 0xC6, 0x00, 0x07, 0x38, 0x00, 0x0C, 0xC0, 0x00, 0x37, 0x00, 0x00,
  0xDC, 0x00, 0x03, 0x60, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x01, 0x80, 0x06, 0xC0, 0x07, 0x00, 0x1D,
  0x80, 0x0E, 0x00, 0x33, 0x00, 0x3C, 0x00, 0xE6, 0x00, 0x78, 0x01, 0xCC,
  0x00, 0xF0, 0x03, 0x18, 0x03, 0x60, 0x0E, 0x30, 0x06, 0xE0, 0x1C, 0x60,
  0x1C, 0xC0, 0x30, 0xC0, 0x31, 0x80, 0xE1, 0x80, 0x63, 0x01, 0xC3, 0x01,
  0xC6, 0x03, 0x06, 0x03, 0x0C, 0x0E, 0x0E, 0x0E, 0x18, 0x18, 0x1C, 0x18,
  0x30, 0x30, 0x38, 0x30, 0x60, 0xE0, 0x70, 0xE0, 0xC1, 0x80, 0xE1, 0x81,
  0x83, 0x01, 0xC7, 0x03, 0x0E, 0x03, 0x8C, 0x06, 0x18, 0x07, 0x18, 0x0E,
  0x70, 0x06, 0x70, 0x0C, 0xE0, 0x0C, 0xC0, 0x19, 0x80, 0x19, 0x80, 0x37,
  0x00, 0x36, 0x00, 0x6C, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x03, 0x80,
  0xE0, 0x00, 0xE0, 0x18, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x18, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x3B, 0x00, 0x03, 0x9C, 0x00, 0x1C,
  0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x18, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x00,
  0x70, 0x18, 0x07, 0x00, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x18, 0x38, 0x00,
  0xC1, 0x80, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x00, 0xCC, 0x00, 0x06, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x0E,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC3, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x01, 0xF8, 0x0F, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0xC0, 0x36, 0x03, 0xB0, 0x19, 0x81, 0xCC, 0x0C, 0x60, 0xE1, 0x86,
  0x0C, 0x70, 0x63, 0x03, 0x38, 0x19, 0x80, 0xDC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x70, 0xE0, 0xE0, 0xC1, 0xC1, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xE3, 0xC1, 0xC0, 0x61, 0xC0, 0x38, 0xC0, 0x1C, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0xFF, 0xC1, 0xFF, 0xE3, 0xE0, 0x31, 0xC0,
  0x39, 0xC0, 0x1D, 0xC0, 0x0C, 0xE0, 0x06, 0x70, 0x03, 0x38, 0x03, 0x9C,
  0x03, 0xCE, 0x03, 0xE3, 0xCF, 0x70, 0xFF, 0x38, 0x3E, 0x1C, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC7, 0xE0, 0x37,
  0xFC, 0x0F, 0xCF, 0x87, 0xC0, 0xE1, 0xE0, 0x1C, 0x70, 0x07, 0x18, 0x00,
  0xC6, 0x00, 0x31, 0x80, 0x0C, 0xE0, 0x03, 0x38, 0x01, 0xCC, 0x00, 0x73,
  0x00, 0x1C, 0xC0, 0x07, 0x70, 0x01, 0x9C, 0x00, 0x67, 0x00, 0x39, 0x80,
  0x0E, 0x60, 0x03, 0x1C, 0x01, 0xCF, 0x80, 0xE3, 0xB8, 0xF0, 0xC7, 0xF8,
  0x30, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x78, 0xF0, 0x38, 0x0E,
  0x1C, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x06, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x03, 0x18, 0x01, 0xC6, 0x00, 0x61, 0xC0, 0x38,
  0x30, 0x1C, 0x0F, 0x1E, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0xF1,
  0xC0, 0xFF, 0x9C, 0x1F, 0x1D, 0xC1, 0xC0, 0x78, 0x38, 0x03, 0x83, 0x00,
  0x38, 0x70, 0x03, 0x86, 0x00, 0x38, 0x60, 0x03, 0x8E, 0x00, 0x30, 0xE0,
  0x03, 0x0E, 0x00, 0x30, 0xE0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x01, 0xE0,
  0x70, 0x3C, 0x07, 0x8F, 0xC0, 0x3F, 0xEC, 0x01, 0xF8, 0xC0, 0x00, 0xFC,
  0x01, 0xFF, 0x01, 0xE3, 0xC1, 0xC0, 0x71, 0xC0, 0x38, 0xC0, 0x0C, 0xE0,
  0x06, 0x60, 0x03, 0x70, 0x01, 0xB8, 0x00, 0xDF, 0xFF, 0xEF, 0xFF, 0xF6,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x83, 0x80, 0xE1, 0xF1, 0xE0, 0x7F, 0xE0, 0x0F,
  0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x1E, 0x40, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x07, 0xFE, 0x1F, 0xF8, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x00, 0x00, 0xFC, 0x30, 0x3F, 0xE7, 0x07, 0xC7, 0x70, 0x70, 0x1E, 0x0E,
  0x00, 0xE0, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x18, 0x00, 0xC3,
  0x80, 0x0C, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x1C,
  0x30, 0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x38, 0x38, 0x03,
  0x83, 0x80, 0x78, 0x1C, 0x0F, 0x01, 0xF3, 0xF0, 0x0F, 0xFB, 0x00, 0x7E,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x40,
  0x0C, 0x0E, 0x01, 0xC0, 0x78, 0x78, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x1F, 0x81,
  0x9F, 0xE0, 0xDC, 0xF8, 0xF8, 0x1C, 0x78, 0x06, 0x38, 0x03, 0x1C, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0x67, 0x00, 0x33, 0x80, 0x39, 0x80, 0x1C, 0xC0,
  0x0E, 0x60, 0x06, 0x70, 0x03, 0x38, 0x01, 0x9C, 0x01, 0xCC, 0x00, 0xE6,
  0x00, 0x73, 0x00, 0x33, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x0E, 0x60, 0x07,
  0x00, 0x02, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0C,
  0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x00, 0x08,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x27, 0x80, 0xFC, 0x03, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x07, 0x06, 0x01, 0xC0, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0x07, 0x00,
  0xC1, 0xC0, 0x18, 0x70, 0x03, 0x1C, 0x00, 0x67, 0x00, 0x1D, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x70, 0x01, 0xCE, 0x00, 0x30, 0xE0, 0x0E,
  0x1C, 0x01, 0xC1, 0xC0, 0x30, 0x38, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x38,
  0x06, 0x07, 0x00, 0xE0, 0xE0, 0x0C, 0x18, 0x01, 0xC0, 0x03, 0x03, 0x03,
  0x07, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70,
  0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x0C, 0x7C, 0x07, 0xE0, 0x33,
  0xFC, 0x3F, 0xC1, 0xFC, 0xF1, 0xC7, 0x87, 0xC0, 0xEC, 0x0E, 0x1E, 0x03,
  0xE0, 0x18, 0x70, 0x07, 0x80, 0x71, 0xC0, 0x1C, 0x01, 0xC6, 0x00, 0x70,
  0x07, 0x38, 0x01, 0x80, 0x1C, 0xE0, 0x06, 0x00, 0x63, 0x80, 0x38, 0x01,
  0x8C, 0x00, 0xE0, 0x06, 0x30, 0x03, 0x80, 0x38, 0xC0, 0x0C, 0x00, 0xE7,
  0x00, 0x30, 0x03, 0x9C, 0x00, 0xC0, 0x0C, 0x70, 0x07, 0x00, 0x31, 0x80,
  0x1C, 0x00, 0xC6, 0x00, 0x70, 0x07, 0x18, 0x01, 0x80, 0x1C, 0xE0, 0x06,
  0x00, 0x73, 0x80, 0x18, 0x01, 0x8C, 0x00, 0xE0, 0x06, 0x30, 0x03, 0x80,
  0x18, 0x0C, 0x7E, 0x06, 0x7F, 0x83, 0x73, 0xE3, 0xE0, 0x71, 0xE0, 0x18,
  0xE0, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00, 0xCE, 0x00,
  0xE6, 0x00, 0x73, 0x00, 0x39, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x06, 0x70,
  0x07, 0x30, 0x03, 0x98, 0x01, 0xCC, 0x00, 0xCE, 0x00, 0x67, 0x00, 0x33,
  0x80, 0x39, 0x80, 0x1C, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xC7, 0x83, 0x80,
  0xE3, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x03, 0xB8, 0x01, 0x9C, 0x01, 0xC7, 0x01,
  0xC1, 0xE3, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x03, 0x1F, 0x80, 0x37, 0xFC,
  0x03, 0xF3, 0xE0, 0x7C, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07, 0x06, 0x00,
  0x70, 0x60, 0x03, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x0E, 0x00, 0x70, 0xC0,
  0x07, 0x0C, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x1C,
  0x00, 0xE1, 0x80, 0x0E, 0x18, 0x00, 0xC1, 0xC0, 0x1C, 0x3E, 0x03, 0x83,
  0xB8, 0xF0, 0x3B, 0xFE, 0x03, 0x0F, 0xC0, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0xC3, 0xFE, 0x71, 0xF1,
  0xD8, 0x70, 0x1E, 0x38, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x39, 0x80, 0x0E,
  0x60, 0x03, 0x38, 0x00, 0xCE, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x07, 0x30,
  0x01, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x03, 0x8C, 0x00,
  0xE3, 0x80, 0x38, 0x60, 0x3C, 0x1E, 0x3F, 0x03, 0xFE, 0xC0, 0x7E, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x78, 0x6F,
  0xC3, 0xFE, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xE7, 0xC1, 0xC0, 0xE1, 0xC0, 0x30, 0xC0,
  0x1C, 0x60, 0x0E, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0x87, 0x01, 0xC3, 0xC7, 0xC0, 0xFF,
  0xC0, 0x1F, 0x80, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x1F,
  0xF7, 0xFE, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3D, 0x03, 0xE0, 0x3C, 0x00, 0x18, 0x01, 0xC6,
  0x00, 0x63, 0x80, 0x18, 0xE0, 0x06, 0x38, 0x01, 0x8C, 0x00, 0xE3, 0x00,
  0x38, 0xC0, 0x0C, 0x70, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x71, 0x80, 0x1C,
  0x60, 0x07, 0x18, 0x01, 0x8E, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x0E, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0x70, 0x3C, 0x1E, 0x3B, 0x03, 0xFD,
  0xC0, 0x7E, 0x70, 0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60, 0x70, 0x70,
  0x60, 0x70, 0x60, 0x30, 0xC0, 0x30, 0xC0, 0x31, 0xC0, 0x31, 0x80, 0x33,
  0x80, 0x33, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0xE0, 0x0C, 0x01, 0xF8, 0x07, 0x00, 0x6E, 0x01, 0xC0,
  0x39, 0x80, 0xF0, 0x0C, 0x60, 0x3C, 0x07, 0x18, 0x0F, 0x01, 0xC6, 0x06,
  0xE0, 0x61, 0x81, 0xB8, 0x38, 0x60, 0xE6, 0x0C, 0x18, 0x31, 0x83, 0x06,
  0x1C, 0x61, 0xC1, 0x86, 0x18, 0x60, 0x61, 0x86, 0x38, 0x18, 0xC1, 0x8C,
  0x06, 0x30, 0x63, 0x01, 0xDC, 0x19, 0x80, 0x76, 0x06, 0x60, 0x1F, 0x81,
  0xB8, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x0E,
  0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x00, 0x70,
  0x60, 0x0E, 0x07, 0x01, 0xC0, 0x30, 0x18, 0x03, 0x83, 0x80, 0x38, 0x70,
  0x01, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x39,
  0x80, 0x07, 0x18, 0x00, 0x71, 0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0xE0, 0x1C,
  0x0E, 0x03, 0x80, 0x60, 0x70, 0x07, 0x0E, 0x00, 0x30, 0x06, 0x00, 0x38,
  0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0x80,
  0x70, 0x0C, 0x03, 0x00, 0x60, 0x38, 0x03, 0x01, 0x80, 0x1C, 0x1C, 0x00,
  0xE0, 0xC0, 0x07, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xC7, 0x00, 0x06, 0x30,
  0x00, 0x33, 0x80, 0x01, 0x98, 0x00, 0x0E, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x02, 0x78, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x40, 0x03,
  0x07, 0x07, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0,
  0xC0, 0x02, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x20, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0xCF,
  0x78, 0x06, 0xE0, 0xE0, 0x36, 0x03, 0x83, 0x30, 0x0F, 0x79, 0x80, 0x3F,
  0x80, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_LightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 32, 9, 1, -32 },
  { 33, 8, 10, 13, 5, -34 },
  { 43, 23, 32, 22, 1, -32 },
  { 135, 18, 40, 21, 2, -36 },
  { 225, 21, 32, 28, 4, -32 },
  { 309, 20, 32, 23, 1, -32 },
  { 389, 4, 10, 7, 4, -34 },
  { 394, 13, 46, 13, 2, -36 },
  { 469, 12, 46, 13, -2, -36 },
  { 538, 18, 18, 19, 2, -32 },
  { 579, 18, 24, 22, 2, -27 },
  { 633, 6, 10, 8, -2, -4 },
  { 641, 9, 2, 11, 1, -15 },
  { 644, 4, 4, 10, 1, -4 },
  { 646, 19, 35, 16, -2, -32 },
  { 730, 18, 32, 21, 2, -32 },
  { 802, 10, 32, 21, 6, -32 },
  { 842, 19, 32, 21, 1, -32 },
  { 918, 19, 32, 21, 1, -32 },
  { 994, 19, 32, 21, 1, -32 },
  { 1070, 19, 32, 21, 3, -32 },
  { 1146, 17, 32, 21, 2, -32 },
  { 1214, 19, 32, 21, 3, -32 },
  { 1290, 19, 32, 21, 1, -32 },
  { 1366, 17, 32, 21, 3, -32 },
  { 1434, 7, 24, 9, 1, -24 },
  { 1455, 10, 30, 8, -2, -24 },
  { 1493, 17, 19, 20, 2, -24 },
  { 1534, 17, 10, 21, 2, -20 },
  { 1556, 17, 19, 20, 1, -24 },
  { 1597, 14, 32, 18, 4, -32 },
  { 1653, 30, 41, 34, 2, -31 },
  { 1807, 22, 32, 24, -1, -32 },
  { 1895, 21, 32, 23, 1, -32 },
  { 1979, 21, 32, 25, 3, -32 },
  { 2063, 22, 32, 25, 1, -32 },
  { 2151, 22, 32, 22, 1, -32 },
  { 2239, 22, 32, 21, 1, -32 },
  { 2327, 21, 32, 26, 3, -32 },
  { 2411, 25, 32, 27, 1, -32 },
  { 2511, 8, 32, 11, 2, -32 },
  { 2543, 20, 32, 21, 1, -32 },
  { 2623, 25, 32, 24, 1, -32 },
  { 2723, 16, 32, 20, 1, -32 },
  { 2787, 31, 32, 33, 1, -32 },
  { 2911, 26, 32, 27, 1, -32 },
  { 3015, 22, 32, 26, 2, -32 },
  { 3103, 22, 32, 24, 1, -32 },
  { 3191, 22, 38, 26, 2, -32 },
  { 3296, 22, 32, 24, 1, -32 },
  { 3384, 22, 32, 23, 1, -32 },
  { 3472, 21, 32, 23, 4, -32 },
  { 3556, 23, 32, 25, 2, -32 },
  { 3648, 22, 32, 24, 4, -32 },
  { 3736, 31, 32, 34, 4, -32 },
  { 3860, 26, 32, 23, -1, -32 },
  { 3964, 21, 32, 23, 4, -32 },
  { 4048, 23, 32, 23, 0, -32 },
  { 4140, 13, 44, 10, 0, -37 },
  { 4212, 7, 35, 15, 5, -32 },
  { 4243, 13, 44, 10, -3, -37 },
  { 4315, 13, 16, 16, 2, -32 },
  { 4341, 16, 2, 17, -2, 0 },
  { 4345, 7, 6, 12, 5, -34 },
  { 4351, 17, 24, 21, 1, -24 },
  { 4402, 18, 34, 21, 1, -34 },
  { 4479, 18, 24, 20, 1, -24 },
  { 4533, 20, 34, 21, 2, -34 },
  { 4618, 17, 24, 20, 1, -24 },
  { 4669, 14, 34, 13, 2, -34 },
  { 4729, 20, 33, 21, 0, -24 },
  { 4812, 17, 34, 21, 1, -34 },
  { 4885, 8, 33, 9, 1, -33 },
  { 4918, 14, 42, 9, -5, -33 },
  { 4992, 19, 34, 19, 1, -34 },
  { 5073, 8, 34, 9, 1, -34 },
  { 5107, 30, 24, 33, 1, -24 },
  { 5197, 17, 24, 21, 1, -24 },
  { 5248, 17, 24, 21, 2, -24 },
  { 5299, 20, 33, 21, -1, -24 },
  { 5382, 18, 33, 21, 2, -24 },
  { 5457, 13, 24, 13, 1, -24 },
  { 5496, 17, 24, 20, 1, -24 },
  { 5547, 11, 30, 13, 2, -30 },
  { 5589, 18, 24, 21, 2, -24 },
  { 5643, 16, 24, 19, 3, -24 },
  { 5691, 26, 24, 29, 3, -24 },
  { 5769, 20, 24, 19, -1, -24 },
  { 5829, 21, 33, 18, -2, -24 },
  { 5916, 18, 24, 19, 0, -24 },
  { 5970, 14, 44, 13, 1, -35 },
  { 6047, 8, 38, 10, 1, -32 },
  { 6085, 14, 44, 13, -2, -35 },
  { 6162, 21, 8, 26, 2, -17 },
};

const GFXfont RobotoCondensed_LightItalic45pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_LightItalic45pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_LightItalic45pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOCONDENSED_LIGHTITALIC45PT7B_H_
