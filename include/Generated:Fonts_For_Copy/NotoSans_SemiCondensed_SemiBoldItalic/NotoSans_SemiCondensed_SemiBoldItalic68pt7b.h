#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC68PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xC1, 0xFE, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1, 0xFC, 0x1F, 0xE3,
  0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0,
  0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF9, 0xE1,
  0xF0, 0x0F, 0xF8, 0xF0, 0x10, 0x07, 0xF8, 0x78, 0x00, 0x03, 0xFC, 0x3C,
  0x00, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0xFF, 0x1E, 0x00, 0x00, 0x7F, 0x8F,
  0x00, 0x00, 0x3F, 0xC7, 0x80, 0x00, 0x1F, 0xF3, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xDF, 0xF8, 0x00, 0x01, 0xE7, 0xFC, 0x00,
  0x00, 0xF1, 0xFE, 0x00, 0x00, 0x78, 0xFF, 0x00, 0x00, 0x78, 0x7F, 0x80,
  0x00, 0x3C, 0x3F, 0xC0, 0x00, 0x1E, 0x1F, 0xE0, 0x80, 0x0F, 0x0F, 0xF0,
  0x70, 0x07, 0x8F, 0xF0, 0x3F, 0x07, 0x9F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x07,
  0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x0F,
  0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x7F, 0x07,
  0xE0, 0xFC, 0x0F, 0xE1, 0xF8, 0x7F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC3, 0xFF,
  0xCF, 0xE1, 0xFC, 0x7F, 0x1F, 0xFF, 0xBF, 0x87, 0xF1, 0xF8, 0xFF, 0xFE,
  0x7F, 0x7F, 0x8F, 0xC7, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0x1F, 0xC7, 0xF7,
  0xFF, 0xF1, 0xF8, 0xFE, 0x1F, 0xCF, 0xFF, 0x8F, 0xC3, 0xF0, 0x3F, 0x1F,
  0xF8, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0xC1, 0xF8, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x07,
  0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xFF,
  0x01, 0xFE, 0x0F, 0xF9, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFC,
  0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF0, 0x7F, 0x80, 0x3F, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xFF,
  0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFE, 0x3F,
  0xE0, 0x0F, 0xFF, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3,
  0xF9, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0,
  0xFC, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x80,
  0x1F, 0x80, 0x07, 0x00, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xFC, 0x3E,
  0x00, 0x1F, 0xF9, 0xF0, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFE, 0x0F, 0xC0, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xBF, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x87, 0xE0,
  0x07, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7C, 0x0F, 0xF0, 0x01,
  0xE0, 0x3F, 0x80, 0x06, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF8,
  0x04, 0x0F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF,
  0xC3, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x1F,
  0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F,
  0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xF7, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE7, 0xFF,
  0xBF, 0xC7, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x0F, 0xC3, 0xFC, 0x0E, 0x07,
  0xF8, 0x18, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x1F, 0x80, 0x3F, 0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x00, 0x30, 0x00, 0x7F,
  0x80, 0x04, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x07, 0xFE, 0x00, 0x38, 0x00,
  0xFF, 0x80, 0x0C, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0xC0, 0x00, 0x1F, 0xF8, 0x3C, 0x00, 0x1F, 0xFC, 0x0F, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0xC0, 0x00, 0x7F, 0xE0, 0x78, 0x00, 0x7F, 0xF0,
  0x3F, 0xC3, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x3F, 0xC7, 0xFF, 0x80, 0x3F, 0xCF, 0xFF, 0xC0, 0x3F, 0xDF,
  0xFF, 0xE0, 0x7F, 0xBF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF0, 0xFF, 0xC0,
  0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80,
  0x0F, 0xF8, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xE3,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F,
  0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC,
  0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0x7F, 0x80, 0x7F, 0xFC, 0xFF, 0x00, 0x7F,
  0xE1, 0xFE, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xC0, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x7E, 0x03, 0xFE, 0x0C, 0x00, 0x7F, 0x82, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xC0, 0x1F, 0xFF,
  0xF0, 0x3F, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0x1F, 0x80, 0x7F, 0xCF,
  0xF0, 0x1F, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x7F, 0x03, 0xF8, 0x07,
  0xE0, 0x3F, 0x7E, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x7E, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0xFC, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0xFC, 0x0F, 0xC0, 0x3F,
  0x80, 0xFC, 0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0xFC, 0x0F, 0xC0, 0x3F,
  0x01, 0xFC, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0xFC, 0x0F, 0xC0, 0xFF,
  0x03, 0xF8, 0xFC, 0x0F, 0xE0, 0xFF, 0x87, 0xF0, 0xFC, 0x0F, 0xF3, 0xFF,
  0x9F, 0xE0, 0xFC, 0x0F, 0xFF, 0xEF, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0xCF,
  0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFD, 0xFF,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x1F, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x07, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0xF8,
  0x01, 0xFF, 0xC0, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0x08, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x20, 0x07, 0xFF, 0x80, 0x1E, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x10, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xF8,
  0xFF, 0x80, 0x1F, 0xFF, 0xE3, 0xFE, 0x00, 0x7F, 0xFF, 0x8F, 0xF8, 0x01,
  0xFF, 0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0x00, 0x3F, 0xFF, 0xC3,
  0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x07,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x38,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0x8F, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x07,
  0xF9, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x7F, 0x80, 0x00, 0x03, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFB, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF7, 0xF8, 0x01,
  0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F,
  0xCF, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3, 0xF8,
  0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x80,
  0x1F, 0xE1, 0xF8, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xE0, 0x3F, 0x87,
  0xF8, 0x01, 0xFC, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7E, 0x07,
  0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xF8, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x07,
  0xF0, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xDF, 0xC0,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFF,
  0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xFC, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xC0, 0x0F, 0xEF, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x0F,
  0xE0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xF8,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0x3F,
  0xC3, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x0F,
  0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF9, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0xC0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF8,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x0F,
  0xFB, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xF0,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x3F,
  0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0x80, 0x0E, 0x00, 0x7F, 0xC0, 0x00,
  0x80, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0x60, 0x00, 0x3F, 0xE0,
  0x1F, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF,
  0x87, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x03, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xEF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0x83, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0xC0,
  0x7F, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0xFC, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF9, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF3,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x8F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFF, 0x00,
  0x3F, 0x81, 0xFC, 0x3F, 0x03, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x7E, 0x07,
  0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF0,
  0xFE, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00,
  0xFC, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xFB,
  0xF8, 0x03, 0xF7, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0xE1, 0xF8, 0x01, 0xFF, 0xF8,
  0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFE, 0x7F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03,
  0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFC, 0xFE,
  0x00, 0x7F, 0xFE, 0x3F, 0x00, 0x0F, 0xFF, 0x1F, 0xC0, 0x01, 0xFF, 0x07,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x06, 0x00, 0x01, 0xFC, 0x3F, 0xE0,
  0x01, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xBF, 0xFF,
  0x80, 0x3F, 0xBF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x1F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F,
  0xF8, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x7E, 0x7F, 0xFF, 0x80, 0x7F, 0x3F, 0xFF, 0x80, 0x3F, 0x8F, 0xFF, 0x80,
  0x1F, 0x81, 0xFF, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x7C,
  0x0F, 0xFC, 0x01, 0x83, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x08, 0x3F, 0xF0, 0x06, 0x07, 0xFF, 0x07, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x02, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0xFC, 0x7F, 0x80, 0x03, 0xFF, 0xF3, 0xFC, 0x00, 0x3F, 0xFF, 0xDF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x87, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFD, 0xFC, 0x00, 0x3F, 0xFF, 0xCF, 0xE0, 0x00, 0xFF, 0xFC, 0x7E, 0x00,
  0x03, 0xFF, 0xC3, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC,
  0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0x0F,
  0xFC, 0x7F, 0x83, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x08, 0x0F, 0xF8, 0x03, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xFF,
  0x87, 0xE0, 0x01, 0xFF, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0xCF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF7,
  0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xCF, 0xF0, 0x00, 0x1F,
  0xF0, 0xFF, 0x00, 0x00, 0x38, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x08, 0x00,
  0x07, 0xFC, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x06, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x3F,
  0xFC, 0x00, 0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0xC0, 0x3F, 0xBF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x9F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0x83, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xE3, 0xFF, 0xFC,
  0x03, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0x83, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x7E, 0x07, 0xFC, 0x00, 0x7F, 0x0F, 0xFF, 0x00, 0x3F, 0x8F, 0xFF, 0xC0,
  0x1F, 0xCF, 0xFF, 0xF0, 0x0F, 0xCF, 0xFF, 0xF8, 0x0F, 0xEF, 0xFF, 0xFC,
  0x07, 0xFF, 0xE7, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xC0, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xC7, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0,
  0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x01,
  0xFF, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x01, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0xFF,
  0xF0, 0x00, 0x3F, 0x8F, 0xFF, 0x80, 0x01, 0xFC, 0xFF, 0xFE, 0x00, 0x0F,
  0xEF, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC7, 0xFE,
  0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0xFF, 0xE0,
  0x01, 0xFD, 0xFF, 0xFE, 0x00, 0x1F, 0xE7, 0xFF, 0xE0, 0x00, 0xFF, 0x1F,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xE1, 0xF8, 0x01, 0xFF,
  0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF, 0xEF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x3F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8,
  0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x87, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFD,
  0xFE, 0x00, 0x7F, 0xFE, 0x7F, 0x00, 0x0F, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x0E, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x1F, 0x83, 0xFC, 0x07, 0xF0, 0xFF, 0x80, 0xFE, 0x3F,
  0xE0, 0x1F, 0xCF, 0xFC, 0x03, 0xFB, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xF9, 0x80, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x7C,
  0x07, 0xF8, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x08, 0x00, 0x1F, 0xF0, 0xE0, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xE0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x30,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0,
  0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFC, 0x0F, 0xFE, 0x03,
  0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xDF, 0xC0,
  0x3F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0xC3, 0xF0,
  0x00, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFE,
  0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x07,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x03, 0xFC,
  0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x1F,
  0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F,
  0xF8, 0x07, 0xF0, 0xFF, 0x01, 0xFB, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xF7,
  0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xBF,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x7F, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xF9, 0xFC, 0x1F, 0xC0, 0x7F, 0x87, 0xF3, 0xF8,
  0x7F, 0x80, 0xFF, 0x0F, 0xC7, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x8F, 0xE3,
  0xFC, 0x01, 0xFC, 0x7E, 0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFC, 0x3F, 0x9F,
  0xE0, 0x07, 0xF3, 0xF8, 0x7F, 0x3F, 0xC0, 0x0F, 0xE7, 0xE0, 0xFE, 0x7F,
  0x00, 0x1F, 0xDF, 0xC1, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x03, 0xFB, 0xF8,
  0x00, 0x7F, 0x7E, 0x07, 0xE7, 0xF0, 0x00, 0xFD, 0xFC, 0x0F, 0xDF, 0xC0,
  0x01, 0xFB, 0xF0, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x3F, 0x7F, 0x00,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03,
  0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x33, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x14, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x02, 0x3F,
  0xFE, 0x00, 0x0D, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0xC0, 0x00, 0xFF, 0xF9, 0x00, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 19, 50, 18, 1, -49 },
  { 120, 23, 18, 28, 7, -49 },
  { 172, 39, 49, 39, 1, -49 },
  { 411, 33, 56, 34, 1, -52 },
  { 642, 46, 50, 53, 4, -49 },
  { 930, 40, 50, 42, 1, -49 },
  { 1180, 10, 18, 16, 7, -49 },
  { 1203, 23, 60, 20, 2, -49 },
  { 1376, 23, 60, 21, -5, -49 },
  { 1549, 29, 30, 33, 6, -52 },
  { 1658, 30, 32, 36, 4, -40 },
  { 1778, 14, 17, 17, -3, -8 },
  { 1808, 18, 7, 21, 1, -22 },
  { 1824, 10, 11, 17, 1, -10 },
  { 1838, 34, 49, 26, -3, -49 },
  { 2047, 32, 50, 34, 2, -49 },
  { 2247, 23, 49, 34, 7, -49 },
  { 2388, 35, 49, 34, -2, -49 },
  { 2603, 34, 50, 34, 0, -49 },
  { 2816, 35, 49, 34, -1, -49 },
  { 3031, 33, 50, 34, 1, -49 },
  { 3238, 32, 50, 34, 3, -49 },
  { 3438, 34, 49, 34, 3, -49 },
  { 3647, 33, 50, 34, 1, -49 },
  { 3854, 31, 50, 34, 2, -49 },
  { 4048, 16, 39, 18, 1, -38 },
  { 4126, 21, 47, 18, -4, -38 },
  { 4250, 30, 33, 36, 4, -41 },
  { 4374, 30, 20, 36, 4, -34 },
  { 4449, 30, 33, 36, 4, -41 },
  { 4573, 26, 50, 27, 4, -49 },
  { 4736, 48, 55, 52, 3, -49 },
  { 5066, 37, 49, 37, -4, -49 },
  { 5293, 37, 49, 38, 1, -49 },
  { 5520, 36, 50, 36, 4, -49 },
  { 5745, 39, 49, 41, 1, -49 },
  { 5984, 34, 49, 33, 1, -49 },
  { 6193, 34, 49, 31, 1, -49 },
  { 6402, 38, 50, 42, 4, -49 },
  { 6640, 43, 49, 43, 1, -49 },
  { 6904, 29, 49, 23, -2, -49 },
  { 7082, 31, 63, 19, -11, -49 },
  { 7327, 42, 49, 37, 1, -49 },
  { 7585, 25, 49, 31, 1, -49 },
  { 7739, 54, 49, 54, 1, -49 },
  { 8070, 45, 49, 45, 1, -49 },
  { 8346, 39, 50, 44, 4, -49 },
  { 8590, 36, 49, 37, 1, -49 },
  { 8811, 39, 61, 44, 4, -49 },
  { 9109, 36, 49, 37, 1, -49 },
  { 9330, 34, 50, 32, 0, -49 },
  { 9543, 31, 49, 32, 6, -49 },
  { 9733, 39, 50, 42, 4, -49 },
  { 9977, 36, 49, 36, 6, -49 },
  { 10198, 55, 49, 55, 6, -49 },
  { 10535, 44, 49, 35, -4, -49 },
  { 10805, 34, 49, 33, 6, -49 },
  { 11014, 38, 49, 32, -2, -49 },
  { 11247, 28, 60, 21, -2, -49 },
  { 11457, 14, 49, 26, 7, -49 },
  { 11543, 27, 60, 21, -5, -49 },
  { 11746, 32, 30, 35, 1, -49 },
  { 11866, 26, 5, 25, -6, 6 },
  { 11883, 12, 11, 20, 10, -52 },
  { 11900, 34, 39, 36, 2, -38 },
  { 12066, 33, 53, 36, 1, -52 },
  { 12285, 27, 39, 29, 3, -38 },
  { 12417, 37, 53, 36, 2, -52 },
  { 12663, 29, 39, 33, 3, -38 },
  { 12805, 38, 68, 22, -8, -52 },
  { 13128, 36, 54, 37, 0, -38 },
  { 13371, 33, 52, 37, 1, -52 },
  { 13586, 18, 51, 18, 1, -51 },
  { 13701, 29, 67, 18, -9, -51 },
  { 13944, 35, 52, 33, 1, -52 },
  { 14172, 19, 52, 18, 1, -52 },
  { 14296, 51, 38, 55, 1, -38 },
  { 14539, 33, 38, 37, 1, -38 },
  { 14696, 30, 39, 36, 3, -38 },
  { 14843, 37, 54, 36, -3, -38 },
  { 15093, 34, 54, 36, 2, -38 },
  { 15323, 27, 38, 25, 1, -38 },
  { 15452, 28, 39, 28, 0, -38 },
  { 15589, 22, 46, 23, 3, -45 },
  { 15716, 33, 38, 37, 3, -37 },
  { 15873, 30, 37, 31, 4, -37 },
  { 16012, 47, 37, 48, 4, -37 },
  { 16230, 37, 37, 32, -3, -37 },
  { 16402, 39, 53, 31, -5, -37 },
  { 16661, 31, 37, 28, -2, -37 },
  { 16805, 27, 60, 24, 1, -49 },
  { 17008, 7, 68, 33, 13, -52 },
  { 17068, 26, 60, 24, -3, -49 },
  { 17263, 31, 10, 36, 3, -29 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC68PT7B_H_
