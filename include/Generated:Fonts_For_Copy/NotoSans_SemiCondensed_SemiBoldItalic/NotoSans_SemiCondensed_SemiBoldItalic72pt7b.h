#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC72PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F,
  0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFE,
  0x07, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x08, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x9E, 0x7F, 0x00, 0x7F,
  0xC7, 0xC1, 0xC0, 0x0F, 0xF0, 0xF0, 0x08, 0x01, 0xFE, 0x1E, 0x00, 0x00,
  0x7F, 0x83, 0xC0, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x01, 0xFE, 0x1F, 0x00,
  0x00, 0x3F, 0xE3, 0xC0, 0x00, 0x07, 0xFC, 0x78, 0x00, 0x00, 0xFF, 0xCF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0x9F, 0xF8, 0x00, 0x00, 0xF1, 0xFF, 0x00, 0x00,
  0x1E, 0x3F, 0xE0, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x00, 0xF0, 0x7F, 0x80,
  0x00, 0x1E, 0x0F, 0xF0, 0x00, 0x03, 0xC3, 0xFE, 0x08, 0x00, 0x78, 0x7F,
  0xC1, 0xC0, 0x1F, 0x1F, 0xF0, 0x3E, 0x03, 0xC7, 0xFE, 0x07, 0xFC, 0x7B,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0C,
  0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x7F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0xFF,
  0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0xFF, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0xFF,
  0xFF, 0x3F, 0x8F, 0xF1, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF1, 0xFC, 0x7F,
  0xFF, 0xEF, 0xFF, 0xF1, 0xFC, 0x7F, 0x87, 0xF3, 0xFF, 0xF0, 0xFE, 0x3F,
  0x83, 0xF9, 0xFF, 0xF0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0xF0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x83,
  0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xBF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0x81, 0xFF, 0xBF, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x0F, 0xFC, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x3F, 0xC1, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xDF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x7F,
  0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x04, 0x00, 0xFE, 0x00, 0x0C,
  0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFF,
  0x8F, 0xC0, 0x03, 0xFF, 0xDF, 0x00, 0x17, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xC1, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x07, 0xFC, 0x7E, 0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x38, 0x07, 0xF8,
  0x00, 0x20, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0x1F, 0x8F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xC3, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x07,
  0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xF7, 0xF8, 0xFF, 0xE7, 0xF8, 0x7F, 0x87,
  0xF8, 0x7F, 0x0F, 0xF8, 0x3C, 0x0F, 0xF0, 0x18, 0x0F, 0xF0, 0x10, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0x9F, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0x80, 0x03, 0xFE, 0x00, 0x08, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFC, 0x1F, 0xFE, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x01, 0x80,
  0x03, 0xFE, 0x00, 0x10, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x80, 0x00, 0x0F, 0xFC, 0x0E, 0x00, 0x01, 0xFF, 0xC0, 0xFC,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x01, 0xFC,
  0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x10, 0x00, 0x03, 0xFF, 0x03, 0x80, 0x00, 0xFF,
  0xE0, 0x7C, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x06, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0xE3, 0xFF, 0xC0, 0x0F, 0xF9,
  0xFF, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF,
  0x0F, 0xFC, 0x00, 0x3F, 0xC3, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC3, 0xFE, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0,
  0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x0F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x3F,
  0xE0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0xC7,
  0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xF8,
  0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x0F, 0xFE, 0x3F, 0xE0, 0x07, 0xFE,
  0x1F, 0xF0, 0x07, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF,
  0xF0, 0x0F, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xE7, 0xFC, 0x00, 0xFF, 0xC3,
  0xFC, 0x00, 0x03, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x08, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0x07, 0xFF, 0x0F, 0x00,
  0x3F, 0xE1, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF,
  0xC0, 0x7E, 0x07, 0xF0, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x7E, 0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x07, 0xE1, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xF1, 0xF8,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE7, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x7E, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE7, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x7E, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xEF, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0xFC, 0xFE, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xCF, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xFC, 0xFC, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF8, 0xFC,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0xFC, 0x07, 0xE0, 0x3F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7F, 0x07, 0xFE, 0x0F,
  0xE0, 0xFC, 0x07, 0xF8, 0xFF, 0xE3, 0xFC, 0x0F, 0xC0, 0x7F, 0xFF, 0x7F,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF3, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF,
  0xBF, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xE0,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xE0,
  0x07, 0xFF, 0x80, 0x01, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0C, 0x00, 0x3F, 0xFC,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF,
  0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0x0E, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x07, 0xFF, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xFE, 0x3F, 0xF0, 0x01, 0xFF,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x87,
  0xFC, 0x00, 0x7F, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x80, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x00,
  0x1F, 0xDF, 0xE0, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFD,
  0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x07,
  0xFB, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x80,
  0x0F, 0xF3, 0xF8, 0x01, 0xFE, 0x7F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE,
  0x3F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC, 0x7F,
  0x80, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0xC3,
  0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0xC1, 0xFC,
  0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x80, 0x1F,
  0xE0, 0x7F, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xE3,
  0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF3, 0xFC, 0x07, 0xF8, 0x01, 0xFE,
  0x03, 0xF9, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFD, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFE, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xC0,
  0x07, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00, 0x7F,
  0xCF, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x00,
  0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFE, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFD,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x03,
  0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x0F, 0xFC, 0x00,
  0x18, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x60, 0x00, 0x1F, 0xF8, 0x07, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFD,
  0xFE, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x03, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xF0, 0x00,
  0x01, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xEF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xE3, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFE, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF3,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x3F, 0x83, 0xFE, 0x00, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0,
  0x3F, 0x87, 0xF8, 0x00, 0x3F, 0xC3, 0xF8, 0x0F, 0xE3, 0xFE, 0x00, 0x0F,
  0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xE0,
  0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xF8, 0x03, 0xF9, 0xFE, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x80,
  0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x1F,
  0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xFC,
  0x00, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0x8F, 0xE0, 0x0F, 0xFF, 0xFB,
  0xFC, 0x03, 0xFF, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE,
  0xFF, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFF, 0x1F,
  0xC0, 0x07, 0xFF, 0xC3, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x0F,
  0x00, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xE3, 0xFF, 0xC0, 0x03, 0xFC,
  0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07,
  0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x1F,
  0xF0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xFF, 0xC0, 0x3F, 0x9F,
  0xFF, 0xF0, 0x0F, 0xE3, 0xFF, 0xFC, 0x01, 0xFC, 0x3F, 0xFE, 0x00, 0x3F,
  0x81, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0xFC, 0x07, 0xFF, 0x00, 0xC0, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x40, 0xFF, 0xE0, 0x1E, 0x03, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x78, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0xFF, 0x00, 0x07, 0xFF, 0xF3, 0xFC, 0x00, 0x3F, 0xFF, 0xEF, 0xF0,
  0x01, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFD,
  0xFF, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xFC,
  0x00, 0xFF, 0xF3, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xF3, 0xF8, 0x00, 0x3F, 0xFF, 0x8F, 0xE0,
  0x00, 0x7F, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01,
  0xFF, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xF8, 0xFF, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xF4, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x40, 0xFF, 0xC0, 0x03, 0x80, 0xFF,
  0xE0, 0x3F, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x04, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x83, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0xFC, 0x3F, 0x80,
  0x03, 0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0xFF, 0xF7, 0xF8, 0x00, 0xFF, 0xFF,
  0xDF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xCF, 0xF0, 0x00, 0x3F, 0xFE,
  0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x00, 0x1C, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x7F,
  0xE0, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x0F, 0x80, 0x00, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xE3, 0xFF, 0xE0, 0x03,
  0xFC, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xFF, 0xE0, 0x1F, 0xEF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x20, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0xFF, 0xC0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00,
  0xFF, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x9F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x87, 0xFC,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xE1,
  0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0x8F, 0xFF, 0xC1, 0xFF, 0xFC, 0x01,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE0, 0x1F, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC1, 0xFF, 0xC0, 0x03,
  0xF8, 0x7F, 0xFC, 0x00, 0x7F, 0x1F, 0xFF, 0xC0, 0x1F, 0xC7, 0xFF, 0xFC,
  0x03, 0xF9, 0xFF, 0xFF, 0x80, 0x7F, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xE0,
  0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC,
  0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF0,
  0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xDF, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x03,
  0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x01,
  0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F,
  0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xC1, 0xFF, 0x80, 0x00, 0x3F, 0x87, 0xFF, 0x80, 0x00, 0x7F, 0x1F, 0xFF,
  0x80, 0x01, 0xFC, 0x7F, 0xFF, 0x80, 0x03, 0xF9, 0xFF, 0xFF, 0x80, 0x07,
  0xF7, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFF,
  0xEF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xBF, 0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0xFF, 0x80, 0x03, 0xFC,
  0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x1E, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x81, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0x8F,
  0xE0, 0x0F, 0xFF, 0xF9, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFE, 0xFF, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x83, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x01,
  0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFD, 0xFE,
  0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x07, 0xFF, 0xCF, 0xF8, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x01, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF0, 0x7F,
  0xC0, 0x3F, 0x87, 0xFC, 0x01, 0xFC, 0x7F, 0xE0, 0x1F, 0xE7, 0xFF, 0x00,
  0xFF, 0x7F, 0xF8, 0x07, 0xF7, 0xFF, 0x80, 0x3F, 0xBF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7C, 0x07,
  0xFC, 0x00, 0xE0, 0x3F, 0xE0, 0x01, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x10, 0x00,
  0x1F, 0xF0, 0xF0, 0x01, 0xFF, 0x87, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xE7, 0xF0, 0x03, 0xFF, 0xF8,
  0xFE, 0x00, 0x3F, 0xFE, 0x1F, 0xC0, 0x03, 0xFF, 0x03, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x7F,
  0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F,
  0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFB, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x3F, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xE1, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x3F, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xDF, 0x80, 0x7F, 0x81,
  0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xE0, 0x7F, 0x01, 0xFD, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0xFE, 0x7E, 0x07, 0xFC, 0x07, 0xF0, 0x3F, 0x9F, 0x81, 0xFE,
  0x01, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x80, 0x7F, 0x07, 0xF1, 0xF8, 0x3F,
  0xC0, 0x1F, 0xC1, 0xFC, 0x7E, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x1F, 0x87,
  0xF8, 0x01, 0xFC, 0x3F, 0x87, 0xE1, 0xFE, 0x00, 0x7F, 0x1F, 0xC1, 0xF8,
  0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x7E, 0x3F, 0xC0, 0x07, 0xF1, 0xF8, 0x1F,
  0x8F, 0xF0, 0x01, 0xFC, 0xFE, 0x07, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0x81,
  0xF9, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x7E, 0x7F, 0x00, 0x07, 0xF7, 0xF0,
  0x1F, 0xBF, 0xC0, 0x01, 0xFD, 0xF8, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE,
  0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F,
  0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xF1,
  0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0x1F, 0xFE, 0x00, 0x01,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x80, 0x00, 0xFF, 0xFC, 0x80, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 20, 52, 19, 1, -51 },
  { 131, 24, 18, 29, 7, -51 },
  { 185, 42, 51, 42, 1, -51 },
  { 453, 35, 59, 36, 1, -55 },
  { 712, 49, 53, 56, 4, -52 },
  { 1037, 42, 53, 44, 1, -52 },
  { 1316, 11, 18, 17, 7, -51 },
  { 1341, 25, 62, 22, 2, -51 },
  { 1535, 24, 63, 22, -5, -52 },
  { 1724, 31, 32, 35, 6, -55 },
  { 1848, 32, 35, 38, 4, -43 },
  { 1988, 15, 18, 18, -3, -9 },
  { 2022, 19, 8, 22, 1, -23 },
  { 2041, 10, 11, 18, 1, -10 },
  { 2055, 36, 52, 28, -3, -52 },
  { 2289, 34, 53, 36, 2, -52 },
  { 2515, 24, 51, 36, 8, -51 },
  { 2668, 37, 52, 36, -2, -52 },
  { 2909, 36, 53, 36, 0, -52 },
  { 3148, 37, 52, 36, -1, -52 },
  { 3389, 35, 52, 36, 1, -51 },
  { 3617, 34, 53, 36, 3, -52 },
  { 3843, 36, 51, 36, 3, -51 },
  { 4073, 35, 53, 36, 1, -52 },
  { 4305, 33, 53, 36, 2, -52 },
  { 4524, 17, 41, 19, 1, -40 },
  { 4612, 22, 49, 19, -4, -40 },
  { 4747, 32, 36, 38, 4, -44 },
  { 4891, 32, 21, 38, 4, -36 },
  { 4975, 32, 36, 38, 4, -44 },
  { 5119, 27, 53, 29, 4, -52 },
  { 5298, 52, 58, 55, 3, -52 },
  { 5675, 39, 51, 39, -4, -51 },
  { 5924, 39, 51, 40, 1, -51 },
  { 6173, 38, 53, 39, 4, -52 },
  { 6425, 41, 51, 44, 1, -51 },
  { 6687, 36, 51, 34, 1, -51 },
  { 6917, 36, 51, 33, 1, -51 },
  { 7147, 41, 53, 45, 4, -52 },
  { 7419, 45, 51, 45, 1, -51 },
  { 7706, 31, 51, 24, -2, -51 },
  { 7904, 32, 66, 20, -11, -51 },
  { 8168, 44, 51, 39, 1, -51 },
  { 8449, 27, 51, 33, 1, -51 },
  { 8622, 57, 51, 57, 1, -51 },
  { 8986, 48, 51, 48, 1, -51 },
  { 9292, 41, 53, 47, 4, -52 },
  { 9564, 39, 51, 39, 1, -51 },
  { 9813, 41, 64, 47, 4, -52 },
  { 10141, 38, 51, 39, 1, -51 },
  { 10384, 36, 53, 34, 0, -52 },
  { 10623, 33, 51, 34, 6, -51 },
  { 10834, 42, 52, 45, 4, -51 },
  { 11107, 38, 51, 38, 6, -51 },
  { 11350, 58, 51, 58, 7, -51 },
  { 11720, 47, 51, 37, -4, -51 },
  { 12020, 36, 51, 35, 6, -51 },
  { 12250, 40, 51, 34, -2, -51 },
  { 12505, 29, 62, 22, -2, -51 },
  { 12730, 15, 52, 28, 8, -52 },
  { 12828, 29, 62, 22, -5, -51 },
  { 13053, 34, 32, 37, 1, -52 },
  { 13189, 28, 5, 27, -7, 6 },
  { 13207, 14, 11, 21, 10, -55 },
  { 13227, 35, 41, 38, 3, -40 },
  { 13407, 35, 56, 39, 1, -55 },
  { 13652, 29, 41, 31, 3, -40 },
  { 13801, 38, 56, 39, 3, -55 },
  { 14067, 31, 41, 35, 3, -40 },
  { 14226, 39, 72, 23, -8, -55 },
  { 14577, 38, 57, 39, 0, -40 },
  { 14848, 35, 55, 39, 1, -55 },
  { 15089, 20, 54, 19, 1, -54 },
  { 15224, 30, 71, 19, -9, -54 },
  { 15491, 37, 55, 35, 1, -55 },
  { 15746, 20, 55, 19, 1, -55 },
  { 15884, 54, 40, 58, 1, -40 },
  { 16154, 35, 40, 39, 1, -40 },
  { 16329, 32, 41, 38, 3, -40 },
  { 16493, 39, 57, 39, -3, -40 },
  { 16771, 35, 57, 39, 3, -40 },
  { 17021, 29, 40, 27, 1, -40 },
  { 17166, 29, 41, 30, 0, -40 },
  { 17315, 23, 49, 25, 3, -48 },
  { 17456, 35, 40, 39, 3, -39 },
  { 17631, 32, 39, 32, 4, -39 },
  { 17787, 50, 39, 50, 4, -39 },
  { 18031, 40, 39, 34, -3, -39 },
  { 18226, 43, 56, 33, -6, -39 },
  { 18527, 32, 39, 29, -2, -39 },
  { 18683, 28, 62, 25, 1, -51 },
  { 18900, 7, 72, 35, 14, -55 },
  { 18963, 28, 62, 25, -4, -51 },
  { 19180, 32, 11, 38, 4, -31 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC72PT7B_H_
