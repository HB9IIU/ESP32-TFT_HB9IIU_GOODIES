#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC51PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0x20, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0xCF, 0x87,
  0xCF, 0xC3, 0xE7, 0xE3, 0xF3, 0xE1, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x78,
  0x3E, 0x3C, 0x1E, 0x3E, 0x0F, 0x1F, 0x0F, 0x8F, 0x07, 0xC0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x0F,
  0x80, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3E, 0x00,
  0x07, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E,
  0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C,
  0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xFD, 0xFF, 0x01, 0xF9, 0xC3, 0x81, 0xF8, 0xE0, 0x00, 0xFC,
  0x70, 0x00, 0x7E, 0x38, 0x00, 0x3F, 0x1C, 0x00, 0x1F, 0xDC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3B, 0xF8, 0x00, 0x1C, 0xFE, 0x00, 0x0E, 0x3F, 0x00, 0x07, 0x1F,
  0x80, 0x03, 0x8F, 0xC4, 0x03, 0x8F, 0xC3, 0x81, 0xCF, 0xE1, 0xF8, 0xEF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0x00, 0xFF, 0x80, 0x07, 0xC0, 0x3F, 0xF8, 0x00, 0xF8, 0x0F, 0xFF,
  0x00, 0x3E, 0x01, 0xFB, 0xF0, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x0F,
  0x87, 0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x03, 0xE0,
  0x0F, 0x83, 0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x07,
  0xC0, 0x0F, 0x83, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x7C, 0x00, 0x3E, 0x0F,
  0x8F, 0x80, 0x07, 0xC3, 0xE3, 0xE3, 0xF8, 0xF8, 0x7C, 0xF8, 0xFF, 0x9F,
  0x1F, 0x1F, 0x3F, 0xFB, 0xF7, 0xE7, 0xCF, 0xFF, 0x3F, 0xF9, 0xF3, 0xF3,
  0xE7, 0xFE, 0x3E, 0x7C, 0x3E, 0x7F, 0x8F, 0x9F, 0x07, 0xC7, 0xE3, 0xE3,
  0xE0, 0xF8, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0x03, 0xC0, 0x07,
  0xC3, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x83, 0xE0,
  0x0F, 0x81, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x1F, 0x00, 0x7C, 0x07, 0xC3,
  0xE0, 0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0x03,
  0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xF8, 0x07, 0xC0, 0x07, 0xFE, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x0F, 0xC1, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x81, 0xF8, 0x7F, 0x7F,
  0x07, 0xE3, 0xF8, 0xFC, 0x3F, 0x1F, 0xC3, 0xF9, 0xFC, 0x7E, 0x07, 0xF7,
  0xE3, 0xF8, 0x0F, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC, 0x3F, 0x00, 0x7F, 0xE0,
  0xFC, 0x01, 0xFF, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFD, 0xFC, 0x07, 0xFF, 0xC7, 0xF0, 0x0F, 0xFC, 0x0F, 0xE0, 0x02, 0x00,
  0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0xF8, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x30, 0x3E, 0x01, 0xE1, 0xE0, 0x1F, 0xCF, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFE,
  0x04, 0x3F, 0xF0, 0x03, 0xF7, 0xC0, 0x3F, 0x3E, 0x03, 0xF8, 0xF8, 0x0F,
  0x87, 0xC0, 0x38, 0x3F, 0x00, 0x80, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83,
  0xF0, 0x7C, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x00, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x30, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0x3F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F,
  0x80, 0xFC, 0x7E, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x7F, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x07, 0xF3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFC, 0x3F,
  0x03, 0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0x3F, 0x1F, 0x8F, 0x83, 0xC7, 0xE0,
  0x41, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0x9F, 0xF0, 0x1F, 0x01, 0xFC, 0x03, 0x80, 0x7F, 0x00, 0x40,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xC7, 0xFC, 0x07, 0x00, 0xFE, 0x01, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE2, 0x00, 0x0F, 0xE1, 0xC0, 0x0F,
  0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xDF, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xE7,
  0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0,
  0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0xF8,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x01, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x84, 0x00,
  0x3F, 0x83, 0x80, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x02, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x3F, 0x7F, 0xE0,
  0x7E, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0x81, 0xF8,
  0x7F, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC,
  0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xE7, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0xFE,
  0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF8, 0x07, 0xE1,
  0xFC, 0x07, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x80,
  0xFE, 0x3F, 0x81, 0xFE, 0x1F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0x7E, 0x0F, 0xFF, 0xFC, 0x07, 0xFC, 0xFC, 0x01, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x80, 0x3F, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x10, 0x00,
  0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7E, 0x1F, 0xC6,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x0F, 0x83, 0xF0, 0x07, 0xC0, 0x3C, 0x1F, 0x01, 0xFF, 0xE1, 0xE1,
  0xF0, 0x1F, 0xFF, 0x0F, 0x0F, 0x83, 0xFF, 0xF0, 0x7C, 0xF8, 0x1F, 0x0F,
  0x83, 0xE7, 0xC1, 0xF0, 0x7C, 0x1F, 0x7C, 0x1F, 0x03, 0xE0, 0xFB, 0xE0,
  0xF8, 0x1E, 0x07, 0x9E, 0x0F, 0x81, 0xF0, 0x3C, 0xF0, 0x7C, 0x0F, 0x81,
  0xEF, 0x83, 0xC0, 0x7C, 0x1F, 0x7C, 0x3E, 0x03, 0xC0, 0xFB, 0xE1, 0xF0,
  0x3E, 0x07, 0x9F, 0x0F, 0x81, 0xF0, 0x7C, 0xF8, 0x7C, 0x0F, 0x83, 0xC7,
  0x83, 0xE0, 0xF8, 0x3E, 0x3C, 0x1F, 0x0F, 0xE1, 0xE1, 0xF0, 0xFC, 0xFF,
  0x3F, 0x0F, 0x83, 0xFF, 0x7F, 0xF0, 0x7C, 0x1F, 0xF3, 0xFF, 0x03, 0xE0,
  0x7F, 0x0F, 0xE0, 0x0F, 0x80, 0x40, 0x0C, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x80, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E,
  0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x87, 0xC0,
  0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x07,
  0xE0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x7F, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0xFC, 0x01,
  0xFC, 0x1F, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x60, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x04, 0x03, 0xFE, 0x03, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0xFE,
  0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xF0, 0x7E, 0x00, 0xFF,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xF8, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0x80, 0xFF, 0x00, 0x04, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x3F, 0x80, 0x7F,
  0xF1, 0xFC, 0x07, 0xFF, 0x8F, 0xC0, 0x3F, 0xFC, 0x7E, 0x01, 0xFF, 0xE3,
  0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03,
  0xF0, 0x7F, 0x80, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x83, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0xC0, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x7F, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x07, 0xEF, 0x80, 0x3E, 0xFC, 0x07, 0xEF, 0x80, 0x3E, 0xFC,
  0x07, 0xEF, 0x80, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0xF9, 0xF8, 0x0F, 0xCF, 0x81, 0xF1,
  0xF8, 0x0F, 0xCF, 0x81, 0xF1, 0xF8, 0x0F, 0x8F, 0x83, 0xE3, 0xF0, 0x1F,
  0x8F, 0x83, 0xE3, 0xF0, 0x1F, 0x8F, 0x87, 0xC3, 0xF0, 0x1F, 0x8F, 0x87,
  0xC3, 0xF0, 0x1F, 0x8F, 0x8F, 0x83, 0xE0, 0x1F, 0x0F, 0x8F, 0x87, 0xE0,
  0x3F, 0x07, 0xDF, 0x07, 0xE0, 0x3F, 0x07, 0xDF, 0x07, 0xE0, 0x3F, 0x07,
  0xFE, 0x07, 0xE0, 0x3E, 0x07, 0xFE, 0x07, 0xC0, 0x3E, 0x07, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x03, 0xE0, 0x1F, 0xE0, 0x01,
  0xF8, 0x07, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0xC0,
  0x07, 0xC0, 0x3F, 0xF8, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x7E, 0xFC, 0x03, 0xE0, 0x1F,
  0xBF, 0x01, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x01, 0xF1, 0xF8, 0x1F, 0x80,
  0x7C, 0x7E, 0x07, 0xE0, 0x3F, 0x1F, 0x81, 0xF0, 0x0F, 0xC3, 0xE0, 0xFC,
  0x03, 0xF0, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC3,
  0xE0, 0x1F, 0x81, 0xF8, 0xF8, 0x07, 0xE0, 0x7E, 0x7E, 0x01, 0xF8, 0x1F,
  0x9F, 0x80, 0x7C, 0x03, 0xE7, 0xE0, 0x3F, 0x00, 0xFD, 0xF0, 0x0F, 0xC0,
  0x3F, 0x7C, 0x03, 0xF0, 0x0F, 0xDF, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x3E,
  0x00, 0x7F, 0xF0, 0x1F, 0x80, 0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xFE, 0x01,
  0xF8, 0x00, 0xFF, 0x80, 0x7C, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0xF8,
  0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD,
  0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xC0, 0x7F,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xBF, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xF0,
  0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8,
  0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFE, 0x0F, 0xC7, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x83,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF0,
  0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x70,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x04, 0x00, 0x7F, 0x83, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC,
  0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x80,
  0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xC0,
  0x0F, 0xCF, 0xC0, 0x1F, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xF0, 0x07, 0xE3,
  0xF0, 0x0F, 0xF8, 0x03, 0xF1, 0xF8, 0x07, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xFF, 0x01, 0xF8, 0x3F, 0x01, 0xFF, 0x80,
  0xFC, 0x1F, 0x81, 0xF7, 0xC0, 0x7E, 0x0F, 0xC0, 0xFB, 0xE0, 0x7E, 0x07,
  0xE0, 0xFD, 0xF0, 0x3F, 0x03, 0xF0, 0x7C, 0xF8, 0x3F, 0x01, 0xF8, 0x3E,
  0x7C, 0x1F, 0x80, 0xFC, 0x3E, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x1F, 0x0F,
  0xC0, 0x3F, 0x1F, 0x0F, 0x87, 0xE0, 0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x0F,
  0xCF, 0xC3, 0xE3, 0xF0, 0x07, 0xE7, 0xC1, 0xF3, 0xF0, 0x03, 0xF3, 0xE0,
  0xF9, 0xF8, 0x01, 0xFB, 0xE0, 0x7C, 0xFC, 0x00, 0xFD, 0xF0, 0x3E, 0xFC,
  0x00, 0x7D, 0xF0, 0x1F, 0x7E, 0x00, 0x3E, 0xF8, 0x0F, 0xBE, 0x00, 0x1F,
  0x7C, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x07,
  0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0x7D,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC1, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0xF9, 0xE0, 0x01, 0xF1, 0xF0,
  0x01, 0xF1, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8,
  0x0F, 0x80, 0x78, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0x3C,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0x80,
  0xFF, 0xCF, 0xC0, 0xFF, 0xE7, 0xC0, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0x0F, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F,
  0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0,
  0x7F, 0x87, 0xE0, 0x3F, 0x83, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFD, 0xF0, 0x0F, 0xFC, 0xF8, 0x03, 0xF8, 0x7C, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x7F, 0xC0, 0x3F, 0x7F, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0x07, 0xF8, 0x1F, 0x83,
  0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07,
  0xF1, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xBF, 0xFE, 0x07, 0xCF,
  0xFE, 0x03, 0xC3, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xF0, 0x30,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x0C, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xF1, 0xF0, 0x07, 0xFF, 0x7E,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xE1, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xFE, 0x00,
  0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xBE, 0x00, 0x7F, 0xE7, 0xC0, 0x07, 0xF8, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0x01, 0xFF, 0xFE, 0x0F, 0xFB, 0xF8, 0x3F, 0x83, 0xF1, 0xFC, 0x0F, 0xCF,
  0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0x83,
  0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0C, 0x1F, 0xE1, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC2, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x83, 0xE0, 0x0F, 0xFC, 0xFC, 0x03, 0xFF, 0x9F, 0x00, 0xFF, 0xFB,
  0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0,
  0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0x7E, 0x07,
  0xF8, 0x0F, 0xE1, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFC, 0x03,
  0xFF, 0xDF, 0x00, 0x3F, 0xF7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x10, 0x00, 0xFC, 0x03, 0x80, 0x7F, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x07, 0xE7, 0xFC, 0x07, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x00,
  0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0x9F, 0xC0, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xC7, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC1,
  0xF8, 0x0F, 0xE0, 0x1F, 0x1F, 0xF0, 0x7F, 0xC0, 0x7C, 0xFF, 0xE3, 0xFF,
  0x81, 0xF7, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xE1,
  0xFF, 0x87, 0xF0, 0xFF, 0x03, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF1, 0xFC, 0x07,
  0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8,
  0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xC1, 0xF8, 0x07, 0xC7, 0xFC, 0x07, 0xCF, 0xFE, 0x07, 0xDF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00,
  0x7E, 0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x9F,
  0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x0F, 0x8F, 0xF8, 0x00, 0xF9, 0xFF, 0xC0, 0x0F, 0xBF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0xFE, 0x01, 0xFE, 0x07, 0xE0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xC0, 0x1F, 0x9F, 0xF8, 0x01, 0xF8, 0xFE,
  0x00, 0x1F, 0x03, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0xFF,
  0xCF, 0x80, 0xFF, 0xF7, 0xC0, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0x0F, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x1F,
  0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7,
  0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F,
  0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFD, 0xF0, 0x0F, 0xFD, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x20,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xC1, 0xF0, 0x7C, 0x7F, 0x07, 0xCF, 0xF0, 0x7D, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xE0, 0x30, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x40, 0x0F, 0xE3, 0x00, 0x7F, 0x1F, 0x9F,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF,
  0xBF, 0xFF, 0xC1, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xFB, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x00, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F,
  0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80,
  0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x07,
  0xE0, 0x7F, 0x83, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFD, 0xF0,
  0x3F, 0xFD, 0xF0, 0x0F, 0xFC, 0xF8, 0x03, 0xF8, 0x7C, 0x00, 0x20, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xF7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0,
  0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0xFC, 0x07,
  0xC1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7C,
  0x7E, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0x7E,
  0x03, 0xFC, 0x07, 0xEF, 0xC0, 0xFF, 0x81, 0xF9, 0xF8, 0x1F, 0xF0, 0x3F,
  0x3F, 0x07, 0xFE, 0x0F, 0xC7, 0xE0, 0xFF, 0xC1, 0xF8, 0xFC, 0x1E, 0xF8,
  0x3E, 0x1F, 0x87, 0xDF, 0x0F, 0xC3, 0xF0, 0xFB, 0xE1, 0xF8, 0x7E, 0x3E,
  0x7C, 0x7E, 0x0F, 0xC7, 0xCF, 0x8F, 0xC1, 0xF8, 0xF1, 0xF3, 0xF0, 0x3F,
  0x3E, 0x3E, 0x7E, 0x07, 0xE7, 0xC7, 0xCF, 0x80, 0xFD, 0xF0, 0xFB, 0xF0,
  0x1F, 0xBE, 0x1F, 0x7C, 0x03, 0xF7, 0x83, 0xEF, 0x80, 0x7F, 0xF0, 0x7F,
  0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0xC0,
  0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x1F,
  0x80, 0x3F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x0F,
  0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x0F,
  0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x02, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xA0, 0x07, 0xFE, 0x40, 0x01, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 37, 14, 1, -36 },
  { 66, 17, 13, 21, 5, -36 },
  { 94, 29, 36, 29, 1, -36 },
  { 225, 25, 42, 26, 1, -39 },
  { 357, 35, 37, 39, 3, -37 },
  { 519, 30, 38, 31, 1, -37 },
  { 662, 8, 13, 12, 5, -36 },
  { 675, 18, 44, 15, 1, -36 },
  { 774, 18, 45, 15, -4, -37 },
  { 876, 21, 23, 25, 5, -39 },
  { 937, 23, 24, 27, 3, -30 },
  { 1006, 11, 13, 13, -2, -6 },
  { 1024, 13, 5, 16, 1, -16 },
  { 1033, 7, 8, 13, 1, -7 },
  { 1040, 26, 37, 20, -2, -37 },
  { 1161, 23, 38, 26, 2, -37 },
  { 1271, 18, 36, 26, 5, -36 },
  { 1352, 26, 37, 26, -1, -37 },
  { 1473, 25, 38, 26, 0, -37 },
  { 1592, 25, 37, 26, 0, -37 },
  { 1708, 25, 37, 26, 1, -36 },
  { 1824, 24, 38, 26, 2, -37 },
  { 1938, 25, 36, 26, 2, -36 },
  { 2051, 25, 38, 26, 1, -37 },
  { 2170, 24, 38, 26, 1, -37 },
  { 2284, 12, 29, 13, 0, -28 },
  { 2328, 15, 35, 13, -3, -28 },
  { 2394, 23, 25, 27, 3, -31 },
  { 2466, 22, 14, 27, 3, -25 },
  { 2505, 23, 25, 27, 3, -31 },
  { 2577, 19, 38, 20, 3, -37 },
  { 2668, 37, 41, 39, 2, -37 },
  { 2858, 28, 36, 28, -3, -36 },
  { 2984, 27, 36, 28, 1, -36 },
  { 3106, 27, 38, 27, 3, -37 },
  { 3235, 29, 36, 31, 1, -36 },
  { 3366, 25, 36, 24, 1, -36 },
  { 3479, 25, 36, 23, 1, -36 },
  { 3592, 29, 38, 32, 3, -37 },
  { 3730, 32, 36, 32, 1, -36 },
  { 3874, 22, 36, 17, -2, -36 },
  { 3973, 23, 46, 14, -8, -36 },
  { 4106, 31, 36, 27, 1, -36 },
  { 4246, 19, 36, 23, 1, -36 },
  { 4332, 40, 36, 41, 1, -36 },
  { 4512, 34, 36, 34, 1, -36 },
  { 4665, 29, 38, 33, 3, -37 },
  { 4803, 27, 36, 27, 1, -36 },
  { 4925, 29, 46, 33, 3, -37 },
  { 5092, 26, 36, 28, 1, -36 },
  { 5209, 26, 38, 24, 0, -37 },
  { 5333, 24, 36, 24, 4, -36 },
  { 5441, 29, 37, 32, 3, -36 },
  { 5576, 26, 36, 27, 5, -36 },
  { 5693, 41, 36, 41, 5, -36 },
  { 5878, 33, 36, 26, -3, -36 },
  { 6027, 25, 36, 25, 5, -36 },
  { 6140, 28, 36, 24, -1, -36 },
  { 6266, 20, 44, 16, -1, -36 },
  { 6376, 11, 37, 20, 5, -37 },
  { 6427, 21, 44, 16, -4, -36 },
  { 6543, 24, 23, 26, 1, -37 },
  { 6612, 20, 4, 19, -5, 4 },
  { 6622, 10, 8, 15, 7, -39 },
  { 6632, 25, 29, 27, 2, -28 },
  { 6723, 25, 40, 27, 1, -39 },
  { 6848, 21, 29, 22, 2, -28 },
  { 6925, 27, 40, 27, 2, -39 },
  { 7060, 22, 29, 25, 2, -28 },
  { 7140, 28, 51, 16, -6, -39 },
  { 7319, 27, 40, 27, 0, -28 },
  { 7454, 24, 39, 27, 1, -39 },
  { 7571, 14, 38, 13, 1, -38 },
  { 7638, 21, 50, 13, -6, -38 },
  { 7770, 26, 39, 25, 1, -39 },
  { 7897, 14, 39, 13, 1, -39 },
  { 7966, 38, 28, 41, 1, -28 },
  { 8099, 24, 28, 27, 1, -28 },
  { 8183, 23, 29, 27, 2, -28 },
  { 8267, 28, 40, 27, -2, -28 },
  { 8407, 25, 40, 27, 2, -28 },
  { 8532, 20, 28, 19, 1, -28 },
  { 8602, 21, 29, 21, 0, -28 },
  { 8679, 17, 35, 17, 2, -34 },
  { 8754, 25, 29, 27, 2, -28 },
  { 8845, 23, 28, 23, 3, -28 },
  { 8926, 35, 28, 36, 3, -28 },
  { 9049, 28, 28, 24, -2, -28 },
  { 9147, 30, 40, 23, -4, -28 },
  { 9297, 23, 28, 21, -1, -28 },
  { 9378, 21, 44, 18, 0, -36 },
  { 9494, 5, 51, 25, 10, -39 },
  { 9526, 20, 44, 18, -3, -36 },
  { 9636, 23, 8, 27, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC51PT7B_H_
