#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x03, 0x00, 0x00, 0x3F, 0x0F,
  0xCF, 0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x9F, 0x87, 0xE7,
  0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFE,
  0xE7, 0xC0, 0x7E, 0x38, 0x20, 0x1F, 0x8E, 0x00, 0x0F, 0xC3, 0x80, 0x03,
  0xF1, 0xC0, 0x00, 0xFC, 0x70, 0x00, 0x3F, 0x9C, 0x00, 0x07, 0xF7, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0x3F, 0x00, 0x01, 0xCF, 0xE0, 0x00, 0xE3, 0xF8,
  0x00, 0x38, 0xFE, 0x00, 0x0E, 0x3F, 0x0C, 0x03, 0x8F, 0xC3, 0xC1, 0xE7,
  0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x01, 0xF0, 0x0F, 0xFF,
  0x00, 0x1F, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x9F, 0x00, 0x7C, 0x03,
  0xF1, 0xF0, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x1F,
  0x00, 0x7C, 0x1F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x3E, 0x00, 0x7C, 0x1F,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x0F,
  0x81, 0xF1, 0xF0, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE3, 0xE1,
  0xF8, 0xF8, 0x7E, 0x7C, 0x7F, 0xCF, 0x87, 0xC7, 0xCF, 0xFE, 0xFC, 0xFC,
  0xF9, 0xFF, 0xF7, 0xFF, 0x9F, 0x1F, 0x3F, 0x7F, 0xF1, 0xF3, 0xE1, 0xF3,
  0xFE, 0x3E, 0x3E, 0x1F, 0x1F, 0xC7, 0xC7, 0xC1, 0xF0, 0x00, 0x7C, 0x7C,
  0x1F, 0x00, 0x0F, 0x87, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x1F,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x83, 0xE0,
  0x07, 0xC0, 0xF8, 0x3E, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0xF8,
  0x7C, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC0,
  0x0F, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x07, 0xFE, 0x01,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xFC,
  0x0F, 0xC3, 0xFD, 0xF8, 0x1F, 0x8F, 0xF3, 0xF8, 0x7E, 0x1F, 0xC3, 0xF8,
  0xFC, 0x7F, 0x07, 0xF3, 0xF0, 0xFC, 0x07, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF,
  0x87, 0xF0, 0x0F, 0xFF, 0x0F, 0xC0, 0x0F, 0xFC, 0x1F, 0x80, 0x1F, 0xF0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x7F, 0x01,
  0xFF, 0xF8, 0xFF, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F,
  0x0F, 0x07, 0x87, 0xC0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0x00, 0xF8,
  0x07, 0x03, 0xC0, 0x1F, 0x0F, 0x00, 0xFF, 0x3C, 0x03, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xC0, 0x41, 0xFF, 0x80, 0x0F, 0xDE, 0x00, 0xFE, 0x7C, 0x07, 0xF1, 0xF0,
  0x0F, 0x87, 0xE0, 0x1E, 0x0F, 0x80, 0x30, 0x3F, 0x00, 0x40, 0xF0, 0x00,
  0x01, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC,
  0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x1F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC,
  0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFF, 0xBF,
  0x7F, 0xBF, 0x1F, 0x1F, 0x8F, 0x0F, 0xC3, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x3C,
  0x03, 0xF8, 0x07, 0x00, 0x7F, 0x00, 0x40, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x7E, 0x0F, 0xF0, 0x0C, 0x01, 0xFC, 0x02, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE3, 0x00, 0x07, 0xF0, 0xF0, 0x07, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x3F,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xE0,
  0x7C, 0x01, 0xF8, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC2, 0x00, 0x1F, 0xE0, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x04,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x7F, 0x80, 0x7E, 0x7F, 0xE0, 0x3F, 0x7F, 0xF8, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0x87, 0xF8, 0x0F, 0xC3, 0xF8,
  0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFC, 0x7F,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0x0F, 0xF0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x0F, 0xE0,
  0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x07,
  0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x07, 0xFD, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x00,
  0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0,
  0x7F, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xC3, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0x7F,
  0x0F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x07,
  0xF1, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0xFF, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x87, 0xF0, 0x7F, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFD, 0xF8, 0x07,
  0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x80, 0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xE0,
  0x08, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xE0,
  0x7F, 0x18, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x7C, 0x01, 0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0xFE, 0x1F, 0x1F, 0x81, 0xFF,
  0xF8, 0x7C, 0x7C, 0x0F, 0xFF, 0xE1, 0xF3, 0xE0, 0x7F, 0x1F, 0x07, 0xCF,
  0x83, 0xF0, 0x7C, 0x1F, 0x3E, 0x0F, 0x81, 0xF0, 0x7D, 0xF0, 0x7C, 0x07,
  0xC1, 0xF7, 0xC1, 0xF0, 0x3E, 0x07, 0xDF, 0x0F, 0x80, 0xF8, 0x1F, 0x78,
  0x3E, 0x03, 0xE0, 0x7B, 0xE0, 0xF8, 0x0F, 0x83, 0xEF, 0x83, 0xC0, 0x7C,
  0x0F, 0xBE, 0x1F, 0x01, 0xF0, 0x3E, 0xF8, 0x7C, 0x07, 0xC1, 0xF3, 0xE1,
  0xF0, 0x3F, 0x07, 0xCF, 0x87, 0xC0, 0xFC, 0x3E, 0x3E, 0x0F, 0x87, 0xF1,
  0xF8, 0xF8, 0x3F, 0xFB, 0xFF, 0xC3, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0x81,
  0xFF, 0x1F, 0xF0, 0x1F, 0x03, 0xF8, 0x7F, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x20, 0x00, 0x3F, 0x80, 0x07, 0x00,
  0x00, 0xFF, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0,
  0x7E, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC1, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0x7F,
  0x07, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xF8, 0x7C, 0x03, 0xFC, 0x00, 0xC0, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x80,
  0x7F, 0xE0, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0xFF, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xC0, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x0F, 0xC0, 0x3F, 0xE0, 0x07, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0x3F, 0x80, 0x7F, 0xF8, 0xFE,
  0x01, 0xFF, 0xE3, 0xF8, 0x07, 0xFF, 0x8F, 0xE0, 0x3F, 0xFE, 0x3F, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x7E,
  0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F, 0x80,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8,
  0x07, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xC0, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xF8, 0x07,
  0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x80, 0x03, 0xF0, 0xFF,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x07, 0xE7, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xE7, 0xE0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3E, 0xF8, 0x00, 0xFB, 0xF0, 0x0F, 0xBE,
  0x00, 0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x1F, 0x7E, 0x01, 0xFB, 0xE0, 0x0F,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8,
  0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x03, 0xF1, 0xF0, 0x3F, 0x3F, 0x00, 0xFC,
  0x7C, 0x0F, 0x8F, 0xC0, 0x3F, 0x1F, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xC1,
  0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0xFC, 0x7E, 0x01, 0xF8, 0x7C, 0x3E, 0x1F,
  0x80, 0x7E, 0x1F, 0x1F, 0x87, 0xE0, 0x1F, 0x87, 0xC7, 0xC1, 0xF8, 0x07,
  0xE1, 0xF3, 0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xDF, 0x03, 0xF0, 0x0F, 0xC1, 0xFF, 0xC0,
  0xFC, 0x03, 0xE0, 0x7F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x1F, 0xE0, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0x80,
  0x07, 0xE0, 0x1F, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x7F,
  0xE0, 0x03, 0xF0, 0x1F, 0xFC, 0x00, 0x7E, 0x03, 0xFF, 0xC0, 0x1F, 0x80,
  0x7F, 0xF8, 0x03, 0xF0, 0x0F, 0xBF, 0x00, 0x7E, 0x01, 0xF7, 0xE0, 0x0F,
  0xC0, 0x7E, 0x7E, 0x03, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x01, 0xF9, 0xF8,
  0x0F, 0xC0, 0x3F, 0x1F, 0x81, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x01, 0xF8,
  0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x3F, 0x00,
  0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x3F,
  0x00, 0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0x01, 0xFB, 0xE0, 0x1F, 0x80, 0x3F, 0x7C, 0x03, 0xF0,
  0x07, 0xFF, 0x80, 0x7E, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x0F, 0xFE, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xC0, 0x03, 0xFE,
  0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x01,
  0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFC, 0x00,
  0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x07,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0xF0, 0x3F,
  0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xE0, 0xFE, 0x03,
  0xFC, 0x0F, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC,
  0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7F,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x03, 0xF1, 0xFF, 0xC0, 0x7E, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03,
  0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F,
  0x00, 0xFE, 0x07, 0xE0, 0x3F, 0xC1, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF1, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFE,
  0x3F, 0x00, 0xFF, 0x00, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x20, 0x00,
  0x7F, 0x03, 0x00, 0x1F, 0xC0, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F, 0xF0,
  0x07, 0xF3, 0xF0, 0x07, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0x00, 0x7E,
  0x3F, 0x00, 0xFF, 0xC0, 0x3F, 0x8F, 0xC0, 0x3F, 0xF0, 0x0F, 0xC3, 0xF0,
  0x1F, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xDF, 0x01, 0xF8, 0x3F, 0x03, 0xF7,
  0xC0, 0x7E, 0x0F, 0xC0, 0xF9, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x7C, 0x0F,
  0xC0, 0xFC, 0x1F, 0x9F, 0x07, 0xF0, 0x3F, 0x07, 0xC7, 0xC1, 0xF8, 0x0F,
  0xC3, 0xF1, 0xF0, 0xFE, 0x03, 0xF0, 0xF8, 0x7C, 0x3F, 0x00, 0xFC, 0x7E,
  0x1F, 0x0F, 0xC0, 0x3F, 0x1F, 0x87, 0xC7, 0xE0, 0x0F, 0xC7, 0xC1, 0xF1,
  0xF8, 0x03, 0xF3, 0xF0, 0x7C, 0xFE, 0x00, 0xFC, 0xF8, 0x1F, 0x3F, 0x00,
  0x3F, 0x7E, 0x07, 0xCF, 0xC0, 0x0F, 0xDF, 0x01, 0xF7, 0xE0, 0x03, 0xF7,
  0xC0, 0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03,
  0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x07, 0xE7, 0xE0,
  0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F,
  0x87, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0x1F,
  0x8F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0x80, 0x00, 0x7F, 0x07, 0xC0,
  0x7F, 0xE3, 0xF0, 0x3F, 0xFC, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFC, 0x7F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8,
  0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07,
  0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xFC,
  0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x9F, 0x00,
  0xFF, 0xC7, 0xC0, 0x1F, 0xE1, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC7,
  0xF0, 0x07, 0xF3, 0xFE, 0x01, 0xFB, 0xFF, 0xC0, 0x7E, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0x83, 0xFE, 0x0F, 0xE0, 0xFF, 0x01, 0xF8,
  0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8,
  0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF0, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x7F,
  0x07, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0x7F,
  0xF8, 0x0F, 0x8F, 0xFC, 0x03, 0xE1, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xC1, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x08, 0x1F, 0xC0, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFF, 0x9F, 0xC0, 0x3F, 0xFD, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x0F,
  0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x0F,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0x00,
  0x3F, 0xF9, 0xF0, 0x01, 0xFE, 0x1F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFC, 0x1F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xFC, 0x07, 0xF3, 0xF0, 0x1F, 0xC7, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x30, 0x7F, 0xEF, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x04, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC1, 0xF0, 0x07, 0xFE,
  0x3F, 0x00, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xF8,
  0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7F,
  0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x81, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFE, 0xFC, 0x00, 0xFF, 0xCF, 0xC0, 0x07, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x80, 0x07, 0xF0, 0x0E, 0x00, 0xFF, 0x00,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x7F,
  0x3F, 0xE0, 0x3F, 0x7F, 0xF8, 0x1F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xFC, 0x3F, 0x87, 0xFC, 0x0F, 0xC3, 0xFC, 0x07, 0xE1, 0xFC, 0x03, 0xF0,
  0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F,
  0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFE, 0x00,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8,
  0x03, 0xF0, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0,
  0x7F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFE,
  0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x1F, 0xC0,
  0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xE1, 0xFC, 0x07,
  0xF0, 0x0F, 0xCF, 0xFC, 0x1F, 0xF8, 0x1F, 0x3F, 0xFC, 0x7F, 0xF0, 0x3E,
  0xFF, 0xF9, 0xFF, 0xF0, 0x7D, 0xFF, 0xF7, 0xFF, 0xE0, 0xFF, 0x87, 0xFF,
  0x1F, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F, 0x87, 0xF8, 0x1F, 0xE0, 0x3F, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFE,
  0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0x0F, 0xE3,
  0xF0, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0xFC, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F,
  0xC0, 0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x03, 0xF1, 0xFC, 0x03,
  0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xE0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xE1, 0xFC, 0x03, 0xE1, 0xFF,
  0x01, 0xF3, 0xFF, 0xC0, 0xFB, 0xFF, 0xF0, 0x7D, 0xFF, 0xF8, 0x3F, 0xE1,
  0xFC, 0x3F, 0xE0, 0x7E, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0,
  0x0F, 0xC3, 0xF0, 0x07, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F,
  0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x07,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x07,
  0xE7, 0xFE, 0x00, 0x3E, 0x7F, 0xF8, 0x01, 0xF7, 0xFF, 0xC0, 0x0F, 0xBF,
  0xFF, 0x00, 0x7F, 0xC3, 0xF8, 0x07, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x07,
  0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFD, 0xFF, 0xF0, 0x07, 0xEF, 0xFF, 0x00, 0x3F, 0x3F, 0xF0,
  0x01, 0xF8, 0xFF, 0x00, 0x0F, 0xC0, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x3F, 0xF3, 0xF0, 0x3F,
  0xFC, 0xF8, 0x1F, 0xFF, 0xBE, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0xE1,
  0xFE, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80,
  0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xF8,
  0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0x00, 0xFF, 0xCF, 0xC0, 0x1F,
  0xE3, 0xF0, 0x00, 0x81, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE1, 0xF8,
  0x3F, 0x3F, 0xC1, 0xFB, 0xFC, 0x0F, 0x9F, 0xE0, 0x7D, 0xFF, 0x03, 0xFF,
  0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0x81, 0xC1, 0xFC, 0x01, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x88, 0x00, 0xFE, 0x38, 0x07, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x04, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xF1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFC, 0x00, 0x40, 0x00, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x07,
  0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xF0,
  0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xE0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x7C, 0x07, 0xFF, 0x9F, 0x00, 0xFF, 0xC7,
  0xC0, 0x1F, 0xE1, 0xF0, 0x00, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x7C,
  0x07, 0xE0, 0x7C, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0x01,
  0xFD, 0xF8, 0x0F, 0xF8, 0x0F, 0xCF, 0xC0, 0x7F, 0xC0, 0xFE, 0x7E, 0x03,
  0xFE, 0x07, 0xE3, 0xF0, 0x3F, 0xF0, 0x3F, 0x1F, 0x81, 0xFF, 0x83, 0xF0,
  0xFC, 0x1F, 0x7C, 0x1F, 0x87, 0xE0, 0xFB, 0xE1, 0xF8, 0x3F, 0x0F, 0x9F,
  0x0F, 0xC1, 0xF8, 0x7C, 0xF8, 0xFE, 0x0F, 0xC3, 0xE7, 0xC7, 0xE0, 0x7E,
  0x3E, 0x3E, 0x3F, 0x01, 0xF1, 0xF1, 0xF3, 0xF0, 0x0F, 0x9F, 0x0F, 0x9F,
  0x80, 0x7C, 0xF8, 0x7D, 0xF8, 0x03, 0xEF, 0xC3, 0xEF, 0xC0, 0x1F, 0x7C,
  0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xBF, 0x00,
  0x3F, 0xF0, 0x3D, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x03,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0,
  0x03, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x87,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0x3F, 0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 39, 14, 1, -38 },
  { 70, 18, 14, 22, 5, -38 },
  { 102, 30, 38, 31, 1, -38 },
  { 245, 26, 43, 27, 1, -40 },
  { 385, 36, 38, 41, 3, -38 },
  { 556, 31, 39, 33, 1, -38 },
  { 708, 9, 14, 12, 5, -38 },
  { 724, 18, 46, 16, 2, -38 },
  { 828, 18, 46, 16, -4, -38 },
  { 932, 22, 24, 26, 5, -41 },
  { 998, 24, 25, 28, 3, -31 },
  { 1073, 12, 13, 14, -3, -6 },
  { 1093, 14, 6, 16, 1, -17 },
  { 1104, 7, 8, 14, 1, -7 },
  { 1111, 28, 38, 20, -3, -38 },
  { 1244, 24, 39, 27, 2, -38 },
  { 1361, 17, 38, 27, 6, -38 },
  { 1442, 27, 38, 27, -1, -38 },
  { 1571, 26, 39, 27, 0, -38 },
  { 1698, 26, 38, 27, 0, -38 },
  { 1822, 26, 39, 27, 1, -38 },
  { 1949, 25, 39, 27, 2, -38 },
  { 2071, 27, 38, 27, 2, -38 },
  { 2200, 26, 39, 27, 1, -38 },
  { 2327, 25, 39, 27, 1, -38 },
  { 2449, 13, 30, 14, 0, -29 },
  { 2498, 16, 36, 14, -3, -29 },
  { 2570, 24, 26, 28, 3, -32 },
  { 2648, 23, 15, 28, 3, -26 },
  { 2692, 24, 26, 28, 3, -32 },
  { 2770, 20, 39, 21, 3, -38 },
  { 2868, 38, 43, 41, 2, -38 },
  { 3073, 29, 38, 29, -3, -38 },
  { 3211, 28, 38, 29, 1, -38 },
  { 3344, 28, 39, 28, 3, -38 },
  { 3481, 30, 38, 32, 1, -38 },
  { 3624, 26, 38, 25, 1, -38 },
  { 3748, 26, 38, 24, 1, -38 },
  { 3872, 30, 39, 33, 3, -38 },
  { 4019, 33, 38, 33, 1, -38 },
  { 4176, 23, 38, 18, -2, -38 },
  { 4286, 24, 49, 15, -8, -38 },
  { 4433, 32, 38, 28, 1, -38 },
  { 4585, 20, 38, 24, 1, -38 },
  { 4680, 42, 38, 42, 1, -38 },
  { 4880, 35, 38, 35, 1, -38 },
  { 5047, 30, 39, 35, 3, -38 },
  { 5194, 28, 38, 28, 1, -38 },
  { 5327, 30, 47, 35, 3, -38 },
  { 5504, 27, 38, 29, 1, -38 },
  { 5633, 27, 39, 25, 0, -38 },
  { 5765, 25, 38, 25, 4, -38 },
  { 5884, 31, 39, 33, 3, -38 },
  { 6036, 28, 38, 28, 5, -38 },
  { 6169, 42, 38, 43, 5, -38 },
  { 6369, 34, 38, 27, -3, -38 },
  { 6531, 26, 38, 26, 5, -38 },
  { 6655, 30, 38, 25, -2, -38 },
  { 6798, 21, 46, 16, -1, -38 },
  { 6919, 11, 38, 20, 6, -38 },
  { 6972, 21, 46, 16, -4, -38 },
  { 7093, 25, 23, 27, 1, -38 },
  { 7165, 20, 3, 20, -5, 5 },
  { 7173, 9, 9, 16, 8, -41 },
  { 7184, 26, 30, 28, 2, -29 },
  { 7282, 26, 41, 28, 1, -40 },
  { 7416, 22, 30, 23, 2, -29 },
  { 7499, 28, 41, 28, 2, -40 },
  { 7643, 23, 30, 26, 2, -29 },
  { 7730, 29, 54, 17, -6, -41 },
  { 7926, 28, 42, 28, 0, -29 },
  { 8073, 25, 40, 29, 1, -40 },
  { 8198, 14, 40, 14, 1, -40 },
  { 8268, 22, 53, 14, -7, -40 },
  { 8414, 27, 40, 26, 1, -40 },
  { 8549, 15, 40, 14, 1, -40 },
  { 8624, 39, 29, 43, 1, -29 },
  { 8766, 25, 29, 29, 1, -29 },
  { 8857, 24, 30, 28, 2, -29 },
  { 8947, 29, 42, 28, -2, -29 },
  { 9100, 26, 42, 28, 2, -29 },
  { 9237, 21, 29, 20, 1, -29 },
  { 9314, 22, 30, 22, 0, -29 },
  { 9397, 17, 36, 18, 2, -35 },
  { 9474, 26, 30, 28, 2, -29 },
  { 9572, 24, 29, 24, 3, -29 },
  { 9659, 37, 29, 37, 3, -29 },
  { 9794, 29, 29, 25, -2, -29 },
  { 9900, 31, 42, 24, -4, -29 },
  { 10063, 23, 29, 22, -1, -29 },
  { 10147, 22, 46, 18, 0, -38 },
  { 10274, 5, 52, 26, 10, -40 },
  { 10307, 21, 46, 18, -3, -38 },
  { 10428, 24, 8, 28, 3, -23 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC53PT7B_H_
