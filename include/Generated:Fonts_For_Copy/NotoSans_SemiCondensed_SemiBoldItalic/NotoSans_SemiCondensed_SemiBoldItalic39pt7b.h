#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x3C, 0x00, 0x7C, 0xFB, 0xE7, 0xDE, 0x3C, 0xF1, 0xE7, 0x8F,
  0x38, 0x7B, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x0E, 0x00, 0x00, 0x78, 0x70,
  0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0xE0, 0x03,
  0x87, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC0, 0xF0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00,
  0x78, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0E, 0x03, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC3, 0xC0,
  0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1E, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xBC, 0x1F, 0x30, 0x83,
  0xC6, 0x00, 0x78, 0xC0, 0x0F, 0xB8, 0x01, 0xF6, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x6F, 0x80, 0x1C, 0xF0, 0x03, 0x1E, 0x20, 0x63, 0xC6, 0x0C, 0xF8, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0xC0, 0x07, 0x81, 0xFC, 0x01,
  0xE0, 0x7F, 0xC0, 0x78, 0x1E, 0x78, 0x0E, 0x03, 0xC7, 0x03, 0xC0, 0xF0,
  0xE0, 0xF0, 0x1E, 0x1C, 0x1C, 0x03, 0xC7, 0x87, 0x80, 0x70, 0xF1, 0xE0,
  0x1E, 0x1E, 0x38, 0x03, 0xC3, 0xCF, 0x00, 0x78, 0xF3, 0xC7, 0xCF, 0x1E,
  0x73, 0xFD, 0xE7, 0x9E, 0xFF, 0x9F, 0xF7, 0x9E, 0x7B, 0xFC, 0xE7, 0x8F,
  0x3F, 0x3C, 0xF1, 0xE0, 0x0F, 0x3C, 0x3C, 0x01, 0xC7, 0x87, 0x80, 0x78,
  0xF0, 0xE0, 0x1E, 0x1E, 0x1C, 0x03, 0x83, 0x87, 0x80, 0xF0, 0x70, 0xF0,
  0x3C, 0x0F, 0x3C, 0x07, 0x01, 0xE7, 0x81, 0xE0, 0x3F, 0xE0, 0x78, 0x03,
  0xF8, 0x1E, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x78, 0x01, 0xE0,
  0xF0, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x43, 0xFC, 0x0F,
  0x1F, 0xFC, 0x3E, 0x3E, 0x7C, 0x78, 0xF8, 0xF9, 0xF3, 0xE0, 0xFB, 0xC7,
  0xC1, 0xFF, 0x8F, 0x81, 0xFE, 0x1F, 0x03, 0xF8, 0x3E, 0x03, 0xF0, 0x7C,
  0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xEF, 0xC0, 0xFF,
  0x0F, 0xC0, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3, 0x80, 0x00, 0x7C,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0x80,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x41, 0xC0, 0xF1, 0xC0, 0xFD, 0xC1,
  0xFF, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x0F, 0xC1, 0x1F, 0xE0, 0x3C, 0xE0,
  0xFC, 0xF0, 0x78, 0xF0, 0x30, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7D, 0xFF,
  0xFF, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xC7, 0xC3,
  0xE1, 0xF1, 0xF0, 0x3C, 0x7C, 0x0F, 0x3E, 0x03, 0xCF, 0x80, 0xF3, 0xC0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x1E,
  0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x83, 0xE1, 0xF1, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x1F,
  0xFB, 0xFF, 0xCF, 0xBE, 0x71, 0xE1, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x03,
  0xC3, 0xF0, 0x30, 0x1F, 0x01, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x30, 0x3E, 0x04,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE6, 0x01, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03,
  0xFE, 0x00, 0xF7, 0xC0, 0x3C, 0xF0, 0x0F, 0x9E, 0x01, 0xE7, 0xC0, 0x78,
  0xF8, 0x1E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x03,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x8C, 0x03,
  0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xCF, 0x81,
  0xE7, 0xF0, 0x7B, 0xFE, 0x3F, 0xFF, 0xCF, 0xE1, 0xF3, 0xF0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x7C, 0xF0, 0x1F, 0x3C, 0x07,
  0x8F, 0x03, 0xE3, 0xE1, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xF7, 0xE0, 0xF8, 0x3E, 0x1E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x0F, 0x03, 0xC1, 0xF0, 0xF8, 0x3E, 0x3E, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3E,
  0x3F, 0x0F, 0x83, 0xE3, 0xE0, 0x3C, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0,
  0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xFE, 0x7E, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x1F, 0x8F, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x07,
  0xCF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x3C, 0x0F, 0xCF, 0x87, 0xE3,
  0xFF, 0xF8, 0xFF, 0xDE, 0x1F, 0xEF, 0x81, 0xF3, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0x03, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x1F, 0x1F, 0x8F, 0xC3, 0xC0, 0x00, 0x40, 0x1E, 0x03,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00,
  0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xF1, 0xFF, 0xF3, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0x81, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0E, 0x3C, 0x0F, 0xF8, 0xE3, 0xC3, 0xFF, 0x8E, 0x78,
  0x7E, 0xF0, 0xF7, 0x87, 0x87, 0x0F, 0x70, 0xF0, 0xF0, 0xEF, 0x1E, 0x0F,
  0x0E, 0xF1, 0xE0, 0xE0, 0xEE, 0x1C, 0x1E, 0x1E, 0xE1, 0xC1, 0xE1, 0xEE,
  0x3C, 0x1E, 0x1C, 0xE3, 0xC3, 0xC3, 0xCE, 0x3C, 0x3C, 0x38, 0xE1, 0xE7,
  0xE7, 0x8E, 0x1F, 0xEF, 0xF0, 0xE0, 0xFC, 0xFE, 0x0F, 0x07, 0x87, 0x80,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x06, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00, 0x7D,
  0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0x00,
  0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x7C, 0xF8,
  0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x78, 0x3F, 0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1E,
  0x0F, 0x81, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x1F, 0x81, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xC3, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x1E, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3C, 0x3E, 0x03,
  0xE1, 0xF0, 0x3F, 0x0F, 0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7E, 0x06, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x60, 0x7F, 0xFF, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xC7, 0xF8, 0x3E, 0x07, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x3C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F,
  0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0xFC, 0x1E, 0x0F,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFC, 0x1F,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xF0, 0x38, 0x3F, 0x00, 0x21, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x7F, 0xEF, 0x81, 0xFF, 0x3E, 0x07, 0xFC, 0xF8, 0x1F,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE3,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x80, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x3E, 0x07, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x7C, 0x0F, 0x00,
  0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01,
  0xE0, 0x7C, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xC0, 0xF8, 0x07, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x02, 0x3F, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03,
  0xF0, 0x3E, 0x0F, 0xC0, 0x78, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xE1, 0xF0,
  0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x80, 0x1E, 0x7E, 0x00, 0x7C, 0xF8, 0x00,
  0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3C, 0x0F,
  0x80, 0x78, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7E,
  0x00, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x03, 0xDC, 0x01, 0xFE, 0x07, 0xB8, 0x07, 0xBC, 0x0F, 0x70, 0x0F,
  0xF8, 0x1E, 0xF0, 0x3D, 0xF0, 0x7D, 0xE0, 0x7B, 0xC0, 0xFB, 0xC1, 0xE7,
  0x81, 0xE7, 0x83, 0xDF, 0x03, 0xCF, 0x0F, 0x3E, 0x07, 0x9E, 0x1E, 0x7C,
  0x1F, 0x3C, 0x78, 0xF0, 0x3E, 0x78, 0xF1, 0xE0, 0x78, 0xF3, 0xC7, 0xC0,
  0xF1, 0xE7, 0x8F, 0x81, 0xE3, 0xDE, 0x1E, 0x07, 0xC7, 0xBC, 0x3C, 0x0F,
  0x07, 0xF0, 0x78, 0x1E, 0x0F, 0xE1, 0xF0, 0x3C, 0x1F, 0x83, 0xE0, 0xF8,
  0x3F, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x81,
  0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xC1, 0xF8, 0x01, 0xE0, 0x7F, 0x00,
  0x78, 0x1F, 0xC0, 0x3E, 0x07, 0xF0, 0x0F, 0x83, 0xFC, 0x03, 0xC0, 0xFF,
  0x80, 0xF0, 0x3D, 0xE0, 0x3C, 0x0F, 0x78, 0x1F, 0x03, 0xDF, 0x07, 0xC1,
  0xF7, 0xC1, 0xE0, 0x7C, 0xF0, 0x78, 0x1E, 0x3C, 0x1E, 0x07, 0x8F, 0x8F,
  0x81, 0xE1, 0xE3, 0xC0, 0xF8, 0x78, 0xF0, 0x3E, 0x1F, 0x3C, 0x0F, 0x07,
  0xCF, 0x03, 0xC0, 0xF7, 0xC0, 0xF0, 0x3D, 0xE0, 0x7C, 0x0F, 0xF8, 0x1E,
  0x01, 0xFE, 0x07, 0x80, 0x7F, 0x81, 0xE0, 0x1F, 0xE0, 0xF8, 0x07, 0xF0,
  0x3E, 0x00, 0xFC, 0x0F, 0x00, 0x3F, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F,
  0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x80,
  0x7E, 0x1F, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1F, 0x03, 0xE1, 0xF1, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F, 0xC1, 0xF8, 0x0F, 0x87, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7,
  0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x1F, 0x01, 0xF8, 0x3F,
  0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x83, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x0F, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0,
  0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC0, 0xC0, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x80, 0x1F, 0x0E, 0x03, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x1F, 0x07, 0x80,
  0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x3E, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x8F,
  0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0,
  0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x79, 0xF0,
  0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x0F, 0x00, 0x7B,
  0xC0, 0x3E, 0x01, 0xF7, 0x80, 0x7C, 0x03, 0xEF, 0x01, 0xF8, 0x0F, 0x9E,
  0x03, 0xF0, 0x1F, 0x3C, 0x0F, 0xE0, 0x3C, 0x78, 0x1F, 0xC0, 0xF8, 0xF0,
  0x3B, 0x81, 0xE1, 0xE0, 0xF7, 0x07, 0xC3, 0xC1, 0xEE, 0x0F, 0x87, 0x87,
  0x9C, 0x3E, 0x0F, 0x0F, 0x38, 0x7C, 0x1E, 0x3C, 0x78, 0xF0, 0x3C, 0x78,
  0xF3, 0xE0, 0x79, 0xF1, 0xE7, 0x80, 0xF3, 0xC3, 0xDF, 0x01, 0xE7, 0x87,
  0xBE, 0x03, 0xDE, 0x0E, 0x78, 0x07, 0xBC, 0x1D, 0xF0, 0x0F, 0xF0, 0x3B,
  0xC0, 0x1F, 0xE0, 0x77, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80,
  0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x07, 0x87, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xFF,
  0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x9F, 0x00, 0xF7, 0xC0, 0x1E,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xF0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xC0, 0x1E, 0x78, 0x07,
  0x9E, 0x03, 0xC3, 0x80, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x07, 0x0F, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x0E, 0xF0, 0x03, 0xC0, 0x7F, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF9, 0xF1, 0xE3, 0xE3, 0xC3, 0xC0, 0x00, 0x40, 0x00, 0x7F,
  0x3C, 0x1F, 0xF7, 0x87, 0xFE, 0xF1, 0xFD, 0xFE, 0x3E, 0x0F, 0x8F, 0xC1,
  0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x03,
  0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F,
  0x0F, 0x87, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFD, 0xE0, 0x3F, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC2, 0x00,
  0x79, 0xF8, 0x07, 0xBF, 0xC0, 0xFF, 0xFE, 0x0F, 0xE7, 0xE0, 0xFC, 0x3E,
  0x0F, 0x81, 0xE0, 0xF8, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xC3, 0xE0,
  0x7C, 0x3E, 0x0F, 0x87, 0xE0, 0xF8, 0x7F, 0xBF, 0x07, 0xFF, 0xF0, 0x7B,
  0xFE, 0x0F, 0x1F, 0x80, 0x00, 0x30, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xCE, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x08, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x41, 0xF0,
  0x1F, 0xCF, 0x01, 0xFF, 0x78, 0x1F, 0xFB, 0xC1, 0xFD, 0xFE, 0x0F, 0x83,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x01, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0xBF, 0xC0, 0xFF,
  0xDC, 0x03, 0xFD, 0xE0, 0x0F, 0xCF, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x01,
  0xFF, 0xC1, 0xFF, 0xF0, 0xF8, 0xF8, 0xF8, 0x3C, 0xF8, 0x1E, 0x7C, 0x1F,
  0x7C, 0x0F, 0xBE, 0x3F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFE, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x02, 0x1F, 0x87, 0x07,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x1F, 0xCF, 0x03, 0xFE, 0xF0, 0x7F, 0xEF, 0x0F,
  0xEF, 0xF0, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xC3, 0xE0, 0x3C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x1F, 0xEF, 0x00, 0xFC, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x80, 0x7E, 0x0F, 0x9F, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC2, 0x00, 0xF3, 0xF8, 0x1E, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0x7E, 0x1F, 0x87, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x0F, 0xC1, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8,
  0xF8, 0x07, 0xC7, 0xC0, 0x3C, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0x7C, 0x00,
  0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xBE,
  0x00, 0xF9, 0xF0, 0x07, 0x87, 0xC0, 0x3C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x07, 0xC0, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x80, 0x1E, 0x7E, 0x0F, 0xC0,
  0x73, 0xFC, 0xFF, 0x83, 0xDF, 0xFF, 0xFE, 0x0F, 0xF7, 0xFC, 0xFC, 0x3F,
  0x0F, 0xE1, 0xF0, 0xF8, 0x3F, 0x07, 0xC3, 0xE0, 0xF8, 0x1F, 0x1F, 0x03,
  0xE0, 0x78, 0x7C, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x0F, 0x87, 0x81, 0xF0,
  0x3E, 0x3E, 0x07, 0xC0, 0xF8, 0xF8, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x0F,
  0x0F, 0x01, 0xE0, 0x7C, 0x3C, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0x1E, 0x1F, 0x03, 0xC0, 0x78, 0x78, 0x0F, 0x03, 0xE3, 0xE0,
  0x7C, 0x0F, 0x80, 0x00, 0x02, 0x00, 0xF3, 0xF8, 0x1C, 0xFF, 0x87, 0xBF,
  0xF0, 0xFF, 0x7E, 0x1F, 0x87, 0xC3, 0xE0, 0x78, 0x7C, 0x0F, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1E, 0x00, 0x00, 0x20, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xDF, 0x87, 0xC1, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x1F, 0x78,
  0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0x78, 0x1F, 0x1F, 0x0F,
  0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0x00, 0x1E, 0x7E, 0x00, 0xE7, 0xF8, 0x0F, 0x7F, 0xE0, 0x7F, 0x3F, 0x03,
  0xF0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x07,
  0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xF7, 0xE0,
  0x7B, 0xFF, 0x03, 0xDF, 0xF0, 0x1E, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0x1C, 0x1F, 0xF7, 0x87, 0xFF, 0xF1, 0xFD, 0xFE, 0x3E, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x03,
  0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F,
  0x0F, 0x87, 0xE1, 0xFB, 0xFC, 0x3F, 0xFF, 0x03, 0xFD, 0xE0, 0x3F, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x02,
  0x07, 0x9F, 0x07, 0xBF, 0x0F, 0x7E, 0x0F, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x00, 0x40, 0x07, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFE, 0x1F, 0x0E, 0x1E, 0x02, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x80, 0xFC, 0xFB, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0,
  0x7F, 0xC0, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFD,
  0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x1E, 0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3C, 0x07, 0x8F, 0x01, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C,
  0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07,
  0xCF, 0x03, 0xE3, 0xC1, 0xF8, 0xF8, 0x7E, 0x3F, 0xFF, 0x8F, 0xFD, 0xC1,
  0xFE, 0xF0, 0x7F, 0x3C, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1E, 0x1E, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0x78,
  0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x01, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0xF8,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0x07, 0xE0, 0x7B,
  0xE0, 0xFC, 0x1F, 0x7C, 0x3F, 0x83, 0xCF, 0x87, 0xF0, 0xF9, 0xF0, 0xEE,
  0x1F, 0x1E, 0x3D, 0xC3, 0xC3, 0xC7, 0xB8, 0xF8, 0x79, 0xE7, 0x1E, 0x0F,
  0x3C, 0xE7, 0xC1, 0xE7, 0x1C, 0xF0, 0x3D, 0xE3, 0x9E, 0x07, 0xB8, 0x77,
  0x80, 0xFF, 0x0E, 0xF0, 0x1F, 0xE1, 0xDE, 0x03, 0xB8, 0x3F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xE0,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x1F, 0x07, 0xE0, 0x3E, 0x1F,
  0x00, 0xF8, 0xF8, 0x01, 0xE7, 0xC0, 0x07, 0x9F, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x7C, 0x3C, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC,
  0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x1E,
  0x07, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x78, 0x01, 0xE1,
  0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x7C,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x7E, 0x00,
  0x7C, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x07,
  0xF8, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x5F, 0xE0, 0x3F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xA0, 0x1F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 28, 10, 0, -28 },
  { 40, 13, 10, 16, 4, -28 },
  { 57, 22, 28, 23, 1, -28 },
  { 134, 19, 32, 20, 1, -30 },
  { 210, 27, 28, 30, 2, -28 },
  { 305, 23, 28, 24, 1, -28 },
  { 386, 6, 10, 9, 4, -28 },
  { 394, 14, 34, 12, 1, -28 },
  { 454, 14, 34, 12, -3, -28 },
  { 514, 16, 17, 19, 4, -30 },
  { 548, 18, 19, 21, 2, -23 },
  { 591, 9, 10, 10, -2, -5 },
  { 603, 10, 5, 12, 1, -13 },
  { 610, 6, 5, 10, 0, -5 },
  { 614, 20, 28, 15, -2, -28 },
  { 684, 18, 28, 20, 1, -28 },
  { 747, 13, 28, 20, 4, -28 },
  { 793, 20, 28, 20, -1, -28 },
  { 863, 19, 28, 20, 0, -28 },
  { 930, 19, 28, 20, 0, -28 },
  { 997, 20, 28, 20, 0, -28 },
  { 1067, 18, 28, 20, 2, -28 },
  { 1130, 19, 28, 20, 2, -28 },
  { 1197, 19, 28, 20, 1, -28 },
  { 1264, 18, 28, 20, 1, -28 },
  { 1327, 9, 22, 10, 0, -22 },
  { 1352, 12, 27, 10, -2, -22 },
  { 1393, 18, 20, 21, 2, -24 },
  { 1438, 17, 11, 21, 2, -19 },
  { 1462, 18, 20, 21, 2, -24 },
  { 1507, 15, 28, 16, 2, -28 },
  { 1560, 28, 31, 30, 2, -28 },
  { 1669, 21, 28, 21, -2, -28 },
  { 1743, 21, 28, 22, 1, -28 },
  { 1817, 21, 28, 21, 2, -28 },
  { 1891, 22, 28, 24, 1, -28 },
  { 1968, 19, 28, 19, 1, -28 },
  { 2035, 19, 28, 18, 1, -28 },
  { 2102, 22, 28, 24, 2, -28 },
  { 2179, 24, 28, 24, 1, -28 },
  { 2263, 17, 28, 13, -1, -28 },
  { 2323, 18, 36, 11, -6, -28 },
  { 2404, 23, 28, 21, 1, -28 },
  { 2485, 14, 28, 18, 1, -28 },
  { 2534, 31, 28, 31, 1, -28 },
  { 2643, 26, 28, 26, 1, -28 },
  { 2734, 23, 28, 25, 2, -28 },
  { 2815, 20, 28, 21, 1, -28 },
  { 2885, 23, 35, 25, 2, -28 },
  { 2986, 20, 28, 21, 1, -28 },
  { 3056, 20, 28, 19, 0, -28 },
  { 3126, 18, 28, 18, 3, -28 },
  { 3189, 23, 28, 24, 2, -28 },
  { 3270, 20, 28, 21, 4, -28 },
  { 3340, 31, 28, 31, 4, -28 },
  { 3449, 25, 28, 20, -2, -28 },
  { 3537, 19, 28, 19, 4, -28 },
  { 3604, 22, 28, 18, -1, -28 },
  { 3681, 16, 34, 12, -1, -28 },
  { 3749, 8, 28, 15, 4, -28 },
  { 3777, 16, 34, 12, -3, -28 },
  { 3845, 18, 17, 20, 1, -28 },
  { 3884, 15, 3, 14, -4, 3 },
  { 3890, 7, 6, 12, 6, -30 },
  { 3896, 19, 22, 21, 1, -22 },
  { 3949, 20, 30, 21, 0, -30 },
  { 4024, 16, 22, 17, 1, -22 },
  { 4068, 21, 30, 21, 1, -30 },
  { 4147, 17, 22, 19, 1, -22 },
  { 4194, 21, 39, 12, -4, -30 },
  { 4297, 20, 31, 21, 0, -22 },
  { 4375, 19, 30, 21, 0, -30 },
  { 4447, 11, 29, 10, 0, -29 },
  { 4487, 16, 38, 10, -5, -29 },
  { 4563, 21, 30, 19, 0, -30 },
  { 4642, 11, 30, 10, 0, -30 },
  { 4684, 30, 22, 31, 0, -22 },
  { 4767, 19, 22, 21, 0, -22 },
  { 4820, 18, 22, 20, 1, -22 },
  { 4870, 21, 31, 21, -1, -22 },
  { 4952, 19, 31, 21, 1, -22 },
  { 5026, 16, 22, 15, 0, -22 },
  { 5070, 16, 22, 16, 0, -22 },
  { 5114, 12, 26, 13, 2, -26 },
  { 5153, 18, 21, 21, 2, -21 },
  { 5201, 18, 21, 18, 2, -21 },
  { 5249, 27, 21, 27, 2, -21 },
  { 5320, 22, 21, 18, -2, -21 },
  { 5378, 23, 30, 18, -3, -21 },
  { 5465, 17, 21, 16, -1, -21 },
  { 5510, 16, 34, 14, 0, -28 },
  { 5578, 3, 39, 19, 8, -30 },
  { 5593, 15, 34, 14, -2, -28 },
  { 5657, 18, 6, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC39PT7B_H_
