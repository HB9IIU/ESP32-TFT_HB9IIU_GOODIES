#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x30,
  0x00, 0x3F, 0x8F, 0xE7, 0xE1, 0xFC, 0xFC, 0x3F, 0x3F, 0x87, 0xE7, 0xE0,
  0xFC, 0xFC, 0x1F, 0x9F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83,
  0xE3, 0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFE, 0xEF, 0xC0, 0x7F, 0x9E, 0x1C, 0x07, 0xF1, 0xE0,
  0x40, 0x7F, 0x1C, 0x00, 0x07, 0xE1, 0xC0, 0x00, 0x7E, 0x1C, 0x00, 0x07,
  0xF3, 0xC0, 0x00, 0x7F, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xEF, 0xF8, 0x00, 0x0E, 0x7F, 0x80, 0x00, 0xE3, 0xF8,
  0x00, 0x1E, 0x3F, 0x80, 0x01, 0xE3, 0xF8, 0x00, 0x1C, 0x3F, 0x8C, 0x01,
  0xC7, 0xF0, 0xF0, 0x1C, 0xFF, 0x0F, 0xF3, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x08, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x03, 0xFF,
  0x80, 0x03, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x80, 0x3F,
  0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x7E, 0x00, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0xF8, 0x00,
  0x7E, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x0F,
  0xC3, 0xE0, 0x00, 0x7C, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x8F, 0xC0,
  0x00, 0xFC, 0x1F, 0x8F, 0x87, 0xF8, 0xFC, 0x1F, 0x1F, 0x8F, 0xFC, 0x7C,
  0x3F, 0x3F, 0x1F, 0xFE, 0x7C, 0x7E, 0x3E, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E,
  0x7F, 0x7E, 0x7F, 0xFC, 0xFC, 0x7C, 0x3F, 0x3F, 0xF8, 0xF8, 0xFC, 0x3F,
  0x1F, 0xF1, 0xF8, 0xF8, 0x3F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3F, 0x00, 0x03,
  0xE1, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF0, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x3E, 0x00,
  0x3F, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x7E, 0x00, 0x7E, 0x03,
  0xE0, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0xF8,
  0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xE0,
  0x03, 0xFF, 0xF0, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFF,
  0xC0, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0xFE, 0x01,
  0xF8, 0x3F, 0xFF, 0xC0, 0xFE, 0x1F, 0xE7, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x3F, 0xC7, 0xF1, 0xFC, 0x07, 0xF3, 0xF8, 0x7F, 0x01,
  0xFF, 0xFC, 0x3F, 0x80, 0x3F, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0x83, 0xF8,
  0x01, 0xFF, 0xC0, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x0F, 0xF8, 0x0F,
  0xF0, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xCF,
  0xF0, 0x1F, 0xFF, 0xC3, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x06, 0x00,
  0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C,
  0x3E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01,
  0x80, 0xF8, 0x00, 0xE0, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0x9E, 0x00,
  0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFC, 0x7E, 0x07, 0xFE, 0x00, 0x07, 0xEF,
  0x80, 0x07, 0xF7, 0xC0, 0x07, 0xF3, 0xF0, 0x07, 0xF0, 0xF8, 0x03, 0xF8,
  0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x18, 0x0F, 0xC0, 0x04, 0x07, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F,
  0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x07,
  0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xFD,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFD, 0xFC,
  0x7F, 0x1F, 0x83, 0xE3, 0xF8, 0x38, 0x3F, 0x81, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3E, 0x01, 0xFE,
  0x00, 0x70, 0x03, 0xF8, 0x00, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x1C, 0x00,
  0xFF, 0x00, 0x40, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x20,
  0x00, 0x3F, 0xC1, 0xC0, 0x03, 0xFE, 0x0F, 0xE1, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8,
  0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF2,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x20, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x08, 0x00, 0x1F, 0xE0, 0xE0, 0x07, 0xFE,
  0x0F, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x20, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x1C, 0x00, 0x1F, 0x8F, 0xF8,
  0x03, 0xF9, 0xFF, 0xC0, 0x3F, 0xBF, 0xFE, 0x03, 0xF7, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x03,
  0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xEF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F,
  0x00, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0x87, 0xF8, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0,
  0x0F, 0xF3, 0xF8, 0x03, 0xFC, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xBF,
  0x81, 0xFF, 0x8F, 0xC0, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0x80,
  0xFE, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x18, 0x00, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF1, 0xF0, 0x3F, 0xC3, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x1F, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0xFF, 0xC1, 0xF0, 0xF8, 0x0F, 0xFF,
  0xF0, 0x7C, 0x7E, 0x07, 0xFF, 0xF8, 0x1F, 0x1F, 0x03, 0xF8, 0x3E, 0x07,
  0xCF, 0xC0, 0xFC, 0x0F, 0x81, 0xF3, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x7E, 0x0F, 0xC0, 0x7C, 0x07, 0xDF, 0x03, 0xE0,
  0x1F, 0x03, 0xE7, 0xC1, 0xF8, 0x0F, 0xC0, 0xF9, 0xF0, 0x7C, 0x03, 0xE0,
  0x3E, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0xBF, 0x07, 0xC0, 0x7E, 0x07, 0xCF,
  0x81, 0xF0, 0x1F, 0x81, 0xF3, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0xF8, 0x3F,
  0x03, 0xF0, 0x3E, 0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0x7F,
  0x0F, 0xC3, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0xFE, 0xFF, 0xF0,
  0x1F, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x01, 0xF0,
  0x07, 0x80, 0x7C, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFC,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC3, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F,
  0xE0, 0x7F, 0x00, 0x7F, 0xC1, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0x01,
  0xFF, 0x80, 0x1C, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xF8,
  0x03, 0xF8, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x83, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xF0, 0x1F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x81, 0xF8,
  0x07, 0xFE, 0x00, 0x1C, 0x03, 0xFE, 0x00, 0x02, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xC7, 0xF0, 0x07, 0xFF, 0xE3, 0xF8, 0x03,
  0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0x00,
  0xFF, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x0E, 0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0xFE, 0x01, 0xFC, 0xF8, 0x03, 0xF3,
  0xF8, 0x07, 0xF3, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0xCF, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x3E, 0x01, 0xF9, 0xFC, 0x01, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x3F, 0x0F, 0xE0, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x01, 0xFC,
  0x3F, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0xC0, 0x1F, 0x83,
  0xF3, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xDF, 0x81, 0xFC, 0x03, 0xF8, 0x1F,
  0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFF,
  0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x0F,
  0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xC0, 0x01,
  0xF8, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x0F,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0x03, 0xF3,
  0xF0, 0x07, 0xF0, 0x0F, 0xCF, 0xE0, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x03, 0xF0,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF8, 0x7F, 0x00, 0xFC, 0x07,
  0xE1, 0xFC, 0x03, 0xF0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC0, 0x7F, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE0, 0x0F,
  0xEF, 0xE0, 0x1F, 0x80, 0x3F, 0xBF, 0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x03,
  0xF8, 0x01, 0xFB, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0x00, 0x1F,
  0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F,
  0xC0, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x1F,
  0xF0, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87,
  0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F,
  0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03,
  0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0x83, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01,
  0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC1,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFE, 0x1F, 0x80, 0x7F, 0xC0, 0x1C, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x10, 0x00, 0x7F, 0x80, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0xC7, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0xFC, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC7, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x1F,
  0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xFE,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFD, 0xF8,
  0x0F, 0xE0, 0x3F, 0x01, 0xFB, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE7, 0xE0,
  0x7F, 0x00, 0xFC, 0x0F, 0xCF, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0x1F, 0x83,
  0xF8, 0x03, 0xF0, 0x7E, 0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x7E, 0x1F,
  0xC0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE1, 0xF8, 0xFE,
  0x00, 0x3F, 0x1F, 0x83, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x07, 0xE3, 0xF0,
  0x00, 0xFC, 0xFC, 0x0F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x1F, 0x9F, 0x80,
  0x03, 0xF3, 0xE0, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x00,
  0x0F, 0xDF, 0x80, 0xFD, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3F, 0x00,
  0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x81,
  0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFE, 0x3F, 0x00, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF,
  0x3F, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x8F, 0xFE, 0x07, 0xFF, 0xF7,
  0xE0, 0x7F, 0xFF, 0x7E, 0x03, 0xFF, 0xEF, 0xC0, 0x1F, 0xF8, 0xFC, 0x00,
  0xFF, 0x0F, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x9F, 0xF8, 0x03, 0xFB, 0xFF, 0xC0,
  0x3F, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F,
  0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFE, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x03,
  0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0x7F, 0xE1, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFD, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF, 0x80, 0xFC, 0xFF,
  0xF0, 0x0F, 0x83, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xF8, 0x0C, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x60, 0x7F, 0xC3, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x3F, 0xFD, 0xFC, 0x00, 0xFF,
  0xFB, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xE1, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x7C, 0x00, 0x7F, 0xFC, 0xF8, 0x00, 0x7F, 0xF1, 0xF0, 0x00, 0x7F,
  0x87, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F,
  0xE3, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F,
  0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3,
  0xF8, 0x3F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x0C, 0x1F, 0xE0, 0x1E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xC4, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xE3, 0xF0, 0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xFF, 0x3F, 0x00, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x03,
  0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x3F, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xBF, 0x80, 0x3F, 0xFC, 0xFC, 0x00,
  0x7F, 0xE7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x40, 0x7F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x08, 0x00, 0x3F, 0xC0, 0x3C, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x9F,
  0xF8, 0x03, 0xFB, 0xFF, 0xC0, 0x3F, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8,
  0x07, 0xF0, 0xFF, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x18,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x04, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x07,
  0xE1, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xCF, 0xFF, 0x0F,
  0xFF, 0x01, 0xF3, 0xFF, 0xE3, 0xFF, 0xE0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFE,
  0x0F, 0xDF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xF8, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xE1, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x87, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE3, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x1F, 0xF8, 0x03, 0xF3, 0xFF, 0xC0,
  0x3E, 0x7F, 0xFE, 0x07, 0xEF, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0x07, 0xFE,
  0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x80, 0x7F,
  0x0F, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0x83, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xCF, 0xF0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF,
  0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xF3, 0xF8, 0x03, 0xFC, 0xFF,
  0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7F,
  0xE0, 0x01, 0xF9, 0xFF, 0xE0, 0x03, 0xE7, 0xFF, 0xC0, 0x07, 0xDF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xF0,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFD, 0xFF, 0xF8, 0x03, 0xFB, 0xFF,
  0xE0, 0x07, 0xF3, 0xFF, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x1F, 0x80, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x1F, 0x00,
  0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1,
  0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xF8,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x8F, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFC, 0x03, 0xFF, 0xCF,
  0xC0, 0x1F, 0xF9, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0x81, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x07, 0xE3, 0xFC, 0x0F, 0xCF, 0xF0, 0x1F, 0xBF, 0xE0, 0x3F, 0x7F, 0xC0,
  0xFD, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0xFC, 0x0F,
  0xF0, 0x1C, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xC0, 0x0F, 0xF0, 0xF8,
  0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x18, 0x3F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x20, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0xFF, 0x07, 0xE0, 0x0F, 0xF0, 0x7E, 0x01, 0xFF, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0x03, 0xFE, 0x07, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0x7E, 0x07, 0xFF,
  0xE7, 0xC0, 0x3F, 0xFE, 0x7C, 0x03, 0xFF, 0x87, 0xC0, 0x1F, 0xF0, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x87,
  0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0xFE,
  0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xF8, 0x07, 0xF7,
  0xE0, 0x1F, 0xF0, 0x0F, 0xEF, 0xC0, 0x7F, 0xE0, 0x3F, 0x9F, 0x80, 0xFF,
  0xC0, 0x7F, 0x3F, 0x03, 0xFF, 0x81, 0xFC, 0x7E, 0x07, 0xDF, 0x03, 0xF8,
  0xFC, 0x0F, 0xBE, 0x07, 0xE1, 0xF8, 0x3F, 0x7C, 0x1F, 0xC3, 0xF0, 0x7C,
  0xF8, 0x3F, 0x07, 0xE1, 0xF9, 0xF0, 0xFE, 0x0F, 0xC3, 0xE3, 0xE1, 0xFC,
  0x1F, 0x87, 0xC7, 0xC7, 0xF0, 0x3F, 0x1F, 0x8F, 0x8F, 0xE0, 0x7E, 0x3E,
  0x1F, 0x1F, 0x80, 0xFC, 0xFC, 0x3E, 0x7F, 0x01, 0xF9, 0xF0, 0x7C, 0xFC,
  0x03, 0xF7, 0xE0, 0xF9, 0xF8, 0x07, 0xEF, 0xC1, 0xF7, 0xE0, 0x0F, 0xDF,
  0x03, 0xEF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x07,
  0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x4F, 0xFE, 0x00, 0x17, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFB, 0x00, 0x1F,
  0xFC, 0x80, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 42, 15, 1, -41 },
  { 85, 19, 15, 24, 6, -41 },
  { 121, 33, 41, 33, 1, -41 },
  { 291, 28, 47, 29, 1, -44 },
  { 456, 40, 43, 45, 3, -42 },
  { 671, 34, 43, 36, 1, -42 },
  { 854, 9, 15, 14, 6, -41 },
  { 871, 20, 50, 17, 2, -41 },
  { 996, 20, 51, 18, -4, -42 },
  { 1124, 25, 25, 28, 5, -44 },
  { 1203, 26, 27, 31, 3, -34 },
  { 1291, 13, 15, 15, -3, -7 },
  { 1316, 15, 7, 18, 1, -19 },
  { 1330, 8, 9, 15, 1, -8 },
  { 1339, 30, 42, 22, -3, -42 },
  { 1497, 27, 43, 29, 2, -42 },
  { 1643, 20, 41, 29, 6, -41 },
  { 1746, 30, 42, 29, -1, -42 },
  { 1904, 29, 43, 29, 0, -42 },
  { 2060, 30, 42, 29, -1, -42 },
  { 2218, 28, 42, 29, 1, -41 },
  { 2365, 28, 43, 29, 2, -42 },
  { 2516, 28, 41, 29, 3, -41 },
  { 2660, 28, 43, 29, 1, -42 },
  { 2811, 26, 43, 29, 2, -42 },
  { 2951, 14, 33, 15, 0, -32 },
  { 3009, 17, 40, 15, -3, -32 },
  { 3094, 26, 28, 31, 3, -35 },
  { 3185, 26, 17, 31, 3, -29 },
  { 3241, 26, 28, 31, 3, -35 },
  { 3332, 22, 43, 23, 3, -42 },
  { 3451, 42, 47, 45, 2, -42 },
  { 3698, 31, 41, 32, -3, -41 },
  { 3857, 31, 41, 32, 1, -41 },
  { 4016, 31, 43, 31, 3, -42 },
  { 4183, 33, 41, 35, 1, -41 },
  { 4353, 29, 41, 28, 1, -41 },
  { 4502, 29, 41, 27, 1, -41 },
  { 4651, 33, 43, 36, 3, -42 },
  { 4829, 36, 41, 36, 1, -41 },
  { 5014, 25, 41, 20, -2, -41 },
  { 5143, 26, 53, 16, -9, -41 },
  { 5316, 35, 41, 31, 1, -41 },
  { 5496, 22, 41, 26, 1, -41 },
  { 5609, 46, 41, 46, 1, -41 },
  { 5845, 38, 41, 39, 1, -41 },
  { 6040, 34, 43, 38, 3, -42 },
  { 6223, 31, 41, 31, 1, -41 },
  { 6382, 34, 52, 38, 3, -42 },
  { 6603, 30, 41, 32, 1, -41 },
  { 6757, 29, 43, 28, 0, -42 },
  { 6913, 27, 41, 27, 5, -41 },
  { 7052, 34, 42, 36, 3, -41 },
  { 7231, 31, 41, 31, 5, -41 },
  { 7390, 47, 41, 47, 5, -41 },
  { 7631, 37, 41, 30, -3, -41 },
  { 7821, 29, 41, 28, 5, -41 },
  { 7970, 33, 41, 27, -2, -41 },
  { 8140, 23, 50, 18, -1, -41 },
  { 8284, 12, 42, 22, 6, -42 },
  { 8347, 23, 50, 18, -4, -41 },
  { 8491, 27, 26, 29, 1, -42 },
  { 8579, 22, 4, 21, -5, 5 },
  { 8590, 11, 9, 17, 8, -44 },
  { 8603, 28, 33, 31, 2, -32 },
  { 8719, 28, 45, 31, 1, -44 },
  { 8877, 24, 33, 25, 2, -32 },
  { 8976, 31, 45, 31, 2, -44 },
  { 9151, 25, 33, 28, 2, -32 },
  { 9255, 32, 58, 19, -7, -44 },
  { 9487, 30, 46, 31, 0, -32 },
  { 9660, 28, 44, 31, 1, -44 },
  { 9814, 16, 44, 15, 1, -44 },
  { 9902, 24, 58, 15, -7, -44 },
  { 10076, 30, 44, 28, 1, -44 },
  { 10241, 16, 44, 15, 1, -44 },
  { 10329, 43, 32, 47, 1, -32 },
  { 10501, 28, 32, 31, 1, -32 },
  { 10613, 26, 33, 30, 2, -32 },
  { 10721, 31, 46, 31, -2, -32 },
  { 10900, 28, 46, 31, 2, -32 },
  { 11061, 23, 32, 22, 1, -32 },
  { 11153, 24, 33, 24, 0, -32 },
  { 11252, 18, 39, 20, 3, -38 },
  { 11340, 28, 32, 31, 2, -31 },
  { 11452, 26, 31, 26, 3, -31 },
  { 11553, 39, 31, 41, 4, -31 },
  { 11705, 32, 31, 27, -3, -31 },
  { 11829, 34, 45, 26, -5, -31 },
  { 12021, 25, 31, 24, -1, -31 },
  { 12118, 24, 50, 20, 0, -41 },
  { 12268, 6, 57, 28, 11, -44 },
  { 12311, 23, 50, 20, -3, -41 },
  { 12455, 26, 9, 31, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC58PT7B_H_
