#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0xC0, 0x6F, 0xEC, 0x2D, 0x3C, 0xDF, 0x75, 0x65, 0xAE, 0x80,
  0x6A, 0x80, 0x56, 0x80, 0xBC, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x6A, 0x40,
  0x76, 0xE0, 0xEA, 0xE5, 0x60, 0xEC, 0xE0, 0x2F, 0xA0, 0x78, 0xE0, 0x7E,
  0xE0, 0x65, 0x40, 0x6E, 0xF0, 0xF5, 0xE0, 0xA0, 0xB0, 0x39, 0x80, 0xFC,
  0x8F, 0x00, 0xEA, 0x40, 0x7F, 0xFB, 0x26, 0x00, 0x6F, 0xD0, 0x6E, 0xF0,
  0x78, 0x86, 0x65, 0xAE, 0x6E, 0x60, 0x6E, 0x40, 0x78, 0xA6, 0x56, 0xAA,
  0x5B, 0x25, 0x2C, 0x74, 0xAA, 0x6B, 0x5E, 0xAD, 0x60, 0x5D, 0xAA, 0x79,
  0x96, 0x77, 0x40, 0x79, 0x96, 0x20, 0x77, 0xD0, 0x68, 0xE0, 0xE9, 0x20,
  0x59, 0xAE, 0xFA, 0x40, 0xDB, 0xAA, 0x74, 0x4A, 0xEA, 0x69, 0x60, 0x6A,
  0x80, 0xF0, 0x56, 0x80, 0x54, 0xE0, 0x80, 0xF7, 0x80, 0x49, 0xDC, 0xF3,
  0x00, 0x27, 0xDE, 0xFB, 0x00, 0x12, 0x64, 0x4C, 0xF7, 0xE0, 0x49, 0xDA,
  0x4A, 0x80, 0x21, 0x25, 0x80, 0x4A, 0xEA, 0x5A, 0x80, 0x7D, 0x6C, 0x76,
  0x80, 0xF7, 0x00, 0x77, 0x40, 0xF7, 0xA0, 0x68, 0xDC, 0x6B, 0xB7, 0x80,
  0xB9, 0x00, 0xBF, 0xA0, 0xEB, 0x00, 0xA9, 0x40, 0xEB, 0x00, 0x5A, 0x80,
  0xFC, 0x56, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 1, 2, 1, -4 },
  { 3, 4, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 4, 5, 0, -4 },
  { 9, 4, 4, 4, 0, -4 },
  { 11, 1, 1, 1, 1, -4 },
  { 12, 2, 5, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 2, 3, 3, 1, -5 },
  { 17, 3, 3, 3, 0, -4 },
  { 19, 1, 2, 2, 0, -1 },
  { 20, 2, 1, 2, 0, -2 },
  { 21, 1, 1, 2, 0, -1 },
  { 22, 3, 4, 2, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 1, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 1, 3, 2, 0, -3 },
  { 44, 1, 4, 2, 0, -3 },
  { 45, 3, 3, 3, 0, -4 },
  { 47, 3, 2, 3, 0, -3 },
  { 48, 3, 3, 3, 0, -4 },
  { 50, 3, 4, 2, 0, -4 },
  { 52, 5, 5, 5, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 4, 4, 3, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 2, 4, 2, 0, -4 },
  { 73, 3, 5, 2, -1, -4 },
  { 75, 4, 4, 3, 0, -4 },
  { 77, 2, 4, 3, 0, -4 },
  { 78, 5, 4, 5, 0, -4 },
  { 81, 4, 4, 4, 0, -4 },
  { 83, 4, 4, 4, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 4, 5, 4, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 3, 4, 3, 0, -4 },
  { 94, 3, 4, 3, 0, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 3, 4, 3, 1, -4 },
  { 100, 4, 4, 5, 1, -4 },
  { 102, 4, 4, 3, 0, -4 },
  { 104, 2, 4, 3, 1, -4 },
  { 105, 3, 4, 3, 0, -4 },
  { 107, 2, 5, 2, 0, -4 },
  { 109, 1, 4, 2, 1, -4 },
  { 110, 2, 5, 2, 0, -4 },
  { 112, 3, 2, 3, 0, -4 },
  { 113, 3, 1, 2, -1, 0 },
  { 114, 1, 1, 2, 1, -5 },
  { 115, 3, 3, 3, 0, -3 },
  { 117, 3, 5, 3, 0, -5 },
  { 119, 3, 3, 3, 0, -3 },
  { 121, 3, 5, 3, 0, -5 },
  { 123, 3, 3, 3, 0, -3 },
  { 125, 4, 6, 2, -1, -5 },
  { 128, 3, 4, 3, 0, -3 },
  { 130, 3, 5, 3, 0, -5 },
  { 132, 2, 5, 2, 0, -5 },
  { 134, 3, 6, 2, -1, -5 },
  { 137, 3, 5, 3, 0, -5 },
  { 139, 2, 5, 2, 0, -5 },
  { 141, 5, 3, 5, 0, -3 },
  { 143, 3, 3, 3, 0, -3 },
  { 145, 3, 3, 3, 0, -3 },
  { 147, 3, 4, 3, 0, -3 },
  { 149, 3, 4, 3, 0, -3 },
  { 151, 2, 3, 2, 0, -3 },
  { 152, 2, 3, 3, 0, -3 },
  { 153, 2, 4, 2, 0, -4 },
  { 154, 3, 3, 3, 0, -3 },
  { 156, 3, 3, 3, 0, -3 },
  { 158, 4, 3, 4, 0, -3 },
  { 160, 3, 3, 3, 0, -3 },
  { 162, 3, 4, 3, 0, -3 },
  { 164, 3, 3, 2, 0, -3 },
  { 166, 2, 5, 2, 0, -4 },
  { 168, 1, 6, 3, 1, -5 },
  { 169, 2, 5, 2, 0, -4 },
  { 171, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC6PT7B_H_
