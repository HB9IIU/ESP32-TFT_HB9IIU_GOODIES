#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x31, 0x9E, 0xAE, 0x50, 0x27, 0x62, 0xD6, 0x69,
  0xAB, 0x9B, 0x35, 0x20, 0x32, 0x98, 0xDB, 0x78, 0xC0, 0x29, 0x49, 0x20,
  0x24, 0x92, 0x70, 0x5F, 0x00, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x12, 0x24,
  0x88, 0x35, 0x59, 0xA6, 0x79, 0x25, 0x00, 0x65, 0x12, 0x4E, 0x71, 0x36,
  0x3E, 0x13, 0x5A, 0xF2, 0x74, 0x63, 0x1E, 0x34, 0x6D, 0x96, 0x71, 0x22,
  0x4C, 0x35, 0x76, 0x9E, 0x65, 0x97, 0x2E, 0x42, 0x42, 0x80, 0x16, 0xC3,
  0xFF, 0x86, 0x3C, 0x64, 0xA1, 0x80, 0x39, 0x17, 0xED, 0xBE, 0x07, 0x00,
  0x33, 0x55, 0xB9, 0x75, 0x57, 0x9E, 0x3A, 0x11, 0x0C, 0x38, 0x72, 0xD2,
  0x99, 0x70, 0x74, 0x56, 0x8E, 0x74, 0x46, 0x88, 0x3A, 0x11, 0x3D, 0x38,
  0x4A, 0x52, 0xE9, 0x48, 0x69, 0x25, 0x80, 0x24, 0x94, 0x94, 0x4A, 0x98,
  0xCA, 0x48, 0x49, 0x29, 0xC0, 0x65, 0x96, 0xDD, 0xB6, 0xA0, 0x6B, 0x5A,
  0xD9, 0xC8, 0x32, 0x53, 0x19, 0xB8, 0x75, 0x57, 0x88, 0x32, 0x53, 0x19,
  0xB8, 0x40, 0x75, 0x56, 0xA9, 0x34, 0x42, 0x2E, 0xE9, 0x49, 0x00, 0x4A,
  0x52, 0xA9, 0x38, 0x9A, 0xAC, 0xC8, 0xA6, 0x9D, 0xB6, 0xD2, 0x40, 0x4A,
  0x98, 0xC6, 0x58, 0xBA, 0xCC, 0x88, 0x71, 0x24, 0xCE, 0x69, 0x29, 0x30,
  0xAA, 0xB0, 0x32, 0x22, 0x22, 0xC0, 0x26, 0x59, 0xE0, 0xC0, 0x79, 0x9E,
  0x44, 0x75, 0x9E, 0x78, 0x86, 0x18, 0x9D, 0x29, 0x70, 0x7E, 0x86, 0x12,
  0x72, 0x24, 0x4C, 0x79, 0x9E, 0x2E, 0x44, 0x75, 0x9A, 0x45, 0xA0, 0x20,
  0x94, 0x96, 0x44, 0x76, 0xAA, 0x55, 0xA0, 0x7D, 0x59, 0x69, 0x75, 0x9A,
  0x79, 0x96, 0x75, 0x9E, 0x88, 0x79, 0x9E, 0x22, 0x6A, 0x40, 0xE8, 0xF0,
  0x5D, 0x4C, 0x55, 0x9E, 0x96, 0x64, 0xB6, 0xE5, 0x94, 0x76, 0x6A, 0x49,
  0x8C, 0x42, 0x60, 0x69, 0x70, 0x29, 0x64, 0xB0, 0xFF, 0x49, 0x35, 0x20,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 4, 0, -6 },
  { 11, 6, 6, 6, 0, -6 },
  { 16, 5, 6, 5, 0, -6 },
  { 20, 1, 2, 2, 1, -6 },
  { 21, 3, 7, 2, 0, -6 },
  { 24, 3, 7, 2, -1, -6 },
  { 27, 3, 3, 4, 1, -6 },
  { 29, 4, 4, 4, 0, -5 },
  { 31, 1, 2, 2, 0, -1 },
  { 32, 2, 1, 2, 0, -3 },
  { 33, 1, 1, 2, 0, -1 },
  { 34, 4, 6, 3, 0, -6 },
  { 37, 4, 6, 4, 0, -6 },
  { 40, 3, 6, 4, 1, -6 },
  { 43, 4, 6, 4, 0, -6 },
  { 46, 4, 6, 4, 0, -6 },
  { 49, 4, 6, 4, 0, -6 },
  { 52, 4, 6, 4, 0, -6 },
  { 55, 4, 6, 4, 0, -6 },
  { 58, 4, 6, 4, 0, -6 },
  { 61, 4, 6, 4, 0, -6 },
  { 64, 4, 6, 4, 0, -6 },
  { 67, 2, 4, 2, 0, -4 },
  { 68, 2, 5, 2, 0, -4 },
  { 70, 4, 4, 4, 0, -5 },
  { 72, 4, 2, 4, 0, -4 },
  { 73, 4, 4, 4, 0, -5 },
  { 75, 3, 6, 3, 0, -6 },
  { 78, 6, 7, 6, 0, -6 },
  { 84, 4, 6, 4, 0, -6 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 5, 6, 4, 0, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 4, 6, 4, 0, -6 },
  { 101, 4, 6, 4, 0, -6 },
  { 104, 5, 6, 5, 0, -6 },
  { 108, 5, 6, 5, 0, -6 },
  { 112, 3, 6, 3, 0, -6 },
  { 115, 3, 8, 2, -1, -6 },
  { 118, 5, 6, 4, 0, -6 },
  { 122, 3, 6, 4, 0, -6 },
  { 125, 6, 6, 6, 0, -6 },
  { 130, 5, 6, 5, 0, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 5, 7, 5, 0, -6 },
  { 146, 4, 6, 4, 0, -6 },
  { 149, 4, 6, 4, 0, -6 },
  { 152, 3, 6, 4, 1, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 4, 6, 4, 1, -6 },
  { 162, 6, 6, 6, 1, -6 },
  { 167, 5, 6, 4, 0, -6 },
  { 171, 4, 6, 4, 1, -6 },
  { 174, 4, 6, 4, 0, -6 },
  { 177, 3, 7, 2, 0, -6 },
  { 180, 2, 6, 3, 1, -6 },
  { 182, 4, 7, 2, -1, -6 },
  { 186, 4, 4, 4, 0, -6 },
  { 188, 3, 1, 3, -1, 0 },
  { 189, 2, 1, 2, 1, -6 },
  { 190, 4, 4, 4, 0, -4 },
  { 192, 4, 6, 4, 0, -6 },
  { 195, 4, 4, 3, 0, -4 },
  { 197, 5, 6, 4, 0, -6 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 4, 8, 3, -1, -6 },
  { 207, 4, 6, 4, 0, -4 },
  { 210, 4, 6, 4, 0, -6 },
  { 213, 2, 6, 2, 0, -6 },
  { 215, 3, 8, 2, -1, -6 },
  { 218, 4, 6, 4, 0, -6 },
  { 221, 2, 6, 2, 0, -6 },
  { 223, 6, 4, 6, 0, -4 },
  { 226, 4, 4, 4, 0, -4 },
  { 228, 4, 4, 4, 0, -4 },
  { 230, 4, 6, 4, 0, -4 },
  { 233, 4, 6, 4, 0, -4 },
  { 236, 3, 4, 3, 0, -4 },
  { 238, 3, 4, 3, 0, -4 },
  { 240, 3, 5, 3, 0, -5 },
  { 242, 4, 4, 4, 0, -4 },
  { 244, 4, 4, 4, 0, -4 },
  { 246, 6, 4, 6, 0, -4 },
  { 249, 4, 4, 4, 0, -4 },
  { 251, 5, 6, 4, -1, -4 },
  { 255, 3, 4, 3, 0, -4 },
  { 257, 3, 7, 3, 0, -6 },
  { 260, 1, 8, 4, 1, -6 },
  { 261, 3, 7, 3, 0, -6 },
  { 264, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC8PT7B_H_
