#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC59PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x30, 0x00, 0x3F, 0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x0F, 0xE3, 0xF0,
  0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF9, 0xC3, 0x80,
  0x7F, 0x8E, 0x04, 0x03, 0xF8, 0xF0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0xFE,
  0x38, 0x00, 0x07, 0xF1, 0xC0, 0x00, 0x3F, 0x8E, 0x00, 0x01, 0xFE, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xF7,
  0xF8, 0x00, 0x07, 0x1F, 0xC0, 0x00, 0x38, 0xFE, 0x00, 0x01, 0xC7, 0xF0,
  0x00, 0x1E, 0x3F, 0x84, 0x00, 0xF1, 0xFC, 0x30, 0x07, 0x0F, 0xE1, 0xF0,
  0x39, 0xFE, 0x0F, 0xFB, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x03,
  0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x1F,
  0x9F, 0x80, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x00,
  0x7C, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F,
  0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x1F, 0x83, 0xE0,
  0x00, 0xF8, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x1F, 0x8F, 0xC0, 0x00, 0xF8,
  0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x1F, 0x8F, 0xF8, 0xF8, 0x3E, 0x3F,
  0x1F, 0xFC, 0xF8, 0x7E, 0x3E, 0x3F, 0xFE, 0xFC, 0xFC, 0x7E, 0x7F, 0xFE,
  0xFF, 0xFC, 0xFC, 0xFE, 0x7E, 0x7F, 0xF8, 0xF8, 0xFC, 0x3E, 0x7F, 0xF1,
  0xF9, 0xF8, 0x3F, 0x3F, 0xE3, 0xF1, 0xF8, 0x3F, 0x07, 0x03, 0xE1, 0xF0,
  0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x3E, 0x00,
  0x0F, 0x83, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xE0, 0x7E, 0x00, 0x3F, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x7C,
  0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x03, 0xF7,
  0xF0, 0x07, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x0F,
  0x80, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x40, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xFF, 0x80, 0xFE, 0x0F,
  0xF7, 0xF8, 0x1F, 0x83, 0xFC, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFC,
  0x1F, 0xC0, 0xFE, 0x3F, 0x87, 0xF0, 0x1F, 0xEF, 0xE0, 0xFE, 0x01, 0xFD,
  0xFC, 0x3F, 0xC0, 0x3F, 0xFF, 0x07, 0xF0, 0x03, 0xFF, 0xE0, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xC0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xCF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF3,
  0xFC, 0x03, 0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0x00, 0xFC, 0x00, 0xE0, 0x7E, 0x00,
  0x7C, 0x3E, 0x00, 0x7F, 0x9F, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x03, 0xFE, 0x01, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x03, 0xF9,
  0xF0, 0x03, 0xF8, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3C,
  0x0F, 0xC0, 0x0C, 0x07, 0xF0, 0x02, 0x03, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x30, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xF0, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F,
  0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFD,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x01, 0xFE, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x07,
  0xF9, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x07, 0xF8, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x81, 0xFE,
  0x07, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xEF, 0xCF, 0xFD, 0xFC, 0x7F, 0x9F, 0xC7, 0xF1, 0xFC, 0x3C, 0x3F,
  0x81, 0x83, 0xF8, 0x10, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0x01, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x00,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x7F, 0xE0, 0x1E, 0x00, 0xFF,
  0x00, 0x60, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE1, 0x00, 0x01, 0xFF, 0x0F, 0x00, 0x1F, 0xF0, 0x7F, 0x87, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xD0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F, 0x01,
  0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x20, 0x00, 0x7F, 0xC1, 0xC0, 0x07, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x60, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xF0,
  0x01, 0xF8, 0xFF, 0xC0, 0x3F, 0xBF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0x87, 0xFC, 0x03,
  0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFE,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF9, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xE0,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F,
  0xC3, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xF7, 0xF0, 0x1F, 0xF8, 0xFE, 0x00, 0x7C, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x01, 0xF3, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x20, 0x03, 0xF0, 0x1F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x1F,
  0xC0, 0x7F, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x87, 0xE0, 0xFF, 0x07, 0x00, 0xFF, 0x08, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xE0, 0x7C, 0x01, 0xFF,
  0xF8, 0x7C, 0x1F, 0x80, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0xC1,
  0xF8, 0xFC, 0x0F, 0xFB, 0xF8, 0x3F, 0x1F, 0x03, 0xF8, 0x3F, 0x03, 0xE7,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x9F, 0x03,
  0xE0, 0x3F, 0x03, 0xE7, 0xE0, 0xFC, 0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0x9F, 0x07, 0xE0, 0x1F, 0x01, 0xF3, 0xE0, 0xFC, 0x07, 0xE0,
  0x7E, 0x7C, 0x1F, 0x00, 0xFC, 0x0F, 0x9F, 0x83, 0xE0, 0x1F, 0x01, 0xF3,
  0xF0, 0x7C, 0x07, 0xE0, 0x7E, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0x8F, 0xC1,
  0xF0, 0x3F, 0x83, 0xF1, 0xF8, 0x3E, 0x07, 0xF0, 0x7C, 0x3F, 0x07, 0xE1,
  0xFE, 0x1F, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xFE, 0x7F,
  0xF8, 0x0F, 0x81, 0xFF, 0x8F, 0xFE, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0x00, 0x70, 0x03, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x04, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F,
  0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x38, 0x03, 0xFE, 0x00, 0x08, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x00, 0x3F,
  0xE0, 0x0E, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7F,
  0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x00,
  0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x0F, 0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x01,
  0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3C, 0x03, 0xFF, 0x00, 0x02,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0xFE, 0x1F, 0xC0, 0x1F, 0xFF, 0x87, 0xF0, 0x07, 0xFF, 0xE3,
  0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xC0, 0x3F, 0xFF,
  0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xF0, 0x07, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x06, 0x1F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFF,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0x0F, 0xDF, 0x80, 0x3F, 0xBE, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0x7C, 0x00, 0x7E, 0xFE, 0x00, 0xFC, 0xFC, 0x01, 0xFD,
  0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xE7,
  0xE0, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F,
  0x80, 0x3F, 0x1F, 0x80, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x03, 0xF8, 0xFC,
  0x01, 0xFC, 0x7E, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x1F, 0xC7, 0xF0,
  0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0xC0,
  0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xC3, 0xF0, 0xFE, 0x00,
  0xFE, 0x0F, 0x8F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x1F, 0x83, 0xF8, 0x03,
  0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x00, 0x7E,
  0x03, 0xFF, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xFF, 0x01, 0xF8, 0x03, 0xF8,
  0x0F, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0xFF, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xE0,
  0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF8,
  0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xF8,
  0x03, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0xDF,
  0x80, 0x1F, 0xC0, 0x3F, 0xBF, 0x80, 0x3F, 0x00, 0x7E, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x7E, 0x01, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF8, 0x03, 0xF1,
  0xFC, 0x07, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x1F,
  0x80, 0x3F, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x3F, 0x87,
  0xE0, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0x03, 0xF9,
  0xF8, 0x03, 0xF0, 0x03, 0xF7, 0xF0, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x1F,
  0xFE, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0,
  0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF8,
  0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x0F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x38, 0x03, 0xFC, 0x00, 0x20, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x08, 0x00, 0x0F, 0xF0, 0x18,
  0x00, 0x3F, 0xC0, 0x78, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x3F,
  0x80, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFB, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xCF, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xF8, 0x00, 0xFE, 0x3F, 0x00,
  0x1F, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xE1, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xC3, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0x3F,
  0x7C, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFD,
  0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xF3, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE7,
  0xC0, 0x7F, 0x01, 0xF8, 0x1F, 0x8F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x1F,
  0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x7E,
  0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC1, 0xF8,
  0xFE, 0x00, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x01, 0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x1F, 0x9F,
  0xC0, 0x07, 0xE7, 0xE0, 0x3F, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x7E, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x7E, 0x01, 0xF7, 0xF0,
  0x00, 0x7E, 0xF8, 0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xDF, 0x80,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03,
  0xFC, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xF9, 0xFC, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x3E, 0x00,
  0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xC7, 0xF1,
  0xFC, 0x3F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xE7, 0xE0, 0x3F,
  0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0xC1, 0xFF, 0x07,
  0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0x9F,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xBF, 0x00, 0xFF, 0xF9, 0xF8,
  0x03, 0xFF, 0x8F, 0xC0, 0x0F, 0xF0, 0x7C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0xC0, 0x01,
  0xFC, 0x7F, 0x80, 0x0F, 0xE7, 0xFF, 0x00, 0x7F, 0x7F, 0xFC, 0x03, 0xF7,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x1F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE1,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0x3F, 0xFE, 0x01,
  0xF8, 0xFF, 0xE0, 0x0F, 0x83, 0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFE, 0x3C, 0x0F, 0xF8, 0x04, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x60, 0x7F, 0xE3, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x06, 0x03, 0xF8, 0x00, 0x3F, 0xC3,
  0xF8, 0x00, 0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0xF3, 0xF0, 0x03, 0xFF, 0xFB,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x7F, 0xF0, 0x0F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x1F,
  0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x7E, 0x00, 0x3F, 0xFE, 0x7E, 0x00, 0x1F, 0xFC, 0x7C,
  0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xF8, 0x3F, 0xC0, 0x7E, 0x0F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0xC7, 0xF1, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFE,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x81, 0xFF, 0x01, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0xFC,
  0x00, 0xFF, 0xF1, 0xF8, 0x03, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xEF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xC0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xEF, 0xE0, 0x03, 0xFF, 0x9F, 0xC0, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x80, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x40,
  0x01, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x08, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xF9, 0xFF, 0xC0,
  0x3F, 0xBF, 0xFE, 0x03, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0x9F, 0xF0, 0x7F, 0xE0, 0x7F, 0x07, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F,
  0x0F, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0x7F,
  0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFE,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x0C, 0x00, 0x3F, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xF1, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0x3F, 0xFC, 0x3F, 0xFE, 0x03, 0xF7, 0xFF, 0xE7,
  0xFF, 0xE0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xFF, 0x9F, 0xFF, 0x9F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF0,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF0, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x3F, 0x07, 0xF8, 0x03, 0xF1, 0xFF, 0xC0, 0x3F,
  0x3F, 0xFE, 0x03, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xDF,
  0xF0, 0x7F, 0xE0, 0x7F, 0x07, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x0F,
  0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC,
  0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x1F,
  0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x07,
  0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE1,
  0xFE, 0x07, 0xF8, 0x3F, 0xF3, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x7E, 0x1F, 0xF0, 0x00,
  0x7E, 0x3F, 0xF8, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x7E, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xC1, 0xFE, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xFE, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xDF, 0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0x00, 0x1F, 0xCF, 0xFE, 0x00, 0x1F,
  0xC7, 0xFC, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xFF, 0x0F, 0xC0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF,
  0xF7, 0xE0, 0x3F, 0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xF1, 0xFF,
  0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF,
  0xC0, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0x9F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0x0C,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x0C, 0x07, 0xE1, 0xFC, 0x0F, 0xC7, 0xF8, 0x1F,
  0x9F, 0xF0, 0x3F, 0x7F, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xC6, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x3C, 0x0F, 0xE0,
  0x04, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x80, 0x07, 0xF8, 0xC0, 0x07, 0xF0, 0xF8, 0x1F,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE3, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xF8,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x7F,
  0xE0, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF, 0xEF, 0xC0, 0xFF, 0xFE, 0xFC, 0x07,
  0xFF, 0xCF, 0xC0, 0x7F, 0xF8, 0xF8, 0x01, 0xFE, 0x0F, 0x80, 0x03, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF,
  0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x07, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0xC3, 0xF0, 0x07, 0xF0, 0x7E, 0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0xFC, 0x03, 0xFE, 0x00, 0xFC, 0xFC, 0x03,
  0xFE, 0x01, 0xFC, 0xFC, 0x07, 0xFE, 0x01, 0xFC, 0xFC, 0x07, 0xFE, 0x03,
  0xF8, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0xFC, 0x0F, 0xFE, 0x07, 0xF0, 0xFC,
  0x0F, 0xBE, 0x07, 0xF0, 0xFC, 0x1F, 0xBE, 0x07, 0xE0, 0xFC, 0x1F, 0x3E,
  0x0F, 0xE0, 0xFC, 0x3F, 0x3E, 0x0F, 0xC0, 0xFC, 0x3F, 0x3E, 0x1F, 0xC0,
  0xFC, 0x3E, 0x3E, 0x1F, 0xC0, 0xFC, 0x7E, 0x3E, 0x3F, 0x80, 0xFC, 0x7C,
  0x3E, 0x3F, 0x80, 0xFC, 0xFC, 0x3E, 0x3F, 0x00, 0xFC, 0xFC, 0x3E, 0x7F,
  0x00, 0xFC, 0xF8, 0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x3E, 0x7E, 0x00, 0xFD,
  0xF0, 0x3E, 0xFC, 0x00, 0xFD, 0xF0, 0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x3E,
  0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07,
  0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x07, 0xFB, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x9F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x2F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xF4, 0x00, 0x1F, 0xF8, 0x80, 0x00, 0x7C, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 16, 43, 16, 1, -42 },
  { 87, 20, 15, 24, 6, -42 },
  { 125, 34, 42, 34, 1, -42 },
  { 304, 29, 48, 30, 1, -45 },
  { 478, 40, 44, 46, 4, -43 },
  { 698, 35, 44, 36, 1, -43 },
  { 891, 9, 15, 14, 6, -42 },
  { 908, 20, 51, 18, 2, -42 },
  { 1036, 20, 52, 18, -4, -43 },
  { 1166, 25, 26, 29, 5, -45 },
  { 1248, 27, 28, 31, 3, -35 },
  { 1343, 13, 15, 15, -3, -7 },
  { 1368, 16, 6, 18, 1, -19 },
  { 1380, 8, 9, 15, 1, -8 },
  { 1389, 30, 42, 23, -3, -42 },
  { 1547, 27, 44, 30, 2, -43 },
  { 1696, 20, 42, 30, 6, -42 },
  { 1801, 30, 43, 30, -1, -43 },
  { 1963, 29, 44, 30, 0, -43 },
  { 2123, 30, 42, 30, -1, -42 },
  { 2281, 29, 43, 30, 1, -42 },
  { 2437, 28, 44, 30, 2, -43 },
  { 2591, 29, 42, 30, 3, -42 },
  { 2744, 29, 44, 30, 1, -43 },
  { 2904, 27, 44, 30, 2, -43 },
  { 3053, 14, 34, 15, 0, -33 },
  { 3113, 17, 41, 15, -3, -33 },
  { 3201, 27, 29, 31, 3, -36 },
  { 3299, 26, 17, 31, 3, -29 },
  { 3355, 27, 29, 31, 3, -36 },
  { 3453, 23, 44, 24, 3, -43 },
  { 3580, 43, 47, 45, 2, -42 },
  { 3833, 33, 42, 32, -4, -42 },
  { 4007, 32, 42, 33, 1, -42 },
  { 4175, 32, 44, 32, 3, -43 },
  { 4351, 34, 42, 36, 1, -42 },
  { 4530, 30, 42, 28, 1, -42 },
  { 4688, 30, 42, 27, 1, -42 },
  { 4846, 34, 44, 37, 3, -43 },
  { 5033, 37, 42, 37, 1, -42 },
  { 5228, 26, 42, 20, -2, -42 },
  { 5365, 27, 54, 17, -9, -42 },
  { 5548, 36, 42, 32, 1, -42 },
  { 5737, 22, 42, 27, 1, -42 },
  { 5853, 47, 42, 47, 1, -42 },
  { 6100, 39, 42, 39, 1, -42 },
  { 6305, 34, 44, 39, 3, -43 },
  { 6492, 31, 42, 32, 1, -42 },
  { 6655, 34, 53, 39, 3, -43 },
  { 6881, 31, 42, 32, 1, -42 },
  { 7044, 30, 44, 28, 0, -43 },
  { 7209, 27, 42, 28, 5, -42 },
  { 7351, 35, 43, 36, 3, -42 },
  { 7540, 31, 42, 31, 5, -42 },
  { 7703, 47, 42, 48, 6, -42 },
  { 7950, 38, 42, 31, -3, -42 },
  { 8150, 29, 42, 29, 5, -42 },
  { 8303, 33, 42, 28, -2, -42 },
  { 8477, 23, 51, 18, -1, -42 },
  { 8624, 12, 42, 23, 6, -42 },
  { 8687, 23, 51, 18, -4, -42 },
  { 8834, 28, 26, 30, 1, -42 },
  { 8925, 22, 4, 22, -5, 5 },
  { 8936, 10, 9, 18, 9, -45 },
  { 8948, 29, 34, 31, 2, -33 },
  { 9072, 29, 46, 32, 1, -45 },
  { 9239, 24, 34, 25, 2, -33 },
  { 9341, 32, 46, 32, 2, -45 },
  { 9525, 26, 34, 29, 2, -33 },
  { 9636, 33, 59, 19, -7, -45 },
  { 9880, 31, 47, 32, 0, -33 },
  { 10063, 28, 45, 32, 1, -45 },
  { 10221, 16, 44, 15, 1, -44 },
  { 10309, 25, 58, 15, -8, -44 },
  { 10491, 30, 45, 29, 1, -45 },
  { 10660, 16, 45, 15, 1, -45 },
  { 10750, 44, 33, 47, 1, -33 },
  { 10932, 28, 33, 32, 1, -33 },
  { 11048, 27, 34, 31, 2, -33 },
  { 11163, 32, 47, 32, -2, -33 },
  { 11351, 29, 47, 32, 2, -33 },
  { 11522, 23, 33, 22, 1, -33 },
  { 11617, 24, 34, 25, 0, -33 },
  { 11719, 19, 40, 20, 3, -39 },
  { 11814, 28, 33, 32, 3, -32 },
  { 11930, 27, 32, 27, 3, -32 },
  { 12038, 40, 32, 41, 4, -32 },
  { 12198, 33, 32, 28, -3, -32 },
  { 12330, 35, 46, 27, -5, -32 },
  { 12532, 26, 32, 24, -1, -32 },
  { 12636, 24, 51, 20, 0, -42 },
  { 12789, 5, 59, 29, 12, -45 },
  { 12826, 23, 51, 20, -3, -42 },
  { 12973, 27, 9, 31, 3, -25 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC59PT7B_H_
