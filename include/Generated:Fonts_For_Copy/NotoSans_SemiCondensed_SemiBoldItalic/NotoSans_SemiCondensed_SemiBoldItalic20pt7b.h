#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x31, 0x80, 0x18, 0xE3, 0x80,
  0x6F, 0xDB, 0x36, 0x6C, 0x80, 0x06, 0x60, 0x64, 0x04, 0xC0, 0xCC, 0x3F,
  0xF0, 0x98, 0x19, 0x81, 0x98, 0xFF, 0xEF, 0xFC, 0x33, 0x03, 0x20, 0x26,
  0x06, 0x60, 0x03, 0x01, 0xC1, 0xFC, 0xEA, 0x32, 0x0D, 0x03, 0xC0, 0x7C,
  0x07, 0x03, 0xE0, 0x9A, 0x2E, 0xFF, 0x1F, 0x81, 0x80, 0x40, 0x3C, 0x39,
  0xB0, 0x86, 0xC6, 0x33, 0x30, 0xCC, 0x83, 0x36, 0xED, 0xB7, 0xDE, 0xB3,
  0x06, 0xCC, 0x33, 0x30, 0x8D, 0x86, 0x26, 0x30, 0xF9, 0x83, 0xC0, 0x0F,
  0x81, 0xDC, 0x18, 0xC1, 0x9C, 0x19, 0x81, 0xF0, 0x1E, 0x03, 0xE7, 0x77,
  0x66, 0x3E, 0xE3, 0xCE, 0x3C, 0x7F, 0xC3, 0xEE, 0x6F, 0x6C, 0x0C, 0x63,
  0x0C, 0x61, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x60, 0x1C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xC6, 0x18, 0xC7, 0x18, 0xC0,
  0x0C, 0x88, 0xD8, 0xFF, 0x1F, 0x7C, 0xEC, 0x4E, 0x08, 0x08, 0x04, 0x02,
  0x01, 0x0F, 0xFF, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x00, 0x37, 0x66, 0xC0,
  0x7F, 0xE0, 0x7F, 0x80, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x00, 0x04, 0x0F,
  0x8F, 0xEE, 0x76, 0x1B, 0x1F, 0x8F, 0x87, 0xC3, 0x61, 0xB1, 0xD8, 0xEC,
  0xE7, 0xE1, 0xE0, 0x0E, 0x79, 0xF7, 0x65, 0xC3, 0x86, 0x0C, 0x18, 0x70,
  0xE1, 0x83, 0x0E, 0x00, 0x1F, 0x8F, 0xF1, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x30, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0x87,
  0xF1, 0x1C, 0x07, 0x01, 0x80, 0xE1, 0xE0, 0x7C, 0x03, 0x80, 0xE0, 0x3A,
  0x0C, 0xFF, 0x3F, 0x80, 0x01, 0xC0, 0xE0, 0x78, 0x36, 0x0D, 0x86, 0xE3,
  0x31, 0x8C, 0x63, 0x3F, 0xFF, 0xF8, 0x18, 0x06, 0x01, 0x80, 0x1F, 0xC7,
  0xF1, 0x80, 0x60, 0x30, 0x0F, 0x83, 0xF0, 0x0E, 0x03, 0x80, 0xE0, 0x3A,
  0x1C, 0xFF, 0x3F, 0x00, 0x01, 0x07, 0xC7, 0xE7, 0x07, 0x03, 0x01, 0xF9,
  0xFE, 0xE3, 0x61, 0xB0, 0xD8, 0x6C, 0x77, 0xF1, 0xF0, 0x7F, 0xDF, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x38, 0x00, 0x02, 0x03, 0xE1, 0xDC, 0xE3, 0x38, 0xCE, 0x71, 0xF8,
  0x38, 0x3F, 0x1C, 0xE6, 0x1B, 0x86, 0xE3, 0x9F, 0xC3, 0xE0, 0x04, 0x1F,
  0x9F, 0xCC, 0x76, 0x3F, 0x1F, 0x8F, 0xCE, 0x7F, 0x1D, 0x81, 0xC0, 0xC0,
  0xE7, 0xE3, 0xC0, 0x39, 0xCC, 0x00, 0x00, 0x00, 0x67, 0x38, 0x1C, 0x71,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xC7, 0x18, 0xC3, 0x00, 0x00, 0x81, 0xC3,
  0xC7, 0x8F, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0x80, 0x40, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x38, 0x3C, 0x78,
  0xF0, 0xE0, 0x40, 0x00, 0x7E, 0x7F, 0x07, 0x07, 0x06, 0x0C, 0x38, 0x30,
  0x60, 0x60, 0x00, 0x60, 0xE0, 0xE0, 0x07, 0xF0, 0x70, 0xE3, 0x80, 0xCC,
  0x43, 0x67, 0xED, 0x39, 0x3C, 0xCC, 0xF2, 0x33, 0xD8, 0xCF, 0x66, 0x6D,
  0xFF, 0x33, 0x98, 0xC0, 0x01, 0x81, 0x03, 0xFC, 0x03, 0xC0, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0x60, 0xEC, 0x19, 0x87, 0x30, 0xC6, 0x3F, 0xC7, 0xF8,
  0xC3, 0x38, 0x76, 0x0F, 0xC1, 0xC0, 0x1F, 0xC3, 0xFC, 0x63, 0x8C, 0x33,
  0x8E, 0x73, 0x8F, 0xC1, 0xFC, 0x31, 0xCE, 0x19, 0xC7, 0x30, 0xE7, 0xF9,
  0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x87, 0xF0, 0x7E, 0x00, 0x1F, 0xC1,
  0xFE, 0x18, 0xE1, 0x87, 0x38, 0x73, 0x87, 0x30, 0x73, 0x06, 0x30, 0x67,
  0x0E, 0x71, 0xC6, 0x3C, 0x7F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF1, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0xF8, 0xFC, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x7F, 0x3F,
  0x80, 0x1F, 0xC7, 0xF1, 0x80, 0x60, 0x38, 0x0E, 0x03, 0xF8, 0xFC, 0x30,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00, 0x0F, 0xE3, 0xFC, 0xE0, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0xFF, 0x1E, 0xE0, 0xDC, 0x1B, 0x87, 0x78, 0xC7,
  0xF8, 0x7F, 0x00, 0x1C, 0x38, 0xC1, 0x86, 0x0C, 0x30, 0x63, 0x87, 0x1F,
  0xF8, 0xFF, 0x87, 0xFC, 0x30, 0x63, 0x87, 0x1C, 0x38, 0xC1, 0x86, 0x0C,
  0x70, 0xE0, 0x1F, 0x87, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18,
  0x0C, 0x06, 0x07, 0x07, 0xC7, 0xE0, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70,
  0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0xF8, 0x78, 0x00, 0x1C, 0x78, 0xC7, 0x06, 0x30, 0x33, 0x03, 0xB8, 0x1F,
  0x80, 0xF8, 0x07, 0xE0, 0x37, 0x03, 0x98, 0x1C, 0xC0, 0xC7, 0x06, 0x18,
  0x70, 0xE0, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70,
  0x70, 0x60, 0x7F, 0xFE, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E,
  0x3E, 0x36, 0x36, 0x36, 0x36, 0x6E, 0x36, 0x6E, 0x36, 0xCC, 0x76, 0xCC,
  0x67, 0x8C, 0x67, 0x9C, 0x67, 0x1C, 0xE3, 0x18, 0x1C, 0x1C, 0x78, 0x61,
  0xE1, 0x87, 0x86, 0x3E, 0x38, 0xDC, 0xC3, 0x33, 0x0C, 0xCC, 0x33, 0xB1,
  0xC7, 0xC6, 0x1E, 0x18, 0x78, 0x61, 0xE3, 0x83, 0x80, 0x01, 0x00, 0xFC,
  0x1F, 0xE3, 0x86, 0x70, 0x77, 0x07, 0x60, 0x7E, 0x06, 0xE0, 0x6E, 0x0E,
  0xE0, 0xEE, 0x1C, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x1F, 0xC3, 0xFC, 0x63,
  0x8C, 0x33, 0x8E, 0x71, 0xCC, 0x71, 0xFC, 0x3E, 0x0E, 0x01, 0xC0, 0x30,
  0x06, 0x01, 0xC0, 0x00, 0x01, 0x00, 0xFC, 0x1F, 0xE3, 0x86, 0x70, 0x77,
  0x07, 0x60, 0x7E, 0x06, 0xE0, 0x6E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE3, 0xC7,
  0xF8, 0x3E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x1F, 0xC3, 0xF8, 0x63, 0x8C,
  0x73, 0x8E, 0x71, 0x8F, 0xF1, 0xF8, 0x37, 0x0E, 0x61, 0xCE, 0x31, 0xC6,
  0x19, 0xC3, 0x80, 0x1F, 0xC7, 0xE3, 0x80, 0xC0, 0x38, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0xC0, 0x32, 0x1C, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xC6,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07,
  0x00, 0x38, 0x73, 0x06, 0x30, 0x67, 0x0E, 0x70, 0xE7, 0x0C, 0x60, 0xC6,
  0x0C, 0xE1, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0x7F, 0x03, 0xE0, 0xC1, 0xF0,
  0x6C, 0x3B, 0x0C, 0xC3, 0x31, 0x8C, 0x63, 0xB8, 0xEC, 0x3F, 0x0F, 0x81,
  0xE0, 0x70, 0x1C, 0x00, 0xC3, 0x87, 0xC3, 0x86, 0xC3, 0x8E, 0xC7, 0x8C,
  0xC7, 0x8C, 0xCD, 0x98, 0xCD, 0x98, 0xD9, 0xB8, 0xD9, 0xB0, 0xD9, 0xB0,
  0xF1, 0xE0, 0xF1, 0xE0, 0xE1, 0xC0, 0xE1, 0xC0, 0x1C, 0x38, 0x63, 0x83,
  0x38, 0x1D, 0x80, 0x7C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x80, 0xFC,
  0x0E, 0x60, 0x63, 0x07, 0x1C, 0x70, 0xE0, 0xC1, 0xF8, 0xEE, 0x71, 0x98,
  0x6E, 0x1B, 0x07, 0x81, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00,
  0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x7F, 0x8F, 0xF8, 0x1F, 0x18,
  0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60, 0xC0,
  0xC0, 0xF0, 0xF0, 0xCC, 0x66, 0x66, 0x66, 0x63, 0x33, 0x33, 0x1F, 0x06,
  0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x38,
  0x30, 0xF0, 0xF0, 0x06, 0x03, 0x80, 0xF0, 0x6C, 0x19, 0x0C, 0x63, 0x19,
  0x82, 0xC0, 0xC0, 0xFF, 0xE6, 0x30, 0x1D, 0xCF, 0xE7, 0x39, 0x8E, 0xE3,
  0xB0, 0xCC, 0x33, 0x1C, 0xC7, 0x3F, 0xC7, 0x60, 0x1C, 0x06, 0x01, 0x80,
  0x60, 0x3B, 0x8D, 0xF3, 0x9C, 0xC3, 0x30, 0xDC, 0x77, 0x1D, 0x86, 0x73,
  0x9F, 0xCD, 0xE0, 0x1F, 0x3E, 0x70, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC2,
  0xFC, 0x7C, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x1D, 0x8F, 0xE7, 0x39, 0x8E,
  0xE3, 0xB0, 0xCC, 0x33, 0x1C, 0xC7, 0x3F, 0xC7, 0x60, 0x1E, 0x3F, 0x73,
  0xE3, 0xE7, 0xFE, 0xC0, 0xC0, 0xC0, 0xFE, 0x7E, 0x03, 0xE0, 0x78, 0x1C,
  0x03, 0x00, 0xF8, 0x3F, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x03, 0xC0, 0x70, 0x00,
  0x0E, 0xE3, 0xF8, 0xE7, 0x18, 0xE7, 0x1C, 0xC3, 0x18, 0x63, 0x1C, 0x63,
  0x8F, 0xF0, 0xEC, 0x01, 0x80, 0x71, 0x0C, 0x3F, 0x83, 0xC0, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x3B, 0x8D, 0xF3, 0x9C, 0xE7, 0x31, 0xDC, 0x67, 0x19,
  0x86, 0x63, 0x98, 0xEE, 0x30, 0x1C, 0x70, 0x80, 0x38, 0xE3, 0x0C, 0x31,
  0xC7, 0x18, 0x61, 0x8E, 0x00, 0x03, 0x81, 0xC0, 0x40, 0x00, 0x70, 0x38,
  0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18,
  0x1C, 0x3E, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x8E, 0x73,
  0x0C, 0xE1, 0xB8, 0x3E, 0x0F, 0xC1, 0xD8, 0x33, 0x06, 0x70, 0xC6, 0x38,
  0xE0, 0x1C, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x31, 0xC7, 0x18, 0x61, 0x8E,
  0x00, 0x33, 0x9C, 0x6F, 0xFC, 0xE7, 0x99, 0x8E, 0x33, 0x1C, 0x6E, 0x31,
  0xDC, 0x63, 0xB0, 0xC6, 0x63, 0x8C, 0xC6, 0x1B, 0x8C, 0x70, 0x33, 0x8D,
  0xF3, 0x9C, 0xE7, 0x31, 0xDC, 0x67, 0x19, 0x86, 0x63, 0x98, 0xEE, 0x30,
  0x1E, 0x1F, 0x9C, 0xFC, 0x7E, 0x3E, 0x1F, 0x0D, 0x86, 0xC7, 0x7F, 0x1F,
  0x00, 0x19, 0xC3, 0x7C, 0x73, 0x8C, 0x31, 0x86, 0x71, 0xCE, 0x39, 0x86,
  0x39, 0xC7, 0xF1, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x1D,
  0x9F, 0xDC, 0xEC, 0x7E, 0x3E, 0x1B, 0x0D, 0x8E, 0xC7, 0x7F, 0x1D, 0x80,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x33, 0x37, 0x3C, 0x38, 0x30, 0x70, 0x70,
  0x60, 0x60, 0x60, 0xE0, 0x1F, 0x3F, 0x71, 0x70, 0x38, 0x3C, 0x0E, 0x06,
  0x8E, 0xFE, 0xFC, 0x18, 0xC7, 0xFF, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x3C,
  0xF0, 0x71, 0xB8, 0xD8, 0x6C, 0x76, 0x3F, 0x1B, 0x0D, 0x8E, 0xC7, 0x7F,
  0x9D, 0x80, 0xC3, 0xE1, 0xB9, 0xDC, 0xCE, 0x63, 0x61, 0xB0, 0xF0, 0x78,
  0x38, 0x1C, 0x00, 0xC3, 0x1F, 0x1C, 0x6C, 0x71, 0xB3, 0x4C, 0xCF, 0x33,
  0x6D, 0xCD, 0xB6, 0x36, 0xD8, 0xF3, 0xC3, 0xCF, 0x0E, 0x38, 0x00, 0x38,
  0xE3, 0x18, 0x76, 0x07, 0xC0, 0xF0, 0x1C, 0x07, 0x80, 0xF8, 0x33, 0x0E,
  0x63, 0x8E, 0x00, 0x18, 0x71, 0xC6, 0x1C, 0x61, 0xCC, 0x0C, 0xC0, 0xD8,
  0x0D, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0xF8, 0x0E, 0x00, 0x1F, 0x8F, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x70,
  0x30, 0x3F, 0xBF, 0x80, 0x07, 0x0F, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x70,
  0xE0, 0x70, 0x30, 0x30, 0x30, 0x70, 0x70, 0x78, 0x38, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x1E, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x07, 0x1E,
  0x18, 0x18, 0x38, 0x30, 0x30, 0xF0, 0xE0, 0x20, 0xFE, 0xE7, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 12, 14, 12, 0, -14 },
  { 38, 10, 16, 10, 0, -15 },
  { 58, 14, 14, 15, 1, -14 },
  { 83, 12, 14, 12, 0, -14 },
  { 104, 3, 5, 5, 2, -14 },
  { 106, 6, 17, 6, 1, -14 },
  { 119, 6, 17, 6, -1, -14 },
  { 132, 8, 9, 10, 2, -15 },
  { 141, 9, 10, 11, 1, -12 },
  { 153, 4, 5, 5, -1, -2 },
  { 156, 6, 2, 6, 0, -6 },
  { 158, 3, 3, 5, 0, -3 },
  { 160, 10, 14, 8, -1, -14 },
  { 178, 9, 15, 10, 1, -15 },
  { 195, 7, 14, 10, 2, -14 },
  { 208, 10, 14, 10, 0, -14 },
  { 226, 10, 14, 10, 0, -14 },
  { 244, 10, 14, 10, 0, -14 },
  { 262, 10, 14, 10, 0, -14 },
  { 280, 9, 15, 10, 1, -15 },
  { 297, 10, 14, 10, 1, -14 },
  { 315, 10, 15, 10, 0, -15 },
  { 334, 9, 15, 10, 1, -15 },
  { 351, 5, 11, 5, 0, -11 },
  { 358, 6, 14, 5, -1, -11 },
  { 369, 9, 10, 11, 1, -12 },
  { 381, 9, 6, 11, 1, -10 },
  { 388, 9, 10, 11, 1, -12 },
  { 400, 8, 14, 8, 1, -14 },
  { 414, 14, 16, 15, 1, -14 },
  { 442, 11, 14, 11, -1, -14 },
  { 462, 11, 14, 11, 0, -14 },
  { 482, 11, 14, 11, 1, -14 },
  { 502, 12, 14, 12, 0, -14 },
  { 523, 10, 14, 10, 0, -14 },
  { 541, 10, 14, 9, 0, -14 },
  { 559, 11, 14, 12, 1, -14 },
  { 579, 13, 14, 13, 0, -14 },
  { 602, 9, 14, 7, -1, -14 },
  { 618, 9, 18, 6, -3, -14 },
  { 639, 13, 14, 11, 0, -14 },
  { 662, 8, 14, 9, 0, -14 },
  { 676, 16, 14, 16, 0, -14 },
  { 704, 14, 14, 13, 0, -14 },
  { 729, 12, 15, 13, 1, -15 },
  { 752, 11, 14, 11, 0, -14 },
  { 772, 12, 18, 13, 1, -15 },
  { 799, 11, 14, 11, 0, -14 },
  { 819, 10, 14, 10, 0, -14 },
  { 837, 9, 14, 9, 2, -14 },
  { 853, 12, 14, 12, 1, -14 },
  { 874, 10, 14, 11, 2, -14 },
  { 892, 16, 14, 16, 2, -14 },
  { 920, 13, 14, 10, -1, -14 },
  { 943, 10, 14, 10, 2, -14 },
  { 961, 12, 14, 9, -1, -14 },
  { 982, 8, 17, 6, 0, -14 },
  { 999, 4, 14, 8, 2, -14 },
  { 1006, 8, 17, 6, -1, -14 },
  { 1023, 10, 9, 10, 0, -14 },
  { 1035, 8, 1, 7, -2, 2 },
  { 1036, 4, 3, 6, 3, -15 },
  { 1038, 10, 11, 11, 1, -11 },
  { 1052, 10, 15, 11, 0, -15 },
  { 1071, 8, 11, 9, 1, -11 },
  { 1082, 10, 15, 11, 1, -15 },
  { 1101, 8, 11, 10, 1, -11 },
  { 1112, 11, 20, 6, -2, -15 },
  { 1140, 11, 16, 11, 0, -11 },
  { 1162, 10, 15, 11, 0, -15 },
  { 1181, 6, 15, 5, 0, -15 },
  { 1193, 9, 20, 5, -3, -15 },
  { 1216, 11, 15, 10, 0, -15 },
  { 1237, 6, 15, 5, 0, -15 },
  { 1249, 15, 11, 16, 0, -11 },
  { 1270, 10, 11, 11, 0, -11 },
  { 1284, 9, 11, 10, 1, -11 },
  { 1297, 11, 16, 11, -1, -11 },
  { 1319, 9, 16, 11, 1, -11 },
  { 1337, 8, 11, 7, 0, -11 },
  { 1348, 8, 11, 8, 0, -11 },
  { 1359, 6, 13, 7, 1, -13 },
  { 1369, 9, 11, 11, 1, -11 },
  { 1382, 9, 11, 9, 1, -11 },
  { 1395, 14, 11, 14, 1, -11 },
  { 1415, 11, 11, 9, -1, -11 },
  { 1431, 12, 16, 9, -2, -11 },
  { 1455, 9, 11, 8, -1, -11 },
  { 1468, 8, 17, 7, 0, -14 },
  { 1485, 2, 20, 10, 4, -15 },
  { 1490, 8, 17, 7, -1, -14 },
  { 1507, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC20PT7B_H_
