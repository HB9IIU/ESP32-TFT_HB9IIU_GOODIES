#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C,
  0x38, 0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0xF0, 0xF0, 0x73, 0xB9, 0xF8,
  0xFC, 0xEE, 0x77, 0x3B, 0x18, 0x01, 0xC6, 0x00, 0xE7, 0x00, 0x63, 0x80,
  0x71, 0x80, 0x38, 0xC0, 0x18, 0xE4, 0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0x38,
  0x03, 0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x07, 0xFF, 0xE3, 0xFF, 0xF2, 0x71,
  0x80, 0x31, 0xC0, 0x18, 0xC0, 0x1C, 0x60, 0x0E, 0x70, 0x06, 0x38, 0x00,
  0x00, 0x60, 0x01, 0x00, 0x3F, 0x83, 0xFF, 0x0F, 0xF8, 0x7B, 0x21, 0xC8,
  0x07, 0x60, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x0D,
  0xC0, 0x37, 0x00, 0x9C, 0x62, 0xF1, 0xFF, 0x8F, 0xFC, 0x07, 0xC0, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x1E, 0x03, 0x87, 0xE0, 0xE1, 0xDC, 0x18,
  0x31, 0x87, 0x0E, 0x31, 0xC1, 0xCE, 0x30, 0x31, 0xCE, 0x06, 0x3B, 0x80,
  0xC6, 0x67, 0xD9, 0xDD, 0xFB, 0xF7, 0x73, 0xBC, 0xCE, 0x70, 0x39, 0x8E,
  0x0E, 0x71, 0xC1, 0x8E, 0x30, 0x71, 0xCE, 0x1C, 0x39, 0xC3, 0x07, 0x70,
  0xE0, 0xFE, 0x38, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1E,
  0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3F, 0x8F, 0x7B, 0x8E, 0xF3, 0xDE, 0xE1, 0xFC, 0xE1, 0xFC, 0xE0,
  0xF8, 0xE0, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0x3E, 0x77, 0xEE, 0xEE,
  0xC0, 0x03, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0x07, 0x00,
  0xE2, 0x18, 0x73, 0x0F, 0xFE, 0x7F, 0xC7, 0xF9, 0xF0, 0x77, 0x1E, 0x60,
  0x8E, 0x01, 0x80, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0xE7, 0x9C, 0x73, 0x8C, 0x00, 0x7F, 0x7F, 0xFE, 0x77,
  0xFF, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x38, 0xF3, 0xC7, 0x9C, 0x1D, 0xE1, 0xEE,
  0x0F, 0x70, 0x7F, 0x83, 0xFC, 0x1D, 0xC0, 0xEE, 0x0F, 0x70, 0x7B, 0x83,
  0x9C, 0x3C, 0xF1, 0xC7, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0x03, 0x87, 0xC7,
  0xE7, 0xFF, 0xF7, 0xB9, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x00, 0x03, 0xF8, 0x0F, 0xF8,
  0x3F, 0xF0, 0x30, 0xF0, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xF1, 0xFF, 0xC7, 0xFF, 0x80, 0x07, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC2, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x80, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0x3C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x0E, 0xE0, 0x77, 0x01, 0xDC, 0x0E,
  0x70, 0x71, 0xC3, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xF0,
  0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0xE0,
  0xFF, 0xC1, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x80, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x01, 0xF8, 0x3F, 0xC3, 0xFE,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x78, 0x77, 0xE3, 0xFF, 0xBE,
  0x3D, 0xE0, 0xEF, 0x07, 0x78, 0x3B, 0x83, 0xDC, 0x1C, 0xF1, 0xE3, 0xFE,
  0x1F, 0xF0, 0x7E, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x9E, 0x78, 0x73, 0x83, 0x9C,
  0x1C, 0xF1, 0xE3, 0x9E, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0, 0xF3, 0xCF, 0x0E,
  0x70, 0x7B, 0x83, 0xDC, 0x1E, 0xE0, 0xE7, 0xDF, 0x1F, 0xF0, 0x7F, 0x00,
  0x07, 0xE0, 0xFF, 0x8F, 0xFC, 0x70, 0xE7, 0x87, 0xB8, 0x3D, 0xC1, 0xEE,
  0x0F, 0x70, 0x73, 0xC7, 0x9F, 0xFC, 0x7E, 0xE1, 0xEF, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC7, 0xFC, 0x3F, 0xC1, 0xF8, 0x00, 0x1E, 0x3C, 0x78,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x1E, 0x3C, 0x00, 0x0F,
  0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x38,
  0x38, 0x70, 0x70, 0xE0, 0xE0, 0xC0, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x0E, 0x00, 0x40, 0x00, 0x3F, 0xBF, 0xF7, 0xFD, 0x07, 0x01, 0xC0,
  0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x1C, 0x00, 0x00,
  0x00, 0x60, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07,
  0xC1, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0x73, 0x81, 0xC7, 0x38, 0xFE, 0x37,
  0x1E, 0xE3, 0x73, 0x8E, 0x36, 0x38, 0xE3, 0xE7, 0x0C, 0x7E, 0x71, 0xC7,
  0xE7, 0x1C, 0x6E, 0x71, 0xCE, 0xE7, 0x3D, 0xCE, 0x7E, 0xF8, 0xE3, 0xCF,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x40, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xEC, 0x00, 0xEE, 0x01,
  0xCE, 0x01, 0xCE, 0x03, 0xCE, 0x03, 0x8E, 0x07, 0x8E, 0x07, 0x0E, 0x0F,
  0x0E, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x1C, 0x0E, 0x3C, 0x0E, 0x38,
  0x0E, 0x78, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x0F,
  0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCF, 0x0F, 0x3F, 0xF8, 0xFF, 0x83, 0xFF,
  0x1E, 0x1E, 0x70, 0x79, 0xC0, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xFF,
  0xCF, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0xF8, 0x21,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x10,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0,
  0xE1, 0xF1, 0xC1, 0xE3, 0x81, 0xCF, 0x03, 0x9E, 0x07, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xEE, 0x07, 0x9C, 0x0F, 0x78, 0x3C,
  0xF1, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x87, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xFF,
  0x83, 0xFE, 0x1F, 0xF8, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9,
  0xF0, 0x23, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC1,
  0xFB, 0x87, 0xF7, 0x0F, 0xEE, 0x03, 0xDC, 0x07, 0x38, 0x0E, 0x78, 0x3C,
  0xF0, 0x78, 0xFF, 0xF1, 0xFF, 0xC0, 0xFF, 0x00, 0x0E, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0xF0, 0x3C, 0x78,
  0x1C, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0x03, 0xC7, 0x81, 0xC3,
  0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0x1C, 0x38, 0x0E,
  0x1C, 0x0F, 0x00, 0x0F, 0xF0, 0xFF, 0x07, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xE0, 0xFF, 0x0F, 0xF0, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x9E, 0x0F, 0xE0, 0xFC, 0x0F, 0x00,
  0x0E, 0x0F, 0x8F, 0x0F, 0x07, 0x87, 0x83, 0x87, 0x81, 0xC7, 0x80, 0xE7,
  0x80, 0xF7, 0x80, 0x7B, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF8, 0x07, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0xF0, 0xE0,
  0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x7C, 0x7C,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F,
  0xE3, 0xB8, 0x3F, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x3B, 0xC3,
  0xB8, 0xEE, 0x1C, 0xE7, 0x38, 0x73, 0x9C, 0xE1, 0xCE, 0xE3, 0x87, 0x3B,
  0x9E, 0x3C, 0x7C, 0x70, 0xE1, 0xF1, 0xC3, 0x87, 0x87, 0x0E, 0x1E, 0x1C,
  0x38, 0x70, 0xF0, 0x0F, 0x01, 0xC7, 0xC0, 0x71, 0xF0, 0x3C, 0x7E, 0x0E,
  0x1F, 0x83, 0x87, 0xE0, 0xE3, 0xB8, 0x38, 0xE7, 0x1C, 0x39, 0xC7, 0x0E,
  0x71, 0xC3, 0x9E, 0x71, 0xC3, 0xBC, 0x70, 0xEE, 0x1C, 0x3B, 0x87, 0x0F,
  0xE3, 0xC1, 0xF8, 0xE0, 0x7E, 0x38, 0x1F, 0x0E, 0x03, 0xC3, 0x80, 0xF0,
  0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xE1, 0xE1, 0xE0, 0x71, 0xE0,
  0x3C, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xB8, 0x03, 0x9C, 0x01, 0xCE,
  0x01, 0xEF, 0x00, 0xF7, 0x80, 0x71, 0xC0, 0x78, 0xE0, 0x3C, 0x78, 0x3C,
  0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xC7, 0x0F, 0x1C, 0x1C, 0x70, 0x73, 0xC1, 0xCF, 0x07, 0x38, 0x3C, 0xE3,
  0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xE1, 0xE1, 0xE0, 0x71, 0xE0, 0x3C, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x71,
  0xC0, 0x78, 0xE0, 0x3C, 0x78, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0x0F, 0x1C, 0x3C, 0x70, 0x73, 0xC3,
  0xCF, 0x0F, 0x38, 0x78, 0xFF, 0xE3, 0xFE, 0x1F, 0xF0, 0x79, 0xC1, 0xC7,
  0x07, 0x1E, 0x3C, 0x38, 0xF0, 0xE3, 0x83, 0xCE, 0x0F, 0x38, 0x1E, 0x03,
  0xF8, 0x3F, 0xF1, 0xFF, 0x87, 0x82, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x81, 0xE3, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xE0, 0x38, 0xE0, 0x78, 0xE0,
  0x78, 0xE0, 0x70, 0xF0, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0x80, 0xE0,
  0x3F, 0x80, 0xFE, 0x07, 0xB8, 0x1E, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38,
  0x78, 0xE1, 0xC3, 0x8F, 0x0E, 0x38, 0x39, 0xE0, 0xE7, 0x03, 0xBC, 0x0E,
  0xE0, 0x3B, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x70,
  0x3F, 0x81, 0xC0, 0xEE, 0x0F, 0x03, 0xB8, 0x3C, 0x1E, 0xE1, 0xF0, 0x73,
  0x87, 0xC3, 0xCE, 0x3B, 0x0E, 0x38, 0xEC, 0x38, 0xE3, 0xB1, 0xC3, 0x9C,
  0xC7, 0x0E, 0x73, 0x3C, 0x3B, 0x8C, 0xE0, 0xEE, 0x33, 0x83, 0xB0, 0xDC,
  0x0F, 0xC3, 0x70, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x0E, 0x1E,
  0x01, 0xC3, 0x80, 0x3C, 0xF0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x0F, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x07, 0x83, 0x81,
  0xE0, 0x70, 0x78, 0x0F, 0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xE3, 0xCF,
  0x1C, 0x39, 0xE1, 0xCE, 0x0E, 0xF0, 0x77, 0x03, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xF0, 0x7E, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x7E, 0x0F, 0xE0, 0xE3, 0x8E, 0x38, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x0E, 0x38, 0xE3, 0x8E, 0x38, 0xE1, 0xC7, 0x07, 0xE0, 0xFC,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x3F, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF8, 0x07, 0xE0, 0x39, 0x80, 0xE7, 0x07, 0x1C, 0x18, 0x30, 0xE0, 0xE3,
  0x03, 0xBC, 0x07, 0x7F, 0xFF, 0xFC, 0xF3, 0x8E, 0x30, 0x0F, 0x9C, 0x7F,
  0xE3, 0xEF, 0x8E, 0x1E, 0x78, 0x79, 0xC1, 0xEF, 0x07, 0x3C, 0x1C, 0xF0,
  0x73, 0x83, 0xCE, 0x0E, 0x3C, 0x78, 0xFF, 0xE1, 0xFB, 0x87, 0xCE, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xEF,
  0x87, 0x7E, 0x1F, 0x3C, 0x78, 0xF1, 0xC1, 0xCF, 0x07, 0x38, 0x3C, 0xE0,
  0xF3, 0x83, 0x9E, 0x0E, 0x78, 0x79, 0xE1, 0xC7, 0xFF, 0x1F, 0xF8, 0xE7,
  0xC0, 0x0F, 0xE3, 0xFC, 0xF9, 0x9C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0xC0, 0x78, 0x4F, 0xF8, 0xFF, 0x0F, 0xE0, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x83, 0xEF, 0x0F,
  0xFC, 0x3C, 0xF8, 0x70, 0xF1, 0xE1, 0xE3, 0x83, 0x8F, 0x07, 0x1E, 0x0E,
  0x3C, 0x1C, 0x70, 0x78, 0xE0, 0xE1, 0xE3, 0xC3, 0xFF, 0x83, 0xF7, 0x03,
  0xCE, 0x00, 0x0F, 0xE1, 0xFF, 0x3C, 0x73, 0x87, 0x70, 0x77, 0x0F, 0xFF,
  0xEF, 0xF8, 0xF8, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF9, 0xC7, 0xFC, 0x3F,
  0x80, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xC8, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x01, 0xFE, 0x03, 0xFC, 0x0B, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x01,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xCE, 0x1F, 0xF8, 0x7D, 0xF0,
  0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0xF0,
  0xF1, 0xC1, 0xC3, 0xC7, 0x87, 0xFF, 0x07, 0xEE, 0x0F, 0xBC, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC3, 0x0F, 0x07, 0xFE, 0x0F, 0xF8, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xEF,
  0x87, 0x7F, 0x1F, 0x7C, 0x78, 0xF1, 0xC3, 0xCF, 0x0F, 0x3C, 0x38, 0xE0,
  0xE3, 0x83, 0x9E, 0x1E, 0x78, 0x79, 0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0xF0,
  0xF0, 0x07, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x0F,
  0xC0, 0xFC, 0x07, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x87, 0x8E, 0x1C, 0x1C, 0x78, 0x39, 0xE0, 0x77,
  0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x3C, 0xE0, 0x79, 0xC0,
  0xE3, 0xC1, 0xC3, 0x83, 0x87, 0x8F, 0x0F, 0x00, 0x07, 0x0F, 0x0F, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x78,
  0x78, 0x70, 0x70, 0x70, 0xF0, 0x1C, 0xF9, 0xF0, 0xEF, 0xDF, 0xC7, 0xDF,
  0xDE, 0x3C, 0x7C, 0x71, 0xC3, 0xC3, 0x9E, 0x1E, 0x1C, 0xE0, 0xE0, 0xE7,
  0x07, 0x0F, 0x38, 0x78, 0x73, 0xC3, 0xC3, 0x9E, 0x1C, 0x1C, 0xE0, 0xE0,
  0xE7, 0x07, 0x0F, 0x38, 0x78, 0x73, 0xC3, 0x83, 0x80, 0x1C, 0xF8, 0x77,
  0xF1, 0xF7, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x0E, 0x38,
  0x39, 0xE1, 0xE7, 0x87, 0x9C, 0x1C, 0x70, 0x71, 0xC1, 0xCF, 0x0F, 0x00,
  0x0F, 0xE0, 0xFF, 0x8F, 0x3C, 0xF0, 0xE7, 0x87, 0xB8, 0x3F, 0xC1, 0xFE,
  0x0E, 0xE0, 0x77, 0x07, 0xB8, 0x3D, 0xE3, 0xC7, 0xFE, 0x3F, 0xE0, 0xFC,
  0x00, 0x0E, 0x7C, 0x1D, 0xF8, 0x3E, 0x78, 0x78, 0xF0, 0xE0, 0xE3, 0xC1,
  0xC7, 0x07, 0x8E, 0x0F, 0x1C, 0x1C, 0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xC3,
  0xFF, 0x87, 0xFE, 0x1E, 0xF8, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x9C, 0x7F, 0xE3, 0xEF,
  0x8E, 0x1E, 0x78, 0x79, 0xC1, 0xCF, 0x07, 0x3C, 0x1C, 0xF0, 0x73, 0x83,
  0xCE, 0x0E, 0x3C, 0x78, 0xFF, 0xE1, 0xFB, 0x87, 0xDE, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0xF1,
  0xDE, 0x1F, 0xE1, 0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x1F, 0xE7, 0xFC,
  0xF1, 0x9C, 0x03, 0x80, 0x78, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0x78, 0x0F,
  0x41, 0xEF, 0xF9, 0xFF, 0x3F, 0xC0, 0x0E, 0x06, 0x07, 0x0F, 0xFF, 0xF9,
  0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xFC,
  0x7E, 0x3F, 0x00, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x78, 0x79,
  0xE1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x78,
  0xFF, 0xE1, 0xFB, 0x87, 0xCE, 0x00, 0xF0, 0x7B, 0x83, 0x9C, 0x3C, 0xE1,
  0xC7, 0x1E, 0x38, 0xE1, 0xCF, 0x0E, 0x70, 0x77, 0x83, 0xB8, 0x1D, 0xC0,
  0xFC, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0xE1, 0xE1, 0xFC, 0x3C, 0x3B,
  0x8F, 0x8F, 0x71, 0xB1, 0xCE, 0x7E, 0x39, 0xCF, 0xCE, 0x39, 0xB9, 0xC7,
  0x77, 0x70, 0xEC, 0xEE, 0x1F, 0x9D, 0xC3, 0xF3, 0xF0, 0x7C, 0x7E, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x1C, 0x78, 0x38,
  0xE0, 0x7B, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0x81, 0xE7, 0x03, 0x8E, 0x0F, 0x1E, 0x3C, 0x1C, 0x00,
  0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x3C, 0x0E, 0x38,
  0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0xFF, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0xFC, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0xE0, 0x7C,
  0x0F, 0x83, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0xF8,
  0x3E, 0x0F, 0x01, 0xF0, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0E, 0x03, 0xC0, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x78, 0x0F, 0x03, 0xC3, 0xF0, 0xE0, 0x78, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x83, 0xC0, 0x3C, 0x0F, 0xFD, 0xFF, 0xFF,
  0x03, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 9, 7, 11, 3, -20 },
  { 29, 17, 20, 16, 0, -20 },
  { 72, 14, 23, 14, 0, -21 },
  { 113, 19, 20, 22, 2, -20 },
  { 161, 16, 20, 17, 1, -20 },
  { 201, 4, 7, 7, 3, -20 },
  { 205, 9, 24, 8, 1, -20 },
  { 232, 10, 24, 8, -2, -20 },
  { 262, 11, 12, 14, 3, -21 },
  { 279, 13, 14, 15, 1, -17 },
  { 302, 6, 7, 7, -1, -3 },
  { 308, 8, 3, 9, 0, -9 },
  { 311, 4, 4, 7, 0, -4 },
  { 313, 14, 20, 11, -1, -20 },
  { 348, 13, 20, 14, 1, -20 },
  { 381, 9, 20, 14, 3, -20 },
  { 404, 15, 20, 14, -1, -20 },
  { 442, 14, 20, 14, 0, -20 },
  { 477, 14, 20, 14, 0, -20 },
  { 512, 14, 20, 14, 0, -20 },
  { 547, 13, 20, 14, 1, -20 },
  { 580, 14, 20, 14, 1, -20 },
  { 615, 13, 20, 14, 1, -20 },
  { 648, 13, 20, 14, 1, -20 },
  { 681, 7, 15, 7, 0, -15 },
  { 695, 8, 19, 7, -1, -15 },
  { 714, 13, 14, 15, 1, -17 },
  { 737, 13, 8, 15, 1, -14 },
  { 750, 13, 14, 15, 1, -17 },
  { 773, 10, 20, 11, 2, -20 },
  { 798, 20, 22, 22, 1, -20 },
  { 853, 16, 20, 15, -2, -20 },
  { 893, 14, 20, 16, 1, -20 },
  { 928, 15, 20, 15, 1, -20 },
  { 966, 15, 20, 17, 1, -20 },
  { 1004, 14, 20, 13, 1, -20 },
  { 1039, 14, 20, 13, 1, -20 },
  { 1074, 15, 20, 17, 2, -20 },
  { 1112, 17, 20, 18, 1, -20 },
  { 1155, 12, 20, 9, -1, -20 },
  { 1185, 12, 26, 8, -4, -20 },
  { 1224, 17, 20, 15, 1, -20 },
  { 1267, 10, 20, 13, 1, -20 },
  { 1292, 22, 20, 22, 1, -20 },
  { 1347, 18, 20, 19, 1, -20 },
  { 1392, 17, 20, 18, 1, -20 },
  { 1435, 14, 20, 15, 1, -20 },
  { 1470, 17, 25, 18, 1, -20 },
  { 1524, 14, 20, 15, 1, -20 },
  { 1559, 14, 20, 13, 0, -20 },
  { 1594, 13, 20, 13, 2, -20 },
  { 1627, 16, 20, 17, 2, -20 },
  { 1667, 14, 20, 15, 3, -20 },
  { 1702, 22, 20, 23, 3, -20 },
  { 1757, 19, 20, 15, -2, -20 },
  { 1805, 13, 20, 14, 3, -20 },
  { 1838, 16, 20, 13, -1, -20 },
  { 1878, 12, 24, 9, -1, -20 },
  { 1914, 6, 20, 11, 3, -20 },
  { 1929, 11, 24, 9, -2, -20 },
  { 1962, 14, 12, 14, 0, -20 },
  { 1983, 11, 2, 10, -3, 2 },
  { 1986, 5, 4, 8, 4, -21 },
  { 1989, 14, 15, 15, 1, -15 },
  { 2016, 14, 21, 15, 0, -21 },
  { 2053, 11, 15, 12, 1, -15 },
  { 2074, 15, 21, 15, 1, -21 },
  { 2114, 12, 15, 14, 1, -15 },
  { 2137, 15, 28, 9, -3, -21 },
  { 2190, 15, 22, 15, 0, -15 },
  { 2232, 14, 21, 15, 0, -21 },
  { 2269, 8, 21, 7, 0, -21 },
  { 2290, 12, 28, 7, -4, -21 },
  { 2332, 15, 21, 14, 0, -21 },
  { 2372, 8, 21, 7, 0, -21 },
  { 2393, 21, 15, 23, 0, -15 },
  { 2433, 14, 15, 15, 0, -15 },
  { 2460, 13, 15, 15, 1, -15 },
  { 2485, 15, 22, 15, -1, -15 },
  { 2527, 14, 22, 15, 1, -15 },
  { 2566, 12, 15, 10, 0, -15 },
  { 2589, 11, 15, 12, 0, -15 },
  { 2610, 9, 18, 10, 1, -18 },
  { 2631, 14, 15, 15, 1, -15 },
  { 2658, 13, 15, 13, 1, -15 },
  { 2683, 19, 15, 20, 2, -15 },
  { 2719, 15, 15, 13, -1, -15 },
  { 2748, 16, 22, 13, -2, -15 },
  { 2792, 13, 15, 11, -1, -15 },
  { 2817, 11, 24, 10, 0, -20 },
  { 2850, 2, 28, 14, 6, -21 },
  { 2857, 10, 24, 10, -1, -20 },
  { 2887, 13, 4, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC28PT7B_H_
