#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC38PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x03, 0xE0, 0xFC, 0x1F,
  0x81, 0xE0, 0x00, 0x7C, 0xFB, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x1E, 0x78,
  0xF3, 0xC7, 0x9E, 0x38, 0xE1, 0xC7, 0x0E, 0x00, 0x00, 0x78, 0xF0, 0x03,
  0x87, 0x00, 0x3C, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0,
  0x07, 0x8F, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1C, 0x38, 0x00,
  0xE1, 0xC0, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x3C, 0x38,
  0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x8F, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x03, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7C,
  0xCE, 0x1E, 0x30, 0x07, 0x9C, 0x01, 0xE6, 0x00, 0x7D, 0x80, 0x1F, 0xE0,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x1D, 0xF0, 0x06, 0x7C, 0x01, 0x9F, 0x00, 0x67, 0xCC, 0x19, 0xE3, 0xEF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xC1,
  0xFE, 0x01, 0xE0, 0x7F, 0xC0, 0x70, 0x3C, 0xF0, 0x3C, 0x1E, 0x3C, 0x1E,
  0x07, 0x8F, 0x07, 0x01, 0xE3, 0xC3, 0xC0, 0x70, 0xF1, 0xE0, 0x3C, 0x3C,
  0x70, 0x0F, 0x0E, 0x3C, 0x03, 0xC7, 0x9E, 0x38, 0xF1, 0xE7, 0x3F, 0xBC,
  0xF3, 0xDF, 0xE7, 0xFD, 0xEF, 0xFD, 0xFE, 0x73, 0xCF, 0x3F, 0x3D, 0xE3,
  0xC2, 0x1E, 0x78, 0xF0, 0x07, 0x1E, 0x3C, 0x03, 0xC7, 0x0F, 0x01, 0xE3,
  0xC3, 0xC0, 0x70, 0xF0, 0xE0, 0x3C, 0x3C, 0x78, 0x1E, 0x0F, 0x1E, 0x07,
  0x03, 0xCF, 0x03, 0xC0, 0x7F, 0xC1, 0xE0, 0x1F, 0xE0, 0xF0, 0x03, 0xF0,
  0x00, 0x08, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xC7, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87,
  0x80, 0x1E, 0x3E, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xC7, 0xFE, 0x1E, 0x3E, 0xF8, 0x79, 0xF1,
  0xF3, 0xCF, 0x87, 0xDF, 0x3E, 0x0F, 0xF8, 0xF0, 0x3F, 0xE3, 0xC0, 0x7F,
  0x0F, 0x00, 0xF8, 0x3E, 0x07, 0xE0, 0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFF, 0xBE, 0x07, 0xF8, 0x7C, 0x7D, 0xE7, 0x9E, 0x73, 0xCF, 0x3C, 0xE3,
  0x80, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x08, 0x1C, 0x07, 0x0E, 0x03,
  0xEF, 0x01, 0xFF, 0x3F, 0x7F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xF8,
  0x03, 0xDE, 0x03, 0xE7, 0x03, 0xE3, 0xC0, 0x61, 0xE0, 0x10, 0xF8, 0x00,
  0x20, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x3E,
  0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0x7D, 0xFF,
  0xFF, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xCF, 0x83, 0xE1, 0xE1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xC0, 0x7D, 0xF0,
  0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F,
  0x83, 0xE1, 0xE1, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0xF8, 0x0F, 0x81, 0xFC, 0x1F, 0xE3, 0xFF, 0x3F, 0xFB, 0xF7,
  0x8F, 0x3C, 0x21, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0C, 0x00,
  0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x38, 0x3F,
  0x01, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C, 0xFE, 0x04, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC4, 0x01, 0xF8, 0xFD, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x77, 0x80, 0x1F, 0xE0, 0x07, 0xBC, 0x01, 0xE7, 0x80,
  0x3D, 0xF0, 0x0F, 0x3E, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x07,
  0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x1E, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x30,
  0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x04, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xF0, 0x83,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE7, 0xE0, 0x7B, 0xFC, 0x3F, 0xFF, 0x8F, 0xE3, 0xE3, 0xF0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C,
  0x0F, 0x8F, 0x03, 0xE3, 0xE1, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFF, 0x0F, 0x87, 0xC3, 0xC1, 0xF1, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x07,
  0xC3, 0xC1, 0xE0, 0xF8, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0x3E, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0x7C, 0xFC, 0x7E,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x20, 0x00, 0x7F, 0x80,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x9F, 0x87, 0xC3, 0xE3, 0xE0, 0x78, 0xF8,
  0x1E, 0x3C, 0x07, 0xCF, 0x01, 0xE7, 0xC0, 0x79, 0xF0, 0x3E, 0x7C, 0x0F,
  0x8F, 0x87, 0xE3, 0xF7, 0xF8, 0xFF, 0xFE, 0x1F, 0xEF, 0x03, 0xF3, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x3E, 0x3F, 0x1F, 0x87, 0x80, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x70, 0x1E, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x00, 0x80, 0x3F, 0xC7,
  0xFF, 0x8F, 0xFF, 0x3C, 0x7C, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x3F,
  0x0E, 0x1E, 0x0F, 0xF8, 0xF3, 0xC3, 0xFF, 0x8F, 0x3C, 0x3C, 0x78, 0xF3,
  0x87, 0x87, 0x0F, 0x78, 0xF0, 0x70, 0xF7, 0x0F, 0x0F, 0x0E, 0x70, 0xE0,
  0xF0, 0xE7, 0x1E, 0x0E, 0x0E, 0x71, 0xE0, 0xE1, 0xE7, 0x1E, 0x1E, 0x1C,
  0xF1, 0xE1, 0xE3, 0xCF, 0x1E, 0x3E, 0x78, 0x70, 0xFF, 0xFF, 0x07, 0x0F,
  0xE7, 0xE0, 0x70, 0x78, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x20, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x3C, 0x78, 0x03,
  0xE3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3E,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xF0,
  0x0F, 0x1F, 0x00, 0x78, 0xF8, 0x03, 0xCF, 0x80, 0x1E, 0x7C, 0x00, 0xF7,
  0xC0, 0x07, 0xBE, 0x00, 0x3E, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0,
  0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xE0, 0xF8, 0x3C, 0x07, 0xC3,
  0xC0, 0x7C, 0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0xFC,
  0x78, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFC, 0x02, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x20, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xF8, 0x3F,
  0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x7C,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xE0, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x80,
  0x41, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x7F, 0xCF, 0x81,
  0xFF, 0x3E, 0x07, 0xFC, 0xF8, 0x3F, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F,
  0x81, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3C, 0x01,
  0xF0, 0x78, 0x03, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0x00, 0xF8, 0x3E,
  0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x02, 0x3F, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1E, 0x07,
  0xE0, 0x3C, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xE0,
  0x07, 0x8F, 0xC0, 0x0F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xBE, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0xF8, 0x00, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0xC0, 0x7C, 0x0F,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x07, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x07, 0xBC, 0x0F, 0xF0, 0x1E, 0xF0, 0x7D, 0xC0, 0xF7, 0xC1,
  0xE7, 0x03, 0xDF, 0x07, 0x9C, 0x1E, 0x78, 0x1E, 0x70, 0x79, 0xE0, 0x79,
  0xE1, 0xC7, 0x83, 0xE7, 0x8F, 0x3E, 0x0F, 0x1E, 0x38, 0xF0, 0x3C, 0x79,
  0xE3, 0xC0, 0xF1, 0xE7, 0x0F, 0x03, 0xC7, 0xBC, 0x7C, 0x1F, 0x1E, 0xE1,
  0xF0, 0x78, 0x7F, 0x87, 0x81, 0xE1, 0xFC, 0x1E, 0x07, 0x87, 0xF0, 0x78,
  0x3E, 0x1F, 0x83, 0xE0, 0xF0, 0x7E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF8,
  0x03, 0xC0, 0xFE, 0x01, 0xE0, 0xFF, 0x00, 0xF0, 0x7F, 0x80, 0xF8, 0x3F,
  0xC0, 0x78, 0x1E, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x0F, 0xBC, 0x0F, 0x07,
  0x9F, 0x0F, 0x83, 0xC7, 0x87, 0x81, 0xE3, 0xC3, 0xC0, 0xF1, 0xE1, 0xE0,
  0xF8, 0xF9, 0xF0, 0x78, 0x3C, 0xF8, 0x3C, 0x1E, 0x78, 0x1E, 0x0F, 0xBC,
  0x0F, 0x03, 0xDE, 0x0F, 0x81, 0xEF, 0x07, 0x80, 0xFF, 0x83, 0xC0, 0x7F,
  0x81, 0xE0, 0x1F, 0xC1, 0xF0, 0x0F, 0xE0, 0xF0, 0x07, 0xF0, 0x78, 0x01,
  0xF0, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F,
  0x87, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x83, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x83, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x0F, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xE1, 0xF8,
  0x0F, 0x87, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x1F, 0x83, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x0F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3E, 0x7C, 0x07, 0x87, 0x80, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x3E, 0x1E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x81, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x20, 0x07, 0xC7, 0x01, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF0,
  0x07, 0xC7, 0xC0, 0x1E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x00, 0x7C, 0x3C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0xC1, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x01, 0xF7, 0x80,
  0x1F, 0x78, 0x03, 0xE7, 0x80, 0x3E, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0x78,
  0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07,
  0x83, 0xE0, 0x78, 0x3C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80,
  0x7C, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0xC0, 0x3E, 0x01, 0xEF,
  0x00, 0xF8, 0x0F, 0xBC, 0x07, 0xE0, 0x3E, 0xF0, 0x1F, 0x81, 0xF3, 0xC0,
  0xFE, 0x07, 0xCF, 0x03, 0xF8, 0x1E, 0x3C, 0x1F, 0xE0, 0xF8, 0xF0, 0x7F,
  0x83, 0xC3, 0xC1, 0xDE, 0x1F, 0x0F, 0x0F, 0x78, 0x7C, 0x3C, 0x3D, 0xE1,
  0xE0, 0xF1, 0xE7, 0x8F, 0x83, 0xC7, 0x9E, 0x3C, 0x0F, 0x3C, 0x79, 0xF0,
  0x3C, 0xF1, 0xE7, 0x80, 0xF3, 0x87, 0x9E, 0x03, 0xDE, 0x1E, 0xF8, 0x0F,
  0x78, 0x7B, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F,
  0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x00,
  0x7B, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x07,
  0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0xF8,
  0x03, 0xEF, 0x00, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0x7B,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x39, 0xC0, 0x1E, 0x78, 0x0F, 0x1E, 0x03, 0xC3, 0x81, 0xE0, 0xF0, 0x70,
  0x3C, 0x3C, 0x07, 0x1E, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x0E, 0xF0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFB, 0xE7, 0x8F, 0x3C, 0x70,
  0x01, 0xF1, 0xE0, 0x7F, 0x3C, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xF8, 0xFC,
  0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x80, 0xF1,
  0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7,
  0xC1, 0xF8, 0x7C, 0x3F, 0x0F, 0xDF, 0xC1, 0xFF, 0xF8, 0x1F, 0xEF, 0x01,
  0xF1, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x8F, 0x00,
  0xF7, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x9F,
  0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7C, 0x7E,
  0x1F, 0x8F, 0xE7, 0xE1, 0xFF, 0xF8, 0x3D, 0xFE, 0x0F, 0x1F, 0x80, 0x00,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x82, 0x3F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x08, 0x7F, 0x78, 0x7F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x01, 0xF3, 0xE0, 0x1F, 0xDF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF0, 0x7C,
  0x07, 0x83, 0xE0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0x78, 0x3F, 0x03, 0xF7,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xBC, 0x01, 0xF9, 0xE0, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xE1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x3E, 0x78, 0x1E, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x04, 0x3F, 0x0E,
  0x0F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0xF0, 0x3F, 0xCF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xC7, 0xE1,
  0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xE0, 0x3C, 0x3E, 0x03, 0xC3, 0xE0, 0x3C,
  0x3C, 0x07, 0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0xC1, 0xF8, 0x7E, 0x3F, 0x83, 0xF7, 0xF0, 0x3F, 0xEF, 0x01, 0xFF,
  0xF0, 0x0F, 0x9F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x0C, 0x07, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x8F, 0x00,
  0xF7, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x81, 0xF0, 0x00,
  0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x0F, 0x80, 0x00, 0x04, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x81, 0xF0, 0x78, 0x3E, 0x0F, 0x87, 0xC0, 0xF8,
  0xF8, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x3E, 0x01, 0xF7, 0xC0, 0x1E,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x78, 0x03,
  0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC3, 0xC0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0,
  0x78, 0x1F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x80,
  0x07, 0x0F, 0x03, 0xE0, 0x39, 0xFC, 0x7F, 0x83, 0xDF, 0xF7, 0xFC, 0x1F,
  0xFF, 0xBF, 0xF0, 0xFC, 0x3F, 0x8F, 0x87, 0xC1, 0xF8, 0x7C, 0x3E, 0x0F,
  0x83, 0xE3, 0xE0, 0x7C, 0x1F, 0x1F, 0x03, 0xC0, 0xF8, 0xF0, 0x3E, 0x07,
  0x87, 0x81, 0xF0, 0x3C, 0x7C, 0x0F, 0x03, 0xE3, 0xE0, 0x78, 0x1F, 0x1F,
  0x03, 0xC0, 0xF0, 0xF0, 0x3E, 0x07, 0x87, 0x81, 0xF0, 0x3C, 0x7C, 0x0F,
  0x03, 0xE3, 0xE0, 0x78, 0x1F, 0x1E, 0x07, 0xC0, 0xF0, 0xF0, 0x3E, 0x07,
  0x8F, 0x81, 0xF0, 0x7C, 0x00, 0x07, 0x0F, 0x00, 0xE7, 0xF8, 0x3D, 0xFF,
  0x07, 0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F,
  0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x8F, 0x81, 0xE3, 0xE0, 0x79, 0xF0,
  0x1F, 0x7C, 0x07, 0x9F, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x3E, 0xF8, 0x0F,
  0xBE, 0x03, 0xEF, 0x81, 0xF1, 0xE0, 0x7C, 0x7C, 0x3E, 0x1F, 0xBF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x39, 0xFC,
  0x07, 0xBF, 0xE0, 0x7F, 0xFF, 0x07, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1, 0xF0,
  0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x7C, 0x3F,
  0x0F, 0xC3, 0xFD, 0xF8, 0x3F, 0xFF, 0x03, 0xDF, 0xE0, 0x3C, 0xFC, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF1,
  0xE0, 0x7F, 0x3C, 0x3F, 0xF7, 0x07, 0xFF, 0xE1, 0xF0, 0xFC, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xE0, 0x3C, 0x7C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x3E,
  0x3C, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8,
  0xF8, 0x3F, 0x0F, 0xDF, 0xC1, 0xFF, 0xF8, 0x1F, 0xEF, 0x01, 0xF3, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x07, 0x0F,
  0x07, 0x3E, 0x0F, 0x7E, 0x0F, 0x7E, 0x0F, 0xF6, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE,
  0x1E, 0x04, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x80, 0xF8, 0xF3, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x90, 0xFF, 0x0F, 0xF0, 0x7F, 0x00,
  0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC1, 0xF8,
  0xF0, 0xFE, 0x3E, 0x7F, 0x0F, 0xFF, 0xC3, 0xFE, 0xF0, 0x7E, 0x3C, 0x00,
  0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE7, 0xC1,
  0xF1, 0xE0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F,
  0x3E, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x03,
  0xFE, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x7B, 0xE1, 0xFC, 0x1E, 0xF8, 0x7F,
  0x0F, 0xBE, 0x1F, 0xC3, 0xCF, 0x8F, 0xF1, 0xF3, 0xE3, 0xBC, 0x78, 0xF9,
  0xEF, 0x3E, 0x3E, 0x73, 0xCF, 0x07, 0xBC, 0xF3, 0xC1, 0xEF, 0x3D, 0xE0,
  0x73, 0x8F, 0x78, 0x1D, 0xE3, 0xFE, 0x07, 0x70, 0xFF, 0x01, 0xDC, 0x3F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF0,
  0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x0F, 0x80,
  0xF0, 0x7C, 0x07, 0x87, 0xC0, 0x3E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBE,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF3, 0xC0,
  0x0F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x83, 0xC0, 0xF8, 0x1F, 0x0F, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF8,
  0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xE0, 0x03,
  0xCF, 0x00, 0x07, 0x7C, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x7F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7F, 0x00, 0x3E, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0xF4, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 27, 10, 0, -27 },
  { 39, 13, 10, 16, 4, -27 },
  { 56, 21, 27, 22, 1, -27 },
  { 127, 18, 31, 19, 1, -29 },
  { 197, 26, 28, 29, 2, -28 },
  { 288, 22, 28, 23, 1, -28 },
  { 365, 6, 10, 9, 4, -27 },
  { 373, 13, 33, 11, 1, -27 },
  { 427, 13, 33, 11, -3, -27 },
  { 481, 17, 17, 19, 3, -29 },
  { 518, 17, 19, 20, 2, -23 },
  { 559, 8, 10, 10, -2, -5 },
  { 569, 10, 4, 12, 1, -12 },
  { 574, 6, 5, 10, 0, -5 },
  { 578, 20, 27, 15, -2, -27 },
  { 646, 18, 28, 19, 1, -28 },
  { 709, 13, 27, 19, 4, -27 },
  { 753, 20, 28, 19, -1, -28 },
  { 823, 19, 28, 19, 0, -28 },
  { 890, 19, 27, 19, 0, -27 },
  { 955, 19, 27, 19, 0, -27 },
  { 1020, 18, 28, 19, 2, -28 },
  { 1083, 18, 27, 19, 2, -27 },
  { 1144, 18, 28, 19, 1, -28 },
  { 1207, 18, 28, 19, 1, -28 },
  { 1270, 9, 21, 10, 0, -21 },
  { 1294, 11, 26, 10, -2, -21 },
  { 1330, 17, 19, 20, 2, -23 },
  { 1371, 17, 11, 20, 2, -19 },
  { 1395, 17, 19, 20, 2, -23 },
  { 1436, 14, 28, 15, 2, -28 },
  { 1485, 28, 30, 29, 1, -27 },
  { 1590, 21, 27, 21, -2, -27 },
  { 1661, 20, 27, 21, 1, -27 },
  { 1729, 20, 28, 20, 2, -28 },
  { 1799, 21, 27, 23, 1, -27 },
  { 1870, 19, 27, 18, 1, -27 },
  { 1935, 19, 27, 17, 1, -27 },
  { 2000, 22, 28, 24, 2, -28 },
  { 2077, 23, 27, 24, 1, -27 },
  { 2155, 16, 27, 13, -1, -27 },
  { 2209, 17, 35, 11, -6, -27 },
  { 2284, 23, 27, 20, 1, -27 },
  { 2362, 14, 27, 17, 1, -27 },
  { 2410, 30, 27, 30, 1, -27 },
  { 2512, 25, 27, 25, 1, -27 },
  { 2597, 22, 28, 25, 2, -28 },
  { 2674, 20, 27, 20, 1, -27 },
  { 2742, 22, 34, 25, 2, -28 },
  { 2836, 19, 27, 21, 1, -27 },
  { 2901, 19, 28, 18, 0, -28 },
  { 2968, 18, 27, 18, 3, -27 },
  { 3029, 22, 27, 23, 2, -27 },
  { 3104, 20, 27, 20, 3, -27 },
  { 3172, 30, 27, 31, 4, -27 },
  { 3274, 25, 27, 20, -2, -27 },
  { 3359, 19, 27, 19, 3, -27 },
  { 3424, 21, 27, 18, -1, -27 },
  { 3495, 15, 33, 12, -1, -27 },
  { 3557, 8, 27, 15, 4, -27 },
  { 3584, 15, 33, 12, -3, -27 },
  { 3646, 18, 17, 19, 1, -27 },
  { 3685, 14, 3, 14, -3, 3 },
  { 3691, 6, 6, 11, 6, -29 },
  { 3696, 19, 21, 20, 1, -21 },
  { 3746, 19, 29, 20, 0, -29 },
  { 3815, 16, 21, 16, 1, -21 },
  { 3857, 21, 29, 20, 1, -29 },
  { 3934, 17, 21, 19, 1, -21 },
  { 3979, 21, 38, 12, -4, -29 },
  { 4079, 20, 30, 20, 0, -21 },
  { 4154, 19, 29, 20, 0, -29 },
  { 4223, 11, 29, 10, 0, -29 },
  { 4263, 16, 38, 10, -5, -29 },
  { 4339, 20, 29, 19, 0, -29 },
  { 4412, 11, 29, 10, 0, -29 },
  { 4452, 29, 21, 31, 0, -21 },
  { 4529, 19, 21, 20, 0, -21 },
  { 4579, 18, 21, 20, 1, -21 },
  { 4627, 20, 30, 20, -1, -21 },
  { 4702, 19, 30, 20, 1, -21 },
  { 4774, 16, 21, 14, 0, -21 },
  { 4816, 16, 21, 16, 0, -21 },
  { 4858, 12, 25, 13, 2, -25 },
  { 4896, 18, 21, 20, 2, -21 },
  { 4944, 17, 21, 17, 2, -21 },
  { 4989, 26, 21, 27, 2, -21 },
  { 5058, 21, 21, 18, -2, -21 },
  { 5114, 22, 30, 17, -3, -21 },
  { 5197, 17, 21, 16, -1, -21 },
  { 5242, 16, 33, 13, 0, -27 },
  { 5308, 3, 38, 18, 8, -29 },
  { 5323, 15, 33, 13, -2, -27 },
  { 5385, 17, 6, 20, 2, -16 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC38PT7B_H_
