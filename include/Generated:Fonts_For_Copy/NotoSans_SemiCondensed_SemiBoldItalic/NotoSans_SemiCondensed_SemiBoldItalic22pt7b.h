#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC22PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x30, 0xC3, 0x10, 0x01, 0x8F,
  0x38, 0x77, 0x66, 0x66, 0x66, 0xCC, 0xCC, 0x03, 0x30, 0x11, 0x81, 0x98,
  0x0C, 0xC0, 0x66, 0x1F, 0xFC, 0xFF, 0xE1, 0x98, 0x18, 0xC0, 0xCC, 0x3F,
  0xFC, 0x33, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0xC0, 0x01, 0x00, 0x20,
  0x1F, 0x0F, 0xF1, 0xB4, 0x74, 0x0E, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x02, 0xE0, 0x5C, 0x9F, 0x3F, 0xE3, 0xF0, 0x08, 0x03, 0x00, 0x1C, 0x0C,
  0x7C, 0x31, 0x98, 0xE3, 0x31, 0x86, 0x66, 0x18, 0xDC, 0x33, 0xB3, 0x66,
  0xDF, 0x7F, 0xB6, 0xE6, 0xCC, 0x19, 0x98, 0x73, 0x30, 0xCE, 0x63, 0x1D,
  0x8E, 0x1F, 0x38, 0x3C, 0x03, 0x80, 0x7F, 0x03, 0x38, 0x39, 0xC1, 0xCE,
  0x0E, 0xE0, 0x3E, 0x01, 0xE0, 0x3F, 0x1B, 0xB9, 0xDC, 0xEC, 0xC3, 0xEE,
  0x1E, 0x38, 0xF1, 0xFF, 0x87, 0xCE, 0x76, 0x66, 0xCC, 0x06, 0x18, 0x71,
  0xC3, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x81, 0x80, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x07, 0x07,
  0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x1C, 0x18, 0x30, 0xF0, 0x0E, 0x06, 0x13,
  0x1D, 0x87, 0xF8, 0xFC, 0xF1, 0xEC, 0x66, 0x02, 0x80, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x39,
  0x9C, 0xC6, 0x60, 0x7F, 0xF0, 0x6F, 0xE0, 0x00, 0x60, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x71, 0xD8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x6C, 0x3B, 0x0E, 0xC7, 0x39, 0xCF, 0xE1,
  0xF0, 0x07, 0x0E, 0x3E, 0x7E, 0xEE, 0x4E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x38, 0x38, 0x38, 0x07, 0x83, 0xF8, 0xF7, 0x88, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x3F, 0xE7, 0xFC, 0x0F, 0x83, 0xF8, 0x67, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0xF0, 0xF8, 0x1F, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x19, 0x07, 0x3F, 0xC7,
  0xF0, 0x00, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x6C, 0x1B, 0x87, 0x70, 0xCC,
  0x31, 0x8C, 0x73, 0xFF, 0xFF, 0xEF, 0xFC, 0x06, 0x01, 0xC0, 0x38, 0x0F,
  0xE1, 0xFC, 0x7F, 0x8C, 0x01, 0x80, 0x70, 0x0F, 0xC1, 0xFC, 0x23, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x19, 0x07, 0x3F, 0xC7, 0xF0, 0x03, 0xC3, 0xF1,
  0xE4, 0xE0, 0x30, 0x1C, 0x06, 0xF3, 0xFE, 0xF3, 0xB8, 0x6E, 0x1B, 0x0E,
  0xE3, 0xB9, 0xC7, 0xF1, 0xF8, 0x3F, 0xEF, 0xFD, 0xFF, 0x00, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0x07, 0x81, 0xFC, 0x73, 0x8C, 0x31, 0x8E, 0x31, 0xC7,
  0xF0, 0x78, 0x1F, 0x8F, 0x71, 0xC7, 0x30, 0xEE, 0x1C, 0xC3, 0x9F, 0xE1,
  0xF8, 0x0F, 0x0F, 0xE7, 0xB9, 0xC7, 0x61, 0xF8, 0x7E, 0x1F, 0x8E, 0x7F,
  0x9F, 0xE0, 0x38, 0x0C, 0x07, 0x03, 0x8F, 0xC3, 0xE0, 0x19, 0xCE, 0x00,
  0x00, 0x00, 0x03, 0x39, 0xC0, 0x0C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xE3, 0x1C, 0x63, 0x8C, 0x00, 0x00, 0xC0, 0xF0, 0xF8, 0xF8, 0xF0, 0x3C,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x04, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0xC0, 0x3C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x70, 0xF8,
  0xF8, 0xF0, 0x30, 0x08, 0x00, 0x1E, 0x3F, 0x99, 0xC0, 0x70, 0x30, 0x38,
  0x38, 0x38, 0x38, 0x18, 0x1C, 0x00, 0x00, 0x03, 0x03, 0x81, 0xC0, 0x01,
  0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x06, 0x30, 0xC6, 0x63, 0xF3, 0x66,
  0x23, 0xC6, 0x63, 0xCC, 0x66, 0xCC, 0x66, 0xCC, 0xE6, 0xCC, 0xCC, 0xCF,
  0x78, 0xC6, 0x30, 0x60, 0x00, 0x70, 0x20, 0x3F, 0xE0, 0x0F, 0x80, 0x01,
  0xE0, 0x1E, 0x03, 0xE0, 0x36, 0x07, 0x60, 0x66, 0x0E, 0x60, 0xC6, 0x1C,
  0x61, 0xFE, 0x3F, 0xE3, 0xFE, 0x70, 0x67, 0x07, 0xE0, 0x7E, 0x07, 0x0F,
  0xC1, 0xFE, 0x1F, 0xF1, 0xC7, 0x18, 0x71, 0x87, 0x38, 0xE3, 0xFC, 0x3F,
  0xC3, 0x0E, 0x30, 0xE7, 0x0E, 0x70, 0xE7, 0x1C, 0x7F, 0xCF, 0xF0, 0x03,
  0xE0, 0xFF, 0x1E, 0x63, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x08, 0x7F, 0x83, 0xF8, 0x0F,
  0x80, 0xFF, 0x07, 0xFC, 0x38, 0xF1, 0xC3, 0x8C, 0x1C, 0xE0, 0xE7, 0x07,
  0x38, 0x39, 0xC1, 0x8C, 0x1C, 0xE0, 0xE7, 0x0E, 0x39, 0xE1, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xFE,
  0x3F, 0x86, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0x1F, 0xC7, 0xF8, 0x0F,
  0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xFE, 0x3F, 0x87,
  0xF0, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x03, 0xE0, 0x7F,
  0xC7, 0x9C, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x3E, 0xE3, 0xF7,
  0x1F, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x38, 0x61, 0xFF, 0x03, 0xF8, 0x0C,
  0x1C, 0x30, 0x71, 0xC1, 0xC7, 0x06, 0x1C, 0x18, 0x60, 0xE3, 0x83, 0x8F,
  0xFE, 0x3F, 0xF0, 0xC1, 0xC3, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0xC1, 0x86,
  0x0E, 0x38, 0x38, 0x0F, 0xC7, 0xF0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x07, 0xE3, 0xF8, 0x01,
  0xC0, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x0F, 0x83, 0xC0,
  0x0C, 0x1C, 0x30, 0xE1, 0xC7, 0x07, 0x38, 0x19, 0xC0, 0x67, 0x03, 0xB8,
  0x0F, 0xC0, 0x3F, 0x00, 0xEC, 0x03, 0x38, 0x1C, 0xE0, 0x71, 0x81, 0xC7,
  0x06, 0x1C, 0x38, 0x38, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0,
  0x70, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x85, 0xFD, 0xFE, 0x0E, 0x03,
  0xC7, 0x81, 0xF1, 0xE0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE3,
  0xB1, 0xB0, 0xEC, 0xEC, 0x33, 0x33, 0x0C, 0xCD, 0xC3, 0x36, 0x71, 0xCD,
  0x98, 0x73, 0xC6, 0x18, 0xF1, 0x86, 0x38, 0xE3, 0x8E, 0x38, 0x0E, 0x0E,
  0x3C, 0x1C, 0x78, 0x30, 0xF8, 0x61, 0xF0, 0xC3, 0x63, 0x8E, 0xC7, 0x1D,
  0xCC, 0x31, 0x98, 0x63, 0x30, 0xC7, 0xE3, 0x8F, 0xC7, 0x0F, 0x0C, 0x1E,
  0x18, 0x3C, 0x70, 0x38, 0x07, 0xC0, 0x7F, 0x87, 0xBC, 0x70, 0x73, 0x83,
  0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xB8, 0x1D, 0xC0, 0xEE,
  0x0E, 0x38, 0xF1, 0xFF, 0x07, 0xE0, 0x0F, 0x81, 0xFE, 0x1F, 0xF1, 0xC7,
  0x1C, 0x71, 0x87, 0x38, 0x73, 0x8E, 0x3F, 0xE3, 0xF8, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xBC, 0x70,
  0x73, 0x83, 0xB8, 0x1D, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xB8, 0x1D,
  0xC0, 0xEE, 0x0E, 0x38, 0xF1, 0xFF, 0x07, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0F, 0x81, 0xFE, 0x1D, 0xF1, 0xC7, 0x1C, 0x71, 0x87,
  0x38, 0xE3, 0x9E, 0x3F, 0xC3, 0xF0, 0x33, 0x87, 0x38, 0x71, 0x87, 0x1C,
  0x61, 0xCE, 0x0E, 0x07, 0xC3, 0xFC, 0x7B, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x39, 0x8F, 0x3F, 0xC7,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0x18, 0x39, 0xC1,
  0xCE, 0x0E, 0x70, 0x63, 0x07, 0x18, 0x39, 0xC1, 0xCE, 0x0C, 0x70, 0x63,
  0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1C, 0x79, 0xE1, 0xFE, 0x07, 0xE0, 0xE0,
  0x7E, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0xE3, 0x8E, 0x70, 0xE7,
  0x06, 0xE0, 0x6E, 0x06, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xE0,
  0xC1, 0xF8, 0x70, 0x6E, 0x1C, 0x3B, 0x8F, 0x0C, 0xE3, 0xC7, 0x39, 0xF1,
  0x8E, 0x6C, 0xE3, 0x9B, 0x38, 0xEC, 0xCC, 0x3B, 0x37, 0x0F, 0xCD, 0x83,
  0xE3, 0x60, 0xD8, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0x83, 0x80, 0x1C,
  0x1C, 0x30, 0xE0, 0xE3, 0x83, 0x9C, 0x06, 0xE0, 0x1B, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xD8, 0x07, 0x70, 0x39, 0xC1, 0xC3, 0x07,
  0x0E, 0x38, 0x38, 0xE0, 0xFC, 0x3B, 0x86, 0x31, 0xC6, 0x70, 0xEC, 0x1F,
  0x83, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0x0F, 0xF8, 0x7F, 0x87, 0xFC, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01,
  0xFF, 0x1F, 0xF8, 0x0F, 0x1F, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30,
  0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC8, 0xF0, 0xF0, 0xE7,
  0x18, 0xC6, 0x31, 0x8E, 0x71, 0x8C, 0x63, 0x1C, 0xE7, 0x0F, 0x87, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x60, 0x30, 0x18, 0x1C, 0x0E, 0x1E, 0x1F, 0x00, 0x03, 0x00, 0xE0, 0x1C,
  0x07, 0xC0, 0xD8, 0x33, 0x0E, 0x71, 0x86, 0x60, 0xDC, 0x1C, 0xFF, 0xE6,
  0x33, 0x1E, 0xE7, 0xF9, 0xC7, 0x38, 0xEE, 0x1D, 0xC3, 0x38, 0x67, 0x1C,
  0xE3, 0x9C, 0xF3, 0xFC, 0x3D, 0x80, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x37, 0x8F, 0xF9, 0xE7, 0x38, 0xE7, 0x1C, 0xC3, 0xB8, 0x77, 0x0C,
  0xE3, 0x9C, 0xF3, 0xFC, 0xCF, 0x00, 0x1F, 0x9F, 0x9C, 0x4E, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x71, 0x3F, 0x8F, 0xC0, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE1, 0xEC, 0x3F, 0xC7, 0x1C, 0x71, 0xCE, 0x1C, 0xE1,
  0x8E, 0x18, 0xC3, 0x8C, 0x38, 0xE7, 0x8F, 0xF0, 0x7B, 0x00, 0x1F, 0x1F,
  0xDC, 0x6C, 0x3E, 0x3F, 0xFB, 0xF1, 0x80, 0xC0, 0x70, 0xBF, 0xCF, 0xC0,
  0x00, 0xF0, 0x3E, 0x03, 0xA0, 0x30, 0x07, 0x00, 0xFC, 0x1F, 0xC0, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x0F, 0x71, 0xFE,
  0x38, 0xE3, 0x8E, 0x70, 0xE7, 0x0C, 0x70, 0xC7, 0x1C, 0x71, 0xC7, 0x3C,
  0x7F, 0x83, 0xD8, 0x03, 0x80, 0x38, 0x87, 0x0F, 0xF0, 0xFE, 0x00, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x37, 0x8F, 0xF9, 0xE7, 0x38, 0xE7,
  0x1C, 0xC3, 0x38, 0x67, 0x1C, 0xE3, 0x98, 0x73, 0x0C, 0xE1, 0x80, 0x08,
  0x71, 0xC0, 0x00, 0x63, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0xC6, 0x18, 0xE0,
  0x00, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81,
  0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x0F, 0x87,
  0x80, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x8F, 0x38, 0xC3,
  0x9C, 0x3B, 0x83, 0x70, 0x3E, 0x07, 0xF0, 0x77, 0x07, 0x70, 0x63, 0x86,
  0x38, 0xE1, 0xC0, 0x0C, 0x31, 0xC7, 0x1C, 0x63, 0x8E, 0x38, 0xC3, 0x1C,
  0x71, 0xC6, 0x18, 0xE0, 0x1B, 0xCF, 0x1F, 0xEF, 0xCF, 0x3C, 0xE7, 0x1C,
  0x73, 0x8E, 0x39, 0x86, 0x19, 0xC3, 0x0C, 0xE3, 0x8E, 0x71, 0xC7, 0x30,
  0xC3, 0x98, 0x61, 0x9C, 0x71, 0xC0, 0x1B, 0xC7, 0xFC, 0xF3, 0x9C, 0x73,
  0x8E, 0x61, 0xDC, 0x33, 0x8E, 0x71, 0xCC, 0x39, 0x86, 0x70, 0xC0, 0x1F,
  0x0F, 0xE7, 0x19, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x06, 0xC3, 0xB9, 0xCF,
  0xF1, 0xF8, 0x0D, 0xE1, 0xFF, 0x1E, 0x71, 0xC7, 0x1C, 0x71, 0x87, 0x38,
  0x73, 0x86, 0x38, 0xE3, 0x9E, 0x3F, 0xC7, 0x78, 0x70, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x00, 0x1E, 0xE7, 0xF9, 0xC7, 0x38, 0xEE, 0x1D, 0xC3,
  0x38, 0x66, 0x1C, 0xC3, 0x9C, 0xF3, 0xFC, 0x3D, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x30, 0x0E, 0x00, 0x1B, 0x9F, 0xCF, 0xA7, 0x03, 0x81, 0x81, 0xC0,
  0xE0, 0x70, 0x30, 0x18, 0x1C, 0x00, 0x1F, 0x1F, 0xDC, 0x4E, 0x03, 0x81,
  0xE0, 0x78, 0x0E, 0x07, 0x43, 0xBF, 0x9F, 0x80, 0x18, 0x30, 0xE3, 0xFF,
  0xEE, 0x1C, 0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1F, 0x1E, 0x00, 0x30, 0xEE,
  0x19, 0xC7, 0x38, 0xE6, 0x1C, 0xC3, 0x38, 0x67, 0x1C, 0xE3, 0x9C, 0xF3,
  0xFC, 0x3D, 0x80, 0xE1, 0xF8, 0x6E, 0x3B, 0x8C, 0x67, 0x19, 0x86, 0xE1,
  0xB0, 0x7C, 0x1E, 0x07, 0x81, 0xC0, 0xE3, 0x87, 0xC7, 0x1F, 0x9E, 0x37,
  0x3C, 0xEE, 0xF9, 0x9D, 0xB3, 0x3B, 0x6E, 0x7C, 0xD8, 0x79, 0xF0, 0xE3,
  0xC1, 0xC7, 0x83, 0x8E, 0x00, 0x1C, 0x71, 0xCE, 0x1C, 0xC0, 0xDC, 0x0F,
  0x80, 0x70, 0x0F, 0x01, 0xF0, 0x1B, 0x83, 0xB8, 0x71, 0x8E, 0x1C, 0x1C,
  0x38, 0xE1, 0x87, 0x1C, 0x18, 0xC0, 0xCE, 0x06, 0x60, 0x37, 0x01, 0xB0,
  0x0D, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x1F,
  0x00, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x18, 0x0E, 0x07, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x1C, 0x07, 0xF3, 0xFC, 0x01, 0x83, 0xC3, 0xC1, 0xC0, 0xC0,
  0x60, 0x70, 0x38, 0x38, 0x78, 0x3C, 0x06, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x70, 0x3C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x1E,
  0x0E, 0x06, 0x06, 0x0E, 0x0E, 0x0C, 0x0E, 0x07, 0x0F, 0x1C, 0x18, 0x18,
  0x38, 0x38, 0x30, 0xF0, 0xE0, 0xFC, 0x7F, 0xF8, 0x78,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 8, 6, 9, 2, -16 },
  { 19, 13, 16, 13, 0, -16 },
  { 45, 11, 18, 11, 0, -17 },
  { 70, 15, 16, 17, 1, -16 },
  { 100, 13, 16, 14, 0, -16 },
  { 126, 4, 6, 5, 2, -16 },
  { 129, 7, 19, 7, 1, -16 },
  { 146, 8, 19, 7, -2, -16 },
  { 165, 9, 10, 11, 2, -17 },
  { 177, 10, 11, 12, 1, -13 },
  { 191, 5, 6, 6, -1, -3 },
  { 195, 6, 2, 7, 0, -7 },
  { 197, 4, 3, 6, 0, -3 },
  { 199, 11, 16, 8, -1, -16 },
  { 221, 10, 16, 11, 1, -16 },
  { 241, 8, 16, 11, 2, -16 },
  { 257, 11, 16, 11, 0, -16 },
  { 279, 11, 16, 11, 0, -16 },
  { 301, 11, 16, 11, 0, -16 },
  { 323, 11, 16, 11, 0, -16 },
  { 345, 10, 16, 11, 1, -16 },
  { 365, 11, 16, 11, 1, -16 },
  { 387, 11, 16, 11, 0, -16 },
  { 409, 10, 16, 11, 1, -16 },
  { 429, 5, 12, 6, 0, -12 },
  { 437, 6, 15, 6, -1, -12 },
  { 449, 10, 11, 12, 1, -13 },
  { 463, 10, 6, 12, 1, -11 },
  { 471, 10, 11, 12, 1, -13 },
  { 485, 9, 16, 9, 1, -16 },
  { 503, 16, 18, 17, 1, -16 },
  { 539, 12, 16, 12, -1, -16 },
  { 563, 12, 16, 12, 0, -16 },
  { 587, 12, 16, 12, 1, -16 },
  { 611, 13, 16, 13, 0, -16 },
  { 637, 11, 16, 11, 0, -16 },
  { 659, 11, 16, 10, 0, -16 },
  { 681, 13, 16, 14, 1, -16 },
  { 707, 14, 16, 14, 0, -16 },
  { 735, 10, 16, 7, -1, -16 },
  { 755, 10, 20, 6, -3, -16 },
  { 780, 14, 16, 12, 0, -16 },
  { 808, 9, 16, 10, 0, -16 },
  { 826, 18, 16, 18, 0, -16 },
  { 862, 15, 16, 15, 0, -16 },
  { 892, 13, 16, 14, 1, -16 },
  { 918, 12, 16, 12, 0, -16 },
  { 942, 13, 20, 14, 1, -16 },
  { 975, 12, 16, 12, 0, -16 },
  { 999, 11, 16, 10, 0, -16 },
  { 1021, 10, 16, 10, 2, -16 },
  { 1041, 13, 16, 14, 1, -16 },
  { 1067, 12, 16, 12, 2, -16 },
  { 1091, 18, 16, 18, 2, -16 },
  { 1127, 14, 16, 11, -1, -16 },
  { 1155, 11, 16, 11, 2, -16 },
  { 1177, 13, 16, 10, -1, -16 },
  { 1203, 8, 20, 7, 0, -16 },
  { 1223, 5, 16, 8, 2, -16 },
  { 1233, 9, 20, 7, -2, -16 },
  { 1256, 11, 10, 11, 0, -16 },
  { 1270, 8, 1, 8, -2, 2 },
  { 1271, 4, 4, 7, 3, -17 },
  { 1273, 11, 12, 12, 1, -12 },
  { 1290, 11, 17, 12, 0, -17 },
  { 1314, 9, 12, 9, 1, -12 },
  { 1328, 12, 17, 12, 1, -17 },
  { 1354, 9, 12, 11, 1, -12 },
  { 1368, 12, 22, 7, -2, -17 },
  { 1401, 12, 17, 12, 0, -12 },
  { 1427, 11, 17, 12, 0, -17 },
  { 1451, 6, 17, 6, 0, -17 },
  { 1464, 9, 22, 6, -3, -17 },
  { 1489, 12, 17, 11, 0, -17 },
  { 1515, 6, 17, 6, 0, -17 },
  { 1528, 17, 12, 18, 0, -12 },
  { 1554, 11, 12, 12, 0, -12 },
  { 1571, 10, 12, 12, 1, -12 },
  { 1586, 12, 17, 12, -1, -12 },
  { 1612, 11, 17, 12, 1, -12 },
  { 1636, 9, 12, 8, 0, -12 },
  { 1650, 9, 12, 9, 0, -12 },
  { 1664, 7, 15, 8, 1, -15 },
  { 1678, 11, 12, 12, 1, -12 },
  { 1695, 10, 12, 10, 1, -12 },
  { 1710, 15, 12, 15, 1, -12 },
  { 1733, 12, 12, 10, -1, -12 },
  { 1751, 13, 17, 10, -2, -12 },
  { 1779, 10, 12, 9, -1, -12 },
  { 1794, 9, 19, 8, 0, -16 },
  { 1816, 2, 22, 11, 4, -17 },
  { 1822, 8, 19, 8, -1, -16 },
  { 1841, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC22PT7B_H_
