#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCC, 0x63, 0x19, 0x8C, 0x00, 0x39, 0x80, 0xDE, 0xF7, 0x20,
  0x0C, 0x83, 0x60, 0x91, 0xFF, 0x7F, 0xC4, 0xC1, 0x23, 0xFE, 0xFF, 0x89,
  0x06, 0x41, 0xB0, 0x06, 0x03, 0x07, 0xE6, 0xA3, 0x41, 0xC0, 0xF0, 0x1C,
  0x0F, 0x05, 0xB5, 0x9F, 0x81, 0x00, 0x80, 0x78, 0x64, 0x8C, 0xC9, 0x8D,
  0x90, 0xDB, 0x0D, 0x6E, 0xF5, 0xB0, 0xD3, 0x1B, 0x21, 0x36, 0x33, 0x66,
  0x1C, 0x0F, 0x06, 0xC1, 0x90, 0x6C, 0x1E, 0x07, 0x03, 0xCD, 0xBB, 0xC7,
  0xB0, 0xC7, 0xF9, 0xF6, 0xFE, 0x0C, 0x61, 0x0C, 0x21, 0x86, 0x18, 0x41,
  0x0C, 0x10, 0x61, 0x86, 0x00, 0x18, 0x60, 0x83, 0x0C, 0x30, 0x86, 0x18,
  0x63, 0x0C, 0x61, 0x8C, 0x00, 0x18, 0x23, 0x43, 0xF7, 0x3B, 0x16, 0x08,
  0x10, 0x10, 0x10, 0xFF, 0xFF, 0x10, 0x10, 0x10, 0x36, 0x6C, 0xF8, 0xF8,
  0x01, 0x81, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18,
  0x18, 0x00, 0x3E, 0xED, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x9B, 0xE3,
  0x80, 0x1D, 0xEF, 0xB6, 0x18, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x1F, 0x3F,
  0x23, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xFE, 0xFE, 0x3F, 0x33,
  0x03, 0x03, 0x07, 0x1C, 0x3E, 0x06, 0x06, 0x06, 0xFE, 0xFC, 0x03, 0x07,
  0x0F, 0x1B, 0x16, 0x36, 0x66, 0xC6, 0xFF, 0x0C, 0x0C, 0x0C, 0x1F, 0x8F,
  0x8C, 0x06, 0x03, 0x83, 0xF0, 0x1C, 0x0E, 0x07, 0x03, 0x3F, 0x9F, 0x80,
  0x1F, 0x39, 0x60, 0x60, 0xDC, 0xFE, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x78,
  0x7F, 0x7F, 0x06, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0,
  0x1F, 0x1D, 0x8C, 0x66, 0x63, 0xF0, 0xE0, 0xF8, 0xCC, 0xC3, 0x61, 0x9B,
  0x8F, 0x80, 0x1E, 0x3B, 0x73, 0x63, 0x63, 0x67, 0x7F, 0x13, 0x06, 0x06,
  0xFC, 0xF8, 0x33, 0x00, 0x00, 0x0E, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x06,
  0x63, 0x30, 0x03, 0x0E, 0x38, 0xE0, 0xE0, 0x3C, 0x0F, 0x03, 0xFE, 0x00,
  0x07, 0xF0, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0x38, 0xE0, 0x80, 0xFD, 0x30,
  0xC3, 0x1C, 0xC6, 0x18, 0x00, 0x0C, 0x30, 0x0F, 0xC1, 0x86, 0x20, 0x36,
  0x7B, 0xCD, 0xBD, 0x93, 0x91, 0x39, 0x32, 0x93, 0x69, 0xDC, 0xC0, 0x06,
  0x08, 0x7F, 0x00, 0x80, 0x03, 0x03, 0xC1, 0x61, 0xB0, 0xD8, 0xCC, 0x66,
  0x7F, 0x3F, 0xB0, 0xD8, 0x78, 0x30, 0x1F, 0x0F, 0xCC, 0x66, 0x33, 0x39,
  0xF1, 0xFC, 0xC6, 0x63, 0xB1, 0x9F, 0xDF, 0x80, 0x1F, 0x9F, 0x9C, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x1F, 0x8F, 0xC0, 0x1F, 0x07,
  0xE3, 0x1C, 0xC3, 0x30, 0xCC, 0x37, 0x0D, 0x86, 0x61, 0x98, 0xC7, 0xE3,
  0xF0, 0x1F, 0x8F, 0x8C, 0x06, 0x03, 0x11, 0xF1, 0xF8, 0xC0, 0x60, 0x30,
  0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0x8C, 0x06, 0x03, 0x01, 0xF1, 0xF8, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x00, 0x1F, 0xCF, 0xE7, 0x01, 0x80, 0xE0, 0x31,
  0xEC, 0x7B, 0x0C, 0xC3, 0x38, 0xC7, 0xF0, 0xFC, 0x18, 0x63, 0x1C, 0xC3,
  0x18, 0x63, 0x0C, 0x7F, 0x8F, 0xE3, 0x0C, 0x61, 0x8C, 0x31, 0x86, 0x71,
  0x80, 0x1F, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x38,
  0xF8, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0xB8, 0xF0, 0x18, 0xE3, 0x30, 0xCC, 0x1B, 0x83, 0x60, 0x78,
  0x0F, 0x03, 0x30, 0x66, 0x0C, 0xC1, 0x9C, 0x61, 0x80, 0x18, 0x30, 0xC1,
  0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0xFF, 0xE0, 0x1C, 0x1C, 0x70, 0xE3,
  0xC3, 0x8F, 0x1E, 0x3C, 0x58, 0xF3, 0x66, 0xCB, 0x1B, 0x6C, 0x65, 0x31,
  0x9C, 0xC6, 0x63, 0x31, 0x98, 0x18, 0x31, 0xC6, 0x3C, 0x63, 0xC6, 0x36,
  0x63, 0x6C, 0x66, 0xC6, 0x6C, 0x63, 0xC6, 0x3C, 0x63, 0x8C, 0x18, 0x1F,
  0x0E, 0xE7, 0x1D, 0x83, 0xE0, 0xF0, 0x7C, 0x1B, 0x06, 0xC1, 0xB0, 0xC7,
  0xF1, 0xF0, 0x1F, 0x0F, 0xCC, 0x66, 0x33, 0x19, 0x9D, 0xFC, 0xF0, 0x60,
  0x30, 0x18, 0x18, 0x00, 0x1F, 0x0E, 0xE7, 0x1D, 0x83, 0xE0, 0xF0, 0x7C,
  0x1B, 0x06, 0xC1, 0xB0, 0xC7, 0xF1, 0xF0, 0x0C, 0x01, 0x80, 0x70, 0x1F,
  0x0F, 0xCC, 0x66, 0x33, 0x19, 0xF9, 0xF8, 0xCC, 0x66, 0x33, 0x18, 0xD8,
  0x60, 0x1F, 0x9F, 0x8C, 0x06, 0x03, 0x01, 0xE0, 0x78, 0x0C, 0x06, 0x03,
  0x3F, 0x1F, 0x00, 0x7F, 0xFF, 0x18, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30,
  0x70, 0x60, 0x60, 0x30, 0xDC, 0x66, 0x19, 0x86, 0x61, 0x98, 0x6C, 0x33,
  0x0C, 0xC3, 0x31, 0xCF, 0xE1, 0xF0, 0xC3, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC,
  0xD8, 0xD8, 0xF0, 0xF0, 0xE0, 0xE0, 0xC6, 0x1E, 0x31, 0xF3, 0x8D, 0x9C,
  0x6D, 0xA6, 0x6D, 0x33, 0x4B, 0x1E, 0x58, 0xA2, 0xC7, 0x1C, 0x38, 0xE1,
  0x86, 0x00, 0x18, 0xE3, 0x18, 0x36, 0x07, 0xC0, 0xF0, 0x1C, 0x03, 0x80,
  0xF0, 0x3B, 0x06, 0x61, 0x8C, 0x71, 0xC0, 0xC7, 0xC6, 0xCC, 0xDC, 0xD8,
  0x70, 0x70, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0x1F, 0xC7, 0xF0, 0x38, 0x0C,
  0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0xF3, 0xFC, 0x1C, 0xC3,
  0x0C, 0x30, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0xCE, 0x00, 0xDB, 0x6C,
  0x9B, 0x6D, 0xB0, 0x1E, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30,
  0x41, 0x83, 0x1E, 0x38, 0x00, 0x0C, 0x0C, 0x1E, 0x16, 0x32, 0x63, 0xC3,
  0x7F, 0xFC, 0xE6, 0x30, 0x3B, 0x67, 0xE6, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC,
  0xFC, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0xF1, 0xD8, 0xCE, 0xC6, 0x63, 0x31,
  0x99, 0xCF, 0xCD, 0xC0, 0x3E, 0xCB, 0x86, 0x0C, 0x18, 0x30, 0x7C, 0x78,
  0x01, 0x81, 0x80, 0xC0, 0x63, 0xB3, 0x3B, 0x99, 0x8C, 0xC6, 0x63, 0x33,
  0x1F, 0x8F, 0xC0, 0x3C, 0xCF, 0x1E, 0x6F, 0x98, 0x30, 0x76, 0x7C, 0x03,
  0x83, 0xC1, 0x80, 0xC1, 0xF0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC1, 0xE0, 0xE0, 0x00, 0x1D, 0x99, 0xDC, 0xCC, 0x66,
  0x33, 0x19, 0x9C, 0xFC, 0x7E, 0x03, 0x03, 0x9F, 0x8F, 0x80, 0x18, 0x18,
  0x30, 0x30, 0x3F, 0x3B, 0x33, 0x63, 0x63, 0x63, 0x63, 0x66, 0xC6, 0x18,
  0xC4, 0x03, 0x18, 0xCC, 0x63, 0x18, 0xCC, 0x00, 0x06, 0x0C, 0x10, 0x00,
  0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x0C, 0x78, 0xE0, 0x18,
  0x0C, 0x0C, 0x06, 0x03, 0x39, 0xB0, 0xF8, 0xD8, 0x7C, 0x36, 0x1B, 0x0C,
  0xCC, 0x60, 0x18, 0xCC, 0x63, 0x18, 0xCC, 0x63, 0x18, 0xCC, 0x00, 0x3F,
  0x79, 0xDC, 0xCC, 0xE6, 0xC6, 0x36, 0x31, 0xB1, 0x99, 0x98, 0xCC, 0xC6,
  0xC6, 0x30, 0x3F, 0x3B, 0x33, 0x63, 0x63, 0x63, 0x63, 0x66, 0xC6, 0x3C,
  0xCF, 0x1E, 0x3C, 0x78, 0xF3, 0xFE, 0x78, 0x1F, 0x87, 0x61, 0x9C, 0xC6,
  0x31, 0x8C, 0x63, 0x38, 0xFC, 0x6E, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x00,
  0x3F, 0x67, 0xE6, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0xFC, 0x0C, 0x0C, 0x18,
  0x18, 0x3E, 0x7C, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xC0, 0x3E, 0xC5, 0x83,
  0x83, 0x81, 0x83, 0x6E, 0xF8, 0x31, 0x3E, 0xC6, 0x63, 0x18, 0xC7, 0xBC,
  0x63, 0x63, 0x66, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0xFC, 0xC7, 0xC6, 0xCC,
  0xCC, 0xD8, 0xD8, 0xF0, 0x70, 0x60, 0xCE, 0x7C, 0xE6, 0xCE, 0x4D, 0xEC,
  0xD6, 0xCF, 0x78, 0xE7, 0x8E, 0x70, 0xE7, 0x00, 0x39, 0xC6, 0xC1, 0xF0,
  0x38, 0x0C, 0x07, 0x83, 0x61, 0xD8, 0xE3, 0x00, 0x31, 0xCC, 0x63, 0x30,
  0xCC, 0x36, 0x05, 0x81, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x03, 0xC0, 0xE0,
  0x00, 0x3E, 0x9C, 0x30, 0xC3, 0x0E, 0x18, 0x7E, 0xF8, 0x0E, 0x3C, 0x60,
  0xC1, 0x86, 0x3C, 0x70, 0x20, 0x61, 0x83, 0x06, 0x0E, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x38, 0x30, 0x60, 0x83, 0x03, 0x07, 0x18,
  0x60, 0xC1, 0x83, 0x1C, 0x30, 0x00, 0xFB, 0x9E,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 5, 0, -12 },
  { 9, 5, 4, 7, 2, -12 },
  { 12, 10, 12, 10, 0, -12 },
  { 27, 9, 14, 9, 0, -13 },
  { 43, 12, 12, 13, 1, -12 },
  { 61, 10, 12, 10, 0, -12 },
  { 76, 2, 4, 4, 2, -12 },
  { 77, 6, 15, 5, 0, -12 },
  { 89, 6, 15, 5, -1, -12 },
  { 101, 7, 8, 8, 2, -13 },
  { 108, 8, 8, 9, 1, -10 },
  { 116, 4, 4, 4, -1, -2 },
  { 118, 5, 1, 5, 0, -5 },
  { 119, 3, 2, 4, 0, -2 },
  { 120, 9, 12, 7, -1, -12 },
  { 134, 7, 12, 9, 1, -12 },
  { 145, 6, 12, 9, 2, -12 },
  { 154, 8, 12, 9, 0, -12 },
  { 166, 8, 12, 9, 0, -12 },
  { 178, 8, 12, 9, 0, -12 },
  { 190, 9, 12, 9, 0, -12 },
  { 204, 8, 12, 9, 1, -12 },
  { 216, 8, 12, 9, 1, -12 },
  { 228, 9, 12, 9, 0, -12 },
  { 242, 8, 12, 9, 0, -12 },
  { 254, 4, 9, 4, 0, -9 },
  { 259, 5, 11, 4, -1, -9 },
  { 266, 8, 8, 9, 1, -10 },
  { 274, 7, 4, 9, 1, -8 },
  { 278, 8, 8, 9, 1, -10 },
  { 286, 6, 12, 7, 1, -12 },
  { 295, 12, 14, 13, 1, -12 },
  { 316, 9, 12, 9, -1, -12 },
  { 330, 9, 12, 9, 0, -12 },
  { 344, 9, 12, 9, 1, -12 },
  { 358, 10, 12, 10, 0, -12 },
  { 373, 9, 12, 8, 0, -12 },
  { 387, 9, 12, 8, 0, -12 },
  { 401, 10, 12, 11, 1, -12 },
  { 416, 11, 12, 11, 0, -12 },
  { 433, 8, 12, 6, -1, -12 },
  { 445, 8, 15, 5, -3, -12 },
  { 460, 11, 12, 9, 0, -12 },
  { 477, 7, 12, 8, 0, -12 },
  { 488, 14, 12, 14, 0, -12 },
  { 509, 12, 12, 11, 0, -12 },
  { 527, 10, 12, 11, 1, -12 },
  { 542, 9, 12, 9, 0, -12 },
  { 556, 10, 15, 11, 1, -12 },
  { 575, 9, 12, 9, 0, -12 },
  { 589, 9, 12, 8, 0, -12 },
  { 603, 8, 12, 8, 1, -12 },
  { 615, 10, 12, 11, 1, -12 },
  { 630, 8, 12, 9, 2, -12 },
  { 642, 13, 12, 14, 2, -12 },
  { 662, 11, 12, 9, -1, -12 },
  { 679, 8, 12, 8, 2, -12 },
  { 691, 10, 12, 8, -1, -12 },
  { 706, 6, 15, 5, 0, -12 },
  { 718, 3, 12, 7, 2, -12 },
  { 723, 7, 15, 5, -1, -12 },
  { 737, 8, 7, 9, 0, -12 },
  { 744, 7, 2, 6, -2, 1 },
  { 746, 4, 3, 5, 2, -13 },
  { 748, 8, 9, 9, 1, -9 },
  { 757, 9, 13, 9, 0, -13 },
  { 772, 7, 9, 7, 1, -9 },
  { 780, 9, 13, 9, 1, -13 },
  { 795, 7, 9, 8, 1, -9 },
  { 803, 9, 17, 5, -2, -13 },
  { 823, 9, 13, 9, 0, -9 },
  { 838, 8, 13, 9, 0, -13 },
  { 851, 5, 13, 4, 0, -13 },
  { 860, 7, 17, 4, -2, -13 },
  { 875, 9, 13, 8, 0, -13 },
  { 890, 5, 13, 4, 0, -13 },
  { 899, 13, 9, 14, 0, -9 },
  { 914, 8, 9, 9, 0, -9 },
  { 923, 7, 9, 9, 1, -9 },
  { 931, 10, 13, 9, -1, -9 },
  { 948, 8, 13, 9, 1, -9 },
  { 961, 7, 9, 6, 0, -9 },
  { 969, 7, 9, 7, 0, -9 },
  { 977, 5, 11, 6, 1, -11 },
  { 984, 8, 9, 9, 1, -9 },
  { 993, 8, 9, 8, 1, -9 },
  { 1002, 12, 9, 12, 1, -9 },
  { 1016, 10, 9, 8, -1, -9 },
  { 1028, 10, 13, 8, -1, -9 },
  { 1045, 7, 9, 7, 0, -9 },
  { 1053, 7, 15, 6, 0, -12 },
  { 1067, 2, 17, 8, 3, -13 },
  { 1072, 7, 15, 6, -1, -12 },
  { 1086, 8, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC17PT7B_H_
