#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_SemiCondensed_SemiBoldItalic
// Headers: 67

#include "NotoSans_SemiCondensed_SemiBoldItalic6pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic7pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic8pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic9pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic10pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic11pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic12pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic13pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic14pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic15pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic16pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic17pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic18pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic19pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic20pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic21pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic22pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic23pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic24pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic25pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic26pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic27pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic28pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic29pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic30pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic31pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic32pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic33pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic34pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic35pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic36pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic37pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic38pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic39pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic40pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic41pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic42pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic43pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic44pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic45pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic46pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic47pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic48pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic49pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic50pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic51pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic52pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic53pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic54pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic55pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic56pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic57pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic58pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic59pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic60pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic61pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic62pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic63pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic64pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic65pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic66pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic67pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic68pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic69pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic70pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic71pt7b.h"
#include "NotoSans_SemiCondensed_SemiBoldItalic72pt7b.h"
