#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x38, 0x00, 0x00, 0x70, 0x78, 0xF8, 0xF0, 0x73, 0xDC,
  0xE7, 0x39, 0x8E, 0xE3, 0x39, 0xCE, 0x73, 0x1C, 0x00, 0xC7, 0x00, 0xE3,
  0x00, 0x71, 0x80, 0x31, 0xC0, 0x18, 0xE0, 0x1C, 0x60, 0xFF, 0xFE, 0x7F,
  0xFF, 0x3F, 0xFF, 0x83, 0x8C, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x03,
  0xFF, 0xF3, 0xFF, 0xF8, 0x38, 0xC0, 0x1C, 0xE0, 0x0C, 0x70, 0x0E, 0x30,
  0x07, 0x18, 0x03, 0x1C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x3E, 0x03, 0xFF,
  0x1F, 0xF8, 0xF6, 0xE3, 0x98, 0x0E, 0x60, 0x3D, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x6F, 0x01, 0x9C, 0x86, 0xF3, 0x17,
  0x8F, 0xFE, 0x3F, 0xF0, 0x3E, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x1E,
  0x01, 0xC7, 0xE0, 0x71, 0xFE, 0x0C, 0x39, 0xC3, 0x8E, 0x38, 0xE1, 0xC7,
  0x18, 0x38, 0xC7, 0x07, 0x39, 0xC0, 0xC7, 0x31, 0x98, 0xEE, 0xFF, 0xBB,
  0xBF, 0xFE, 0x67, 0x37, 0x9D, 0xC6, 0x07, 0x38, 0xC0, 0xC6, 0x38, 0x38,
  0xC7, 0x0E, 0x38, 0xE1, 0x87, 0x18, 0x70, 0x67, 0x1C, 0x0F, 0xC7, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0xF1, 0xC0, 0x39, 0xE0, 0x1D, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE1,
  0xE7, 0xF0, 0xE7, 0xBC, 0xF7, 0x8F, 0x73, 0x87, 0xF9, 0xC1, 0xF8, 0xE0,
  0xF8, 0x78, 0x7C, 0x3F, 0xFF, 0x1F, 0xFF, 0x83, 0xF1, 0xE0, 0x77, 0x77,
  0xEE, 0xEC, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0,
  0x38, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0C, 0x00, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x00, 0x07, 0x00, 0x70, 0x87,
  0x0E, 0x60, 0xFE, 0x1F, 0xFF, 0x0F, 0xF1, 0xF1, 0x3B, 0x0F, 0x38, 0x73,
  0x82, 0x3C, 0x02, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x3C, 0xE7, 0x9C, 0x73, 0x8C, 0x00, 0xFF, 0xFF, 0xF8,
  0x77, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFE, 0x3C, 0xF3, 0xC3,
  0x9E, 0x1D, 0xE0, 0xEF, 0x07, 0x70, 0x3B, 0x81, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF0, 0x3B, 0x83, 0xDC, 0x1E, 0xE1, 0xE7, 0x8F, 0x1F, 0xF0, 0xFF,
  0x03, 0xF0, 0x00, 0x01, 0xC1, 0xF0, 0xF8, 0xFE, 0x7F, 0xBD, 0xE6, 0x79,
  0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8,
  0x38, 0xF0, 0x40, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x80, 0x03, 0xF0,
  0x3F, 0xE1, 0xFF, 0xC3, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x72, 0x03, 0xCF, 0xFE, 0x3F, 0xF8, 0x7F, 0x80, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x81,
  0xDE, 0x0E, 0x78, 0x39, 0xC1, 0xC7, 0x0E, 0x1C, 0x70, 0xF1, 0xC3, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x71, 0x01, 0xE3, 0xFF, 0x87,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC3, 0xC0, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x7B, 0xE1, 0xDF, 0xC7, 0xFF, 0x3E,
  0x1C, 0xF0, 0x73, 0xC1, 0xCF, 0x07, 0x3C, 0x1C, 0xF0, 0xF3, 0xC7, 0x87,
  0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0xFE, 0x7F, 0xF8, 0xFF, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x3F,
  0xE1, 0xFF, 0x87, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x87, 0x1E, 0x1F,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF8, 0x79, 0xE3, 0xC3, 0xCE, 0x07, 0x38,
  0x1C, 0xE0, 0xF3, 0x83, 0xCF, 0xBE, 0x1F, 0xF0, 0x3F, 0x80, 0x07, 0xE0,
  0x7F, 0x87, 0xFC, 0x78, 0xF3, 0x83, 0xBC, 0x1D, 0xE0, 0xEE, 0x0F, 0x70,
  0x7B, 0xC3, 0xDE, 0x7E, 0xFF, 0xE3, 0xF7, 0x06, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x1E, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x00, 0x0E, 0x3C, 0x78,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x1F, 0x3C, 0x78, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1C, 0x00, 0x00, 0x08,
  0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x1E, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x06, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x01, 0xF8, 0x3F, 0x0F, 0xE1, 0xF8, 0x0F, 0x00, 0x60, 0x02, 0x00, 0x00,
  0x1F, 0x0F, 0xF9, 0xFF, 0x30, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x0C,
  0x03, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0xFD,
  0xF8, 0x0E, 0x01, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x1C, 0xE1, 0xFC, 0xE6,
  0x1F, 0xE7, 0x71, 0xC6, 0x3B, 0x9C, 0x31, 0xD8, 0xE3, 0x8F, 0xC6, 0x1C,
  0x7E, 0x70, 0xC3, 0x73, 0x8E, 0x3B, 0x9C, 0x71, 0x9C, 0xF7, 0x9C, 0xE3,
  0xEF, 0xC7, 0x0E, 0x3C, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x40,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xEE, 0x00, 0xEE, 0x01, 0xEE, 0x01, 0xCE,
  0x03, 0xCE, 0x03, 0x8E, 0x07, 0x8E, 0x07, 0x0E, 0x0F, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x07,
  0xF0, 0x07, 0x0F, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3,
  0x83, 0xC7, 0x07, 0x9E, 0x0E, 0x3C, 0x7C, 0x7F, 0xF0, 0xFF, 0x81, 0xFF,
  0xC7, 0x87, 0x8F, 0x07, 0x9C, 0x0F, 0x38, 0x1C, 0xF0, 0x79, 0xE1, 0xF3,
  0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0xF8, 0x63, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x01, 0xF0, 0x41, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x0F, 0xF8, 0x1F, 0xFC, 0x1E, 0x7E, 0x1E, 0x1E, 0x1C, 0x0F, 0x1C, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x0E,
  0x78, 0x1E, 0x78, 0x1E, 0x70, 0x3C, 0xF0, 0x78, 0xF1, 0xF8, 0xFF, 0xF0,
  0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF8, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC7, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x43, 0xFE,
  0x0F, 0xF8, 0x7F, 0xE1, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0x06, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0xFE, 0xE0, 0xFC, 0xE0, 0xFC, 0xE0, 0x1C, 0xE0, 0x3C,
  0xE0, 0x3C, 0xF0, 0x38, 0xF8, 0x38, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0,
  0x0F, 0x03, 0xC3, 0x80, 0xE1, 0xE0, 0x38, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x01, 0xC1, 0xC0, 0x70, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF8, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xC0, 0x70,
  0x70, 0x1C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x38, 0x00,
  0x0F, 0xF8, 0x7F, 0x81, 0xF8, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x81, 0xFF, 0x0F, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0E,
  0x07, 0x87, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC0, 0xE3, 0xC0,
  0x73, 0xC0, 0x7B, 0xC0, 0x3D, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xDC, 0x03, 0xCF, 0x01, 0xC7, 0x80, 0xE3, 0xC0, 0x70, 0xE0, 0x78,
  0x78, 0x3C, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x80, 0x0E, 0x03, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x80, 0x7C, 0x3E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81,
  0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x3B, 0x8F, 0xE0, 0xEE, 0x3B, 0x87, 0x78,
  0xEE, 0x1D, 0xE3, 0xB8, 0xE7, 0x0E, 0x63, 0x9C, 0x79, 0x9C, 0x71, 0xC6,
  0x73, 0xC7, 0x1F, 0x8E, 0x1C, 0x7E, 0x38, 0xF1, 0xF0, 0xE3, 0xC7, 0xC3,
  0x8E, 0x1E, 0x1E, 0x38, 0x78, 0x70, 0xE1, 0xC1, 0xC0, 0x0F, 0x01, 0xE1,
  0xE0, 0x38, 0x7E, 0x07, 0x0F, 0xC0, 0xE1, 0xF8, 0x1C, 0x3F, 0x07, 0x87,
  0xF0, 0xE1, 0xEE, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE7, 0x9E, 0x1C,
  0x73, 0x87, 0x8E, 0x70, 0xE1, 0xEE, 0x1C, 0x1D, 0xC3, 0x83, 0xF8, 0xF0,
  0x7E, 0x1E, 0x0F, 0xC3, 0x80, 0xF8, 0x70, 0x1F, 0x0E, 0x03, 0xC0, 0x01,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78,
  0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x3E, 0xF0, 0x3C, 0xF0, 0x78, 0x7F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1,
  0xF1, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x78,
  0xFF, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x07, 0x70,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1E, 0xE0, 0x1E, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0x7F, 0xF8, 0x7F,
  0xE0, 0x1F, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x0F, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE1, 0xE1, 0xE3, 0x83,
  0xC7, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x78, 0xF0, 0xFF, 0xE1, 0xFF, 0x07,
  0xFC, 0x0F, 0x3C, 0x1C, 0x78, 0x38, 0x70, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x03, 0xCE, 0x07, 0x80, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xF8,
  0xC1, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF1, 0x83, 0xE3, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xA1, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x1C, 0x07,
  0x1C, 0x07, 0x3C, 0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0E, 0x78, 0x0E,
  0x78, 0x1E, 0x78, 0x1E, 0x70, 0x1C, 0x70, 0x1C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0x78, 0xF0, 0xF0, 0xFF, 0xF0,
  0x7F, 0xE0, 0x3F, 0x80, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE,
  0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x70, 0x70, 0xE1, 0xE1, 0xC3, 0x83, 0x8F,
  0x07, 0x9C, 0x0F, 0x78, 0x1E, 0xE0, 0x1D, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x1F, 0xC0,
  0xF0, 0x3B, 0x81, 0xE0, 0x77, 0x07, 0xC1, 0xEE, 0x0F, 0x83, 0x9C, 0x3F,
  0x0F, 0x38, 0x7E, 0x1C, 0x70, 0xFC, 0x78, 0xE3, 0xB8, 0xE1, 0xC7, 0x71,
  0xC3, 0x9C, 0xE7, 0x87, 0x39, 0xCE, 0x0E, 0xE3, 0xBC, 0x1D, 0xC7, 0x70,
  0x3B, 0x8E, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7E, 0x03,
  0xE0, 0xF8, 0x07, 0x81, 0xF0, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0,
  0xF0, 0x38, 0x0E, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x03, 0x9E, 0x00,
  0x77, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x79, 0xE0, 0x1E,
  0x3C, 0x03, 0xC3, 0x80, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x81, 0xE0, 0xE0,
  0x3F, 0x81, 0xEF, 0x07, 0x3C, 0x3C, 0xF0, 0xE1, 0xC7, 0x87, 0x3C, 0x1C,
  0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x00,
  0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x70,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x78, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xE3, 0x8E, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x71, 0xC7,
  0x1C, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0xF8, 0x03,
  0x60, 0x1D, 0xC0, 0xE7, 0x03, 0x8C, 0x1C, 0x38, 0x60, 0xE3, 0x81, 0x9C,
  0x07, 0xF0, 0x1C, 0x7F, 0xFF, 0xFC, 0xF1, 0xC3, 0x8F, 0x07, 0x9C, 0x3F,
  0x71, 0xFF, 0xCF, 0x1F, 0x78, 0x79, 0xE0, 0xE7, 0x07, 0xBC, 0x1E, 0xF0,
  0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xFF, 0x87, 0xFE, 0x0F,
  0x38, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x9E, 0x0F, 0xFE, 0x1F, 0xFC, 0x3E, 0x38, 0x78, 0x70, 0xE0, 0xF3,
  0xC1, 0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1,
  0xE3, 0xFF, 0x87, 0xFE, 0x1C, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0x1F, 0xE3,
  0xC2, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x47, 0xF8, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x07, 0x9C, 0x0F, 0xDC, 0x1F,
  0xFC, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x38, 0x70, 0x78, 0xF0, 0x78, 0xF0,
  0x70, 0xF0, 0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x3E, 0xE0, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x78, 0xF7, 0x87, 0x3C,
  0x39, 0xC7, 0xDF, 0xFC, 0xFF, 0x87, 0x80, 0x38, 0x01, 0xE0, 0x0F, 0x02,
  0x3E, 0xE1, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x03, 0xCE, 0x0F, 0xDC, 0x3F, 0xF8, 0xF1, 0xF3, 0xC3,
  0xC7, 0x83, 0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0x71, 0xE1, 0xE3,
  0xC3, 0xC7, 0x8F, 0x8F, 0xFE, 0x0F, 0xDC, 0x0F, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x84, 0x0F, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE7, 0x87,
  0xFF, 0x1F, 0xFC, 0x7C, 0x71, 0xE1, 0xC7, 0x07, 0x3C, 0x1C, 0xF0, 0xF3,
  0x83, 0xCE, 0x0E, 0x78, 0x39, 0xE0, 0xE7, 0x87, 0x9C, 0x1E, 0x70, 0x73,
  0xC1, 0xC0, 0x07, 0x07, 0x0F, 0x07, 0x00, 0x00, 0x0E, 0x1E, 0x1E, 0x1C,
  0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0E, 0x01, 0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x87, 0x8F, 0x0E, 0x1E,
  0x38, 0x38, 0xF0, 0x73, 0xC0, 0xEF, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0,
  0x1E, 0xE0, 0x79, 0xE0, 0xF3, 0xC1, 0xC3, 0x83, 0x87, 0x87, 0x0F, 0x1E,
  0x0F, 0x00, 0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E,
  0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x07, 0x80, 0x0C, 0x78, 0xF8, 0x77, 0xE7, 0xF1, 0xFF, 0xFF, 0xC7,
  0xCF, 0xCF, 0x1E, 0x1E, 0x1C, 0x70, 0x70, 0x73, 0xC3, 0xC3, 0xCF, 0x0F,
  0x0F, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x9E, 0x1E, 0x1E,
  0x78, 0x78, 0x79, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x3C, 0x3C, 0x3C, 0x0C,
  0x78, 0x77, 0xF1, 0xFF, 0xC7, 0xC7, 0x1E, 0x1C, 0x70, 0x73, 0xC1, 0xCF,
  0x0F, 0x38, 0x3C, 0xE0, 0xE7, 0x83, 0x9E, 0x0E, 0x78, 0x79, 0xC1, 0xE7,
  0x07, 0x3C, 0x1C, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF7, 0x87, 0xBC,
  0x1D, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE1, 0xEF, 0x0F,
  0x3F, 0xF1, 0xFF, 0x07, 0xF0, 0x06, 0x3C, 0x0E, 0xFE, 0x0F, 0xFE, 0x0F,
  0x8E, 0x0F, 0x0E, 0x0E, 0x0F, 0x1E, 0x0E, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C,
  0x1E, 0x1C, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3F, 0xF8, 0x3F, 0xF0, 0x7B,
  0xE0, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x07, 0x9C, 0x3F, 0x71, 0xFF, 0xCF, 0x1F, 0x78, 0x79,
  0xE0, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF1, 0xF3, 0xFF, 0x87, 0xEE, 0x0F, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0x0C, 0x71, 0xDF, 0x1D,
  0xE1, 0xFA, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x07, 0xC1, 0xFF, 0x3F,
  0xE3, 0xC2, 0x38, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x1C, 0x83, 0xCF, 0xFC, 0xFF, 0x8F, 0xF0, 0x0E, 0x03, 0x81, 0xC0,
  0xFF, 0x7F, 0xBF, 0xE3, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70,
  0x1C, 0x0F, 0x03, 0xC0, 0xFE, 0x1F, 0x87, 0xE0, 0x3C, 0x1C, 0xF0, 0x73,
  0xC3, 0xCE, 0x0F, 0x38, 0x39, 0xE0, 0xE7, 0x87, 0x9C, 0x1E, 0x70, 0x71,
  0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xFF, 0x87, 0xFE, 0x1F, 0x38,
  0xE0, 0x7F, 0x07, 0xB8, 0x3D, 0xC3, 0xCE, 0x1E, 0x70, 0xE3, 0x8F, 0x1C,
  0x70, 0xE7, 0x07, 0x38, 0x3B, 0x81, 0xDC, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xE0, 0xE0, 0xFE, 0x1E, 0x0E, 0xE1, 0xE1, 0xEE, 0x3E, 0x1C,
  0xE3, 0xE3, 0xCE, 0x76, 0x38, 0xE7, 0x63, 0x8E, 0x66, 0x70, 0xEE, 0x67,
  0x0E, 0xE6, 0xF0, 0xFC, 0x6E, 0x0F, 0xC6, 0xE0, 0xF8, 0x7C, 0x0F, 0x87,
  0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x0E, 0x1E, 0x0E, 0x3C,
  0x0F, 0x38, 0x07, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x38, 0xF0, 0x78, 0xF0,
  0xF0, 0x78, 0x0E, 0x07, 0x87, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE1,
  0xE0, 0x70, 0xE0, 0x38, 0xF0, 0x1C, 0x70, 0x0F, 0x78, 0x03, 0xB8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x7F, 0xC7, 0xFE, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0x00, 0x30, 0x1F, 0x03, 0xE0, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x07, 0xE0, 0x78,
  0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x01, 0xF0, 0x3E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xE0, 0x3E, 0x07, 0x83,
  0xF0, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x1E, 0x07,
  0xC0, 0xF0, 0x10, 0x00, 0x7F, 0x0F, 0xFF, 0xFE, 0x7F, 0xE0, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 21, 8, 0, -21 },
  { 22, 10, 8, 12, 3, -21 },
  { 32, 17, 21, 17, 0, -21 },
  { 77, 14, 24, 15, 1, -22 },
  { 119, 19, 21, 22, 2, -21 },
  { 169, 17, 21, 18, 1, -21 },
  { 214, 4, 8, 7, 3, -21 },
  { 218, 10, 26, 9, 1, -21 },
  { 251, 10, 26, 9, -2, -21 },
  { 284, 12, 13, 14, 3, -22 },
  { 304, 13, 14, 15, 2, -17 },
  { 327, 6, 7, 7, -1, -3 },
  { 333, 7, 3, 9, 1, -9 },
  { 336, 5, 4, 7, 0, -4 },
  { 339, 14, 21, 11, -1, -21 },
  { 376, 13, 21, 15, 1, -21 },
  { 411, 10, 21, 15, 3, -21 },
  { 438, 15, 21, 15, -1, -21 },
  { 478, 14, 21, 15, 0, -21 },
  { 515, 14, 21, 15, 0, -21 },
  { 552, 15, 21, 15, 0, -21 },
  { 592, 14, 21, 15, 1, -21 },
  { 629, 15, 21, 15, 1, -21 },
  { 669, 14, 21, 15, 1, -21 },
  { 706, 13, 21, 15, 1, -21 },
  { 741, 7, 16, 7, 0, -16 },
  { 755, 9, 20, 7, -2, -16 },
  { 778, 13, 15, 15, 2, -18 },
  { 803, 12, 8, 15, 2, -14 },
  { 815, 13, 15, 15, 2, -18 },
  { 840, 11, 21, 12, 2, -21 },
  { 869, 21, 24, 22, 1, -21 },
  { 932, 16, 21, 16, -2, -21 },
  { 974, 15, 21, 16, 1, -21 },
  { 1014, 15, 21, 16, 2, -21 },
  { 1054, 16, 21, 18, 1, -21 },
  { 1096, 14, 21, 14, 1, -21 },
  { 1133, 14, 21, 13, 1, -21 },
  { 1170, 16, 21, 18, 2, -21 },
  { 1212, 18, 21, 18, 1, -21 },
  { 1260, 13, 21, 10, -1, -21 },
  { 1295, 14, 27, 8, -5, -21 },
  { 1343, 17, 21, 16, 1, -21 },
  { 1388, 10, 21, 13, 1, -21 },
  { 1415, 22, 21, 23, 1, -21 },
  { 1473, 19, 21, 19, 1, -21 },
  { 1523, 16, 21, 19, 2, -21 },
  { 1565, 15, 21, 16, 1, -21 },
  { 1605, 16, 26, 19, 2, -21 },
  { 1657, 15, 21, 16, 1, -21 },
  { 1697, 15, 21, 14, 0, -21 },
  { 1737, 14, 21, 14, 2, -21 },
  { 1774, 16, 21, 18, 2, -21 },
  { 1816, 15, 21, 15, 3, -21 },
  { 1856, 23, 21, 23, 3, -21 },
  { 1917, 19, 21, 15, -2, -21 },
  { 1967, 14, 21, 14, 3, -21 },
  { 2004, 16, 21, 14, -1, -21 },
  { 2046, 12, 26, 9, -1, -21 },
  { 2085, 6, 21, 11, 3, -21 },
  { 2101, 12, 26, 9, -2, -21 },
  { 2140, 14, 13, 15, 0, -21 },
  { 2163, 11, 2, 11, -3, 3 },
  { 2166, 6, 4, 9, 4, -22 },
  { 2169, 14, 16, 15, 1, -16 },
  { 2197, 15, 22, 16, 0, -22 },
  { 2239, 12, 16, 12, 1, -16 },
  { 2263, 16, 22, 16, 1, -22 },
  { 2307, 13, 16, 14, 1, -16 },
  { 2333, 16, 29, 9, -3, -22 },
  { 2391, 15, 23, 16, 0, -16 },
  { 2435, 14, 22, 16, 0, -22 },
  { 2474, 8, 22, 7, 0, -22 },
  { 2496, 12, 29, 8, -4, -22 },
  { 2540, 15, 22, 14, 0, -22 },
  { 2582, 9, 22, 7, 0, -22 },
  { 2607, 22, 16, 23, 0, -16 },
  { 2651, 14, 16, 16, 0, -16 },
  { 2679, 13, 16, 15, 1, -16 },
  { 2705, 16, 23, 16, -1, -16 },
  { 2751, 14, 23, 16, 1, -16 },
  { 2792, 12, 16, 11, 0, -16 },
  { 2816, 12, 16, 12, 0, -16 },
  { 2840, 10, 19, 10, 1, -19 },
  { 2864, 14, 16, 16, 1, -16 },
  { 2892, 13, 16, 13, 2, -16 },
  { 2918, 20, 16, 20, 2, -16 },
  { 2958, 16, 16, 14, -1, -16 },
  { 2990, 17, 23, 13, -2, -16 },
  { 3039, 13, 16, 12, -1, -16 },
  { 3065, 12, 26, 10, 0, -21 },
  { 3104, 2, 29, 14, 6, -22 },
  { 3112, 11, 26, 10, -1, -21 },
  { 3148, 14, 4, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC29PT7B_H_
