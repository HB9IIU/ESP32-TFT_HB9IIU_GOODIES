#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x63, 0x18, 0xCC, 0x60, 0x11, 0xCE, 0x00, 0xEF, 0x2D,
  0xB6, 0x98, 0x04, 0xC1, 0x90, 0x32, 0x04, 0xC7, 0xFE, 0x32, 0x06, 0xC0,
  0x98, 0xFF, 0xC6, 0xC0, 0x98, 0x32, 0x06, 0xC0, 0x02, 0x01, 0x07, 0xE7,
  0xF3, 0x41, 0xA0, 0xF0, 0x3C, 0x0F, 0x05, 0xA2, 0xDF, 0xEF, 0xE0, 0x80,
  0x40, 0x38, 0x66, 0xC4, 0x4C, 0xCC, 0xD8, 0xC9, 0x0D, 0xB6, 0xDE, 0xF7,
  0x59, 0x0D, 0x91, 0x9B, 0x11, 0x33, 0x1E, 0x61, 0xE0, 0x0F, 0x03, 0xF0,
  0x66, 0x0C, 0xC1, 0xB0, 0x3C, 0x0F, 0x1B, 0xF6, 0x66, 0xDC, 0xF3, 0x8E,
  0x3F, 0xC7, 0xDC, 0xFB, 0x68, 0x1C, 0x63, 0x18, 0x63, 0x8C, 0x30, 0xC3,
  0x08, 0x20, 0xC3, 0x0C, 0x30, 0x18, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x18,
  0x61, 0x8C, 0x31, 0x86, 0x30, 0x18, 0x33, 0x47, 0xF3, 0xEF, 0x32, 0x26,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x36, 0x6C, 0x7F,
  0xC0, 0x5F, 0x80, 0x01, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30,
  0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x00, 0x1E, 0x3F, 0x73, 0x63, 0xE3, 0xC3,
  0xC7, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0x0C, 0xF7, 0xB6, 0x98, 0x63,
  0x8C, 0x30, 0xC3, 0x1C, 0x60, 0x1F, 0x1F, 0xCC, 0xE0, 0x30, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x1F, 0xCF, 0xE0, 0x1F, 0x1F, 0xC8, 0x60,
  0x30, 0x30, 0x78, 0x70, 0x0E, 0x03, 0x01, 0x81, 0xDF, 0xCF, 0xC0, 0x03,
  0x81, 0xC1, 0xC1, 0xE1, 0xB0, 0x98, 0xDC, 0xCC, 0xFF, 0xFF, 0x81, 0x81,
  0x80, 0xC0, 0x1F, 0x8F, 0xC6, 0x06, 0x03, 0x01, 0xF1, 0xFC, 0x06, 0x03,
  0x01, 0xA1, 0xDF, 0xCF, 0xC0, 0x0F, 0x1F, 0x30, 0x60, 0x60, 0xDE, 0xFE,
  0xC6, 0xC6, 0xC6, 0xC6, 0xFC, 0x78, 0x7F, 0xBF, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x00, 0x0F, 0x0F, 0xCC,
  0x66, 0x33, 0x38, 0xF8, 0x78, 0xEE, 0x63, 0x71, 0xB8, 0xCF, 0xE7, 0xC0,
  0x1F, 0x1F, 0x8C, 0xEE, 0x36, 0x1B, 0x1D, 0xDC, 0x7E, 0x03, 0x03, 0x81,
  0x9F, 0x8F, 0x80, 0x33, 0x30, 0x00, 0x04, 0xEE, 0x18, 0xC6, 0x00, 0x00,
  0x00, 0x33, 0x19, 0x80, 0x01, 0x07, 0x1E, 0x78, 0xE0, 0x70, 0x1E, 0x07,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x0E,
  0x78, 0xE0, 0x80, 0x7C, 0xFD, 0x18, 0x30, 0xC3, 0x8C, 0x30, 0x60, 0x01,
  0x07, 0x0C, 0x00, 0x07, 0xC0, 0xF7, 0x0C, 0x0C, 0xC0, 0x24, 0x7D, 0xE6,
  0x4F, 0x66, 0x73, 0x32, 0x99, 0x34, 0xD9, 0x27, 0x71, 0x80, 0x06, 0x08,
  0x1F, 0xC0, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x0D, 0x83, 0x61,
  0x98, 0x66, 0x3F, 0x8F, 0xF6, 0x1D, 0x83, 0xC0, 0xC0, 0x1F, 0x07, 0xF1,
  0x9C, 0xE3, 0x31, 0xCF, 0xE3, 0xF0, 0xCE, 0x61, 0x98, 0x66, 0x39, 0xFC,
  0xFE, 0x00, 0x0F, 0xC7, 0xE3, 0x89, 0xC0, 0x60, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0E, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x03, 0xF8, 0x67, 0x1C,
  0x63, 0x0E, 0x61, 0xCC, 0x31, 0x86, 0x71, 0xCC, 0x31, 0x8E, 0x3F, 0x8F,
  0xC0, 0x1F, 0x8F, 0xC6, 0x07, 0x03, 0x01, 0xF8, 0xFC, 0x60, 0x60, 0x30,
  0x18, 0x0F, 0xCF, 0xE0, 0x1F, 0x8F, 0xC6, 0x07, 0x03, 0x01, 0x80, 0xFC,
  0x7C, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x00, 0x0F, 0xC7, 0xF3, 0x85, 0xC0,
  0x60, 0x38, 0x0C, 0x7B, 0x1E, 0xC1, 0xB0, 0x6E, 0x39, 0xFC, 0x3F, 0x00,
  0x18, 0x71, 0x86, 0x18, 0x63, 0x86, 0x30, 0xE3, 0xFC, 0x3F, 0xC3, 0x0C,
  0x70, 0xC6, 0x1C, 0x61, 0x86, 0x18, 0xE1, 0x80, 0x1F, 0x1F, 0x0C, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0xFC, 0x03, 0x03, 0x03,
  0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x38,
  0xF8, 0xE0, 0x18, 0x63, 0x18, 0x66, 0x1D, 0xC3, 0x70, 0x7C, 0x0F, 0x81,
  0xF0, 0x66, 0x0C, 0xE1, 0x8C, 0x31, 0x8E, 0x38, 0x18, 0x30, 0x61, 0xC3,
  0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0xFF, 0xE0, 0x1C, 0x1E, 0x38, 0x38,
  0x70, 0xF1, 0xE1, 0xE3, 0xC6, 0xC6, 0x8F, 0x0D, 0x36, 0x1A, 0x6C, 0x67,
  0x98, 0xCF, 0x31, 0x9C, 0xC3, 0x39, 0x8C, 0x63, 0x00, 0x1C, 0x31, 0xC3,
  0x1C, 0x33, 0xC3, 0x36, 0x63, 0x66, 0x36, 0x63, 0x36, 0x63, 0x46, 0x3C,
  0x63, 0xC6, 0x1C, 0xC1, 0xC0, 0x0F, 0x87, 0xF3, 0x0D, 0xC3, 0x60, 0xF8,
  0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x6E, 0x39, 0xFC, 0x3E, 0x00, 0x1F, 0x07,
  0xE1, 0x9C, 0xE3, 0x30, 0xCC, 0x73, 0xF8, 0xFC, 0x60, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x00, 0x0F, 0x87, 0xF3, 0x0D, 0xC3, 0x60, 0xF8, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x6E, 0x39, 0xFC, 0x3E, 0x03, 0x80, 0x60, 0x1C, 0x1F,
  0x07, 0xE1, 0x9C, 0xE7, 0x31, 0xCC, 0x63, 0xF0, 0xF8, 0x66, 0x19, 0xC6,
  0x31, 0x8C, 0xE3, 0x80, 0x0F, 0x1F, 0xCC, 0x26, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x03, 0xA1, 0x9F, 0xCF, 0xC0, 0x7F, 0xFF, 0xC6, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x00, 0x30, 0xCC,
  0x37, 0x0D, 0x83, 0x61, 0xD8, 0x66, 0x1B, 0x86, 0xC3, 0xB0, 0xCC, 0x33,
  0xF8, 0x7C, 0x00, 0xC1, 0xE1, 0xB0, 0xD8, 0xCC, 0x66, 0x63, 0x31, 0xB0,
  0xD8, 0x7C, 0x3C, 0x1E, 0x0E, 0x00, 0xC3, 0x0F, 0x1C, 0x7C, 0x71, 0xB3,
  0xC6, 0xCF, 0x33, 0x2C, 0xCD, 0xB6, 0x36, 0xD8, 0xF3, 0x63, 0xCF, 0x0E,
  0x3C, 0x38, 0xE0, 0xC3, 0x80, 0x18, 0x71, 0xCE, 0x0C, 0xC0, 0xD8, 0x0F,
  0x80, 0xF0, 0x0E, 0x00, 0xF0, 0x1B, 0x03, 0xB0, 0x33, 0x86, 0x18, 0xE1,
  0x80, 0xC3, 0xC7, 0xC6, 0xCC, 0x7C, 0x78, 0x70, 0x70, 0x60, 0x60, 0x60,
  0x60, 0xC0, 0x1F, 0xC7, 0xF0, 0x1C, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30,
  0x18, 0x0E, 0x07, 0x01, 0xFC, 0xFF, 0x00, 0x1E, 0x38, 0xC1, 0x83, 0x06,
  0x0C, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x3C, 0x70, 0xCC, 0xCC, 0x46,
  0x66, 0x66, 0x62, 0x30, 0x1E, 0x3C, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18,
  0x30, 0x60, 0x83, 0x06, 0x3C, 0x78, 0x04, 0x07, 0x03, 0x83, 0x43, 0x31,
  0x99, 0x85, 0x83, 0xFE, 0xD9, 0x80, 0x39, 0x7F, 0x67, 0xE3, 0xC7, 0xC6,
  0xC6, 0xCE, 0xFE, 0xF4, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x71, 0xFC, 0xC6,
  0x63, 0x61, 0xB0, 0xD8, 0xCC, 0x67, 0xE6, 0xF0, 0x1E, 0xFD, 0x87, 0x0C,
  0x18, 0x30, 0x60, 0xF8, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x73, 0xB3, 0xF9,
  0x9D, 0xC6, 0xC7, 0x63, 0x31, 0x99, 0xCF, 0xE7, 0xA0, 0x1C, 0xFD, 0x9E,
  0x3F, 0xFF, 0x30, 0x60, 0xFC, 0xF8, 0x01, 0xC1, 0xE0, 0x60, 0x18, 0x0F,
  0x87, 0xC0, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xC0, 0xF0, 0x38, 0x00, 0x1C, 0x9F, 0xCC, 0xEE, 0x36, 0x3B, 0x19,
  0x8C, 0xCE, 0x7F, 0x3F, 0x01, 0x80, 0xCD, 0xE7, 0xE0, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x71, 0xFC, 0xE6, 0x63, 0x73, 0xB1, 0x98, 0xCC, 0x66, 0x36,
  0x38, 0x08, 0xC6, 0x03, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x60, 0x02, 0x0C,
  0x18, 0x00, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18,
  0xF1, 0xC0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x31, 0xCC, 0xC3, 0x70, 0xF8,
  0x7C, 0x1F, 0x06, 0xE1, 0x98, 0x66, 0x31, 0xC0, 0x18, 0xC6, 0x73, 0x18,
  0xC6, 0x73, 0x18, 0xC6, 0x60, 0x37, 0x38, 0xFF, 0xF3, 0x98, 0xCC, 0x63,
  0x73, 0x19, 0x8C, 0x66, 0x31, 0x98, 0xC6, 0x63, 0x3B, 0x18, 0xC0, 0x37,
  0x1F, 0xCE, 0x66, 0x37, 0x3B, 0x19, 0x8C, 0xC6, 0x63, 0x63, 0x80, 0x1C,
  0x7E, 0x67, 0xC3, 0xC3, 0xC7, 0xC6, 0xC6, 0xFC, 0x78, 0x1B, 0x87, 0xF1,
  0x8C, 0x63, 0x30, 0xCC, 0x33, 0x18, 0xC6, 0x3F, 0x1B, 0xC6, 0x01, 0x80,
  0x60, 0x38, 0x00, 0x39, 0x7F, 0x67, 0xE3, 0xC7, 0xC6, 0xC6, 0xCE, 0xFE,
  0xFC, 0x0C, 0x0C, 0x0C, 0x1C, 0x36, 0x7C, 0xE1, 0x87, 0x0C, 0x18, 0x30,
  0x61, 0x80, 0x1E, 0xFD, 0x83, 0x83, 0x83, 0x83, 0x06, 0xFD, 0xF0, 0x30,
  0xC7, 0xFE, 0x61, 0x8E, 0x30, 0xC3, 0x0F, 0x3C, 0x63, 0x63, 0x63, 0x63,
  0xC7, 0xC6, 0xC6, 0xCE, 0xFE, 0xF4, 0xC3, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8,
  0xD8, 0x70, 0x70, 0x60, 0xC6, 0x3C, 0x63, 0xCE, 0x6C, 0xA6, 0xDA, 0xED,
  0xAC, 0xF2, 0xCF, 0x38, 0xE3, 0x8E, 0x30, 0x38, 0xC6, 0x61, 0xB0, 0x7C,
  0x0E, 0x03, 0x81, 0xE0, 0xD8, 0x77, 0x38, 0xC0, 0x30, 0xCC, 0x63, 0x18,
  0xCC, 0x33, 0x05, 0x81, 0x60, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0xF0,
  0x38, 0x00, 0x3F, 0x7E, 0x0E, 0x0C, 0x18, 0x30, 0x70, 0x60, 0xFC, 0xFC,
  0x06, 0x1C, 0x60, 0xC1, 0x83, 0x0C, 0x78, 0xE0, 0x60, 0xC3, 0x06, 0x0C,
  0x1C, 0x18, 0xFF, 0xFF, 0xC0, 0x18, 0x38, 0x30, 0x60, 0xC1, 0x87, 0x07,
  0x0E, 0x30, 0xC1, 0x83, 0x06, 0x38, 0x60, 0x61, 0xFF, 0x8F,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 13, 5, 0, -13 },
  { 10, 6, 5, 7, 2, -13 },
  { 14, 11, 13, 10, 0, -13 },
  { 32, 9, 15, 9, 0, -14 },
  { 49, 12, 13, 14, 1, -13 },
  { 69, 11, 13, 11, 0, -13 },
  { 87, 3, 5, 4, 2, -13 },
  { 89, 6, 16, 5, 1, -13 },
  { 101, 6, 16, 5, -1, -13 },
  { 113, 7, 8, 9, 2, -14 },
  { 120, 8, 9, 10, 1, -11 },
  { 129, 4, 4, 5, -1, -2 },
  { 131, 5, 2, 5, 0, -6 },
  { 133, 3, 3, 5, 0, -3 },
  { 135, 9, 13, 7, -1, -13 },
  { 150, 8, 13, 9, 1, -13 },
  { 163, 6, 13, 9, 2, -13 },
  { 173, 9, 13, 9, 0, -13 },
  { 188, 9, 13, 9, 0, -13 },
  { 203, 9, 13, 9, 0, -13 },
  { 218, 9, 13, 9, 0, -13 },
  { 233, 8, 13, 9, 1, -13 },
  { 246, 9, 13, 9, 1, -13 },
  { 261, 9, 13, 9, 0, -13 },
  { 276, 9, 13, 9, 0, -13 },
  { 291, 4, 10, 5, 0, -10 },
  { 296, 5, 12, 5, -1, -10 },
  { 304, 8, 9, 10, 1, -11 },
  { 313, 8, 5, 10, 1, -9 },
  { 318, 8, 9, 10, 1, -11 },
  { 327, 7, 13, 7, 1, -13 },
  { 339, 13, 15, 14, 1, -13 },
  { 364, 10, 13, 10, -1, -13 },
  { 381, 10, 13, 10, 0, -13 },
  { 398, 10, 13, 10, 1, -13 },
  { 415, 11, 13, 11, 0, -13 },
  { 433, 9, 13, 9, 0, -13 },
  { 448, 9, 13, 8, 0, -13 },
  { 463, 10, 13, 11, 1, -13 },
  { 480, 12, 13, 11, 0, -13 },
  { 500, 8, 13, 6, -1, -13 },
  { 513, 8, 17, 5, -3, -13 },
  { 530, 11, 13, 10, 0, -13 },
  { 548, 7, 13, 8, 0, -13 },
  { 560, 15, 13, 14, 0, -13 },
  { 585, 12, 13, 12, 0, -13 },
  { 605, 10, 13, 12, 1, -13 },
  { 622, 10, 13, 10, 0, -13 },
  { 639, 10, 16, 12, 1, -13 },
  { 659, 10, 13, 10, 0, -13 },
  { 676, 9, 13, 9, 0, -13 },
  { 691, 9, 13, 8, 1, -13 },
  { 706, 10, 13, 11, 1, -13 },
  { 723, 9, 13, 9, 2, -13 },
  { 738, 14, 13, 15, 2, -13 },
  { 761, 12, 13, 9, -1, -13 },
  { 781, 8, 13, 9, 2, -13 },
  { 794, 10, 13, 9, -1, -13 },
  { 811, 7, 16, 5, 0, -13 },
  { 825, 4, 13, 7, 2, -13 },
  { 832, 7, 16, 5, -1, -13 },
  { 846, 9, 8, 9, 0, -13 },
  { 855, 7, 1, 7, -2, 2 },
  { 856, 3, 3, 5, 3, -14 },
  { 858, 8, 10, 10, 1, -10 },
  { 868, 9, 14, 10, 0, -14 },
  { 884, 7, 10, 8, 1, -10 },
  { 893, 9, 14, 10, 1, -14 },
  { 909, 7, 10, 9, 1, -10 },
  { 918, 10, 18, 6, -2, -14 },
  { 941, 9, 14, 10, 0, -10 },
  { 957, 9, 14, 10, 0, -14 },
  { 973, 5, 14, 5, 0, -14 },
  { 982, 7, 18, 5, -2, -14 },
  { 998, 10, 14, 9, 0, -14 },
  { 1016, 5, 14, 5, 0, -14 },
  { 1025, 14, 10, 14, 0, -10 },
  { 1043, 9, 10, 10, 0, -10 },
  { 1055, 8, 10, 9, 1, -10 },
  { 1065, 10, 14, 10, -1, -10 },
  { 1083, 8, 14, 10, 1, -10 },
  { 1097, 7, 10, 7, 0, -10 },
  { 1106, 7, 10, 7, 0, -10 },
  { 1115, 6, 12, 6, 1, -12 },
  { 1124, 8, 10, 10, 1, -10 },
  { 1134, 8, 10, 8, 1, -10 },
  { 1144, 12, 10, 13, 1, -10 },
  { 1159, 10, 10, 8, -1, -10 },
  { 1172, 10, 14, 8, -1, -10 },
  { 1190, 8, 10, 7, 0, -10 },
  { 1200, 7, 16, 6, 0, -13 },
  { 1214, 1, 18, 9, 4, -14 },
  { 1217, 7, 16, 6, -1, -13 },
  { 1231, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC18PT7B_H_
