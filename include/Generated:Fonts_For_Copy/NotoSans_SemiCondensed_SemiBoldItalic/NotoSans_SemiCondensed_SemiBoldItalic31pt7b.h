#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC31PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F,
  0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x0F,
  0x83, 0x80, 0x79, 0xEE, 0x39, 0xCF, 0x39, 0xC7, 0x39, 0xC7, 0x38, 0xE7,
  0x18, 0x00, 0xE3, 0x80, 0x38, 0xC0, 0x0C, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x61, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xC7, 0x00,
  0x71, 0xC0, 0x1C, 0x60, 0x06, 0x38, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF,
  0xFC, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x63, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x00, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x1F, 0xC0, 0xFF,
  0xE3, 0xFF, 0x87, 0xB2, 0x1E, 0x40, 0x3D, 0x80, 0x7B, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xBC, 0x02, 0x78, 0x0C,
  0xF2, 0x19, 0xE7, 0xBF, 0x8F, 0xFE, 0x1F, 0xF8, 0x07, 0xC0, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x1F, 0x00, 0xE1, 0xFC, 0x0E, 0x1E, 0xE0, 0xE0,
  0xE3, 0x07, 0x07, 0x38, 0x70, 0x71, 0xC7, 0x03, 0x8E, 0x38, 0x1C, 0x73,
  0x80, 0xE3, 0xB8, 0xC7, 0x39, 0xDF, 0xB9, 0xDD, 0xFF, 0xFD, 0xCE, 0x77,
  0xCE, 0xE3, 0x80, 0xE7, 0x1C, 0x0E, 0x38, 0xE0, 0x73, 0x87, 0x07, 0x1C,
  0x70, 0x70, 0xE3, 0x83, 0x87, 0x1C, 0x38, 0x3D, 0xC3, 0x80, 0xFE, 0x3C,
  0x03, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0x3C, 0x70, 0x0E,
  0x1C, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0x0F, 0x7F, 0xC7, 0x9E, 0x79, 0xEF, 0x0F, 0xF3,
  0xC3, 0xF8, 0xE0, 0x7E, 0x38, 0x1F, 0x0F, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F,
  0xDE, 0x0F, 0xE3, 0xC0, 0x7B, 0xDC, 0xE7, 0x73, 0x9C, 0x01, 0xE0, 0x70,
  0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x0E, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xE0, 0x86, 0x0F, 0x30, 0x7F, 0x8D, 0xFF, 0xE1, 0xFF, 0x1F, 0x09,
  0xFC, 0x1E, 0xE1, 0xE3, 0x83, 0x1C, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x3C,
  0xF3, 0x9E, 0x71, 0xCE, 0x38, 0xFF, 0xFE, 0xFE, 0x7F, 0xFE, 0xE0, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F,
  0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xDE, 0x07, 0x78, 0x3D, 0xE0, 0xF7, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xC3,
  0xCF, 0x1E, 0x1F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x01, 0xE0, 0xF8, 0x3F,
  0x1F, 0xE7, 0xFD, 0xF7, 0x98, 0xE2, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xC0, 0x78, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x07, 0x0F, 0x04,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xF8, 0x07,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x60, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x7C, 0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF3, 0x03, 0xE7, 0xFF,
  0x8F, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3B, 0x80, 0xFF, 0x01, 0xDE, 0x07, 0x3C, 0x1C, 0x70,
  0x78, 0xE1, 0xE3, 0xC3, 0x87, 0x8E, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x08, 0xFC, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0xC0,
  0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x7C, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x7B, 0xF0,
  0xFF, 0xE1, 0xFF, 0xE3, 0xE3, 0xCF, 0x83, 0x9E, 0x07, 0x3C, 0x0E, 0x78,
  0x3C, 0xF0, 0x79, 0xE0, 0xF1, 0xE3, 0xC3, 0xFF, 0x03, 0xFE, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x07, 0xF8, 0x1F,
  0xF8, 0x7F, 0xF0, 0xF0, 0xF1, 0xC1, 0xE3, 0x83, 0xC7, 0x07, 0x0F, 0x1E,
  0x1F, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0xFF, 0x07, 0xCF, 0x0F, 0x0F, 0x3C,
  0x1E, 0x70, 0x3C, 0xE0, 0x79, 0xC0, 0xF3, 0xC3, 0xC7, 0xFF, 0x87, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F, 0x3C, 0x3D,
  0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3D, 0xE1, 0xF7, 0x8F, 0xDF, 0xFE,
  0x3F, 0xB8, 0x7D, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x0E, 0x1F, 0x1E, 0x1E, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF0, 0x03,
  0x81, 0xF0, 0x78, 0x1E, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x03, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x0C, 0x00, 0x20,
  0x00, 0x3F, 0xCF, 0xFD, 0xFF, 0x90, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x07, 0xC1, 0xF0, 0x7C, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x3E, 0x0F, 0x81, 0xE0, 0x0E, 0x0E, 0x00, 0x1C, 0x70, 0x00,
  0x71, 0xC3, 0xF8, 0xCE, 0x1F, 0xE3, 0x30, 0xE3, 0x8D, 0xC7, 0x0C, 0x37,
  0x18, 0x70, 0xD8, 0xE1, 0xC7, 0xE3, 0x87, 0x1F, 0x8E, 0x38, 0x7E, 0x30,
  0xE3, 0xB8, 0xE7, 0x8E, 0xE3, 0xFF, 0xF3, 0x8F, 0xDF, 0x87, 0x0C, 0x38,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0C, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0E, 0xE0, 0x07, 0x70, 0x07, 0xB8, 0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC7,
  0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0, 0x78, 0x70, 0x7F, 0xF8, 0x3F,
  0xFE, 0x3F, 0xFF, 0x1E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x7F, 0x80, 0x3C, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1E, 0x1F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x3E, 0x3F, 0xFC,
  0x3F, 0xF0, 0x3F, 0xF8, 0x38, 0x3C, 0x78, 0x1C, 0x78, 0x1E, 0x78, 0x1E,
  0x70, 0x3C, 0x70, 0x3C, 0xF0, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0x01, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x02, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x30, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0xC3, 0xC3, 0xE1, 0xE0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x38,
  0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x7B,
  0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x3C, 0x78, 0x3E, 0x38, 0x3E, 0x3C, 0x7E,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x10, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3,
  0xFF, 0xE3, 0xF0, 0x63, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x1F, 0xDE, 0x1F, 0xEF, 0x0F, 0xE7, 0x80,
  0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0E, 0x3F, 0x0F, 0x0F,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x07, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xE0, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0x80,
  0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x0E, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xC1, 0xE0, 0x78, 0x00, 0x07,
  0xF8, 0x7F, 0xC0, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x7E, 0x0F, 0xF8, 0x7F, 0xC0, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x83, 0xFC, 0x0F, 0xE0, 0x3F, 0x00,
  0x0F, 0x03, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x38, 0x78, 0x1E, 0x3E, 0x07,
  0x8F, 0x01, 0xE7, 0x80, 0x73, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1E, 0x78, 0x07, 0x8E, 0x01, 0xE3, 0xC0,
  0x70, 0xF0, 0x1C, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x3F,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE,
  0x1D, 0xC0, 0xFE, 0x1D, 0xC1, 0xFE, 0x1D, 0xC1, 0xDC, 0x3D, 0xC1, 0xDC,
  0x3D, 0xC3, 0x9C, 0x39, 0xC3, 0xBC, 0x39, 0xC7, 0x3C, 0x39, 0xC7, 0x38,
  0x79, 0xCE, 0x38, 0x79, 0xCE, 0x78, 0x71, 0xDC, 0x78, 0x71, 0xDC, 0x78,
  0x71, 0xF8, 0x70, 0xF1, 0xF8, 0x70, 0xF0, 0xF0, 0xF0, 0xE0, 0xF0, 0xF0,
  0xE0, 0xE0, 0xF0, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x80, 0xF1, 0xFC,
  0x0E, 0x1F, 0xC0, 0xE1, 0xDC, 0x1E, 0x1D, 0xC1, 0xE1, 0xDE, 0x1C, 0x3D,
  0xE1, 0xC3, 0xCE, 0x1C, 0x38, 0xF3, 0xC3, 0x8F, 0x3C, 0x38, 0x73, 0x87,
  0x87, 0x38, 0x78, 0x7B, 0x87, 0x07, 0xF8, 0x70, 0x3F, 0x87, 0x03, 0xF0,
  0xF0, 0x3F, 0x0F, 0x01, 0xF0, 0xE0, 0x1F, 0x0E, 0x01, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x7C, 0x3E, 0x3E, 0x07, 0x8F, 0x01, 0xE7,
  0x80, 0x39, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E,
  0x3C, 0x0F, 0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x7E, 0x3F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xC0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7C, 0x3E, 0x3E, 0x07, 0x8F, 0x01, 0xE7, 0x80, 0x39,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x0F,
  0x8F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFE, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x79,
  0xE0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x7C, 0xE0, 0x3C, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0x04, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x80, 0x78, 0xC1, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xC0, 0x78, 0xF0,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0xF1, 0xE0, 0x3C, 0x78, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x8F, 0x83, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0,
  0xF0, 0xE0, 0xF1, 0xE0, 0x71, 0xC0, 0x73, 0xC0, 0x73, 0x80, 0x77, 0x80,
  0x77, 0x00, 0x77, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xE0, 0x3C, 0x07, 0xF0, 0x1E, 0x07, 0xB8, 0x1F, 0x03, 0xDC,
  0x0F, 0x83, 0xCE, 0x07, 0xC1, 0xE7, 0x07, 0xE0, 0xE3, 0x83, 0xF0, 0xF1,
  0xC3, 0xB8, 0x78, 0xE1, 0xDC, 0x78, 0x71, 0xEE, 0x3C, 0x38, 0xE7, 0x1C,
  0x1C, 0x73, 0x9E, 0x0E, 0x71, 0xCE, 0x07, 0x38, 0xEF, 0x03, 0xBC, 0x77,
  0x81, 0xDC, 0x3B, 0x80, 0xEE, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x07,
  0x80, 0xF0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x01, 0xC7, 0x80,
  0x1E, 0x70, 0x01, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xBC,
  0x00, 0x79, 0xC0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC0,
  0xE0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x1F, 0xE0, 0x7B, 0xC1, 0xE3,
  0x83, 0xC7, 0x0F, 0x0F, 0x1C, 0x1E, 0x78, 0x3D, 0xE0, 0x3B, 0xC0, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0x03,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x7E, 0x03, 0xF0, 0x3F, 0x80, 0xF1, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xE7, 0x01, 0xCE, 0x07, 0x1C, 0x1E,
  0x1C, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0x7F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF9, 0xE3, 0x8F, 0x1C, 0x07, 0xCE, 0x1F, 0xDC, 0x7F, 0xF9, 0xF1, 0xF3,
  0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC1,
  0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x3E, 0x3F, 0xFC, 0x3F, 0xB8, 0x3E, 0x70,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x78, 0x0E, 0xFC, 0x1F, 0xFE, 0x1F, 0x1E, 0x1E, 0x0E,
  0x1E, 0x0F, 0x1C, 0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E,
  0x38, 0x3C, 0x78, 0x3C, 0x7C, 0x78, 0x7F, 0xF8, 0x77, 0xF0, 0xE7, 0xE0,
  0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x7C, 0x23, 0xC0, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x21, 0xFF,
  0x0F, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x0F, 0x9C, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0x8F, 0x87, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1,
  0xE0, 0x70, 0xF0, 0x38, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F,
  0x07, 0xFF, 0x81, 0xFD, 0xC0, 0x7C, 0xE0, 0x03, 0xE0, 0x7F, 0xC7, 0xFE,
  0x78, 0x73, 0xC3, 0xBC, 0x1D, 0xE1, 0xEF, 0xFE, 0xFF, 0xE7, 0xF8, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x11, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x00,
  0x0E, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xF9, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x03, 0xE7, 0x07, 0xF7, 0x0F, 0xFF, 0x1F, 0x1F, 0x1E, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x7C, 0x78, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x81, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x3E, 0x0E, 0xFE, 0x3F, 0xFC, 0x7E, 0x78, 0xF8, 0x71,
  0xE0, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1C, 0x70, 0x38, 0xE0,
  0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1C, 0x0E, 0x78, 0x3C, 0x07, 0x83,
  0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC0,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x81, 0xFC, 0x0F, 0xC0, 0x7C,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x1F, 0x0E, 0x1E, 0x0F, 0x1E, 0x07, 0x9F,
  0x03, 0xCF, 0x01, 0xCF, 0x00, 0xEF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x1E, 0xF0, 0x0E, 0x38, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC3, 0xC1,
  0xC1, 0xE1, 0xE0, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0x0E, 0x7C, 0x7C, 0x0E, 0xFC,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0x1F, 0x8F, 0x1F, 0x1F, 0x0F, 0x1E, 0x1E,
  0x0E, 0x1C, 0x1E, 0x0E, 0x3C, 0x1E, 0x1E, 0x3C, 0x1C, 0x1E, 0x3C, 0x1C,
  0x1E, 0x38, 0x3C, 0x1E, 0x38, 0x3C, 0x1C, 0x78, 0x3C, 0x3C, 0x78, 0x38,
  0x3C, 0x78, 0x78, 0x3C, 0x70, 0x78, 0x38, 0xF0, 0x78, 0x78, 0x0E, 0x7C,
  0x1D, 0xFC, 0x7F, 0xF8, 0xFC, 0xF1, 0xF0, 0xE3, 0xC1, 0xC7, 0x87, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xE0, 0x71, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x0E, 0x38, 0x3C, 0xF0, 0x78, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F,
  0x8F, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xBC, 0x1E, 0xF0, 0x7B, 0xC3, 0xC7, 0xFF, 0x0F, 0xF8, 0x1F, 0x80,
  0x07, 0x3C, 0x03, 0xBF, 0x03, 0xFF, 0xC1, 0xF1, 0xE0, 0xF0, 0x70, 0x78,
  0x3C, 0x38, 0x1C, 0x3C, 0x0E, 0x1E, 0x0F, 0x0F, 0x07, 0x87, 0x03, 0xC3,
  0x83, 0xC3, 0xC1, 0xE1, 0xF1, 0xE0, 0xFF, 0xF0, 0x77, 0xF0, 0x79, 0xF0,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x07, 0xCE, 0x1F, 0xDC, 0x7F, 0xF9, 0xF1, 0xF3, 0xC3,
  0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x1E, 0xF0, 0x3D, 0xE0, 0x73, 0xC1, 0xE7,
  0x83, 0xCF, 0x0F, 0x9E, 0x1E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3E, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x0E, 0x78, 0x77, 0x87, 0xFC, 0x3F, 0xE1, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0xCF, 0xFC, 0x78, 0x23, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x40, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0x00, 0x07, 0x03, 0x80, 0xE0,
  0x7F, 0x7F, 0xFF, 0xF3, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3F, 0x87, 0xE1, 0xF8, 0x1C, 0x0E, 0x38,
  0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xC7, 0x07, 0x9E, 0x0F, 0x3C, 0x1E,
  0x78, 0x38, 0xE0, 0x71, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x9E, 0x3E, 0x3F,
  0xFC, 0x3F, 0xB8, 0x3E, 0x70, 0xE0, 0x3F, 0x81, 0xEE, 0x07, 0x38, 0x3C,
  0xE0, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0x83, 0xDE, 0x07, 0x70,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00, 0xE0,
  0xF0, 0x7F, 0x07, 0x83, 0xF8, 0x7C, 0x3D, 0xC3, 0xE1, 0xEE, 0x1B, 0x0E,
  0x71, 0xD8, 0xF3, 0x8E, 0xC7, 0x1C, 0xE6, 0x78, 0xE7, 0x33, 0x87, 0x71,
  0x9C, 0x3B, 0x8D, 0xE1, 0xDC, 0x6E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x87, 0x87,
  0x83, 0xC7, 0x81, 0xE7, 0x80, 0x73, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xEF, 0x01,
  0xE7, 0x81, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0x78, 0x00, 0x0E, 0x03, 0xC3,
  0x81, 0xE0, 0xE0, 0x78, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x3C, 0xF0, 0x07, 0x3C, 0x01, 0xDE, 0x00, 0x77, 0x80, 0x1D, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x03, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x1F, 0x80, 0x38, 0x0F, 0xC0, 0xF8, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0xFC, 0x07, 0xE0, 0x3C,
  0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 9, 22, 8, 0, -22 },
  { 26, 11, 8, 13, 3, -22 },
  { 37, 18, 22, 18, 0, -22 },
  { 87, 15, 26, 16, 1, -24 },
  { 136, 21, 22, 24, 2, -22 },
  { 194, 18, 22, 19, 1, -22 },
  { 244, 5, 8, 7, 3, -22 },
  { 249, 11, 27, 9, 1, -22 },
  { 287, 10, 27, 9, -2, -22 },
  { 321, 13, 14, 15, 3, -24 },
  { 344, 14, 15, 16, 2, -18 },
  { 371, 6, 8, 8, -1, -4 },
  { 377, 8, 3, 9, 1, -10 },
  { 380, 5, 4, 8, 0, -4 },
  { 383, 15, 22, 12, -1, -22 },
  { 425, 14, 22, 16, 1, -22 },
  { 464, 11, 22, 16, 3, -22 },
  { 495, 16, 22, 16, -1, -22 },
  { 539, 15, 22, 16, 0, -22 },
  { 581, 15, 22, 16, 0, -22 },
  { 623, 16, 22, 16, 0, -22 },
  { 667, 15, 22, 16, 1, -22 },
  { 709, 16, 22, 16, 1, -22 },
  { 753, 15, 22, 16, 1, -22 },
  { 795, 14, 22, 16, 1, -22 },
  { 834, 8, 17, 8, 0, -17 },
  { 851, 10, 21, 8, -2, -17 },
  { 878, 14, 16, 16, 2, -19 },
  { 906, 13, 9, 16, 2, -15 },
  { 921, 14, 16, 16, 2, -19 },
  { 949, 11, 22, 12, 2, -22 },
  { 980, 22, 25, 24, 1, -22 },
  { 1049, 17, 22, 17, -2, -22 },
  { 1096, 16, 22, 17, 1, -22 },
  { 1140, 16, 22, 17, 2, -22 },
  { 1184, 17, 22, 19, 1, -22 },
  { 1231, 15, 22, 15, 1, -22 },
  { 1273, 15, 22, 14, 1, -22 },
  { 1315, 17, 22, 19, 2, -22 },
  { 1362, 19, 22, 19, 1, -22 },
  { 1415, 13, 22, 10, -1, -22 },
  { 1451, 14, 28, 9, -5, -22 },
  { 1500, 18, 22, 17, 1, -22 },
  { 1550, 11, 22, 14, 1, -22 },
  { 1581, 24, 22, 25, 1, -22 },
  { 1647, 20, 22, 21, 1, -22 },
  { 1702, 18, 22, 20, 2, -22 },
  { 1752, 16, 22, 17, 1, -22 },
  { 1796, 18, 27, 20, 2, -22 },
  { 1857, 16, 22, 17, 1, -22 },
  { 1901, 16, 22, 15, 0, -22 },
  { 1945, 14, 22, 15, 3, -22 },
  { 1984, 18, 22, 19, 2, -22 },
  { 2034, 16, 22, 16, 3, -22 },
  { 2078, 25, 22, 25, 3, -22 },
  { 2147, 20, 22, 16, -2, -22 },
  { 2202, 15, 22, 15, 3, -22 },
  { 2244, 17, 22, 15, -1, -22 },
  { 2291, 13, 27, 9, -1, -22 },
  { 2335, 7, 22, 12, 3, -22 },
  { 2355, 12, 27, 9, -2, -22 },
  { 2396, 15, 13, 16, 0, -22 },
  { 2421, 12, 2, 11, -3, 3 },
  { 2424, 6, 5, 9, 4, -24 },
  { 2428, 15, 17, 17, 1, -17 },
  { 2460, 16, 24, 17, 0, -24 },
  { 2508, 13, 17, 13, 1, -17 },
  { 2536, 17, 24, 17, 1, -24 },
  { 2587, 13, 17, 15, 1, -17 },
  { 2615, 16, 31, 10, -3, -24 },
  { 2677, 16, 24, 17, 0, -17 },
  { 2725, 15, 24, 17, 0, -24 },
  { 2770, 9, 23, 8, 0, -23 },
  { 2796, 13, 30, 8, -4, -23 },
  { 2845, 17, 24, 15, 0, -24 },
  { 2896, 9, 24, 8, 0, -24 },
  { 2923, 24, 17, 25, 0, -17 },
  { 2974, 15, 17, 17, 0, -17 },
  { 3006, 14, 17, 16, 1, -17 },
  { 3036, 17, 24, 17, -1, -17 },
  { 3087, 15, 24, 17, 1, -17 },
  { 3132, 13, 17, 12, 0, -17 },
  { 3160, 13, 17, 13, 0, -17 },
  { 3188, 10, 20, 11, 1, -20 },
  { 3213, 15, 17, 17, 1, -17 },
  { 3245, 14, 17, 14, 2, -17 },
  { 3275, 21, 17, 22, 2, -17 },
  { 3320, 17, 17, 14, -1, -17 },
  { 3357, 18, 24, 14, -2, -17 },
  { 3411, 14, 17, 13, -1, -17 },
  { 3441, 13, 27, 11, 0, -22 },
  { 3485, 3, 31, 15, 6, -24 },
  { 3497, 13, 27, 11, -2, -22 },
  { 3541, 14, 4, 16, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC31PT7B_H_
