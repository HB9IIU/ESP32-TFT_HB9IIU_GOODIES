#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x00, 0x00,
  0x00, 0x40, 0x78, 0x3E, 0x0F, 0x81, 0xE0, 0x79, 0xEF, 0x3D, 0xE7, 0xBC,
  0xF7, 0x1C, 0xE3, 0x9C, 0x77, 0x1C, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x18,
  0x70, 0x07, 0x0C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE3,
  0x81, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0xE1, 0x80, 0x1C, 0x70, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x03, 0x8E, 0x00, 0x61, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x1C, 0x30, 0x03, 0x8E, 0x00, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x03,
  0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0xC4, 0x3C, 0xC0, 0x3C, 0xC0, 0x3C,
  0xC0, 0x1E, 0x80, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x03,
  0x7C, 0x03, 0x3C, 0x03, 0x3C, 0x03, 0x3C, 0xC2, 0x78, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x0E, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0F,
  0x00, 0x78, 0x7E, 0x01, 0xC3, 0xFC, 0x0E, 0x1E, 0x70, 0x70, 0x71, 0xC1,
  0xC1, 0xC7, 0x0E, 0x0F, 0x1C, 0x70, 0x38, 0x71, 0xC0, 0xE3, 0xCE, 0x03,
  0x8E, 0x70, 0x0E, 0x39, 0xCF, 0xB9, 0xEE, 0x7F, 0xFF, 0x7B, 0xDD, 0xF9,
  0xDE, 0x73, 0xCE, 0x71, 0xC0, 0x79, 0xC7, 0x01, 0xCF, 0x1C, 0x0E, 0x38,
  0x70, 0x78, 0xE1, 0xC1, 0xC3, 0x8E, 0x0E, 0x0E, 0x38, 0x78, 0x3D, 0xC1,
  0xC0, 0x7F, 0x0E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8,
  0x03, 0xCF, 0x00, 0xF0, 0xE0, 0x1E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x3C, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x1E,
  0x7F, 0xC7, 0x9E, 0x7C, 0xF7, 0x87, 0xBC, 0xF0, 0xFF, 0x9E, 0x0F, 0xE3,
  0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x8F, 0xE1, 0xFF, 0xFE, 0x1F, 0xFB, 0xC1,
  0xFC, 0x7C, 0x3B, 0xDE, 0xF7, 0x39, 0xCE, 0xE0, 0x00, 0xE0, 0x38, 0x0F,
  0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80,
  0xE0, 0x38, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x18, 0xE0, 0xFB,
  0x83, 0xFC, 0xF3, 0xFF, 0xC1, 0xFF, 0x0F, 0x84, 0x76, 0x07, 0xDC, 0x1E,
  0x78, 0x30, 0xE0, 0x43, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x38, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x13,
  0xFF, 0xF7, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF0,
  0x7D, 0xF1, 0xF1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xC7, 0x9F, 0x0F, 0xFC, 0x1F,
  0xF0, 0x1F, 0xC0, 0x00, 0xF0, 0x1E, 0x07, 0xE0, 0xFE, 0x1F, 0xEF, 0xDE,
  0x7B, 0xC7, 0x3C, 0x23, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xF0,
  0x70, 0x78, 0x10, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0x0F, 0xBF, 0x04, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x07, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x80, 0x3C, 0xC0, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xEE, 0x01, 0xFE, 0x01, 0xDE, 0x03, 0x9E,
  0x07, 0x9C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x78, 0x38,
  0x70, 0x78, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x10, 0x0F,
  0x8E, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0xFF, 0x03, 0xFF, 0x07, 0xF2, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x39, 0xF0, 0x7B, 0xF8, 0x7F, 0xFC, 0x7E, 0x7C, 0x78,
  0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0x78,
  0x78, 0x78, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFF, 0x8F,
  0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x7C, 0x0F, 0xF8, 0x07, 0xE0,
  0x1F, 0xF0, 0x3E, 0xF8, 0x7C, 0x78, 0xF8, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0,
  0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x83, 0xCF,
  0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xFB, 0xE3, 0xF3, 0xFF,
  0xC7, 0xFF, 0x87, 0xEF, 0x02, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x88, 0x3E, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0x1F, 0x1F,
  0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x78,
  0xF8, 0xF8, 0xF0, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x00, 0x00, 0x06, 0x00, 0x3C, 0x01,
  0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3E, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x40, 0x00, 0x0F,
  0x83, 0xFE, 0x7F, 0xF7, 0xDF, 0x20, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x00, 0x00, 0x00, 0x02, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x1C, 0x1F, 0xC7, 0x38,
  0x7F, 0xC7, 0x38, 0xF1, 0xC7, 0x70, 0xE1, 0xC7, 0x71, 0xC3, 0x87, 0x71,
  0xC3, 0x87, 0x63, 0x83, 0x86, 0xE3, 0x87, 0x8E, 0xE3, 0x87, 0x0E, 0xE3,
  0x87, 0x1C, 0xE3, 0x8F, 0x3C, 0xE1, 0xFB, 0xF8, 0x71, 0xF3, 0xF0, 0x70,
  0x40, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3E, 0x01, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0x78,
  0x03, 0xDE, 0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x38, 0x0F, 0x0E, 0x03,
  0xC3, 0x81, 0xE0, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F,
  0xC0, 0x0F, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0,
  0xF8, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x0F, 0x8F,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC1, 0xE3, 0xF0, 0xF0, 0x78, 0xF0, 0x3E,
  0x78, 0x1F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xCF, 0x0F, 0xC7, 0xFF,
  0xE3, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xE1, 0xF8, 0x10, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC3, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x0F, 0x83, 0xC1, 0xF1, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0x78, 0x0F, 0x9E, 0x03,
  0xC7, 0x81, 0xF1, 0xE0, 0xF8, 0xF3, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0,
  0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE1,
  0xF8, 0x08, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x3F, 0xCF, 0x07, 0xF9, 0xE0, 0xFF, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x7C,
  0x0F, 0x07, 0xE1, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0,
  0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xC0, 0x78, 0x3C, 0x07,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x07,
  0xFC, 0x1F, 0xF0, 0xFF, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01,
  0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x07, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x3E, 0x00, 0x00, 0x07, 0x81, 0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0,
  0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xE7, 0xC0,
  0x1E, 0x78, 0x01, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F,
  0xFF, 0xFF, 0xEF, 0xFE, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0x70, 0x7F, 0x01, 0xDC, 0x1F, 0xC0, 0xFF, 0x07, 0x78, 0x3B,
  0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0x38, 0x3D, 0xE3, 0xDE, 0x0F, 0x38,
  0xE7, 0x83, 0x8E, 0x79, 0xE1, 0xE3, 0x9C, 0x78, 0x78, 0xEF, 0x1C, 0x1E,
  0x3B, 0x8F, 0x07, 0x0F, 0xE3, 0xC1, 0xC3, 0xF0, 0xF0, 0xF0, 0xFC, 0x38,
  0x3C, 0x3E, 0x1E, 0x0F, 0x0F, 0x87, 0x83, 0x83, 0xC1, 0xE0, 0x07, 0x80,
  0x38, 0x7C, 0x01, 0xC3, 0xF0, 0x1E, 0x1F, 0x80, 0xF0, 0xFC, 0x07, 0x87,
  0xF0, 0x38, 0x7F, 0x83, 0xC3, 0xFC, 0x1E, 0x1C, 0xE0, 0xF0, 0xE7, 0x87,
  0x8F, 0x3C, 0x38, 0x79, 0xE3, 0xC3, 0xC7, 0x9E, 0x1E, 0x3C, 0xF0, 0xE1,
  0xE7, 0x0F, 0x07, 0x38, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1C, 0x0F, 0xF0,
  0xE0, 0x3F, 0x0F, 0x01, 0xF8, 0x78, 0x0F, 0xC3, 0xC0, 0x3E, 0x1C, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0,
  0x7C, 0x7C, 0x07, 0x8F, 0x00, 0xFB, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0x7C, 0x0F,
  0x87, 0xC7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xCF, 0x03, 0xC7, 0x87, 0xE3,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0,
  0x7C, 0x7C, 0x07, 0x8F, 0x00, 0xFB, 0xE0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x01, 0xF3, 0xC0, 0x3C, 0x7C, 0x0F,
  0x87, 0xC7, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0xF0,
  0x78, 0x7C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x87,
  0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x0F, 0x03, 0xC7, 0x81, 0xE3,
  0xC0, 0xF1, 0xE0, 0x7C, 0x00, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xE0, 0xF0, 0x20, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x10, 0x0F, 0x0F, 0x1F,
  0x87, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x8F,
  0x01, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF0, 0xF0,
  0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x1F, 0x0F, 0x87, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x78, 0x38, 0x3C, 0x1C, 0x3C,
  0x0E, 0x1E, 0x07, 0x1E, 0x03, 0x8F, 0x01, 0xC7, 0x00, 0xF7, 0x80, 0x7B,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x7B, 0xC0,
  0x78, 0x0F, 0x78, 0x1F, 0x03, 0xCF, 0x03, 0xE0, 0x79, 0xE0, 0xFC, 0x1E,
  0x3C, 0x1F, 0x83, 0xC7, 0x87, 0xF0, 0x78, 0xF0, 0xEE, 0x1E, 0x1E, 0x1D,
  0xC3, 0xC3, 0xC7, 0xB8, 0xF0, 0x78, 0xE7, 0x1E, 0x0F, 0x3C, 0xE3, 0x81,
  0xE7, 0x1C, 0xF0, 0x3D, 0xE3, 0x9E, 0x07, 0xB8, 0x77, 0x80, 0xF7, 0x0E,
  0xF0, 0x1F, 0xE1, 0xDC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x78,
  0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xF7, 0x80, 0x07, 0xDE, 0x00,
  0x1E, 0x78, 0x00, 0xF1, 0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF0,
  0x3C, 0x07, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1E, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x39,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x00, 0xF0, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0xC3,
  0xC7, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xF1, 0xE3, 0xC3, 0x87, 0x03, 0xF8,
  0x1F, 0xC1, 0xFC, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0xEE, 0x01, 0xDC, 0x07,
  0x3C, 0x1E, 0x38, 0x38, 0x70, 0xE0, 0x71, 0xC0, 0xE7, 0x01, 0xDE, 0x03,
  0xF8, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xF1, 0xE7, 0x8E, 0x1C, 0x07,
  0xE7, 0x0F, 0xF7, 0x1F, 0xFF, 0x1F, 0x3F, 0x3E, 0x1E, 0x3C, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x7C, 0xF0, 0x7C, 0xF8, 0xF8, 0x7F, 0xB8, 0x7F, 0xF8, 0x3E, 0x78, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x78, 0x0F, 0xFE, 0x07, 0x7F, 0x87, 0xE3, 0xC3, 0xE1,
  0xE1, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E,
  0x07, 0x8F, 0x07, 0xC7, 0x83, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xFF, 0xF0,
  0xEF, 0xF0, 0xF3, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xC4,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x86, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x1F, 0xBC, 0x0F, 0xFF, 0x07, 0xFF, 0xC1,
  0xE3, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0xF0, 0x3C, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0x78,
  0x3E, 0x3E, 0x07, 0xFF, 0x81, 0xFE, 0xE0, 0x3E, 0x78, 0x00, 0x03, 0xF0,
  0x3F, 0xF1, 0xFF, 0xC7, 0x8F, 0x3C, 0x1D, 0xF0, 0xF7, 0x83, 0xDE, 0x7E,
  0x7F, 0xF3, 0xFF, 0x8F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x81,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x27,
  0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF3, 0x83,
  0xFD, 0xC3, 0xFF, 0xE1, 0xF3, 0xF1, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83,
  0xE3, 0xC1, 0xE1, 0xF1, 0xF0, 0x7F, 0xF8, 0x3F, 0xBC, 0x0F, 0x9E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x84, 0x07, 0x83, 0x87, 0xC1, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x3E, 0x0F, 0xFF, 0x0E,
  0xFF, 0x1F, 0x8F, 0x1F, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78,
  0x1C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x10, 0x00, 0x00, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF0, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x5F,
  0x03, 0xF8, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x1F,
  0x0F, 0x0F, 0x03, 0xC7, 0x81, 0xE3, 0xE0, 0x79, 0xF0, 0x1E, 0xF8, 0x07,
  0xBC, 0x01, 0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xCF,
  0x00, 0xE3, 0xC0, 0x78, 0xF8, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0xF0,
  0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x00, 0x0E,
  0x3E, 0x1F, 0x07, 0x7F, 0x3F, 0xC3, 0xFF, 0xFF, 0xE3, 0xF1, 0xF8, 0xF1,
  0xF0, 0xF8, 0x78, 0xF0, 0x7C, 0x3C, 0x78, 0x3C, 0x1E, 0x3C, 0x1E, 0x0F,
  0x3C, 0x0E, 0x07, 0x1E, 0x0F, 0x07, 0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC1,
  0xE3, 0x81, 0xE0, 0xF3, 0xC1, 0xE0, 0x71, 0xE0, 0xF0, 0x78, 0xF0, 0x78,
  0x3C, 0x78, 0x3C, 0x1E, 0x78, 0x1E, 0x0F, 0x00, 0x0E, 0x3E, 0x0E, 0xFF,
  0x0F, 0xFF, 0x1F, 0x8F, 0x1F, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x78, 0x1E,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xF1, 0xF3, 0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xEF, 0x03, 0xDE, 0x0F, 0x1E, 0x3E,
  0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x07, 0x1E, 0x01, 0xDF, 0xC0, 0x7F,
  0xF8, 0x3F, 0x1E, 0x0F, 0x87, 0x83, 0xC1, 0xF0, 0xF0, 0x78, 0x3C, 0x1E,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x3E, 0x1E, 0x0F, 0x0F,
  0x87, 0xC3, 0xE3, 0xE0, 0xFF, 0xF8, 0x3B, 0xFC, 0x0E, 0x7C, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE7, 0x0F, 0xF7, 0x1F, 0xFF, 0x1E,
  0x3F, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF8, 0xF8, 0x7F,
  0xF8, 0x7F, 0x78, 0x3E, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x3C, 0x3B,
  0xE0, 0xEF, 0x87, 0xFE, 0x1F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xF1, 0xFF, 0x8F, 0x84,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x07, 0xCC, 0x1E, 0x3F, 0xF8, 0xFF, 0xC1, 0xFE,
  0x00, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFC, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0F,
  0x03, 0xF8, 0xFE, 0x1F, 0x80, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x3C,
  0x0F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF8, 0xF8, 0x7F,
  0xB8, 0x7F, 0x38, 0x3E, 0x78, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xE7, 0x83,
  0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xC0, 0xE7, 0x81,
  0xCE, 0x03, 0xBC, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x78, 0x1F, 0xE1, 0xF0, 0x7B, 0xC3, 0xE0, 0xF7,
  0x87, 0xC3, 0xCF, 0x1F, 0x87, 0x9E, 0x3F, 0x1E, 0x3C, 0xEE, 0x3C, 0x79,
  0xDC, 0x70, 0xF7, 0xB9, 0xE1, 0xEE, 0x73, 0x83, 0xDC, 0xEF, 0x07, 0xF1,
  0xDE, 0x0F, 0xE3, 0xB8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0xF0, 0xF8,
  0x1E, 0x1E, 0x01, 0xE7, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x1E, 0x1F,
  0x03, 0xC0, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0x78, 0x3C,
  0x07, 0x87, 0xC0, 0x78, 0x78, 0x03, 0x87, 0x80, 0x38, 0xF0, 0x03, 0x8F,
  0x00, 0x39, 0xE0, 0x03, 0x9C, 0x00, 0x3B, 0xC0, 0x03, 0xB8, 0x00, 0x3B,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x9F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x18, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x3F, 0x01, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x02, 0x00, 0x1E, 0x01, 0xF8, 0x0F,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xFF, 0x1F, 0xFF, 0xFC,
  0x1F, 0xE8, 0x0F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 11, 9, 14, 3, -24 },
  { 44, 19, 24, 19, 1, -24 },
  { 101, 16, 27, 17, 1, -25 },
  { 155, 22, 24, 26, 2, -24 },
  { 221, 19, 24, 20, 1, -24 },
  { 278, 5, 9, 8, 3, -24 },
  { 284, 11, 29, 10, 1, -24 },
  { 324, 11, 29, 10, -2, -24 },
  { 364, 14, 14, 16, 3, -25 },
  { 389, 15, 16, 17, 2, -20 },
  { 419, 8, 8, 8, -2, -4 },
  { 427, 8, 4, 10, 1, -11 },
  { 431, 5, 5, 8, 0, -5 },
  { 435, 17, 24, 13, -2, -24 },
  { 486, 15, 24, 17, 1, -24 },
  { 531, 12, 24, 17, 3, -24 },
  { 567, 17, 24, 17, -1, -24 },
  { 618, 16, 24, 17, 0, -24 },
  { 666, 16, 24, 17, 0, -24 },
  { 714, 17, 24, 17, 0, -24 },
  { 765, 16, 24, 17, 1, -24 },
  { 813, 17, 24, 17, 1, -24 },
  { 864, 16, 24, 17, 1, -24 },
  { 912, 15, 24, 17, 1, -24 },
  { 957, 8, 18, 9, 0, -18 },
  { 975, 10, 22, 9, -2, -18 },
  { 1003, 15, 16, 17, 2, -20 },
  { 1033, 14, 9, 17, 2, -16 },
  { 1049, 15, 16, 17, 2, -20 },
  { 1079, 12, 24, 13, 2, -24 },
  { 1115, 24, 27, 25, 1, -24 },
  { 1196, 18, 24, 18, -2, -24 },
  { 1250, 17, 24, 18, 1, -24 },
  { 1301, 17, 24, 18, 2, -24 },
  { 1352, 18, 24, 20, 1, -24 },
  { 1406, 16, 24, 16, 1, -24 },
  { 1454, 16, 24, 15, 1, -24 },
  { 1502, 19, 24, 21, 2, -24 },
  { 1559, 20, 24, 21, 1, -24 },
  { 1619, 14, 24, 11, -1, -24 },
  { 1661, 15, 31, 9, -5, -24 },
  { 1720, 20, 24, 18, 1, -24 },
  { 1780, 12, 24, 15, 1, -24 },
  { 1816, 26, 24, 26, 1, -24 },
  { 1894, 21, 24, 22, 1, -24 },
  { 1957, 19, 24, 22, 2, -24 },
  { 2014, 17, 24, 18, 1, -24 },
  { 2065, 19, 30, 22, 2, -24 },
  { 2137, 17, 24, 18, 1, -24 },
  { 2188, 17, 24, 16, 0, -24 },
  { 2239, 15, 24, 15, 3, -24 },
  { 2284, 19, 24, 20, 2, -24 },
  { 2341, 17, 24, 17, 3, -24 },
  { 2392, 27, 24, 27, 3, -24 },
  { 2473, 22, 24, 17, -2, -24 },
  { 2539, 16, 24, 16, 3, -24 },
  { 2587, 18, 24, 16, -1, -24 },
  { 2641, 13, 29, 10, -1, -24 },
  { 2689, 7, 24, 13, 3, -24 },
  { 2710, 13, 29, 10, -2, -24 },
  { 2758, 15, 15, 17, 1, -24 },
  { 2787, 13, 2, 12, -3, 3 },
  { 2791, 6, 5, 10, 5, -25 },
  { 2795, 16, 18, 18, 1, -18 },
  { 2831, 17, 25, 18, 0, -25 },
  { 2885, 14, 18, 14, 1, -18 },
  { 2917, 18, 25, 18, 1, -25 },
  { 2974, 14, 18, 16, 1, -18 },
  { 3006, 18, 33, 11, -4, -25 },
  { 3081, 17, 26, 18, 0, -18 },
  { 3137, 16, 25, 18, 0, -25 },
  { 3187, 9, 25, 9, 0, -25 },
  { 3216, 13, 33, 9, -4, -25 },
  { 3270, 18, 25, 16, 0, -25 },
  { 3327, 10, 25, 9, 0, -25 },
  { 3359, 25, 18, 27, 0, -18 },
  { 3416, 16, 18, 18, 0, -18 },
  { 3452, 15, 18, 17, 1, -18 },
  { 3486, 18, 26, 18, -1, -18 },
  { 3545, 16, 26, 18, 1, -18 },
  { 3597, 14, 18, 12, 0, -18 },
  { 3629, 14, 18, 14, 0, -18 },
  { 3661, 10, 22, 11, 2, -22 },
  { 3689, 16, 18, 18, 1, -18 },
  { 3725, 15, 18, 15, 2, -18 },
  { 3759, 23, 18, 23, 2, -18 },
  { 3811, 19, 18, 15, -2, -18 },
  { 3854, 20, 26, 15, -3, -18 },
  { 3919, 15, 18, 13, -1, -18 },
  { 3953, 13, 29, 11, 0, -24 },
  { 4001, 3, 33, 16, 7, -25 },
  { 4014, 13, 29, 11, -2, -24 },
  { 4062, 15, 5, 17, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC33PT7B_H_
