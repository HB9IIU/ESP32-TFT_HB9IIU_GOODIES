#ifndef _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-SemiBoldItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_SemiBoldItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x00, 0x3F,
  0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF0, 0x7E, 0x3F, 0x0F, 0xE7,
  0xF0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFD,
  0xE7, 0xC0, 0x3F, 0x8E, 0x0E, 0x03, 0xF8, 0x70, 0x00, 0x1F, 0xC3, 0x80,
  0x00, 0xFE, 0x3C, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x3F, 0x8E, 0x00, 0x01,
  0xFE, 0x70, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0x9F, 0xE0, 0x00, 0x3C, 0xFF, 0x00, 0x01,
  0xC3, 0xF8, 0x00, 0x0E, 0x1F, 0xC0, 0x00, 0x70, 0xFE, 0x20, 0x07, 0x8F,
  0xE1, 0xC0, 0x3C, 0x7F, 0x0F, 0x81, 0xC7, 0xF8, 0x7F, 0xEF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x00,
  0x03, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0x8F, 0xC0, 0x0F, 0x80, 0x3F, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E,
  0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC3,
  0xF0, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x87, 0xE0, 0x00,
  0xF8, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x1F, 0x0F, 0x87, 0xF8, 0xF8, 0x3F,
  0x1F, 0x8F, 0xFC, 0xF8, 0x3F, 0x3F, 0x1F, 0xFE, 0xFC, 0x7E, 0x3E, 0x3F,
  0xFE, 0xFF, 0xFE, 0x7E, 0x7F, 0xFF, 0xFF, 0xFC, 0xFC, 0x7E, 0x3F, 0x7F,
  0xF8, 0xF8, 0xFC, 0x3F, 0x3F, 0xF1, 0xF8, 0xFC, 0x1F, 0x1F, 0xC3, 0xF1,
  0xF8, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x3F, 0x00, 0x1F,
  0x83, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xF0,
  0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x03,
  0xF1, 0xF8, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xE0, 0x03, 0xFF, 0xF0,
  0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x03, 0xFB, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0xFF, 0xFC, 0x03,
  0xF8, 0x3F, 0xFF, 0x80, 0xFE, 0x0F, 0xF7, 0xF8, 0x1F, 0xC3, 0xFC, 0x7F,
  0x87, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x3F, 0xC0, 0xFF, 0x3F, 0x87, 0xF0,
  0x0F, 0xE7, 0xF0, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xC0, 0x1F, 0xFF, 0x87,
  0xF8, 0x03, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xC0, 0x07, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF9, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xC0,
  0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF,
  0xE7, 0xE3, 0xF3, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0x8F, 0xC7,
  0xE3, 0xE1, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x08, 0x03, 0xE0, 0x03, 0x00, 0xF8, 0x00, 0xF0, 0x3E,
  0x00, 0x7F, 0x1F, 0x00, 0x1F, 0xF7, 0xC0, 0x07, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFE, 0x3F, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0x7C,
  0x00, 0x7F, 0x9F, 0x80, 0x3F, 0xC7, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xF8,
  0x3F, 0x00, 0x1C, 0x0F, 0xE0, 0x02, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0,
  0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x3F, 0x3F, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFB, 0xFD, 0xFC, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xF8,
  0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0x7F, 0x3F, 0xF7, 0xF0, 0xFF,
  0x3F, 0x83, 0xE1, 0xFC, 0x0E, 0x0F, 0xE0, 0x40, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0x81, 0xFF, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x40,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x7F,
  0x80, 0x18, 0x00, 0xFF, 0x00, 0x40, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x20, 0x00, 0x1F,
  0xE0, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFC,
  0xFE, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0E, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC1, 0x00, 0x03, 0xFE, 0x0F, 0x00, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xC0, 0x00,
  0xFE, 0x3F, 0xE0, 0x07, 0xE7, 0xFF, 0x80, 0x7F, 0x7F, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xF3, 0xFE, 0x0F, 0xFC, 0x07,
  0xF8, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFC,
  0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x03,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x03,
  0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03,
  0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07,
  0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0xE1, 0xFC, 0x01, 0xFC,
  0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7,
  0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xF3, 0xFC, 0x03,
  0xFE, 0x7F, 0x80, 0xFF, 0x8F, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFB, 0xF8, 0x1F, 0xFE, 0xFE, 0x01, 0xFF, 0x1F,
  0xC0, 0x03, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0x00, 0x3F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF8,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x01,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0x30, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xC0, 0x7F,
  0x86, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x40, 0x03, 0xF0, 0x7E, 0x00, 0xFF, 0xF0, 0x3E, 0x0F, 0x80, 0x7F,
  0xFF, 0x07, 0xC3, 0xF0, 0x1F, 0xFF, 0xE0, 0xF8, 0xFC, 0x07, 0xFF, 0xF8,
  0x1F, 0x1F, 0x81, 0xFC, 0x1F, 0x03, 0xE3, 0xE0, 0x7F, 0x03, 0xE0, 0x7C,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x9F, 0x03, 0xF0, 0x1F, 0x01, 0xF3, 0xE0,
  0x7C, 0x03, 0xE0, 0x3E, 0xFC, 0x1F, 0x80, 0x7C, 0x07, 0xDF, 0x03, 0xE0,
  0x1F, 0x80, 0xFB, 0xE0, 0x7C, 0x03, 0xE0, 0x3F, 0x7C, 0x1F, 0x80, 0x7C,
  0x07, 0xCF, 0x83, 0xF0, 0x1F, 0x80, 0xF9, 0xF0, 0x7C, 0x03, 0xF0, 0x3F,
  0x7E, 0x0F, 0x80, 0x7C, 0x07, 0xCF, 0xC1, 0xF0, 0x1F, 0x81, 0xF9, 0xF8,
  0x3E, 0x03, 0xF0, 0x3E, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xC7, 0xE0, 0xFC,
  0x3F, 0xE3, 0xF0, 0xFC, 0x1F, 0xFF, 0x7F, 0xFC, 0x0F, 0x81, 0xFF, 0xEF,
  0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3E, 0x01, 0xFC, 0x0F, 0xF0,
  0x07, 0xE0, 0x06, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x03,
  0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x3F,
  0x80, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x7C, 0x01,
  0xFF, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0x00, 0x3F, 0xF0, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xE1, 0xFF, 0xF0, 0x03, 0xF8, 0x07,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x0F,
  0xF0, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0x83, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xF0,
  0x07, 0xFE, 0x00, 0x0C, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0x1F,
  0xC0, 0x0F, 0xFF, 0xC7, 0xF0, 0x07, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xF8,
  0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0x8F, 0xF0, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF,
  0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x83, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x01, 0xFC, 0xFF,
  0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFB, 0xF8, 0x03, 0xFB,
  0xF0, 0x01, 0xFB, 0xF8, 0x03, 0xFB, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xFB,
  0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xF3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x07, 0xF3, 0xF0, 0x1F, 0x8F, 0xE0, 0x07, 0xE3,
  0xF0, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xF0, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1, 0xF0, 0x7E, 0x0F, 0xC0, 0x0F, 0xE1,
  0xF8, 0x7E, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1,
  0xF8, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xF9, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1,
  0xF9, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xFB, 0xF0, 0x3F, 0x80, 0x1F, 0x81,
  0xFB, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0x81,
  0xFF, 0xE0, 0x3F, 0x80, 0x3F, 0x81, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0x01,
  0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x01,
  0xFF, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x00,
  0x7E, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xE0,
  0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFC,
  0x01, 0xFB, 0xF0, 0x01, 0xFC, 0x01, 0xFB, 0xF8, 0x01, 0xF8, 0x01, 0xFB,
  0xF8, 0x03, 0xF8, 0x03, 0xFB, 0xF8, 0x03, 0xF8, 0x03, 0xF9, 0xF8, 0x03,
  0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0x03,
  0xF1, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x8F, 0xC0, 0x0F, 0xC0, 0x3F, 0x8F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xC0, 0x1F, 0x9F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xDF, 0xC0, 0x1F, 0x80, 0x1F, 0xDF, 0x80, 0x1F, 0x80, 0x1F,
  0xDF, 0x80, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFF, 0x80,
  0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xF0,
  0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0x81, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8,
  0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF8, 0x1F, 0x00, 0x7F, 0x80, 0x0C, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x08, 0x00, 0x07,
  0xF0, 0x18, 0x00, 0x3F, 0xC0, 0x7C, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F,
  0x01, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F,
  0x8F, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0xFC,
  0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xE7, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x00, 0xFC,
  0x0F, 0xE7, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xC7, 0xE0, 0xFF, 0x00, 0xFC,
  0x0F, 0xC7, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x00, 0xFC,
  0x1F, 0x87, 0xE1, 0xFC, 0x00, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x00, 0xFC,
  0x3F, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7F, 0x07, 0xE3, 0xF8, 0x00, 0xFC,
  0x7E, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x7E, 0x07, 0xE7, 0xF0, 0x00, 0xFC,
  0xFC, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x00, 0xFD,
  0xF8, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x00, 0xFD,
  0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x00,
  0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x03,
  0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFF,
  0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7C, 0x00, 0x1F, 0xC0, 0xFC, 0x01, 0xFF, 0x87, 0xE0, 0x0F, 0xFF, 0x1F,
  0x80, 0x7F, 0xFE, 0x7E, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F,
  0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC,
  0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFD, 0xF8, 0x03, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0x1F,
  0x80, 0x0F, 0xF0, 0x7E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x0F, 0xE3, 0xFF, 0x00, 0x7F, 0x3F, 0xFC, 0x03, 0xFB, 0xFF, 0xE0, 0x1F,
  0xBF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F,
  0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xF1,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xF9, 0xFF, 0xF8,
  0x0F, 0xC7, 0xFF, 0x80, 0x7C, 0x1F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xF0, 0x38, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x08, 0x1F, 0xE0, 0x18,
  0x0F, 0xFE, 0x7C, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0xE3, 0xF8, 0x00,
  0xFF, 0xF3, 0xF8, 0x01, 0xFF, 0xFB, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F,
  0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x7E, 0x00, 0x3F, 0xFE, 0x7E, 0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x0F,
  0xF8, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0x8F, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x9F, 0xE0, 0x7F, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x81, 0xFF,
  0x01, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x08, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x1F,
  0xFC, 0x7E, 0x00, 0x3F, 0xFC, 0x7E, 0x00, 0x7F, 0xFE, 0x7E, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xBF, 0x80, 0x07, 0xFF,
  0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x20, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x80, 0x01, 0xFE, 0x00, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xFF, 0x00, 0x7F, 0x3F, 0xFC,
  0x03, 0xFB, 0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFF, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0,
  0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x1F,
  0xE0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xE7, 0xF8,
  0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7E, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0x7F, 0xCF, 0xE0, 0x00,
  0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0,
  0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x87, 0xFE, 0x07, 0xFE,
  0x00, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x07, 0xE7, 0xFF, 0xC7, 0xFF, 0xE0,
  0x3F, 0x7F, 0xFF, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFC, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x07, 0xFC,
  0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xC3, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x80,
  0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0x1F,
  0x87, 0xFE, 0x00, 0xFC, 0x7F, 0xF8, 0x07, 0xE7, 0xFF, 0xE0, 0x3F, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x1F, 0xE0,
  0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F,
  0xE7, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x07, 0xF8, 0x3F, 0xF7, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x7E,
  0x3F, 0xFC, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x7E, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0,
  0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x0F, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF,
  0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0x00, 0x1F, 0xC7,
  0xFC, 0x00, 0x1F, 0xC0, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0xF8, 0x03, 0xFF, 0x8F, 0xC0, 0x3F, 0xFE, 0x7E, 0x03, 0xFF, 0xF3,
  0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0xFF, 0xC1,
  0xFE, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF0,
  0x03, 0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07,
  0xF1, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xBF, 0x00, 0xFF,
  0xFB, 0xF8, 0x03, 0xFF, 0x9F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x0E, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0xFE, 0x03, 0xF1, 0xFE, 0x03, 0xF3,
  0xFE, 0x03, 0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF7, 0xF0, 0x3F,
  0xC0, 0x38, 0x1F, 0xC0, 0x08, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x40, 0x03,
  0xFC, 0x30, 0x01, 0xFE, 0x1F, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x1F, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x60, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x01,
  0xFF, 0xC0, 0x03, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC,
  0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xE3, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x8F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x1F, 0xF0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFE, 0x07, 0xFE, 0x0F, 0xF9, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xEF, 0xC0, 0x7F, 0xFC, 0xFC, 0x07, 0xFF, 0x8F, 0xC0, 0x1F, 0xE0, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFF,
  0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x0F,
  0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03,
  0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0xC0, 0x1F, 0xDF,
  0x80, 0x3F, 0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F,
  0xF8, 0x0F, 0xF3, 0xF0, 0x0F, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xFE, 0x03,
  0xF8, 0xFC, 0x07, 0xDF, 0x03, 0xF8, 0x7E, 0x07, 0xEF, 0x81, 0xFC, 0x3F,
  0x03, 0xEF, 0xC1, 0xFC, 0x1F, 0x83, 0xF7, 0xE0, 0xFE, 0x0F, 0xC1, 0xFB,
  0xF0, 0x7E, 0x07, 0xE0, 0xF9, 0xF8, 0x7F, 0x03, 0xF0, 0xFC, 0xFC, 0x3F,
  0x81, 0xF8, 0x7C, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x3F, 0x1F, 0xC0, 0x7E,
  0x3F, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x0F, 0xCF, 0xE0, 0x1F, 0x9F, 0x87,
  0xE7, 0xE0, 0x0F, 0xCF, 0x83, 0xF7, 0xF0, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0x03, 0xF7, 0xE0, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xFC,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x80,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x23, 0xFF, 0x00, 0x05, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x80, 0x01, 0xFF, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_SemiBoldItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 17, 44, 16, 1, -43 },
  { 95, 20, 16, 25, 6, -43 },
  { 135, 34, 43, 35, 1, -43 },
  { 318, 29, 49, 30, 1, -46 },
  { 496, 40, 44, 46, 4, -43 },
  { 716, 35, 44, 37, 1, -43 },
  { 909, 9, 16, 14, 6, -43 },
  { 927, 20, 52, 18, 2, -43 },
  { 1057, 20, 52, 18, -4, -43 },
  { 1187, 26, 27, 29, 5, -46 },
  { 1275, 27, 29, 32, 3, -36 },
  { 1373, 13, 15, 15, -3, -7 },
  { 1398, 16, 6, 18, 1, -19 },
  { 1410, 9, 9, 15, 1, -8 },
  { 1421, 31, 43, 23, -3, -43 },
  { 1588, 28, 45, 30, 2, -44 },
  { 1746, 21, 43, 30, 6, -43 },
  { 1859, 31, 43, 30, -1, -43 },
  { 2026, 30, 44, 30, 0, -43 },
  { 2191, 31, 43, 30, -1, -43 },
  { 2358, 29, 44, 30, 1, -43 },
  { 2518, 29, 45, 30, 2, -44 },
  { 2682, 29, 43, 30, 3, -43 },
  { 2838, 29, 45, 30, 1, -44 },
  { 3002, 27, 45, 30, 2, -44 },
  { 3154, 15, 34, 15, 0, -33 },
  { 3218, 18, 41, 15, -3, -33 },
  { 3311, 27, 29, 32, 3, -36 },
  { 3409, 27, 18, 32, 3, -30 },
  { 3470, 27, 29, 32, 3, -36 },
  { 3568, 23, 44, 24, 3, -43 },
  { 3695, 43, 48, 46, 2, -43 },
  { 3953, 33, 43, 33, -4, -43 },
  { 4131, 32, 43, 33, 1, -43 },
  { 4303, 32, 44, 32, 3, -43 },
  { 4479, 34, 43, 36, 1, -43 },
  { 4662, 30, 43, 29, 1, -43 },
  { 4824, 30, 43, 28, 1, -43 },
  { 4986, 34, 44, 37, 3, -43 },
  { 5173, 37, 43, 38, 1, -43 },
  { 5372, 26, 43, 20, -2, -43 },
  { 5512, 27, 55, 17, -9, -43 },
  { 5698, 37, 43, 32, 1, -43 },
  { 5897, 22, 43, 27, 1, -43 },
  { 6016, 48, 43, 48, 1, -43 },
  { 6274, 40, 43, 40, 1, -43 },
  { 6489, 35, 45, 39, 3, -44 },
  { 6686, 32, 43, 32, 1, -43 },
  { 6858, 35, 54, 39, 3, -44 },
  { 7095, 31, 43, 33, 1, -43 },
  { 7262, 30, 44, 29, 0, -43 },
  { 7427, 28, 43, 28, 5, -43 },
  { 7578, 35, 44, 37, 3, -43 },
  { 7771, 32, 43, 32, 5, -43 },
  { 7943, 48, 43, 48, 6, -43 },
  { 8201, 39, 43, 31, -3, -43 },
  { 8411, 30, 43, 29, 5, -43 },
  { 8573, 34, 43, 28, -2, -43 },
  { 8756, 24, 53, 18, -1, -43 },
  { 8915, 13, 43, 23, 6, -43 },
  { 8985, 24, 53, 18, -4, -43 },
  { 9144, 28, 27, 30, 1, -43 },
  { 9239, 23, 4, 22, -5, 5 },
  { 9251, 11, 10, 18, 9, -46 },
  { 9265, 30, 34, 32, 2, -33 },
  { 9393, 29, 47, 32, 1, -46 },
  { 9564, 25, 34, 26, 2, -33 },
  { 9671, 32, 47, 32, 2, -46 },
  { 9859, 26, 34, 29, 2, -33 },
  { 9970, 33, 60, 19, -7, -46 },
  { 10218, 32, 47, 32, 0, -33 },
  { 10406, 29, 46, 32, 1, -46 },
  { 10573, 16, 45, 15, 1, -45 },
  { 10663, 25, 59, 16, -8, -45 },
  { 10848, 31, 46, 29, 1, -46 },
  { 11027, 17, 46, 15, 1, -46 },
  { 11125, 45, 33, 48, 1, -33 },
  { 11311, 29, 33, 32, 1, -33 },
  { 11431, 27, 34, 31, 2, -33 },
  { 11546, 32, 47, 32, -2, -33 },
  { 11734, 29, 47, 32, 2, -33 },
  { 11905, 24, 33, 22, 1, -33 },
  { 12004, 25, 34, 25, 0, -33 },
  { 12111, 19, 41, 20, 3, -40 },
  { 12209, 28, 34, 32, 3, -33 },
  { 12328, 27, 33, 27, 3, -33 },
  { 12440, 41, 33, 42, 4, -33 },
  { 12610, 33, 33, 28, -3, -33 },
  { 12747, 35, 47, 27, -5, -33 },
  { 12953, 27, 33, 24, -2, -33 },
  { 13065, 24, 52, 21, 0, -43 },
  { 13221, 6, 60, 29, 12, -46 },
  { 13266, 23, 52, 21, -3, -43 },
  { 13416, 27, 9, 32, 3, -26 },
};

const GFXfont NotoSans_SemiCondensed_SemiBoldItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_SemiBoldItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_SemiBoldItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_SEMIBOLDITALIC60PT7B_H_
