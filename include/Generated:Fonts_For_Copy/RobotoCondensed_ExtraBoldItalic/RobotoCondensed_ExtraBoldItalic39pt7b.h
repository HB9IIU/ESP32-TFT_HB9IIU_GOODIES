#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC39PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0xFC, 0x3F, 0x0F, 0x81, 0xC0,
  0x3C, 0xF7, 0x8F, 0x79, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xEF, 0x1C,
  0xF1, 0xCF, 0x3C, 0xE3, 0xC0, 0x00, 0x39, 0xE0, 0x07, 0x9E, 0x00, 0x79,
  0xC0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x0F, 0x38, 0x00, 0xE7, 0x80, 0x0E,
  0x78, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x3C, 0xE0, 0x03,
  0xCE, 0x00, 0x39, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xC0, 0x07, 0x3C, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x0E, 0x78, 0x01, 0xE7, 0x00,
  0x1E, 0x70, 0x01, 0xCF, 0x00, 0x3C, 0xE0, 0x03, 0xCE, 0x00, 0x39, 0xE0,
  0x07, 0x9E, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0xC7, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xF0, 0x87, 0x9E, 0x3C,
  0xE3, 0xC7, 0x1C, 0x79, 0xE7, 0x8F, 0x78, 0xF1, 0xEE, 0x0F, 0x7B, 0xC1,
  0xFF, 0xF0, 0x1F, 0xDC, 0x01, 0xE7, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x78, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1D, 0xEF, 0x07, 0xBC, 0xF1,
  0xEF, 0x1E, 0x39, 0xE3, 0xCF, 0x3C, 0x7B, 0xC7, 0x8E, 0x30, 0x7B, 0xC0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7C, 0x78, 0x07, 0xC7,
  0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF1, 0xF1, 0xFF, 0x9F, 0x3F,
  0xF9, 0xF7, 0xEF, 0xDF, 0x7E, 0x7F, 0xE7, 0xE7, 0xFE, 0x7C, 0x3F, 0xE7,
  0xC3, 0xFC, 0x7E, 0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xF7, 0xE0, 0x7E, 0x7E, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0xF3,
  0xCF, 0x00, 0x00, 0x20, 0x06, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0C,
  0x00, 0x40, 0x01, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3C, 0x01, 0xC0, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x03, 0x8E, 0x3B, 0xF7, 0xFD, 0xFF, 0xFF,
  0x1F, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xEF, 0x03, 0xE3,
  0xC1, 0xE1, 0xE0, 0x60, 0x70, 0x10, 0x20, 0x00, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0xF8, 0xF0, 0x20,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xEF, 0xFC, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0xFC,
  0x3E, 0x7E, 0x1F, 0xBE, 0x0F, 0xDF, 0x07, 0xDF, 0x83, 0xEF, 0xC1, 0xF7,
  0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F, 0x3E, 0x0F,
  0x9F, 0x0F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE3, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x30, 0x0F, 0x07,
  0xF1, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xEF, 0x7E, 0xC7, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x9F, 0x87,
  0xE1, 0xF8, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0xC1, 0xF8, 0xF8,
  0x3F, 0x1F, 0x8F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7B, 0xF0, 0x3E, 0xFC, 0x0F, 0x3E, 0x07, 0xCF, 0x83,
  0xE7, 0xE0, 0xF9, 0xF8, 0x7C, 0x7E, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xBE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE,
  0x1F, 0xDF, 0xC0, 0x43, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xBC, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xF8, 0xFE, 0xFC, 0x3F, 0x7C, 0x1F, 0xBE, 0x0F,
  0xDF, 0x07, 0xEF, 0x83, 0xF7, 0xC1, 0xF3, 0xE1, 0xF9, 0xF0, 0xFC, 0xFF,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF9, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x3E, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xEF, 0xCF, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x8F, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xF8, 0x7B, 0xF0, 0x07, 0xC0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0x0F, 0xCF, 0xE3, 0xF1, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x87,
  0x80, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x03, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00,
  0xF8, 0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0, 0xFE, 0x01,
  0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x70, 0x00, 0x20, 0x1F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xE3, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF0, 0x10,
  0x00, 0x30, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x0F, 0xF8, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0xF8, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x03,
  0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C,
  0x3E, 0xFC, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0xF8, 0x01, 0xF8, 0x03,
  0xC0, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x0F,
  0x83, 0xE0, 0xE0, 0xF0, 0xFF, 0x8E, 0x1E, 0x1F, 0xF8, 0xF1, 0xE3, 0xF7,
  0x8F, 0x3C, 0x3C, 0x78, 0xF3, 0xC7, 0x87, 0x8F, 0x3C, 0x78, 0x78, 0xF3,
  0x8F, 0x8F, 0x0E, 0x78, 0xF0, 0xF0, 0xE7, 0x8F, 0x0F, 0x0E, 0x78, 0xF0,
  0xF0, 0xE7, 0x1F, 0x1E, 0x1E, 0x71, 0xF1, 0xE1, 0xC7, 0x1F, 0x1E, 0x1C,
  0xF1, 0xF3, 0xE3, 0x87, 0x0F, 0xFE, 0x78, 0x70, 0xFF, 0xFF, 0x07, 0x0F,
  0xEF, 0xE0, 0x70, 0x78, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x08, 0x00, 0x1F,
  0xEF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7C, 0x01, 0xF9,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xE0, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xFC, 0x03,
  0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE1, 0xFC, 0x3F, 0x07,
  0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F,
  0x1F, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8,
  0x7E, 0x07, 0xC7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF9, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xE3, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x3E, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xE1, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x0F,
  0xF9, 0xF8, 0xFF, 0xCF, 0xC7, 0xFE, 0x7E, 0x3F, 0xF3, 0xF0, 0x3F, 0x1F,
  0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xFC, 0x3F,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0x83,
  0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFF, 0x07, 0xC0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xC3, 0xF8,
  0x0F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xCF, 0xE0, 0x0F, 0x8F, 0xC0,
  0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x00, 0x7F, 0x3F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xF7, 0x87,
  0xFF, 0x07, 0xDE, 0x1F, 0xFC, 0x1F, 0x78, 0x7B, 0xE0, 0xFD, 0xE3, 0xEF,
  0x83, 0xF7, 0x8F, 0x7E, 0x0F, 0xDE, 0x7D, 0xF8, 0x3F, 0x79, 0xF7, 0xE0,
  0xFD, 0xF7, 0x9F, 0x83, 0xE3, 0xFE, 0x7C, 0x1F, 0x8F, 0xF3, 0xF0, 0x7E,
  0x3F, 0xCF, 0xC1, 0xF8, 0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC3, 0xE0, 0x7E, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x7E, 0x0F, 0xC3, 0xE1,
  0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xE0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F,
  0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0xFC, 0x1F,
  0xF8, 0xFC, 0x1F, 0xF8, 0xFC, 0x1F, 0xBC, 0xFC, 0x3F, 0x3C, 0xFC, 0x3F,
  0x3C, 0xF8, 0x3F, 0x3D, 0xF8, 0x3F, 0x1F, 0xF8, 0x3F, 0x1F, 0xF8, 0x3F,
  0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E,
  0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xFC, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00,
  0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xE0, 0x1F, 0x9F,
  0x00, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0,
  0x00, 0x02, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8,
  0x7F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7E, 0x1F, 0x83, 0xF1, 0xF0,
  0x3F, 0x1F, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F,
  0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F,
  0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0xF9, 0xF8, 0x07, 0xCF, 0xC0,
  0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x07, 0xFF,
  0x83, 0xE0, 0xFF, 0xF0, 0xFC, 0x3F, 0x7E, 0x1F, 0x87, 0xEF, 0xC3, 0xF0,
  0xFD, 0xF8, 0xFE, 0x1F, 0x3F, 0x1F, 0xC7, 0xE7, 0xE3, 0xF8, 0xFC, 0xFC,
  0xFF, 0x1F, 0x1F, 0x9F, 0xE7, 0xE3, 0xF3, 0xFC, 0xFC, 0x7E, 0xFF, 0x9F,
  0x0F, 0xDF, 0xF7, 0xE1, 0xFB, 0xFE, 0xFC, 0x3F, 0xFB, 0xDF, 0x03, 0xFF,
  0x7B, 0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0x3F, 0xE0,
  0x3F, 0xE7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01,
  0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x03, 0xF1, 0xFC, 0x03, 0xF1,
  0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x01, 0xF7, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xEF, 0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0xCF,
  0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0x07, 0xE0, 0x7F, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0xFC, 0x03, 0xF7, 0xE0, 0x7F,
  0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8, 0x3E, 0x1F,
  0x83, 0xE3, 0xF0, 0x3E, 0x3F, 0x03, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xFF,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C,
  0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xF0, 0x3D, 0xC0, 0xF7, 0x07, 0xDE, 0x1E, 0x78, 0xF9, 0xE3, 0xC7,
  0x9F, 0x1E, 0x78, 0x7B, 0xE1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xEF, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xFB, 0xF1, 0xF8, 0xF8,
  0xFC, 0x7C, 0x00, 0x3E, 0x03, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xE7,
  0xE7, 0xE3, 0xF7, 0xE1, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFE, 0xFE, 0x7F,
  0xFF, 0x1F, 0xFF, 0x87, 0xFF, 0xC1, 0xF7, 0xE0, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0xBE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x87, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0x83,
  0xF3, 0xE0, 0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9,
  0xF8, 0x7C, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xEF, 0xF0, 0xF8,
  0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE,
  0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFF, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xCF, 0xC3, 0xFD, 0xF0, 0xFF, 0xBE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFC, 0x7F, 0x1F, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x3F,
  0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C,
  0x3E, 0x1F, 0x87, 0xE3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFE, 0x01, 0xE7, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFF, 0x7E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x18, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x00, 0x03, 0xE3, 0xE0, 0xFE, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF,
  0xC1, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F,
  0x07, 0xE3, 0xF0, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xFB, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x81, 0x03, 0xF0, 0x7F,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xBE, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF,
  0xF1, 0xFF, 0xF9, 0xF8, 0xFC, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E, 0x1F, 0x9F,
  0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xF3, 0xF0, 0xF9, 0xF0, 0xFC,
  0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x9F, 0x87, 0xCF, 0x87,
  0xE0, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x0F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0xFF, 0x83,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0x9F, 0xC1, 0xFB,
  0xF8, 0x1F, 0x7F, 0x01, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0,
  0x1F, 0xBE, 0x1F, 0x07, 0xFF, 0xCF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xC7, 0xF1, 0xF3, 0xF1, 0xF8, 0x7C, 0xFC,
  0x7E, 0x1F, 0x3F, 0x1F, 0x87, 0xCF, 0x87, 0xE3, 0xF3, 0xE1, 0xF8, 0xFD,
  0xF8, 0x7C, 0x3F, 0x7E, 0x1F, 0x0F, 0xDF, 0x8F, 0xC3, 0xE7, 0xE3, 0xF0,
  0xF9, 0xF0, 0xFC, 0x7E, 0x7C, 0x3F, 0x1F, 0xBF, 0x0F, 0x87, 0xEF, 0xC3,
  0xE1, 0xFB, 0xF1, 0xF8, 0x7C, 0xFC, 0x7E, 0x1F, 0x00, 0x1F, 0x3E, 0x0F,
  0xBF, 0x87, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9, 0xF8, 0xFC, 0xFC, 0x3E,
  0x7E, 0x1F, 0x3E, 0x1F, 0x9F, 0x0F, 0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1,
  0xF3, 0xF0, 0xF9, 0xF0, 0xFC, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF,
  0x0F, 0x9F, 0x87, 0xCF, 0x87, 0xE0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xFF, 0xE3, 0xFF, 0xF3, 0xF1, 0xF9, 0xF8, 0x7D, 0xF8, 0x3F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xBF, 0x07, 0xDF, 0x83, 0xEF, 0x83, 0xF7, 0xC1, 0xFB,
  0xE0, 0xFD, 0xF8, 0xFC, 0xFF, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE,
  0x00, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0x3C, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xCF, 0x87, 0xFB, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC, 0x3F,
  0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F,
  0x87, 0xE3, 0xF1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1E, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xBC,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xF1, 0xF1, 0xF8, 0xF8,
  0xF8, 0x7E, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xF3, 0xE1, 0xF9, 0xF0, 0xFC, 0xFC, 0x7E, 0x3F,
  0xFE, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF8, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xE7, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07,
  0xC0, 0xFF, 0x1F, 0xE3, 0xF8, 0x3F, 0x03, 0xE0, 0x3F, 0x0F, 0xCF, 0xC3,
  0xE3, 0xE1, 0xF8, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9,
  0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC,
  0x3F, 0x3F, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x3E, 0x7C, 0x00, 0xFC, 0x3F, 0xFC, 0x3F,
  0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0xFC, 0x7C, 0xFC, 0x7C, 0xF8,
  0x7D, 0xF8, 0x7D, 0xF0, 0x7D, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0xFC, 0x78, 0x7F, 0xF8, 0xF0, 0xFB, 0xE3, 0xE1, 0xF7, 0xC7,
  0xE7, 0xEF, 0x8F, 0xCF, 0x9F, 0x3F, 0x9F, 0x3E, 0x7F, 0x7E, 0x7C, 0xFE,
  0xF8, 0xFB, 0xFD, 0xF1, 0xF7, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFD, 0xFF,
  0x0F, 0xFB, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xC0,
  0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x87, 0xE1, 0xF1, 0xF8, 0x3E, 0x3F, 0x07, 0xEF,
  0xC0, 0xFD, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xE7, 0xC1, 0xF8, 0xF8,
  0x7F, 0x1F, 0x8F, 0xC3, 0xF0, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F,
  0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xFB,
  0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x20, 0x0E, 0x01, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xC0,
  0x0C, 0x00, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78,
  0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x02,
  0x00, 0x70, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03,
  0xF0, 0x1E, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x0F, 0x80, 0xF8, 0x0E, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0xF3,
  0xFC, 0x3D, 0xFF, 0x8F, 0x7F, 0xFF, 0xDE, 0x3F, 0xEF, 0x8F, 0xFB, 0xC1,
  0xFC, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 28, 10, 1, -28 },
  { 36, 12, 11, 12, 2, -29 },
  { 53, 20, 28, 20, 0, -28 },
  { 123, 18, 36, 19, 1, -32 },
  { 204, 19, 28, 24, 3, -28 },
  { 271, 20, 28, 22, 0, -28 },
  { 341, 6, 11, 6, 2, -29 },
  { 350, 12, 40, 12, 2, -31 },
  { 410, 13, 40, 12, -2, -31 },
  { 475, 17, 17, 17, 2, -28 },
  { 512, 16, 20, 18, 1, -22 },
  { 552, 8, 12, 10, -2, -5 },
  { 564, 11, 5, 15, 2, -15 },
  { 571, 6, 6, 11, 1, -6 },
  { 576, 18, 30, 12, -3, -28 },
  { 644, 17, 28, 19, 2, -28 },
  { 704, 12, 28, 19, 4, -28 },
  { 746, 19, 28, 19, 0, -28 },
  { 813, 19, 28, 19, 0, -28 },
  { 880, 18, 28, 19, 1, -28 },
  { 943, 18, 28, 19, 1, -28 },
  { 1006, 17, 28, 19, 1, -28 },
  { 1066, 19, 28, 19, 1, -28 },
  { 1133, 18, 28, 19, 1, -28 },
  { 1196, 15, 28, 19, 3, -28 },
  { 1249, 9, 21, 11, 1, -21 },
  { 1273, 12, 28, 10, -2, -21 },
  { 1315, 15, 18, 17, 1, -21 },
  { 1349, 17, 14, 19, 1, -19 },
  { 1379, 15, 19, 17, 1, -21 },
  { 1415, 16, 28, 17, 2, -28 },
  { 1471, 28, 36, 29, 0, -27 },
  { 1597, 22, 28, 23, -2, -28 },
  { 1674, 21, 28, 21, 0, -28 },
  { 1748, 21, 28, 22, 1, -28 },
  { 1822, 21, 28, 21, 0, -28 },
  { 1896, 21, 28, 19, 0, -28 },
  { 1970, 20, 28, 18, 0, -28 },
  { 2040, 21, 28, 22, 1, -28 },
  { 2114, 24, 28, 23, 0, -28 },
  { 2198, 11, 28, 10, 0, -28 },
  { 2237, 19, 28, 19, 0, -28 },
  { 2304, 24, 28, 21, 0, -28 },
  { 2388, 16, 28, 18, 0, -28 },
  { 2444, 30, 28, 29, 0, -28 },
  { 2549, 24, 28, 23, 0, -28 },
  { 2633, 21, 28, 23, 1, -28 },
  { 2707, 22, 28, 22, 0, -28 },
  { 2784, 21, 33, 23, 1, -28 },
  { 2871, 21, 28, 21, 0, -28 },
  { 2945, 20, 28, 21, 1, -28 },
  { 3015, 20, 28, 21, 3, -28 },
  { 3085, 22, 28, 22, 1, -28 },
  { 3162, 21, 28, 22, 3, -28 },
  { 3236, 27, 28, 28, 3, -28 },
  { 3331, 24, 28, 21, -1, -28 },
  { 3415, 20, 28, 21, 3, -28 },
  { 3485, 23, 28, 20, -1, -28 },
  { 3566, 14, 39, 10, -1, -32 },
  { 3635, 10, 30, 15, 3, -28 },
  { 3673, 13, 39, 10, -2, -32 },
  { 3737, 14, 14, 15, 1, -28 },
  { 3762, 15, 5, 15, -2, 0 },
  { 3772, 9, 6, 13, 4, -29 },
  { 3779, 17, 21, 18, 0, -21 },
  { 3824, 18, 29, 19, 0, -29 },
  { 3890, 16, 21, 17, 1, -21 },
  { 3932, 19, 29, 19, 1, -29 },
  { 4001, 16, 21, 18, 1, -21 },
  { 4043, 14, 29, 12, 1, -29 },
  { 4094, 19, 29, 19, 0, -21 },
  { 4163, 17, 29, 19, 0, -29 },
  { 4225, 10, 29, 10, 0, -29 },
  { 4262, 14, 37, 9, -4, -29 },
  { 4327, 20, 29, 18, 0, -29 },
  { 4400, 11, 29, 10, 0, -29 },
  { 4440, 26, 21, 28, 0, -21 },
  { 4509, 17, 21, 19, 0, -21 },
  { 4554, 17, 21, 19, 1, -21 },
  { 4599, 20, 29, 19, -2, -21 },
  { 4672, 18, 29, 19, 1, -21 },
  { 4738, 14, 21, 13, 0, -21 },
  { 4775, 17, 21, 17, 0, -21 },
  { 4820, 11, 26, 12, 1, -26 },
  { 4856, 18, 21, 19, 1, -21 },
  { 4904, 16, 21, 17, 2, -21 },
  { 4946, 23, 21, 24, 2, -21 },
  { 5007, 19, 21, 17, -1, -21 },
  { 5057, 20, 29, 17, -1, -21 },
  { 5130, 18, 21, 17, -1, -21 },
  { 5178, 12, 37, 11, 1, -30 },
  { 5234, 8, 33, 10, 1, -28 },
  { 5267, 12, 37, 11, -1, -30 },
  { 5323, 18, 9, 21, 1, -16 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC39PT7B_H_
