#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC25PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC0,
  0x00, 0x1C, 0x78, 0xF0, 0xE0, 0x77, 0x77, 0x66, 0x66, 0x66, 0xEE, 0xCC,
  0x03, 0x30, 0x1B, 0x80, 0xD8, 0x0E, 0xC0, 0x66, 0x1F, 0xFC, 0xFF, 0xC1,
  0x98, 0x0D, 0xC0, 0xEC, 0x06, 0x60, 0xFF, 0xCF, 0xFE, 0x19, 0x80, 0xDC,
  0x06, 0xC0, 0x76, 0x03, 0x30, 0x00, 0x01, 0x00, 0x20, 0x0C, 0x07, 0xC1,
  0xFC, 0x7F, 0xCF, 0x79, 0xCF, 0x79, 0xE7, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF7, 0x1E, 0xE3, 0xDE, 0x7B, 0xFE, 0x3F, 0x83, 0xE0, 0x30,
  0x06, 0x00, 0x3C, 0x07, 0xC0, 0xEE, 0x6E, 0x66, 0xEE, 0xCE, 0xFC, 0x7D,
  0x83, 0xB0, 0x07, 0x00, 0x60, 0x0D, 0xE1, 0xFF, 0x3B, 0x73, 0x73, 0x67,
  0x76, 0x77, 0x03, 0xE0, 0x1C, 0x03, 0x80, 0x7E, 0x03, 0xF8, 0x39, 0xC1,
  0xCE, 0x0E, 0x70, 0x77, 0x03, 0xF0, 0x0F, 0x01, 0xF9, 0xDF, 0xEE, 0xEF,
  0xFF, 0x3F, 0x79, 0xFB, 0xC7, 0x8F, 0xFC, 0x7F, 0xF1, 0xF7, 0x80, 0x77,
  0x76, 0x66, 0xE0, 0x02, 0x07, 0x0E, 0x0E, 0x1C, 0x38, 0x38, 0x38, 0x70,
  0x70, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x60, 0x70, 0x70, 0x30, 0x10, 0x08, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0xF0, 0xE0, 0x80, 0x07, 0x00, 0xC0, 0x18, 0x33,
  0x3F, 0xFE, 0x7F, 0x87, 0x81, 0xF8, 0x73, 0x0E, 0x70, 0x84, 0x00, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1C, 0x07, 0x03,
  0xC0, 0xF0, 0x3C, 0x00, 0x39, 0xCE, 0xE7, 0x7B, 0x88, 0x7E, 0xFD, 0xF8,
  0x73, 0xDE, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x1C,
  0xF7, 0x9E, 0xF3, 0xDC, 0x7B, 0x8F, 0xF1, 0xFE, 0x3B, 0xC7, 0x78, 0xEE,
  0x3D, 0xC7, 0xBC, 0xE3, 0xFC, 0x7F, 0x07, 0xC0, 0x02, 0x3D, 0xFF, 0xFF,
  0xE3, 0xC7, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C, 0x78, 0xF0,
  0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0xF3, 0x8F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0xFE,
  0xFF, 0xCF, 0xFC, 0x07, 0xC1, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0xF0, 0x0F,
  0x00, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xEF, 0x1E,
  0xF3, 0xC7, 0xFC, 0x7F, 0x81, 0xE0, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xDE, 0x1D, 0xC3, 0x9C, 0x73, 0xC7, 0xFE,
  0xFF, 0xEF, 0xFE, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x1F, 0xE7, 0xFC,
  0xFF, 0x9C, 0x03, 0x80, 0xF0, 0x1D, 0xC3, 0xFC, 0x7F, 0xC2, 0x78, 0x0F,
  0x01, 0xE0, 0x3D, 0xC7, 0xBC, 0xE7, 0xFC, 0x7F, 0x07, 0xC0, 0x03, 0xC3,
  0xF1, 0xFC, 0x78, 0x3C, 0x1E, 0x07, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0x1F,
  0xC7, 0xF1, 0xFC, 0xFF, 0x3D, 0xFE, 0x7F, 0x0F, 0x80, 0x7F, 0xF7, 0xFF,
  0x7F, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0xF7, 0x9E, 0xF3, 0xCE, 0x71, 0xFE, 0x3F,
  0x8F, 0xF3, 0xCE, 0x79, 0xEE, 0x3D, 0xC7, 0xBD, 0xE7, 0xFC, 0x7F, 0x07,
  0xC0, 0x1E, 0x0F, 0xE7, 0xFB, 0xCE, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xF3,
  0xFF, 0xE7, 0xF9, 0xFE, 0x07, 0x03, 0xC1, 0xE3, 0xF0, 0xF8, 0x38, 0x00,
  0x3B, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x39, 0xEF, 0x70, 0x0C, 0x3C, 0x78,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x87, 0x0E, 0x38, 0x71,
  0xC1, 0x00, 0x00, 0x40, 0x38, 0x1F, 0x0F, 0xE7, 0xF0, 0xF8, 0x1E, 0x07,
  0xF0, 0x3F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x7F, 0xCF, 0xF9, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xBF, 0xE7, 0xFC, 0x20, 0x0E, 0x03, 0xE0, 0xFE, 0x0F,
  0xC0, 0xF0, 0x7C, 0x7F, 0x7F, 0x1F, 0x07, 0x02, 0x00, 0x3E, 0x3F, 0xBF,
  0xFE, 0xFE, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x0E, 0x0F, 0x00, 0x00,
  0x01, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x78,
  0x70, 0x38, 0x0E, 0x1C, 0x01, 0x86, 0x1C, 0x63, 0x9F, 0xCC, 0xCF, 0x73,
  0x73, 0x98, 0xDD, 0xC6, 0x76, 0x73, 0x9D, 0x9C, 0xE6, 0xE6, 0x31, 0xB9,
  0x9C, 0xEE, 0x77, 0x33, 0x9F, 0xF8, 0xE3, 0x9C, 0x18, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x60, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x81, 0xDE,
  0x0F, 0x38, 0x38, 0xE1, 0xE3, 0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xF7, 0x83,
  0xDE, 0x0F, 0x78, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x78,
  0xF3, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0xFE, 0x3F, 0xE3, 0xFF, 0x1E, 0x3C,
  0xF0, 0xE7, 0x8F, 0x3C, 0x79, 0xC7, 0xDF, 0xFC, 0xFF, 0xE7, 0xFC, 0x00,
  0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x78, 0xF7, 0x87, 0xBC, 0x3D, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0x78, 0x7B, 0xC7,
  0x8F, 0xFC, 0x7F, 0xC0, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x79,
  0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x38, 0x7B, 0xC3, 0xDE, 0x1E,
  0xF0, 0xE7, 0x8F, 0x3C, 0x79, 0xC7, 0x9F, 0xFC, 0xFF, 0xC7, 0xF8, 0x00,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0xFC, 0x3F, 0xE3, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1F, 0xFC, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE3, 0xFF, 0x1F, 0xF0,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0xFF, 0x87, 0xFC, 0x78, 0xF7, 0x87, 0xBC, 0x3D, 0xE0, 0x0E,
  0x00, 0xF3, 0xFF, 0x9F, 0xBC, 0xFD, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xE7,
  0xCF, 0xFC, 0x3F, 0xE0, 0xFC, 0x00, 0x1E, 0x0E, 0x3C, 0x3C, 0x70, 0x79,
  0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x0F, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF,
  0xF9, 0xE0, 0xF3, 0xC1, 0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xE0, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x71, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0xF1, 0xE0, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0xF1, 0xCF, 0x3C, 0xF3, 0xC7, 0xF8, 0x7F, 0x03, 0xE0, 0x1E,
  0x3E, 0x1E, 0x3C, 0x1C, 0x7C, 0x3C, 0xF8, 0x3C, 0xF0, 0x3D, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x79,
  0xE0, 0x79, 0xE0, 0x71, 0xE0, 0xF1, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1E,
  0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x03,
  0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F,
  0x8E, 0xC7, 0xF1, 0xD8, 0xFE, 0x3B, 0x3B, 0x8F, 0x77, 0x71, 0xEE, 0xFE,
  0x3D, 0xFB, 0xC7, 0xBF, 0x78, 0xF7, 0xCF, 0x1C, 0xF9, 0xC7, 0x9E, 0x78,
  0xF1, 0xCF, 0x1E, 0x31, 0xE0, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xF8,
  0xF3, 0xF1, 0xE7, 0xE3, 0x8F, 0xCF, 0x1F, 0xDE, 0x3B, 0xBC, 0xF3, 0x79,
  0xE6, 0xF3, 0xCF, 0xC7, 0x9F, 0x8F, 0x3F, 0x1C, 0x3E, 0x78, 0x7C, 0xF0,
  0xF9, 0xE1, 0xE0, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF7, 0x87, 0xBC,
  0x3D, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xEF, 0x0F,
  0x78, 0x7B, 0xE7, 0x8F, 0xFC, 0x3F, 0xC0, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x8F, 0x1E, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x38,
  0x79, 0xFF, 0xC7, 0xFF, 0x1F, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF7,
  0x87, 0xBC, 0x3D, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xEF, 0x0F, 0x78, 0x7B, 0xE7, 0x8F, 0xFC, 0x3F, 0xC0, 0xFE, 0x00, 0xF8,
  0x03, 0xC0, 0x08, 0x00, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x8F, 0x1E, 0x3C,
  0x38, 0xF0, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0xF9, 0xFF, 0xC7, 0xFE, 0x1F,
  0xF0, 0x79, 0xC1, 0xE7, 0x87, 0x1E, 0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xC0,
  0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x3C, 0xF3, 0xC3, 0x9E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xEF, 0x0F, 0x38, 0x79, 0xE7,
  0xCF, 0xFC, 0x3F, 0xC0, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x00,
  0x3C, 0x38, 0xF1, 0xE3, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87,
  0x1E, 0x3C, 0x70, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0xF0, 0x7B, 0xC1, 0xEF,
  0x0F, 0xBC, 0x3C, 0xF0, 0xF3, 0xC7, 0x87, 0x1E, 0x1C, 0x70, 0x73, 0xC1,
  0xCF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x00, 0xF1, 0xC7, 0xF8, 0xE3, 0xFC, 0xF1, 0xFE, 0x79,
  0xEF, 0x3C, 0xF7, 0xBE, 0x7B, 0xDF, 0x39, 0xEF, 0xBC, 0xFF, 0xDE, 0x7F,
  0xEE, 0x3F, 0xFF, 0x1F, 0xBF, 0x8F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1,
  0xF1, 0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x00, 0x1E, 0x1F, 0x0F, 0x1E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x07, 0x78, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x7F, 0x87, 0x9C, 0x3C,
  0xE3, 0xC7, 0x9C, 0x3D, 0xE0, 0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0x87, 0xC3,
  0xE1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF0,
  0x78, 0x00, 0xF3, 0xCF, 0x3C, 0xF1, 0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x38,
  0xE3, 0x8F, 0x3C, 0xF3, 0xCF, 0x1F, 0x1F, 0x1F, 0x0F, 0x0F, 0x0E, 0x0E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x38, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0x0E, 0x1E, 0x1E, 0x3E, 0x3F, 0x77,
  0x77, 0xE3, 0xE3, 0x7F, 0xDF, 0xF7, 0xFC, 0x78, 0xE3, 0x87, 0x0F, 0x83,
  0xF8, 0xFF, 0x3C, 0xF0, 0x1C, 0x3F, 0x9F, 0xF3, 0xDE, 0xF3, 0xDE, 0x7B,
  0xFF, 0x3F, 0xC3, 0xBC, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78,
  0x0F, 0xF1, 0xFF, 0x3F, 0xE7, 0x1D, 0xE3, 0xBC, 0x77, 0x8E, 0xE3, 0xDC,
  0x7F, 0x8F, 0xFF, 0xDF, 0xFB, 0x9C, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x3C,
  0xF7, 0x9E, 0xE0, 0x1C, 0x07, 0x80, 0xF3, 0xCE, 0x79, 0xFE, 0x3F, 0xC1,
  0xE0, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x7B,
  0xC7, 0xFE, 0x3F, 0xE3, 0xCF, 0x1E, 0x78, 0xE3, 0xC7, 0x1E, 0x78, 0xF3,
  0xC7, 0x1E, 0x78, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x0F, 0x83, 0xF8, 0xFF,
  0xBC, 0xF7, 0x8E, 0xFF, 0xDF, 0xFB, 0xFF, 0x70, 0x0F, 0x11, 0xFF, 0x1F,
  0xE1, 0xF0, 0x07, 0x8F, 0xC7, 0xC7, 0x83, 0xC1, 0xE3, 0xF9, 0xFC, 0xFE,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x00,
  0x0F, 0x73, 0xFF, 0x3F, 0xF7, 0x8F, 0x78, 0xE7, 0x0E, 0x71, 0xE7, 0x1E,
  0xF1, 0xE7, 0x1C, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0x3C, 0x47, 0xCF, 0xF8,
  0xFF, 0x07, 0xE0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0xF1, 0xFF, 0x3F, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E, 0xE3, 0xDC, 0x77,
  0x8E, 0xF3, 0xDE, 0x7B, 0x8F, 0x00, 0x0C, 0x3C, 0x78, 0xE0, 0x07, 0x8F,
  0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x78, 0xF1, 0xE0, 0x01, 0x80,
  0xF0, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0xFC,
  0x3E, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xF3, 0xC7, 0x3C, 0x3B, 0xE3, 0xDE, 0x1F, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x1E, 0x70, 0xF3, 0xC7, 0x9E, 0x3C, 0xF0, 0x1E, 0x3C,
  0x78, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8F, 0x1C, 0x38,
  0xF1, 0xE3, 0xC0, 0x3F, 0xCF, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0x3C, 0xF7,
  0x9E, 0x7B, 0xCF, 0x3D, 0xE7, 0x9E, 0xE3, 0x8E, 0x71, 0xC7, 0x79, 0xE7,
  0xBC, 0xF3, 0xDE, 0x79, 0xEF, 0x3C, 0xF0, 0x3B, 0xC7, 0xFC, 0xFF, 0xBC,
  0xF7, 0x9E, 0xF3, 0xDE, 0x7B, 0x8F, 0x71, 0xDE, 0x3B, 0xCF, 0x79, 0xEF,
  0x3C, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0xF7, 0x8E, 0xE1, 0xDC, 0x3B, 0x8F,
  0x71, 0xEE, 0x39, 0xFF, 0x1F, 0xC1, 0xF0, 0x1D, 0xE1, 0xFF, 0x1F, 0xF1,
  0xCF, 0x3C, 0x73, 0xC7, 0x3C, 0x73, 0x8F, 0x38, 0xF7, 0x8F, 0x7F, 0xE7,
  0xFC, 0x7B, 0x87, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0xF3,
  0xFF, 0x3F, 0xE7, 0x9E, 0x79, 0xE7, 0x1E, 0x71, 0xEF, 0x1E, 0xF1, 0xCF,
  0x3C, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x3F, 0x9F, 0xCF, 0xC7, 0xE7, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78,
  0x3C, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0xF8, 0xFF, 0x3C, 0xF7, 0x80, 0x7C,
  0x0F, 0xC0, 0x7C, 0x03, 0xDC, 0x7B, 0xFE, 0x3F, 0xC3, 0xE0, 0x3C, 0x78,
  0xE7, 0xFF, 0xFF, 0xDE, 0x3C, 0x70, 0xE3, 0xC7, 0x8F, 0x1F, 0x3E, 0x3C,
  0x79, 0xEE, 0x3D, 0xC7, 0xF8, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x1E, 0xE3,
  0x9C, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0xF1, 0xFE, 0x7B, 0xCF, 0x39, 0xC7,
  0x78, 0xEE, 0x1D, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x03, 0x80,
  0xF3, 0x9F, 0xE7, 0x3B, 0xDE, 0x77, 0xBD, 0xE7, 0x7B, 0x8F, 0xF7, 0x1F,
  0x7E, 0x3E, 0xF8, 0x7D, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1C,
  0x00, 0x1C, 0xF0, 0xE7, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x81, 0xFE, 0x0E, 0xF0, 0xF3, 0x8F, 0x1C, 0x00, 0x3C,
  0x79, 0xE7, 0x8F, 0x3C, 0x3B, 0xC1, 0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xFE, 0x7F, 0xCF, 0xF8, 0x03,
  0x07, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x78, 0x70, 0x70,
  0x78, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x38, 0x38, 0x10, 0x0C,
  0x71, 0x86, 0x18, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x30, 0xC7, 0x18, 0x61,
  0x86, 0x18, 0xE0, 0x08, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E,
  0x0E, 0x0F, 0x07, 0x1F, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70,
  0xE0, 0x40, 0x38, 0x6F, 0x8D, 0xFB, 0xF3, 0xFE, 0x7D, 0x87, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 18, 6, 0, -18 },
  { 17, 8, 7, 8, 1, -19 },
  { 24, 13, 18, 13, 0, -18 },
  { 54, 11, 23, 12, 1, -21 },
  { 86, 12, 18, 16, 2, -18 },
  { 113, 13, 18, 14, 0, -18 },
  { 143, 4, 7, 4, 1, -19 },
  { 147, 8, 26, 8, 1, -20 },
  { 173, 8, 26, 8, -1, -20 },
  { 199, 11, 11, 11, 1, -18 },
  { 215, 10, 13, 11, 1, -15 },
  { 232, 5, 8, 6, -1, -3 },
  { 237, 7, 3, 9, 1, -9 },
  { 240, 5, 4, 7, 0, -4 },
  { 243, 11, 20, 8, -2, -18 },
  { 271, 11, 18, 12, 1, -18 },
  { 296, 7, 18, 12, 3, -18 },
  { 312, 12, 18, 12, 0, -18 },
  { 339, 12, 18, 12, 0, -18 },
  { 366, 12, 18, 12, 0, -18 },
  { 393, 11, 18, 12, 1, -18 },
  { 418, 10, 18, 12, 1, -18 },
  { 441, 12, 18, 12, 1, -18 },
  { 468, 11, 18, 12, 1, -18 },
  { 493, 10, 18, 12, 2, -18 },
  { 516, 5, 14, 7, 1, -14 },
  { 525, 7, 19, 7, -1, -14 },
  { 542, 11, 12, 11, 0, -14 },
  { 559, 11, 8, 12, 1, -12 },
  { 570, 10, 12, 11, 0, -13 },
  { 585, 9, 18, 11, 2, -18 },
  { 606, 18, 23, 19, 0, -17 },
  { 658, 14, 18, 15, -1, -18 },
  { 690, 13, 18, 14, 0, -18 },
  { 720, 13, 18, 14, 1, -18 },
  { 750, 13, 18, 14, 0, -18 },
  { 780, 13, 18, 12, 0, -18 },
  { 810, 13, 18, 12, 0, -18 },
  { 840, 13, 18, 14, 1, -18 },
  { 870, 15, 18, 15, 0, -18 },
  { 904, 7, 18, 7, 0, -18 },
  { 920, 12, 18, 12, 0, -18 },
  { 947, 16, 18, 13, 0, -18 },
  { 983, 10, 18, 12, 0, -18 },
  { 1006, 19, 18, 18, 0, -18 },
  { 1049, 15, 18, 15, 0, -18 },
  { 1083, 13, 18, 15, 1, -18 },
  { 1113, 14, 18, 14, 0, -18 },
  { 1145, 13, 21, 15, 1, -18 },
  { 1180, 14, 18, 14, 0, -18 },
  { 1212, 13, 18, 13, 0, -18 },
  { 1242, 13, 18, 13, 2, -18 },
  { 1272, 14, 18, 14, 1, -18 },
  { 1304, 14, 18, 14, 2, -18 },
  { 1336, 17, 18, 18, 2, -18 },
  { 1375, 16, 18, 14, -1, -18 },
  { 1411, 13, 18, 13, 2, -18 },
  { 1441, 14, 18, 13, 0, -18 },
  { 1473, 9, 25, 6, -1, -21 },
  { 1502, 6, 20, 9, 2, -18 },
  { 1517, 8, 25, 6, -1, -21 },
  { 1542, 8, 9, 10, 1, -18 },
  { 1551, 10, 3, 10, -2, 0 },
  { 1555, 6, 4, 8, 2, -19 },
  { 1558, 11, 13, 11, 0, -13 },
  { 1576, 11, 19, 12, 0, -19 },
  { 1603, 11, 13, 11, 0, -13 },
  { 1621, 13, 19, 12, 0, -19 },
  { 1652, 11, 13, 12, 0, -13 },
  { 1670, 9, 19, 8, 1, -19 },
  { 1692, 12, 18, 12, 0, -13 },
  { 1719, 11, 19, 12, 0, -19 },
  { 1746, 7, 18, 6, 0, -18 },
  { 1762, 10, 23, 6, -3, -18 },
  { 1791, 13, 19, 12, 0, -19 },
  { 1822, 7, 19, 6, 0, -19 },
  { 1839, 17, 13, 18, 0, -13 },
  { 1867, 11, 13, 12, 0, -13 },
  { 1885, 11, 13, 12, 0, -13 },
  { 1903, 12, 18, 12, -1, -13 },
  { 1930, 12, 18, 12, 0, -13 },
  { 1957, 9, 13, 8, 0, -13 },
  { 1972, 11, 13, 11, 0, -13 },
  { 1990, 7, 16, 8, 1, -16 },
  { 2004, 11, 13, 12, 1, -13 },
  { 2022, 11, 13, 11, 1, -13 },
  { 2040, 15, 13, 15, 1, -13 },
  { 2065, 13, 13, 11, -1, -13 },
  { 2087, 13, 18, 11, -1, -13 },
  { 2117, 11, 13, 11, 0, -13 },
  { 2135, 8, 24, 7, 0, -20 },
  { 2159, 6, 21, 6, 0, -18 },
  { 2175, 8, 23, 7, -1, -19 },
  { 2198, 11, 6, 13, 1, -11 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC25PT7B_H_
