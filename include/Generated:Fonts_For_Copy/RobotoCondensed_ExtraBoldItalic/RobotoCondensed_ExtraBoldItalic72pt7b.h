#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC72PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3, 0xFC,
  0x3F, 0x8F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83,
  0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC7, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x1F,
  0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x81, 0xFE, 0x1F, 0x80,
  0x78, 0x7F, 0x07, 0xE0, 0x3F, 0x9F, 0xC1, 0xFC, 0x0F, 0xC7, 0xF0, 0x7F,
  0x07, 0xF1, 0xF8, 0x1F, 0x83, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x3F, 0x81,
  0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x9F, 0xC0, 0x7E,
  0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xF3, 0xF8, 0x07, 0xFF, 0xFD, 0xFC, 0x01,
  0xFF, 0xFE, 0x7F, 0x00, 0x3F, 0xFF, 0xBF, 0x80, 0x07, 0xFF, 0xDF, 0xC0,
  0x00, 0xFF, 0xE7, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01,
  0xFC, 0xFF, 0xE0, 0x00, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xBF, 0xFF, 0x80,
  0x1F, 0xDF, 0xFF, 0xE0, 0x0F, 0xEF, 0xFF, 0xF8, 0x03, 0xFB, 0xFC, 0x7F,
  0x01, 0xFC, 0xFE, 0x1F, 0xC0, 0xFE, 0x7F, 0x07, 0xF0, 0x3F, 0x9F, 0xC1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFC, 0xFE, 0x07, 0xF0, 0x7F, 0x3F, 0x01,
  0xFC, 0x3F, 0x8F, 0xC0, 0x7F, 0x0F, 0xE1, 0xE0, 0x1F, 0xE7, 0xF8, 0x10,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0xFF,
  0xC3, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0xF1,
  0xFF, 0x3F, 0xFB, 0xFF, 0xBF, 0xF7, 0xFF, 0x3F, 0xFB, 0xFE, 0x7F, 0xF1,
  0xFF, 0xFF, 0xE7, 0xFE, 0x1F, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xCF,
  0xFE, 0x0F, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFE, 0x07, 0xFF,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xE0,
  0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xF9, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFC, 0x3F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x30, 0x07, 0xE0, 0x08, 0xF0, 0x1F, 0x81, 0xF7, 0xF8, 0x7E, 0x1F,
  0xDF, 0xF9, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F, 0x9F, 0x80, 0x03, 0xFC, 0x7F,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x0C, 0x00, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x07, 0x01, 0xFC,
  0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xF7, 0xFE,
  0x3F, 0xC0, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x00,
  0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07,
  0xFE, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F,
  0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFF,
  0xBF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xF9,
  0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xDF,
  0xFC, 0x03, 0xFF, 0xBF, 0xF8, 0x07, 0xFF, 0x7F, 0xF0, 0x0F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE,
  0x01, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFD, 0xFF, 0xCF,
  0x87, 0xFF, 0x30, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8,
  0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xFE, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07,
  0xFB, 0xFF, 0x80, 0x07, 0xF9, 0xFF, 0xC0, 0x07, 0xFC, 0xFF, 0xE0, 0x03,
  0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFE, 0x1F, 0xF8, 0x03,
  0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x3F, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x0F,
  0xFE, 0x00, 0x1F, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE3, 0xF8, 0x01,
  0xFF, 0xBF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x0F,
  0xFE, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF,
  0x00, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x7F, 0xF1, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x1F, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xF1, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF,
  0x0F, 0xFE, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xF8, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFE, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF, 0x01, 0xFF, 0x3F, 0xF0,
  0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xF7, 0xFE, 0x00, 0x7F, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F,
  0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0xFF,
  0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xC0, 0xFC, 0x1F, 0xC0, 0x3F,
  0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F,
  0xFE, 0xFF, 0x03, 0xF0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0xFC, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0x3F, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xC7, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x0F, 0xCF,
  0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFD,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7E, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0x9F, 0xC1, 0xFE, 0x03, 0xF8, 0x07, 0xE7, 0xE0, 0x7F, 0x80, 0xFE, 0x01,
  0xFB, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xCF, 0xE0, 0x7F, 0x01, 0xFC,
  0x07, 0xF3, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0xFE, 0x07, 0xF0, 0x3F,
  0xC0, 0x7E, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0x87,
  0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xE0, 0xFE, 0x07, 0xFF,
  0xFF, 0xC3, 0xF8, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F,
  0xFE, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0x3F, 0xFF, 0x00, 0xFE, 0x01,
  0xFF, 0x87, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x07, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x9F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF,
  0x87, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x87,
  0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xFF, 0x1F, 0xFC, 0x0F, 0xFF,
  0xFC, 0x7F, 0xF0, 0x3F, 0xFF, 0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0x8F, 0xFE,
  0x03, 0xFF, 0xFE, 0x3F, 0xF8, 0x0F, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF8,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFD, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xEF, 0xF0, 0x0F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xE0, 0x3F, 0xEF,
  0xFC, 0x01, 0xFF, 0xBF, 0xC0, 0x7F, 0xBF, 0xF8, 0x03, 0xFF, 0x3F, 0x81,
  0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0xC0, 0x1F, 0xFC,
  0xFF, 0x07, 0xF9, 0xFF, 0x80, 0x3F, 0xF9, 0xFE, 0x1F, 0xF7, 0xFF, 0x00,
  0x7F, 0xE3, 0xFC, 0x3F, 0xCF, 0xFE, 0x00, 0xFF, 0xC7, 0xF8, 0xFF, 0x9F,
  0xFC, 0x01, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0xE0, 0x0F, 0xFE, 0x3F, 0xCF, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x7F, 0x9F, 0xE3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0x7F, 0x87, 0xFF, 0x00,
  0x7F, 0xF0, 0xFE, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x3F, 0xF8,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF7, 0xF0, 0x3F, 0xF8, 0x07,
  0xFF, 0x7F, 0x83, 0xFF, 0x80, 0x7F, 0xF3, 0xF8, 0x3F, 0xF0, 0x07, 0xFF,
  0x3F, 0x87, 0xFF, 0x00, 0x7F, 0xF3, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x3F,
  0x87, 0xFF, 0x00, 0xFF, 0xE1, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xC7,
  0xFF, 0x00, 0xFF, 0xE1, 0xFC, 0x7F, 0xE0, 0x0F, 0xFE, 0x1F, 0xCF, 0xFE,
  0x00, 0xFF, 0xE1, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xEF, 0xFE, 0x01,
  0xFF, 0xC0, 0xFE, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xEF, 0xFE, 0x01, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xC7,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xFC,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80,
  0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC7, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xE1,
  0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF,
  0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xFF,
  0x80, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x87, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x3F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFE,
  0x7F, 0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x01,
  0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F,
  0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x0F,
  0xFD, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xBF,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xFB,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF,
  0x3F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x80, 0x7F,
  0xF3, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0xFF, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0x00, 0xFF,
  0xCF, 0xFF, 0xFD, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0xFF, 0x7F, 0xE0, 0x0F,
  0xFD, 0xFF, 0x7F, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xDF, 0xFF, 0xFE, 0x00,
  0xFF, 0xDF, 0xF7, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF,
  0xC7, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xF0,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE7,
  0xF0, 0x0F, 0xF3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF8, 0xFE, 0x07, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF1, 0xFE,
  0x03, 0xF8, 0xFF, 0x01, 0xFC, 0xFF, 0x80, 0xFE, 0x7F, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x9F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x8F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xFC, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF,
  0xC7, 0xFF, 0x03, 0xFF, 0x8F, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x0F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0x1F, 0xFC, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0x00, 0x03, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x1F,
  0xF8, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF,
  0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xEF, 0xFF, 0xF8, 0x3F, 0xF7, 0xFF, 0xF8, 0x1F, 0xF9, 0xFF,
  0xF8, 0x0F, 0xFC, 0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x3F,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xDF, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x0F, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xFB, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE7, 0xFF, 0x00, 0xFF, 0xCF, 0xFC,
  0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x10, 0x0F, 0xFE, 0x00, 0xF0,
  0x1F, 0xFE, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x3F, 0xFE, 0x3F, 0xF0, 0x07, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFE, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xE1,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0xC0, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0xFF, 0xF0,
  0x01, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x07, 0x80, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F,
  0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0,
  0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE,
  0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0x7F,
  0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE, 0x0F,
  0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0x8F,
  0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xC7, 0xFF, 0x80, 0x07,
  0xFE, 0x7F, 0xF8, 0x00, 0x3F, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xE7, 0xFE, 0x00, 0x0F, 0xFE,
  0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xDF,
  0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x87,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE1,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0xC3, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE1, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x81,
  0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC,
  0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF,
  0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87,
  0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x07, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF8, 0x07,
  0xFE, 0x3F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07,
  0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xF0, 0x07,
  0xFE, 0x7F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x07,
  0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F,
  0xFE, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x0F,
  0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFD, 0xFF, 0xF8, 0x01, 0xFF, 0x9F, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0,
  0x01, 0xFF, 0x81, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF, 0x3F,
  0xF0, 0x3F, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xE0,
  0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8,
  0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFB, 0xFF,
  0x80, 0x01, 0xF1, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x01, 0xFF, 0x9F, 0xC0, 0xFF, 0xDF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC,
  0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8,
  0x07, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8,
  0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0,
  0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x7F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF8, 0xFF, 0xE0,
  0x3F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x01,
  0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x8F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x1F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x1F, 0xFC,
  0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80,
  0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0xFF, 0xBF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F,
  0xEF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFB, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF3, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x87,
  0xFE, 0x3F, 0xF1, 0xFF, 0xE1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF8, 0xFF, 0xC3,
  0xFF, 0x1F, 0xFE, 0x3F, 0xF0, 0xFF, 0x8F, 0xFF, 0x8F, 0xF8, 0x3F, 0xE3,
  0xFF, 0xE7, 0xFE, 0x0F, 0xF9, 0xFF, 0xF9, 0xFF, 0x83, 0xFE, 0x7F, 0xFE,
  0x7F, 0xC0, 0xFF, 0x9F, 0xFF, 0x9F, 0xF0, 0x3F, 0xEF, 0xFF, 0xEF, 0xF8,
  0x0F, 0xFB, 0xFB, 0xFB, 0xFE, 0x01, 0xFF, 0xFE, 0xFE, 0xFF, 0x80, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x07, 0xFF, 0xF3,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00,
  0x3F, 0xE7, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x00,
  0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xC3,
  0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x3F,
  0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xE0,
  0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x9F,
  0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0xF8, 0x03, 0xFC, 0x3F, 0xFF, 0x00,
  0xFF, 0x1F, 0xFF, 0xE0, 0x3F, 0x87, 0xFF, 0xFC, 0x1F, 0xE3, 0xFF, 0xFF,
  0x87, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0,
  0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xFF, 0xE1, 0xFE, 0x07, 0xFF, 0xF8, 0x7F,
  0x00, 0xFF, 0xFC, 0x1F, 0xC0, 0x1F, 0xFE, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 19, 52, 18, 1, -51 },
  { 125, 22, 20, 22, 4, -54 },
  { 180, 36, 51, 36, 1, -51 },
  { 410, 33, 67, 36, 2, -59 },
  { 687, 34, 53, 45, 6, -52 },
  { 913, 36, 53, 41, 1, -52 },
  { 1152, 11, 20, 11, 4, -54 },
  { 1180, 22, 73, 23, 3, -57 },
  { 1381, 23, 73, 23, -3, -57 },
  { 1591, 30, 31, 32, 4, -51 },
  { 1708, 30, 38, 33, 2, -43 },
  { 1851, 16, 22, 18, -4, -9 },
  { 1895, 19, 9, 27, 4, -27 },
  { 1917, 12, 12, 21, 1, -11 },
  { 1935, 32, 55, 22, -5, -51 },
  { 2155, 31, 53, 36, 3, -52 },
  { 2361, 22, 51, 36, 8, -51 },
  { 2502, 35, 52, 36, 0, -52 },
  { 2730, 34, 53, 36, 1, -52 },
  { 2956, 33, 51, 36, 1, -51 },
  { 3167, 34, 52, 36, 2, -51 },
  { 3388, 30, 52, 36, 3, -51 },
  { 3583, 34, 51, 36, 3, -51 },
  { 3800, 33, 53, 36, 2, -52 },
  { 4019, 29, 52, 36, 5, -52 },
  { 4208, 17, 40, 20, 1, -39 },
  { 4293, 21, 52, 19, -3, -39 },
  { 4430, 29, 34, 31, 1, -39 },
  { 4554, 30, 25, 36, 3, -35 },
  { 4648, 29, 35, 32, 1, -39 },
  { 4775, 27, 53, 32, 5, -52 },
  { 4954, 50, 66, 54, 1, -50 },
  { 5367, 41, 51, 42, -3, -51 },
  { 5629, 39, 51, 39, 0, -51 },
  { 5878, 38, 53, 40, 2, -52 },
  { 6130, 38, 51, 39, 0, -51 },
  { 6373, 38, 51, 34, 0, -51 },
  { 6616, 37, 51, 33, 0, -51 },
  { 6852, 38, 53, 41, 3, -52 },
  { 7104, 44, 51, 43, 0, -51 },
  { 7385, 20, 51, 19, 0, -51 },
  { 7513, 36, 52, 34, 0, -51 },
  { 7747, 45, 51, 39, 0, -51 },
  { 8034, 30, 51, 33, 0, -51 },
  { 8226, 55, 51, 53, 0, -51 },
  { 8577, 44, 51, 43, 0, -51 },
  { 8858, 38, 53, 42, 3, -52 },
  { 9110, 40, 51, 40, 0, -51 },
  { 9365, 38, 61, 42, 3, -52 },
  { 9655, 39, 51, 39, 0, -51 },
  { 9904, 37, 53, 38, 1, -52 },
  { 10150, 37, 51, 38, 5, -51 },
  { 10386, 40, 52, 40, 2, -51 },
  { 10646, 40, 51, 41, 5, -51 },
  { 10901, 50, 51, 52, 6, -51 },
  { 11220, 46, 51, 39, -3, -51 },
  { 11514, 37, 51, 38, 6, -51 },
  { 11750, 41, 51, 37, -1, -51 },
  { 12012, 25, 72, 19, -2, -60 },
  { 12237, 19, 55, 27, 5, -51 },
  { 12368, 25, 72, 19, -4, -60 },
  { 12593, 25, 26, 28, 2, -51 },
  { 12675, 27, 8, 28, -4, 0 },
  { 12702, 16, 11, 23, 7, -54 },
  { 12724, 31, 40, 33, 0, -39 },
  { 12879, 33, 55, 35, 0, -54 },
  { 13106, 30, 40, 32, 1, -39 },
  { 13256, 36, 55, 35, 1, -54 },
  { 13504, 31, 40, 34, 1, -39 },
  { 13659, 26, 55, 23, 2, -55 },
  { 13838, 36, 54, 35, -1, -39 },
  { 14081, 33, 54, 35, -1, -54 },
  { 14304, 19, 53, 18, 0, -53 },
  { 14430, 27, 68, 17, -8, -53 },
  { 14660, 37, 54, 34, 0, -54 },
  { 14910, 20, 54, 18, 0, -54 },
  { 15045, 49, 39, 52, 0, -39 },
  { 15284, 33, 39, 35, -1, -39 },
  { 15445, 32, 40, 35, 1, -39 },
  { 15605, 36, 54, 35, -3, -39 },
  { 15848, 33, 54, 35, 1, -39 },
  { 16071, 25, 39, 24, 0, -39 },
  { 16193, 31, 40, 32, 0, -39 },
  { 16348, 21, 48, 22, 2, -47 },
  { 16474, 32, 39, 35, 2, -38 },
  { 16630, 31, 38, 32, 3, -38 },
  { 16778, 42, 38, 44, 4, -38 },
  { 16978, 37, 38, 32, -3, -38 },
  { 17154, 36, 53, 32, -2, -38 },
  { 17393, 33, 38, 32, -1, -38 },
  { 17550, 22, 69, 21, 1, -56 },
  { 17740, 16, 61, 18, 1, -51 },
  { 17862, 21, 69, 21, -2, -56 },
  { 18044, 34, 16, 38, 2, -29 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC72PT7B_H_
