#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC67PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFC,
  0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F,
  0x87, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFE,
  0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x03, 0xFF,
  0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xF0, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x1C, 0x3F, 0x0F, 0xE0, 0x7C, 0xFE, 0x0F,
  0xC0, 0xFD, 0xFC, 0x1F, 0x83, 0xF3, 0xF0, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE,
  0x1F, 0x8F, 0xC1, 0xFC, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x3F, 0x07, 0xE3,
  0xF0, 0x7F, 0x1F, 0xCF, 0xC0, 0xFF, 0x7F, 0xBF, 0x80, 0xFF, 0xFE, 0x7E,
  0x01, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xF7, 0xF0, 0x01, 0xFF, 0xCF, 0xC0,
  0x01, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xFE, 0x00,
  0x1F, 0x9F, 0xFE, 0x00, 0x7F, 0x7F, 0xFE, 0x01, 0xFD, 0xFF, 0xFE, 0x03,
  0xF3, 0xFF, 0xFC, 0x0F, 0xEF, 0xE1, 0xF8, 0x3F, 0x9F, 0xC3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE1, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0x7E, 0xFE, 0x0F, 0xE1, 0xFD, 0xF8, 0x0F,
  0xC3, 0xF9, 0xE0, 0x1F, 0x8F, 0xE0, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x7F,
  0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0x87, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x8F, 0xFF, 0xFF, 0x1F,
  0xE3, 0xFF, 0xFF, 0xEF, 0xF9, 0xFF, 0x9F, 0xFB, 0xFE, 0x7F, 0xE7, 0xFF,
  0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0x07,
  0xFF, 0xF8, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFC,
  0x07, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F,
  0xFC, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF9, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x02, 0x00, 0xFC, 0x00, 0x1C, 0x07, 0xC0, 0x71, 0xF8, 0x3E, 0x0F, 0x8F,
  0xF1, 0xF3, 0xFC, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xBF, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC,
  0x1F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0x01,
  0xF0, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x0F, 0x07, 0xF9,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xC7, 0xF0, 0x38,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE,
  0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0xF9, 0xFF, 0x00, 0xFF, 0xCF, 0xF8, 0x07,
  0xFE, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xF9,
  0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xF3, 0xFE,
  0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x03,
  0xFE, 0x7F, 0xE0, 0x1F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC,
  0xFF, 0x80, 0x7F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF,
  0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xFC, 0x7F, 0xC0, 0x7F, 0xC3, 0xFE, 0x03,
  0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xF7, 0xFE, 0x3E, 0x3F, 0xF3, 0x81, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xCF, 0xFE,
  0x03, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF,
  0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0x9F, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x8F,
  0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0x7F,
  0xE0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xE7, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0x7F, 0xE0, 0x01, 0xFE, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0x80,
  0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xF8, 0x01,
  0xFE, 0x3F, 0xF0, 0x07, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xC1, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x07, 0xFB, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0,
  0x03, 0xF0, 0x3F, 0xF0, 0x00, 0x20, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x7F, 0xF9, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x7F, 0xF8, 0x7F, 0xF3, 0xFF,
  0x81, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x01,
  0xFF, 0x3F, 0xF0, 0x0F, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE,
  0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0xFF,
  0x80, 0x7F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x01,
  0xFF, 0x87, 0xFC, 0x1F, 0xF8, 0x3F, 0xF3, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x9F, 0xFC,
  0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF,
  0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x07,
  0xFE, 0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF,
  0x8F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xC3,
  0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFC, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0x3F,
  0xE3, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE, 0x7F,
  0xE0, 0x3F, 0xE7, 0xFE, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xE7,
  0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xE0,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xEF, 0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x03, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC0, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F, 0xF9, 0xFF, 0x9F, 0xF8, 0x3F, 0xF7,
  0xFE, 0x0F, 0xFD, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x7E, 0x07, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7C, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0xF8, 0x3F, 0x80, 0xFF, 0xFF,
  0xC1, 0xF0, 0x7F, 0x03, 0xFF, 0xFF, 0x83, 0xE0, 0xFC, 0x07, 0xF8, 0x7E,
  0x07, 0xE3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xC7, 0xE0, 0x7F, 0x83, 0xF8,
  0x1F, 0x9F, 0xC0, 0xFE, 0x07, 0xF0, 0x3E, 0x3F, 0x83, 0xFC, 0x0F, 0xC0,
  0x7C, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF3, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xE7, 0xF0, 0x7F, 0x01, 0xF8, 0x0F,
  0xCF, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x9F, 0x83, 0xFC, 0x0F, 0xE0, 0x3F,
  0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0x7C, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF9,
  0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF3, 0xF8, 0x3F, 0x81, 0xFC, 0x07, 0xE7,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x8F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x1F,
  0x81, 0xFC, 0x1F, 0xC0, 0x7C, 0x3F, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x7E,
  0x07, 0xF0, 0xFF, 0x07, 0xE0, 0xFC, 0x0F, 0xF3, 0xFE, 0x0F, 0xC1, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0xFE, 0xFF, 0xFC, 0x07, 0xE0,
  0x3F, 0xFD, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0x80, 0x1E, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x04, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00,
  0x3F, 0xE3, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x07,
  0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x7F, 0xF0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x7F, 0xF1, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x8F, 0xFF, 0xC0, 0x1F,
  0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xF8, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xFC,
  0x3F, 0xF0, 0x3F, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xFC, 0x7F, 0xF0, 0x3F,
  0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0xC7, 0xFE,
  0x07, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8,
  0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0xFF,
  0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x7F, 0xBF, 0xE0, 0x0F, 0xFB,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0x83, 0xFD, 0xFF, 0x80, 0x7F,
  0xE7, 0xF0, 0x7F, 0xBF, 0xF0, 0x0F, 0xFC, 0xFE, 0x1F, 0xE7, 0xFC, 0x01,
  0xFF, 0x9F, 0xC3, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xF8, 0x7F, 0x3F, 0xF0,
  0x07, 0xFC, 0x7F, 0x1F, 0xE7, 0xFE, 0x01, 0xFF, 0x8F, 0xE3, 0xF8, 0xFF,
  0xC0, 0x3F, 0xF1, 0xFC, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0x9F, 0xE3,
  0xFE, 0x00, 0xFF, 0xC7, 0xF7, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFE, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xDF, 0xC3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x01,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFE, 0x03, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFC, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x7E, 0x07, 0xFE, 0x01, 0xFF,
  0xBF, 0x83, 0xFF, 0x00, 0xFF, 0xDF, 0xC1, 0xFF, 0x80, 0x7F, 0xEF, 0xE1,
  0xFF, 0xC0, 0x3F, 0xF3, 0xF0, 0xFF, 0xC0, 0x3F, 0xF9, 0xFC, 0x7F, 0xE0,
  0x1F, 0xF8, 0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0x1F, 0xF8, 0x07, 0xFE,
  0x1F, 0x8F, 0xFC, 0x03, 0xFF, 0x0F, 0xEF, 0xFE, 0x01, 0xFF, 0x87, 0xF7,
  0xFE, 0x01, 0xFF, 0xC3, 0xFB, 0xFF, 0x00, 0xFF, 0xC0, 0xFD, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x3F,
  0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F,
  0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF,
  0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x1F,
  0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x87, 0xFE, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x3F, 0xFD,
  0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF0, 0x00,
  0xFF, 0xF1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFC,
  0x3F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x3F, 0xE0, 0x3F, 0xF8,
  0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xE3, 0xFE, 0x07, 0xFF, 0x81,
  0xFF, 0x8F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xF8, 0x3F,
  0xF0, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x7F, 0xFE, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF, 0xF8, 0x7F, 0xE0,
  0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0x8F, 0xFC, 0x0F,
  0xF8, 0xFF, 0xFE, 0x3F, 0xF0, 0x3F, 0xE3, 0xFF, 0xF8, 0xFF, 0x80, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFE, 0x03, 0xFE, 0x7F, 0xFF, 0x9F, 0xF8, 0x0F, 0xF9,
  0xFF, 0xFE, 0x7F, 0xE0, 0x3F, 0xEF, 0xFF, 0xF9, 0xFF, 0x00, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0x7F, 0xBF, 0xF0, 0x0F, 0xFF, 0xFD,
  0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFE,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC7,
  0xFF, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF7, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00,
  0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x87, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x07, 0xFF, 0x3F,
  0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x03,
  0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE7, 0xFE, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xF7,
  0xE0, 0x1F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0xFE, 0x3F, 0x01, 0xFC, 0x7E,
  0x07, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF1,
  0xFE, 0x0F, 0xE3, 0xF8, 0x0F, 0xCF, 0xF0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x83,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC1, 0xFF, 0x8F, 0xFC,
  0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F,
  0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x1F, 0xFC, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xF7, 0xFC, 0x07, 0xFF, 0xBF, 0xE0, 0x0F, 0xF1, 0xFF, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF1, 0xE0, 0x00, 0xFF,
  0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F,
  0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7, 0xFE,
  0x03, 0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xF3, 0xFF, 0x00,
  0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F,
  0xE3, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF1,
  0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0xCF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xE7,
  0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x83,
  0xFE, 0x3F, 0xF0, 0x1F, 0xF3, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3,
  0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xCF, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7C,
  0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xE7, 0xFE, 0x01, 0xFF,
  0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xF8, 0x07, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFE, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x7F,
  0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x9F, 0xF0, 0x0F, 0xFC, 0xFF, 0x80,
  0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0x80, 0xFF, 0xC0, 0x3C,
  0x07, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xF2, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0xFB, 0xFE,
  0x01, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x7F,
  0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFE, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3E, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0C, 0x00, 0xFF,
  0xC0, 0x07, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC3, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0xFF,
  0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC,
  0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xF0, 0x07,
  0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xCF, 0xFF, 0x00,
  0x3F, 0xF3, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x0F, 0xF9, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xEF, 0xFE, 0x1F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x3F, 0xFF, 0x3F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFE,
  0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC3, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x87,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x87, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x03,
  0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE,
  0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC7, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0x3F,
  0xF3, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x7F, 0xEF,
  0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF0,
  0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFB, 0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xF1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFD, 0xFF, 0xF8, 0x07, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0x3F, 0xF0,
  0x01, 0xFF, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x07, 0xFF, 0x8F, 0xF8, 0x1F,
  0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF0,
  0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x01,
  0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF,
  0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1,
  0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1C, 0x07, 0xFD, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xE7,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF1,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF,
  0xC1, 0xFF, 0x87, 0xFE, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8,
  0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF,
  0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x87,
  0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x03, 0xFF, 0x9F, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE7, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0xFF, 0xE7, 0xFC, 0x0F, 0xFC, 0x7F,
  0xC0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xE3, 0xFE, 0x03,
  0xFE, 0x7F, 0xE0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xEF,
  0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xFF, 0x03,
  0xFC, 0x0F, 0xFB, 0xFE, 0x07, 0xF8, 0x3F, 0xF7, 0xFC, 0x1F, 0xF0, 0x7F,
  0xCF, 0xF8, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0xFF, 0xC3, 0xFF, 0x3F, 0xE1,
  0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xFE, 0x1F,
  0xF1, 0xFF, 0x1F, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xF8, 0xFF, 0x87, 0xFC,
  0xFF, 0xF1, 0xFE, 0x0F, 0xF9, 0xFF, 0xE7, 0xFC, 0x1F, 0xE7, 0xFF, 0xCF,
  0xF8, 0x3F, 0xCF, 0xFF, 0x9F, 0xE0, 0x7F, 0xBF, 0xFF, 0x7F, 0xC0, 0xFF,
  0x7F, 0x7E, 0xFF, 0x81, 0xFE, 0xFE, 0xFD, 0xFE, 0x03, 0xFF, 0xF9, 0xFF,
  0xFC, 0x07, 0xFF, 0xF3, 0xFF, 0xF0, 0x0F, 0xFF, 0xE7, 0xFF, 0xE0, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC0, 0x3F, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x7F,
  0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x01,
  0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF,
  0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F,
  0xE7, 0xFE, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07,
  0xFD, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x3F,
  0xFC, 0x03, 0xF8, 0x7F, 0xFC, 0x07, 0xF1, 0xFF, 0xFC, 0x0F, 0xE7, 0xFF,
  0xFC, 0x3F, 0xCF, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0x8F,
  0xFF, 0xFC, 0xFF, 0x0F, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0xE3, 0xF8, 0x0F,
  0xFF, 0x8F, 0xE0, 0x0F, 0xFE, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 18, 49, 17, 1, -48 },
  { 112, 21, 18, 21, 3, -50 },
  { 160, 33, 48, 34, 1, -48 },
  { 358, 31, 63, 33, 2, -56 },
  { 603, 31, 50, 42, 6, -49 },
  { 797, 34, 50, 38, 1, -49 },
  { 1010, 10, 18, 10, 4, -50 },
  { 1033, 21, 68, 21, 3, -53 },
  { 1212, 21, 68, 21, -3, -53 },
  { 1391, 29, 29, 30, 3, -48 },
  { 1497, 28, 35, 31, 2, -40 },
  { 1620, 15, 21, 17, -4, -8 },
  { 1660, 17, 8, 25, 4, -24 },
  { 1677, 11, 11, 19, 1, -10 },
  { 1693, 30, 52, 21, -5, -48 },
  { 1888, 29, 50, 33, 3, -49 },
  { 2070, 21, 48, 33, 7, -48 },
  { 2196, 32, 49, 33, 0, -49 },
  { 2392, 31, 50, 33, 1, -49 },
  { 2586, 31, 48, 33, 1, -48 },
  { 2772, 32, 49, 33, 1, -48 },
  { 2968, 29, 49, 33, 2, -48 },
  { 3146, 32, 48, 33, 3, -48 },
  { 3338, 30, 50, 33, 2, -49 },
  { 3526, 28, 49, 33, 4, -49 },
  { 3698, 16, 37, 19, 1, -36 },
  { 3772, 20, 49, 18, -3, -36 },
  { 3895, 27, 32, 29, 1, -36 },
  { 4003, 29, 22, 33, 2, -32 },
  { 4083, 27, 32, 29, 1, -36 },
  { 4191, 26, 50, 29, 4, -49 },
  { 4354, 47, 61, 50, 1, -46 },
  { 4713, 38, 48, 39, -3, -48 },
  { 4941, 36, 48, 37, 0, -48 },
  { 5157, 36, 50, 37, 2, -49 },
  { 5382, 36, 48, 37, 0, -48 },
  { 5598, 35, 48, 32, 0, -48 },
  { 5808, 34, 48, 31, 0, -48 },
  { 6012, 36, 50, 38, 2, -49 },
  { 6237, 41, 48, 40, 0, -48 },
  { 6483, 19, 48, 18, 0, -48 },
  { 6597, 33, 49, 32, 0, -48 },
  { 6800, 42, 48, 36, 0, -48 },
  { 7052, 28, 48, 31, 0, -48 },
  { 7220, 51, 48, 49, 0, -48 },
  { 7526, 41, 48, 40, 0, -48 },
  { 7772, 36, 50, 39, 2, -49 },
  { 7997, 37, 48, 37, 0, -48 },
  { 8219, 36, 58, 39, 2, -49 },
  { 8480, 36, 48, 36, 0, -48 },
  { 8696, 35, 50, 35, 1, -49 },
  { 8915, 34, 48, 36, 5, -48 },
  { 9119, 37, 49, 37, 2, -48 },
  { 9346, 37, 48, 38, 5, -48 },
  { 9568, 46, 48, 49, 6, -48 },
  { 9844, 43, 48, 37, -3, -48 },
  { 10102, 35, 48, 36, 5, -48 },
  { 10312, 38, 48, 35, -1, -48 },
  { 10540, 24, 67, 17, -2, -56 },
  { 10741, 17, 52, 25, 5, -48 },
  { 10852, 23, 67, 17, -4, -56 },
  { 11045, 23, 24, 26, 2, -48 },
  { 11114, 26, 8, 26, -4, 0 },
  { 11140, 15, 10, 22, 7, -50 },
  { 11159, 29, 37, 30, 0, -36 },
  { 11294, 30, 51, 32, 0, -50 },
  { 11486, 28, 37, 30, 1, -36 },
  { 11616, 33, 51, 32, 1, -50 },
  { 11827, 29, 37, 31, 1, -36 },
  { 11962, 24, 51, 21, 2, -51 },
  { 12115, 34, 50, 33, -1, -36 },
  { 12328, 31, 50, 32, -1, -50 },
  { 12522, 18, 49, 17, 0, -49 },
  { 12633, 26, 63, 16, -8, -49 },
  { 12838, 34, 50, 31, 0, -50 },
  { 13051, 19, 50, 17, 0, -50 },
  { 13170, 46, 36, 48, 0, -36 },
  { 13377, 31, 36, 32, -1, -36 },
  { 13517, 29, 37, 32, 1, -36 },
  { 13652, 33, 50, 32, -3, -36 },
  { 13859, 31, 50, 32, 1, -36 },
  { 14053, 23, 36, 22, 0, -36 },
  { 14157, 28, 37, 29, 0, -36 },
  { 14287, 19, 45, 20, 2, -44 },
  { 14394, 31, 36, 32, 1, -35 },
  { 14534, 28, 35, 30, 3, -35 },
  { 14657, 39, 35, 41, 4, -35 },
  { 14828, 33, 35, 30, -2, -35 },
  { 14973, 33, 49, 29, -1, -35 },
  { 15176, 31, 35, 30, -1, -35 },
  { 15312, 21, 64, 19, 1, -52 },
  { 15480, 15, 57, 17, 1, -48 },
  { 15587, 20, 64, 19, -2, -52 },
  { 15747, 31, 15, 36, 2, -27 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC67PT7B_H_
