#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC28PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0x70, 0x73, 0xB9, 0xDC,
  0xEE, 0x67, 0x73, 0x39, 0x9D, 0xCC, 0x01, 0x98, 0x06, 0x60, 0x3B, 0x80,
  0xEE, 0x03, 0x30, 0x1D, 0xC3, 0xFF, 0xCF, 0xFF, 0x0E, 0xE0, 0x3B, 0x80,
  0xCC, 0x03, 0x30, 0x7F, 0xF3, 0xFF, 0xC1, 0x98, 0x0E, 0xE0, 0x3B, 0x80,
  0xCC, 0x07, 0x70, 0x1D, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0F, 0x80,
  0xFE, 0x0F, 0xF8, 0xFB, 0xC7, 0x8E, 0x3C, 0x79, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79,
  0xF7, 0xC7, 0xFC, 0x3F, 0xC0, 0x7C, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x00,
  0x1C, 0x01, 0xF8, 0x07, 0x71, 0x19, 0xCE, 0x67, 0x33, 0x9D, 0xC7, 0xEE,
  0x1F, 0xF0, 0x3D, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xBC, 0x0F, 0xF8, 0x77,
  0xE1, 0xB9, 0xCE, 0xE7, 0x73, 0x99, 0x8E, 0xE0, 0x1F, 0x80, 0x3C, 0x03,
  0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7B, 0x81, 0xE7, 0x83, 0xCE, 0x07, 0xBC,
  0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x71, 0xFC, 0xE7, 0xBF, 0xCF,
  0x7F, 0xBE, 0x7E, 0x7C, 0xFC, 0x79, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFB,
  0xE0, 0x3B, 0xDC, 0xE7, 0x39, 0x8C, 0x01, 0x01, 0xC1, 0xE1, 0xE0, 0xE0,
  0xE0, 0x70, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x06,
  0x01, 0x00, 0x08, 0x06, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81,
  0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x10, 0x00, 0x03, 0x80,
  0x30, 0x03, 0x06, 0x31, 0x7B, 0xF7, 0xFF, 0x0F, 0x81, 0xF0, 0x1F, 0x83,
  0x98, 0x71, 0xC0, 0x08, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x00,
  0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x1E, 0x38, 0x20, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x07, 0xC0,
  0xFE, 0x1F, 0xF3, 0xEF, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xF7,
  0x8F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xFB, 0xC7,
  0xFC, 0x7F, 0x81, 0xE0, 0x01, 0x87, 0x8F, 0xDF, 0xEF, 0xF7, 0x78, 0x3C,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x0F, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x3D, 0xF3, 0xC7, 0x9E,
  0x3C, 0xF1, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0,
  0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x7D, 0xF3, 0xC7, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x07, 0xF0, 0x3E, 0x01, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x7B, 0xC3,
  0xDF, 0x1E, 0x7F, 0xF3, 0xFF, 0x0F, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFE, 0x0E, 0xF0,
  0xE7, 0x8F, 0x7C, 0x73, 0xC7, 0x9E, 0x3F, 0xFD, 0xFF, 0xDF, 0xFE, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0E, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF3, 0xC7, 0x9E, 0x3C, 0xFB, 0xC3, 0xFE, 0x1F,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1E, 0x03, 0xC0,
  0x7C, 0x07, 0xBC, 0x7F, 0xE7, 0xFE, 0xFD, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF1, 0xFF, 0x1E, 0x7B, 0xE7, 0xFC, 0x3F, 0x81, 0xF0, 0x3F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x07, 0xC1, 0xFE, 0x1F,
  0xF3, 0xEF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xDF, 0x1F, 0xE3, 0xF8, 0x7F,
  0xC7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xFB, 0xCF, 0xFC, 0x7F,
  0x83, 0xF0, 0x0F, 0x87, 0xF8, 0xFF, 0x3C, 0xFF, 0x9F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x7F, 0xFF, 0xBF, 0xE3, 0xFC, 0x07, 0x81, 0xE0, 0x7C,
  0x7F, 0x0F, 0xC1, 0xF0, 0x78, 0x00, 0x3D, 0xF3, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0xF3, 0xCE, 0x00, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78,
  0x70, 0xE0, 0x40, 0x00, 0x10, 0x0F, 0x03, 0xE0, 0xFE, 0x3F, 0xC7, 0xF0,
  0x78, 0x07, 0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xC0, 0x1C, 0x00, 0x40, 0x7F,
  0xF7, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0xFF,
  0xC0, 0x10, 0x03, 0xC0, 0x3E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xE0,
  0x7E, 0x3F, 0xC7, 0xF0, 0x7C, 0x07, 0x00, 0xC0, 0x00, 0x1F, 0x07, 0xF1,
  0xFF, 0x7D, 0xEF, 0x3D, 0xE7, 0x80, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x78,
  0x1E, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x38,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xE3, 0xC0, 0x78, 0x0E, 0x0E,
  0x00, 0x61, 0xC0, 0x06, 0x1C, 0x3C, 0x73, 0x8F, 0xE7, 0x39, 0xFE, 0x77,
  0x1C, 0xE7, 0x73, 0x8E, 0x77, 0x38, 0xC7, 0x63, 0x9C, 0x66, 0x71, 0xC6,
  0xE7, 0x1C, 0xEE, 0x73, 0xCC, 0xE7, 0xFD, 0xCE, 0x3F, 0xF8, 0x61, 0xCF,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xBC, 0x07, 0x9C,
  0x0F, 0x1C, 0x0F, 0x1E, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE,
  0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1F, 0x1F, 0xF0, 0x3F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x8F, 0x9E, 0x1E, 0x3F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xE3, 0xE3, 0xC7, 0xC3, 0xCF, 0x07, 0x9E, 0x1F,
  0x3C, 0x3C, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xC3, 0xCF, 0x87, 0xDE, 0x0F, 0xBC,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0F,
  0x3C, 0x1E, 0x78, 0x7C, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xE3, 0xC3, 0xC3, 0xCF,
  0x87, 0x9E, 0x0F, 0x3C, 0x3E, 0x78, 0x7C, 0xF0, 0xF3, 0xE1, 0xE7, 0xC3,
  0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x7C, 0x7B, 0xF1, 0xFF, 0xE3, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC7, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F,
  0xFC, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFB, 0xE3, 0xC3,
  0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x00, 0x78, 0x00, 0xF3, 0xFB, 0xE7, 0xF7,
  0xCF, 0xEF, 0x07, 0xDE, 0x0F, 0xBC, 0x1E, 0x7C, 0x3C, 0x7F, 0xF8, 0xFF,
  0xF0, 0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3,
  0xC1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x78, 0x1E, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0xFF, 0x8F, 0xFF, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0,
  0xF8, 0xF0, 0x7C, 0x78, 0x3C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x80,
  0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xCF, 0x1E, 0x3C, 0x78,
  0xFF, 0xE1, 0xFF, 0x07, 0xF8, 0x07, 0xC0, 0x1F, 0x0F, 0x8F, 0x0F, 0x87,
  0x8F, 0x83, 0xC7, 0xC1, 0xE7, 0xC0, 0xF7, 0xC0, 0xFB, 0xC0, 0x7B, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x1E,
  0x0F, 0x80, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x8E, 0xF1, 0xFE, 0x77, 0x8F, 0x77,
  0xF8, 0xFB, 0xBB, 0xC7, 0x9F, 0xDE, 0x3C, 0xFC, 0xF1, 0xE7, 0xEF, 0x8F,
  0x3E, 0x7C, 0x79, 0xF3, 0xC7, 0xCF, 0x1E, 0x3E, 0x78, 0xF1, 0xE3, 0xC7,
  0x80, 0x1F, 0x07, 0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xE1, 0xF1, 0xF8, 0xF0,
  0xFC, 0x78, 0xFE, 0x3C, 0x7B, 0x1E, 0x3D, 0xDF, 0x1E, 0xEF, 0x8F, 0x77,
  0x8F, 0x9B, 0xC7, 0xCF, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF0, 0xFC, 0x78,
  0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xF0,
  0x7F, 0xF1, 0xFF, 0xE3, 0xC3, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78,
  0x1F, 0xF0, 0x7F, 0xE0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1F,
  0x7C, 0x3C, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x1F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xC3, 0xEF,
  0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xF0, 0x7F, 0xE0, 0xF7, 0x81,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x1F, 0x7C, 0x3C, 0x7F, 0xF8, 0xFF, 0xE0,
  0xFF, 0x80, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x20, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x87,
  0x9E, 0x0F, 0x3C, 0x3E, 0x79, 0xF8, 0xFF, 0xE3, 0xFF, 0x87, 0xFE, 0x0F,
  0x3E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xF1, 0xF3, 0xE3, 0xE7, 0x83,
  0xC0, 0x01, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F,
  0x80, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xEF,
  0x87, 0x9F, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF9, 0xE1, 0xF7, 0xC3,
  0xCF, 0x87, 0x9E, 0x0F, 0x3C, 0x3E, 0x78, 0x78, 0xFF, 0xF0, 0xFF, 0xC1,
  0xFF, 0x00, 0xFC, 0x00, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x7C,
  0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x79, 0xE0,
  0x79, 0xE0, 0x7B, 0xE0, 0x3B, 0xC0, 0x3B, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0xF1, 0xEF, 0x8F,
  0x1E, 0xF1, 0xF1, 0xEF, 0x1F, 0x3E, 0xF1, 0xF3, 0xCF, 0x3F, 0x3C, 0xF3,
  0xF7, 0xCF, 0x3F, 0x78, 0xF7, 0xF7, 0x8F, 0x7F, 0x78, 0x77, 0x7F, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0x80, 0x1F, 0x07,
  0x83, 0xC3, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x07, 0xBE, 0x01, 0xEF, 0x00,
  0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x3E, 0x7C,
  0x1F, 0x1F, 0x07, 0xC3, 0xC3, 0xE0, 0xF0, 0xF8, 0x3E, 0xF0, 0xF9, 0xE1,
  0xE3, 0xC7, 0xC7, 0x8F, 0x07, 0x3E, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF0, 0x07, 0xC1, 0xF0, 0xFC, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC3, 0xF0,
  0xF1, 0xE3, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x7C, 0x78, 0xF1, 0xE3, 0xC0, 0x07, 0xC1, 0xF0, 0xFC,
  0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0xC3, 0xF0, 0x07, 0x07, 0x83, 0xC3, 0xE1,
  0xF9, 0xDC, 0xEE, 0xE7, 0x73, 0xF1, 0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0x80,
  0xF1, 0xE3, 0x8F, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x3C, 0xF0, 0x0F,
  0x0F, 0xF3, 0xFE, 0x7D, 0xEF, 0x9E, 0xF1, 0xEF, 0x3E, 0xFF, 0xE7, 0xFE,
  0x3D, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF7, 0x87, 0xFE, 0x3F, 0xF1, 0xF7, 0xCF, 0x1E, 0x78, 0xF7, 0x87, 0xBC,
  0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF7, 0xEF, 0xBF, 0xF9, 0xFF, 0x8F, 0x78,
  0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xE3, 0xDF, 0x78, 0xF7, 0x8F, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x71, 0xE7, 0xBE, 0x7F, 0xC3, 0xFC, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0xF7,
  0x87, 0xFE, 0x3F, 0xF8, 0xF3, 0xE7, 0x8F, 0x9E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x3E, 0x3C, 0x79, 0xF1, 0xE7, 0x87, 0xFE, 0x1F, 0xF8, 0x3D,
  0xE0, 0x0F, 0x87, 0xF9, 0xFF, 0xBE, 0xFF, 0x0F, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0xC2, 0x7D, 0xCF, 0xFC, 0xFF, 0x87, 0xC0, 0x07, 0xC3,
  0xF1, 0xFC, 0x7C, 0x1E, 0x0F, 0x0F, 0xF3, 0xFC, 0xFF, 0x0F, 0x07, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x3C, 0x7F, 0xE3, 0xFF, 0x8F, 0xBE, 0x7C, 0x79, 0xE1, 0xE7,
  0x8F, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0x7C, 0x7F, 0xF0,
  0xFF, 0x81, 0xFE, 0x00, 0x78, 0x01, 0xE1, 0x8F, 0x0F, 0xFC, 0x3F, 0xE0,
  0x3E, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3D,
  0xE3, 0xFF, 0x3F, 0xF3, 0xDF, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78,
  0xF7, 0x8F, 0xF9, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0, 0x0E, 0x3C,
  0x78, 0x70, 0x00, 0x0F, 0x9E, 0x3C, 0x78, 0xF1, 0xE7, 0xCF, 0x1E, 0x3C,
  0x78, 0xF3, 0xE7, 0x8F, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE3, 0xF8, 0xFC,
  0x3E, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xC7, 0xCF, 0x3E, 0x3D, 0xF0, 0xF7, 0x83, 0xFC, 0x1F, 0xF0,
  0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xC3, 0xEF, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xF0, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF0,
  0xF0, 0x3D, 0xE3, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0x7F, 0xF3, 0xCF,
  0x1E, 0x79, 0xE3, 0xDE, 0x3C, 0x7B, 0xC7, 0x8F, 0x78, 0xF3, 0xCF, 0x3E,
  0x79, 0xE7, 0x8F, 0x7C, 0xF1, 0xEF, 0x1E, 0x3D, 0xE3, 0xC7, 0xBC, 0x79,
  0xE0, 0x3D, 0xE3, 0xFF, 0x3F, 0xF3, 0xDF, 0x3C, 0xF7, 0x8F, 0x78, 0xF7,
  0x8F, 0x78, 0xF7, 0x8F, 0x79, 0xFF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xE0,
  0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x79, 0xE7, 0x87, 0x3C, 0x3D, 0xE3, 0xEF,
  0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xFB, 0xC7, 0xFE, 0x1F, 0xE0, 0x7C,
  0x00, 0x1E, 0xF0, 0x7F, 0xE1, 0xFF, 0x87, 0xDF, 0x1E, 0x3C, 0xF8, 0xF3,
  0xC3, 0xCF, 0x1F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x9F, 0x3E, 0x7F, 0xF1,
  0xFF, 0x87, 0xBC, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x0F, 0x38, 0xFF, 0xCF, 0xFE, 0x79, 0xF7, 0x8F, 0xBC, 0x79,
  0xE3, 0xCF, 0x1E, 0x78, 0xF7, 0xC7, 0x9E, 0x7C, 0xF3, 0xC7, 0xFE, 0x3F,
  0xF0, 0xF7, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0x3D, 0xCF, 0xF3, 0xF8, 0xFE, 0x3E, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xFE, 0x3F,
  0xE3, 0xCF, 0x78, 0xF3, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0xF1,
  0xEF, 0x3E, 0x7F, 0xC7, 0xF8, 0x1F, 0x00, 0x1E, 0x3C, 0x3C, 0xFF, 0xFF,
  0xFF, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF8, 0xFC, 0x7C,
  0x3C, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x79, 0xFF, 0x1E, 0xF1, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1E, 0xF3, 0xEF, 0x3C, 0xFF, 0xCF, 0xFC, 0x7B, 0xC0,
  0xF8, 0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0x7B, 0xC7, 0xBC, 0x7B, 0x87, 0xF8,
  0x7F, 0x87, 0xF0, 0x7F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x00, 0xE3,
  0x8F, 0xE3, 0x9E, 0xE7, 0x9E, 0xE7, 0x9E, 0xEF, 0xBC, 0xEF, 0xBC, 0xEF,
  0xBC, 0xFD, 0xB8, 0xFD, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1,
  0xE0, 0xF1, 0xE0, 0xF1, 0xE0, 0x1E, 0x7C, 0x79, 0xE1, 0xEF, 0x83, 0xBC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFE,
  0x0F, 0x78, 0x7D, 0xE1, 0xE7, 0x8F, 0x8F, 0x00, 0x3E, 0x3C, 0x79, 0xF1,
  0xE7, 0x87, 0x9E, 0x1E, 0xF0, 0x7B, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x3F, 0xF3, 0xFF,
  0x3F, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0, 0x03, 0x07, 0x0F, 0x1E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0xF0, 0xE0, 0xE0, 0x70,
  0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x30, 0x10, 0x0C,
  0x18, 0x30, 0x61, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C,
  0x18, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18, 0x70, 0x08, 0x07, 0x03, 0x81,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x78, 0x38,
  0x3C, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0xF0,
  0x70, 0x10, 0x00, 0x3C, 0x3B, 0xF1, 0xDF, 0xDF, 0xEF, 0xEE, 0x3F, 0x00,
  0xF0,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 8, 20, 7, 0, -20 },
  { 21, 9, 8, 9, 1, -21 },
  { 30, 14, 20, 14, 0, -20 },
  { 65, 13, 26, 14, 1, -23 },
  { 108, 14, 20, 17, 2, -20 },
  { 143, 15, 20, 16, 0, -20 },
  { 181, 5, 8, 4, 1, -21 },
  { 186, 9, 28, 9, 1, -22 },
  { 218, 9, 28, 9, -1, -22 },
  { 250, 12, 12, 12, 1, -20 },
  { 268, 11, 14, 13, 1, -16 },
  { 288, 7, 9, 7, -2, -3 },
  { 296, 7, 3, 11, 2, -10 },
  { 299, 4, 4, 8, 1, -4 },
  { 301, 12, 22, 9, -2, -20 },
  { 334, 12, 20, 14, 1, -20 },
  { 364, 9, 20, 14, 3, -20 },
  { 387, 13, 20, 14, 0, -20 },
  { 420, 13, 20, 14, 0, -20 },
  { 453, 13, 20, 14, 0, -20 },
  { 486, 13, 20, 14, 1, -20 },
  { 519, 12, 20, 14, 1, -20 },
  { 549, 14, 20, 14, 1, -20 },
  { 584, 12, 20, 14, 1, -20 },
  { 614, 11, 20, 14, 2, -20 },
  { 642, 6, 15, 8, 1, -15 },
  { 654, 8, 21, 7, -1, -15 },
  { 675, 12, 13, 12, 0, -15 },
  { 695, 12, 9, 14, 1, -13 },
  { 709, 12, 13, 12, 0, -15 },
  { 729, 11, 20, 12, 2, -20 },
  { 757, 20, 25, 21, 0, -19 },
  { 820, 16, 20, 16, -1, -20 },
  { 860, 15, 20, 15, 0, -20 },
  { 898, 15, 20, 16, 1, -20 },
  { 936, 15, 20, 15, 0, -20 },
  { 974, 15, 20, 13, 0, -20 },
  { 1012, 14, 20, 13, 0, -20 },
  { 1047, 15, 20, 16, 1, -20 },
  { 1085, 17, 20, 17, 0, -20 },
  { 1128, 8, 20, 7, 0, -20 },
  { 1148, 14, 20, 13, 0, -20 },
  { 1183, 17, 20, 15, 0, -20 },
  { 1226, 12, 20, 13, 0, -20 },
  { 1256, 21, 20, 21, 0, -20 },
  { 1309, 17, 20, 17, 0, -20 },
  { 1352, 15, 20, 16, 1, -20 },
  { 1390, 16, 20, 16, 0, -20 },
  { 1430, 15, 24, 16, 1, -20 },
  { 1475, 15, 20, 15, 0, -20 },
  { 1513, 15, 20, 15, 0, -20 },
  { 1551, 14, 20, 15, 2, -20 },
  { 1586, 15, 20, 16, 1, -20 },
  { 1624, 16, 20, 16, 2, -20 },
  { 1664, 20, 20, 20, 2, -20 },
  { 1714, 18, 20, 15, -1, -20 },
  { 1759, 15, 20, 15, 2, -20 },
  { 1797, 16, 20, 14, 0, -20 },
  { 1837, 10, 28, 7, -1, -23 },
  { 1872, 7, 22, 10, 2, -20 },
  { 1892, 10, 28, 7, -2, -23 },
  { 1927, 9, 10, 11, 1, -20 },
  { 1939, 11, 3, 11, -2, 0 },
  { 1944, 6, 4, 9, 3, -21 },
  { 1947, 12, 15, 13, 0, -15 },
  { 1970, 13, 21, 13, 0, -21 },
  { 2005, 12, 15, 12, 0, -15 },
  { 2028, 14, 21, 13, 0, -21 },
  { 2065, 11, 15, 13, 1, -15 },
  { 2086, 10, 21, 9, 1, -21 },
  { 2113, 14, 21, 14, 0, -15 },
  { 2150, 12, 21, 13, 0, -21 },
  { 2182, 7, 21, 7, 0, -21 },
  { 2201, 10, 27, 7, -3, -21 },
  { 2235, 14, 21, 13, 0, -21 },
  { 2272, 8, 21, 7, 0, -21 },
  { 2293, 19, 15, 20, 0, -15 },
  { 2329, 12, 15, 13, 0, -15 },
  { 2352, 13, 15, 13, 0, -15 },
  { 2377, 14, 21, 13, -1, -15 },
  { 2414, 13, 21, 13, 0, -15 },
  { 2449, 10, 15, 9, 0, -15 },
  { 2468, 12, 15, 12, 0, -15 },
  { 2491, 8, 18, 8, 1, -18 },
  { 2509, 12, 15, 13, 1, -15 },
  { 2532, 12, 15, 12, 1, -15 },
  { 2555, 16, 15, 17, 2, -15 },
  { 2585, 14, 15, 12, -1, -15 },
  { 2612, 14, 21, 12, -1, -15 },
  { 2649, 12, 15, 12, 0, -15 },
  { 2672, 8, 27, 8, 1, -22 },
  { 2699, 7, 24, 7, 0, -20 },
  { 2720, 9, 27, 8, -1, -22 },
  { 2751, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic28pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic28pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic28pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC28PT7B_H_
