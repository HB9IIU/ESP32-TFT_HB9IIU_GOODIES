#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC50PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x70, 0x00,
  0x1F, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0x8F, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x78, 0x00,
  0x1E, 0x3C, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x03, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x07, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0x8F,
  0x80, 0x03, 0xC7, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x3E,
  0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xCF, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x9F, 0xE0, 0x7F, 0x3F,
  0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFE,
  0x3F, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8,
  0x18, 0x7C, 0x7C, 0x1E, 0x7C, 0x7C, 0x3E, 0x78, 0x7C, 0x7C, 0xF8, 0x7C,
  0xF8, 0xF8, 0x7C, 0xF8, 0xF8, 0x79, 0xF0, 0x78, 0xFB, 0xE0, 0x7D, 0xFB,
  0xC0, 0x7F, 0xF7, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xEF, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xFC, 0x01, 0xF7, 0xFE, 0x01, 0xEF, 0xFE, 0x03, 0xFF, 0x9F, 0x07, 0xDF,
  0x1F, 0x07, 0x9F, 0x1F, 0x0F, 0x9E, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1E,
  0x1F, 0x3E, 0x1E, 0x1F, 0x7C, 0x1E, 0x3E, 0x38, 0x1F, 0x3E, 0x08, 0x1F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07,
  0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00,
  0x7E, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x87, 0xE3, 0xFF, 0xC3,
  0xF3, 0xFF, 0xF3, 0xF9, 0xFF, 0xF9, 0xF9, 0xFD, 0xFE, 0xFD, 0xFE, 0x7F,
  0xFE, 0xFF, 0x3F, 0xFF, 0x7F, 0x0F, 0xFF, 0x3F, 0x87, 0xFF, 0x9F, 0xC1,
  0xFF, 0x8F, 0xE0, 0xFF, 0xC7, 0xF8, 0x3F, 0xC3, 0xFE, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x81,
  0xFF, 0x1F, 0xE0, 0x08, 0x00, 0x00, 0x3E, 0x7D, 0xFB, 0xF7, 0xEF, 0x9F,
  0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x9E, 0x00, 0x00, 0x02, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x07, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x40, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x03, 0x83, 0xC1, 0x8F, 0x8F,
  0x3E, 0x7F, 0xBF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xF7, 0x80, 0x1F,
  0x9F, 0x00, 0xFC, 0x3E, 0x07, 0xF0, 0xF8, 0x0F, 0x81, 0xF0, 0x0C, 0x07,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE,
  0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x06, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0x87,
  0xF0, 0x7E, 0x1F, 0xC1, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x81, 0xFD, 0xFE, 0x0F, 0xF7, 0xF0, 0x3F, 0xDF, 0xC0, 0xFE,
  0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFF,
  0x07, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07,
  0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE1,
  0xFC, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00,
  0x7E, 0x03, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFC, 0x7D, 0xFC, 0x61, 0xFC, 0x81, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x1F,
  0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0xFF, 0x1F, 0xE3, 0xFE, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xDF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0xFF, 0x00, 0xFD, 0xFC, 0x03, 0xF3,
  0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0xC1, 0xFC, 0x7F,
  0x83, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xDF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0x87, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x7F,
  0x0F, 0xF0, 0x7F, 0x8F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF9, 0xF0, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xE3,
  0xFD, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F,
  0xEF, 0xE0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF8,
  0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF9, 0xFE, 0x0F,
  0xF3, 0xFC, 0x1F, 0xC7, 0xF8, 0x3F, 0x8F, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0x1F,
  0xC7, 0xF0, 0xFE, 0x7F, 0x87, 0xF3, 0xF8, 0x1F, 0x9F, 0xC1, 0xFD, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFB, 0xFC, 0x1F, 0xDF, 0xE0, 0xFE,
  0x7F, 0x07, 0xF3, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFB, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xE1, 0xFF, 0x1F,
  0xF0, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xC0, 0x00,
  0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0,
  0x1E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x10, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xDF, 0xE7, 0xFB, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xC0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x1F,
  0x01, 0xF8, 0x0F, 0x07, 0xC0, 0xFF, 0xC1, 0xE0, 0xF8, 0x3F, 0xFC, 0x3C,
  0x3E, 0x0F, 0xFF, 0xC7, 0x87, 0xC1, 0xFD, 0xF0, 0xF1, 0xF0, 0x7E, 0x3E,
  0x1E, 0x3E, 0x1F, 0x87, 0xC3, 0xC7, 0xC3, 0xE0, 0xF8, 0x79, 0xF0, 0xFC,
  0x3E, 0x0F, 0x3E, 0x1F, 0x07, 0xC1, 0xE7, 0xC3, 0xE0, 0xF8, 0x3C, 0xF0,
  0xFC, 0x1F, 0x07, 0xBE, 0x1F, 0x87, 0xC0, 0xF7, 0xC3, 0xE0, 0xF8, 0x3E,
  0xF8, 0x7C, 0x1F, 0x07, 0x9F, 0x0F, 0x83, 0xE0, 0xF3, 0xE3, 0xF0, 0x7C,
  0x1E, 0x78, 0x7E, 0x1F, 0x07, 0x8F, 0x0F, 0xC3, 0xE0, 0xF1, 0xE0, 0xF8,
  0xFC, 0x3E, 0x3C, 0x1F, 0x1F, 0x87, 0x87, 0x83, 0xFF, 0xFF, 0xE0, 0xF0,
  0x7F, 0xFF, 0xFC, 0x1F, 0x07, 0xFB, 0xFF, 0x03, 0xE0, 0x7E, 0x3F, 0x80,
  0x7C, 0x02, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x10, 0x00, 0x03, 0xFF, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x03,
  0xF9, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0,
  0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF0,
  0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0x80, 0xFE, 0x1F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFF,
  0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xE0,
  0x1F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x87,
  0xF8, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xFC,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC1, 0xFF,
  0xE7, 0xF0, 0x7F, 0xFB, 0xFC, 0x1F, 0xFE, 0xFF, 0x07, 0xFF, 0xBF, 0xC3,
  0xFF, 0xEF, 0xF0, 0xFF, 0xF3, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0x81, 0xFE,
  0x1F, 0xF1, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x01, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x07, 0xF0, 0x1F, 0xF8, 0x0F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x83, 0xFF, 0x00, 0xFF,
  0x07, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xF8, 0x7F, 0xC0, 0x07, 0xF0,
  0xFF, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFB, 0xFC, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFE,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xDF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0xFF, 0xF8, 0x1F, 0xCF, 0x87, 0xEF, 0xE0, 0x7F, 0x3E, 0x1F, 0xBF, 0x81,
  0xFC, 0xF8, 0xFD, 0xFE, 0x07, 0xF3, 0xE3, 0xF7, 0xF8, 0x1F, 0xCF, 0x8F,
  0x9F, 0xC0, 0xFF, 0x3E, 0x7E, 0x7F, 0x03, 0xFC, 0xF9, 0xF1, 0xFC, 0x0F,
  0xF3, 0xEF, 0xCF, 0xF0, 0x3F, 0x8F, 0xBF, 0x3F, 0xC0, 0xFE, 0x3F, 0xF8,
  0xFE, 0x03, 0xF8, 0xFF, 0xE3, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xE0, 0x7F,
  0x87, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x87,
  0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3F, 0xC1, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F,
  0x81, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0x03, 0xF8,
  0x0F, 0xFE, 0x0F, 0xF0, 0x3F, 0xFC, 0x1F, 0xE0, 0x7F, 0xF8, 0x3F, 0xC0,
  0xFF, 0xF8, 0x7F, 0x81, 0xFD, 0xF0, 0xFE, 0x03, 0xFB, 0xE1, 0xFC, 0x07,
  0xF7, 0xC7, 0xF8, 0x1F, 0xEF, 0xCF, 0xF0, 0x3F, 0xCF, 0x9F, 0xE0, 0x7F,
  0x9F, 0x3F, 0xC0, 0xFE, 0x3E, 0x7F, 0x01, 0xFC, 0x7C, 0xFE, 0x07, 0xF8,
  0x7F, 0xFC, 0x0F, 0xF0, 0xFF, 0xF8, 0x1F, 0xE1, 0xFF, 0xF0, 0x3F, 0xC3,
  0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x03, 0xFC, 0x0F,
  0xFE, 0x07, 0xF8, 0x1F, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xE0, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x81, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xFB, 0xFC, 0x00,
  0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F,
  0xC0, 0x1F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFF,
  0x8F, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xE0,
  0x7F, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3,
  0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F,
  0xEF, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x1F, 0xE7, 0xF0,
  0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC,
  0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x8F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F,
  0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xFE, 0x1F, 0xE0, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFE, 0x3F, 0xC0,
  0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03,
  0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0xC7, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8,
  0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8,
  0x7F, 0x03, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF0,
  0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0,
  0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x7F,
  0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF1,
  0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x1F, 0xDF, 0xE0, 0x7F, 0x03, 0xFB,
  0xFC, 0x1F, 0xE0, 0xFF, 0x7F, 0x83, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0x83,
  0xF9, 0xFE, 0x1F, 0xF0, 0xFF, 0x3F, 0xC3, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F,
  0xC3, 0xF8, 0xFF, 0x1F, 0xF8, 0x7F, 0x1F, 0xE3, 0xFF, 0x1F, 0xE3, 0xFC,
  0x7F, 0xE3, 0xF8, 0x7F, 0x1F, 0xFC, 0x7F, 0x0F, 0xE3, 0xFF, 0x9F, 0xE1,
  0xFC, 0x7F, 0xF3, 0xF8, 0x3F, 0x9F, 0xFE, 0x7F, 0x07, 0xF3, 0xFF, 0xDF,
  0xE0, 0xFE, 0x7F, 0xFB, 0xF8, 0x1F, 0xDF, 0xFF, 0x7F, 0x03, 0xFB, 0xF7,
  0xEF, 0xE0, 0x7F, 0x7E, 0xFF, 0xF8, 0x0F, 0xFF, 0xDF, 0xFF, 0x00, 0xFF,
  0xF3, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xF8, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x7F, 0xF1, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x03,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xE7,
  0xF0, 0x0F, 0xF9, 0xFC, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F,
  0x83, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07,
  0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF,
  0x01, 0xF3, 0xC0, 0xFC, 0xF0, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xE3,
  0xF0, 0xF8, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x83, 0xF0, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80,
  0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x00,
  0x1F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9,
  0xFF, 0x9F, 0xCF, 0xF0, 0xFE, 0x7F, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3,
  0xF9, 0xFE, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x1F, 0xEF, 0xE0, 0x7C, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x7C, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0xCF,
  0xF0, 0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC0,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x87, 0xF7, 0xFF, 0x0F, 0xE7, 0xFC, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFF, 0x1F, 0xCF, 0xF0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x1F,
  0x9F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x87, 0xF9,
  0xFE, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0x9F, 0xE0,
  0x3F, 0xEF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x3F,
  0x83, 0xF8, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07,
  0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFE, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0x0F,
  0xE7, 0xF0, 0x7F, 0x7F, 0x83, 0xFB, 0xF8, 0x1F, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x60, 0xFF, 0x0F, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x03, 0xFF,
  0x7F, 0x07, 0xFF, 0x7F, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x81, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03,
  0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xE7,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x20, 0x1F, 0xE0, 0x30, 0x3F,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE,
  0x7F, 0x03, 0xF9, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC1, 0xFC, 0xFF,
  0x07, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC, 0xFE, 0x0F,
  0xF3, 0xF8, 0x3F, 0x80, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xF8, 0x7F, 0x0F, 0xF8, 0x3F, 0x8F, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F,
  0xE7, 0xFC, 0x0F, 0xF7, 0xFC, 0x07, 0xF7, 0xFC, 0x03, 0xFB, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF8, 0x00, 0x0F, 0xE3, 0xE0, 0x7E, 0x03, 0xFB, 0xFC, 0x7F, 0xC0,
  0xFF, 0xFF, 0xBF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0x07, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x07, 0xF1, 0xFC, 0x3F,
  0xC3, 0xFC, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0x83, 0xF8, 0x3F, 0x8F, 0xE0,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x7F,
  0x87, 0xF8, 0x7F, 0x9F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x07, 0xF1,
  0xFC, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x3F,
  0xCF, 0xF0, 0xFF, 0x0F, 0xF3, 0xF8, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE0,
  0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x3F, 0xBF, 0xC0,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x9F,
  0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x1F, 0xE7, 0xF0, 0x7F, 0x9F, 0xC1,
  0xFC, 0xFF, 0x07, 0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC,
  0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFC,
  0x7F, 0x8F, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0xBF, 0xC0, 0xFE, 0xFF, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF,
  0x80, 0xFE, 0xFE, 0x07, 0xFB, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0xC3,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0x7F, 0xF0, 0x3F, 0x9F, 0xE0,
  0x1F, 0xC7, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0xFE, 0x0F, 0xF9, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0x03,
  0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x3F, 0xCF, 0xE0, 0x7F,
  0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1,
  0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE7, 0x87, 0xF7, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xF1,
  0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE7,
  0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xFB, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xC0, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1,
  0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xFC, 0x1F,
  0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFF, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xF8,
  0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x8F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFC,
  0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF8, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xEF, 0xC0, 0x1F, 0x00,
  0x00, 0xFF, 0x07, 0xFB, 0xF8, 0x3F, 0xDF, 0xC1, 0xFC, 0xFE, 0x1F, 0xE7,
  0xF0, 0xFF, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x7F, 0x03, 0xF7, 0xF0, 0x1F,
  0xBF, 0x80, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x1F,
  0x83, 0xFF, 0xF0, 0xFC, 0x3F, 0xBF, 0x87, 0xE1, 0xFD, 0xFC, 0x7F, 0x0F,
  0xEF, 0xE3, 0xF8, 0xFE, 0x7E, 0x3F, 0xC7, 0xF3, 0xF1, 0xFE, 0x3F, 0x1F,
  0x8F, 0xF3, 0xF8, 0xFC, 0xFF, 0x9F, 0xC7, 0xE7, 0xFC, 0xFC, 0x3F, 0x7F,
  0xEF, 0xE1, 0xFB, 0xFF, 0x7F, 0x0F, 0xDF, 0xFB, 0xF0, 0x7F, 0xFF, 0xDF,
  0x83, 0xFF, 0x9F, 0xF8, 0x1F, 0xFC, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07,
  0xFE, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x7F,
  0x83, 0xFC, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F,
  0xE0, 0x1F, 0xCF, 0xE0, 0x07, 0xEF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0xFC, 0x01,
  0xFE, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x87, 0xF0,
  0x7F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF8, 0x07,
  0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFD, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xC0, 0x7C, 0xFF, 0xC1, 0xFB, 0xFF, 0xC3, 0xF7, 0xFF, 0xCF, 0xCF,
  0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0x7E, 0x1F, 0xFC, 0xF8, 0x3F, 0xF1, 0xF0,
  0x3F, 0xE0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 13, 36, 13, 1, -36 },
  { 60, 16, 14, 15, 2, -38 },
  { 88, 25, 36, 25, 1, -36 },
  { 201, 23, 46, 25, 1, -41 },
  { 334, 24, 36, 31, 4, -36 },
  { 442, 25, 37, 28, 1, -36 },
  { 558, 7, 14, 8, 3, -38 },
  { 571, 16, 50, 16, 2, -39 },
  { 671, 16, 50, 16, -2, -39 },
  { 771, 22, 22, 22, 2, -36 },
  { 832, 21, 26, 23, 1, -29 },
  { 901, 11, 15, 12, -3, -6 },
  { 922, 13, 6, 19, 3, -18 },
  { 932, 8, 8, 14, 1, -8 },
  { 940, 22, 39, 16, -3, -36 },
  { 1048, 22, 36, 25, 2, -36 },
  { 1147, 16, 36, 25, 5, -36 },
  { 1219, 24, 36, 25, 0, -36 },
  { 1327, 23, 36, 25, 1, -36 },
  { 1431, 23, 36, 25, 1, -36 },
  { 1535, 24, 36, 25, 1, -36 },
  { 1643, 21, 36, 25, 2, -36 },
  { 1738, 24, 36, 25, 2, -36 },
  { 1846, 23, 36, 25, 1, -36 },
  { 1950, 21, 36, 25, 3, -36 },
  { 2045, 12, 28, 14, 1, -28 },
  { 2087, 14, 37, 13, -2, -28 },
  { 2152, 20, 24, 22, 1, -27 },
  { 2212, 21, 17, 25, 2, -24 },
  { 2257, 20, 24, 22, 1, -27 },
  { 2317, 19, 36, 22, 3, -36 },
  { 2403, 35, 46, 37, 1, -35 },
  { 2605, 28, 36, 29, -2, -36 },
  { 2731, 27, 36, 27, 0, -36 },
  { 2853, 26, 36, 28, 2, -36 },
  { 2970, 27, 36, 27, 0, -36 },
  { 3092, 26, 36, 24, 0, -36 },
  { 3209, 26, 36, 23, 0, -36 },
  { 3326, 26, 36, 29, 2, -36 },
  { 3443, 31, 36, 30, 0, -36 },
  { 3583, 14, 36, 13, 0, -36 },
  { 3646, 25, 36, 24, 0, -36 },
  { 3759, 31, 36, 27, 0, -36 },
  { 3899, 21, 36, 23, 0, -36 },
  { 3994, 38, 36, 37, 0, -36 },
  { 4165, 31, 36, 30, 0, -36 },
  { 4305, 27, 36, 29, 2, -36 },
  { 4427, 28, 36, 28, 0, -36 },
  { 4553, 27, 42, 29, 2, -36 },
  { 4695, 27, 36, 27, 0, -36 },
  { 4817, 26, 36, 26, 1, -36 },
  { 4934, 25, 36, 27, 4, -36 },
  { 5047, 28, 36, 28, 1, -36 },
  { 5173, 27, 36, 28, 4, -36 },
  { 5295, 35, 36, 36, 4, -36 },
  { 5453, 32, 36, 27, -2, -36 },
  { 5597, 26, 36, 27, 4, -36 },
  { 5714, 29, 36, 26, -1, -36 },
  { 5845, 17, 50, 13, -1, -42 },
  { 5952, 12, 39, 19, 4, -36 },
  { 6011, 18, 50, 13, -3, -42 },
  { 6124, 18, 18, 19, 1, -36 },
  { 6165, 19, 6, 19, -3, 0 },
  { 6180, 11, 8, 16, 5, -38 },
  { 6191, 21, 26, 23, 0, -26 },
  { 6260, 23, 38, 24, 0, -38 },
  { 6370, 21, 26, 22, 1, -26 },
  { 6439, 25, 38, 24, 1, -38 },
  { 6558, 21, 26, 23, 1, -26 },
  { 6627, 18, 39, 16, 1, -39 },
  { 6715, 24, 36, 25, 0, -26 },
  { 6823, 22, 38, 24, 0, -38 },
  { 6928, 13, 37, 12, 0, -37 },
  { 6989, 19, 47, 12, -6, -37 },
  { 7101, 25, 38, 23, 0, -38 },
  { 7220, 14, 38, 12, 0, -38 },
  { 7287, 34, 26, 36, 0, -26 },
  { 7398, 22, 26, 24, 0, -26 },
  { 7470, 22, 26, 24, 1, -26 },
  { 7542, 25, 36, 24, -2, -26 },
  { 7655, 23, 36, 24, 1, -26 },
  { 7759, 17, 26, 16, 0, -26 },
  { 7815, 21, 26, 22, 0, -26 },
  { 7884, 14, 33, 15, 2, -33 },
  { 7942, 23, 26, 24, 1, -26 },
  { 8017, 21, 26, 22, 2, -26 },
  { 8086, 29, 26, 31, 3, -26 },
  { 8181, 25, 26, 22, -2, -26 },
  { 8263, 25, 36, 22, -1, -26 },
  { 8376, 23, 26, 22, -1, -26 },
  { 8451, 15, 48, 14, 1, -39 },
  { 8541, 11, 43, 12, 1, -36 },
  { 8601, 16, 48, 14, -2, -39 },
  { 8697, 23, 11, 27, 2, -20 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic50pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic50pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic50pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC50PT7B_H_
