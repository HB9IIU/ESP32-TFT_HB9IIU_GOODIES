#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC43PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1E, 0x00, 0x3C, 0x79, 0xE3, 0xCF,
  0x3E, 0xF9, 0xF7, 0xCF, 0xBC, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0x8F,
  0x3C, 0x79, 0xE3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x38, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x07, 0x9E, 0x00, 0x1C, 0x78, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x0E, 0x3C, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x38,
  0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x1E, 0x00, 0x3C, 0xF0, 0x00,
  0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x7E, 0x0F, 0xC7, 0xF1, 0xFC, 0x3F,
  0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x1F, 0xCF, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xF3, 0xF8, 0x7F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x08, 0xF9, 0xE0, 0xCF, 0x1E, 0x1E, 0xF1,
  0xE3, 0xCF, 0x1E, 0x7C, 0xF1, 0xE7, 0x8F, 0x3E, 0xF0, 0xFF, 0xDE, 0x07,
  0xFD, 0xE0, 0x7F, 0xBC, 0x01, 0xE7, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0xF8, 0x03, 0xDF, 0xC0, 0x7B, 0xFE, 0x0F, 0xFF,
  0xF0, 0xF7, 0x8F, 0x1E, 0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF7, 0x8F,
  0x8F, 0xF0, 0x79, 0xE3, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xDF, 0x80, 0x7E, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0xFC, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0x0F, 0xFC,
  0x7C, 0x7F, 0xF1, 0xF3, 0xFF, 0xEF, 0xDF, 0xDF, 0xBF, 0x7E, 0x7F, 0xF9,
  0xF8, 0xFF, 0xE7, 0xE3, 0xFF, 0x1F, 0x87, 0xFC, 0x7E, 0x1F, 0xE1, 0xFC,
  0x7F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xEF,
  0xE0, 0x7E, 0x1F, 0x80, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x9F, 0x3C, 0x78,
  0xF3, 0xE7, 0x80, 0x00, 0x10, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x07, 0x00, 0x10, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x41, 0xE1, 0x9F, 0x3C, 0xF3, 0xFF,
  0xFE, 0xFF, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x3E, 0xF0, 0x0F, 0x8F, 0x03, 0xF1, 0xE0, 0x7C, 0x3E, 0x03, 0x03,
  0x80, 0x00, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF0,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3E, 0x1E, 0x02, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0x7F, 0xEF, 0xFC, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF3, 0xF0, 0xFC,
  0xFC, 0x3F, 0x3F, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E,
  0x0F, 0xDF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x18, 0x07, 0xC0, 0xFE, 0x3F,
  0xE7, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xF7, 0xF4, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xF3,
  0xF8, 0x3F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF3, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F,
  0xC3, 0xF9, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7D, 0xFC, 0x07,
  0xDF, 0x80, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF1, 0xF8, 0x3F, 0x3F, 0x87,
  0xE3, 0xF8, 0x7C, 0x3F, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x7C, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF,
  0x81, 0xE1, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xF8, 0xFE,
  0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF7, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFC, 0xFE, 0xFE, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0xFE, 0xFC,
  0x3F, 0x3F, 0x9F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x7E,
  0x0F, 0xC7, 0xE1, 0xFC, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x0F, 0xCF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E,
  0x1F, 0x8F, 0xE1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFE, 0x1F, 0x8F,
  0xE3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xF1, 0xF9, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xF7, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFC,
  0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x07, 0x03, 0xE1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0xC3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xC1, 0xE0, 0x00, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x06, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00,
  0x00, 0x80, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x80, 0x10, 0x00,
  0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0xE0,
  0xFF, 0xF3, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x80, 0xFE, 0x00, 0x7C, 0x00,
  0x38, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0x78, 0x3C, 0x0F, 0xC1, 0xE1, 0xF0, 0x7F, 0x83,
  0x87, 0x83, 0xFF, 0x8E, 0x3E, 0x1F, 0xFC, 0x38, 0xF0, 0xF8, 0xF0, 0xE3,
  0xC7, 0xC3, 0xC3, 0xDE, 0x1F, 0x0F, 0x0E, 0x78, 0x78, 0x7C, 0x39, 0xE3,
  0xE1, 0xE0, 0xEF, 0x8F, 0x87, 0x87, 0xBC, 0x3C, 0x1E, 0x1E, 0xF1, 0xF0,
  0xF8, 0x7B, 0xC7, 0xC3, 0xC1, 0xCF, 0x1F, 0x0F, 0x0F, 0x3C, 0x7C, 0x7C,
  0x3C, 0xF1, 0xF1, 0xF0, 0xE3, 0xC7, 0xCF, 0xC7, 0x8F, 0x1F, 0xFF, 0xFC,
  0x3C, 0x3F, 0xFF, 0xE0, 0xF0, 0xFE, 0x7F, 0x03, 0xC1, 0xF0, 0xF8, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x60, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x7C, 0x01, 0xFC,
  0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC1, 0xFC, 0x7F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE,
  0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFE, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF8, 0xFC, 0x1F,
  0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFE, 0x7F, 0x83, 0xF0, 0x3F,
  0x0F, 0xE0, 0x7F, 0x1F, 0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFE, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01,
  0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xFC, 0xFF, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFC,
  0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F,
  0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFC, 0x7F,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xCF, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00,
  0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0xBF, 0x87, 0xFE, 0xFE, 0x1F, 0xFB, 0xF8,
  0xFF, 0xEF, 0xC3, 0xFF, 0xBF, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF1, 0xFE, 0x7F, 0xC7,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0, 0xFE, 0x3F, 0x83,
  0xFB, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x0F, 0xF8, 0x1F,
  0x81, 0xFE, 0x03, 0xF0, 0x7F, 0x80, 0x7E, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x0F, 0xC7, 0xF0, 0x01, 0xF9,
  0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x3F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE,
  0x07, 0xFE, 0x07, 0xFF, 0x07, 0xEF, 0x03, 0xFF, 0x83, 0xF7, 0x83, 0xEF,
  0xC1, 0xFB, 0xC1, 0xFF, 0xC0, 0xFD, 0xF1, 0xFF, 0xE0, 0x7E, 0xF8, 0xFB,
  0xF0, 0x3F, 0x7C, 0x7D, 0xF8, 0x3F, 0xBE, 0x7D, 0xFC, 0x1F, 0xDF, 0x3E,
  0xFE, 0x0F, 0xCF, 0xBE, 0x7E, 0x07, 0xE7, 0xDF, 0x3F, 0x03, 0xF1, 0xEF,
  0x9F, 0x81, 0xF8, 0xFF, 0x9F, 0xC1, 0xFC, 0x7F, 0xCF, 0xE0, 0xFE, 0x3F,
  0xC7, 0xF0, 0x7F, 0x1F, 0xE3, 0xF0, 0x3F, 0x0F, 0xE1, 0xF8, 0x1F, 0x87,
  0xF1, 0xFC, 0x0F, 0xC3, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x7F, 0x07, 0xF0,
  0xFC, 0x3F, 0x83, 0xF8, 0x7C, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC3,
  0xFE, 0x07, 0xE0, 0xFF, 0x81, 0xF8, 0x3F, 0xE0, 0x7E, 0x0F, 0xFC, 0x3F,
  0x83, 0xFF, 0x0F, 0xE1, 0xFF, 0xC3, 0xF8, 0x7F, 0xF0, 0xFC, 0x1F, 0xFE,
  0x3F, 0x07, 0xF7, 0x8F, 0xC1, 0xF9, 0xE7, 0xF0, 0x7E, 0x79, 0xFC, 0x3F,
  0x9F, 0x7F, 0x0F, 0xE3, 0xDF, 0x83, 0xF8, 0xF7, 0xE0, 0xFE, 0x3D, 0xF8,
  0x3F, 0x0F, 0xFE, 0x0F, 0xC3, 0xFF, 0x87, 0xF0, 0x7F, 0xE1, 0xFC, 0x1F,
  0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0x81, 0xFF, 0x07, 0xE0, 0x3F, 0xC1, 0xF8,
  0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x07, 0xF0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F,
  0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01,
  0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F,
  0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x0F, 0xE0,
  0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xE1, 0xFE,
  0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE,
  0x1F, 0x83, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x07, 0xF0, 0x7F, 0x1F,
  0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0xFE, 0x01, 0xF9, 0xFC, 0x03, 0xF3, 0xF0,
  0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x7F, 0x00,
  0xFE, 0xFE, 0x01, 0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFC, 0x7E, 0x03, 0xF8,
  0xFE, 0x0F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x20, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xE1, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03,
  0xF1, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xF0, 0x7F,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x8F, 0xE0,
  0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xCF,
  0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFE, 0x0F, 0xE1, 0xFE, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE,
  0x1F, 0x80, 0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8,
  0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0x7E, 0x07, 0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x81, 0xFF, 0xE0, 0xFC,
  0x1F, 0xFF, 0x07, 0xE0, 0xFD, 0xF8, 0x7F, 0x07, 0xEF, 0xC3, 0xF8, 0x7F,
  0x7E, 0x1F, 0xC3, 0xF3, 0xF1, 0xFE, 0x1F, 0x9F, 0x8F, 0xF1, 0xFC, 0xFC,
  0x7F, 0x8F, 0xE7, 0xE7, 0xFC, 0x7E, 0x3F, 0x3F, 0xE3, 0xF1, 0xF9, 0xFF,
  0x3F, 0x8F, 0xDF, 0xF9, 0xF8, 0x7E, 0xFF, 0xCF, 0xC3, 0xF7, 0xFE, 0xFE,
  0x1F, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0x7F, 0xF8, 0x3F,
  0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0, 0x7F, 0xE7,
  0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x8F, 0xF8,
  0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x83,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x1F,
  0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x00,
  0x7E, 0x01, 0xFE, 0xFC, 0x03, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC3,
  0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC3, 0xF8, 0x1F, 0x87, 0xF0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81,
  0xFE, 0x03, 0xFC, 0x00, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0,
  0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01,
  0xEF, 0x07, 0xDE, 0x0F, 0x3C, 0x3E, 0x78, 0x78, 0xF1, 0xF1, 0xE3, 0xC3,
  0xEF, 0x87, 0xDE, 0x0F, 0x80, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7C, 0x1F, 0x83, 0xE0,
  0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF,
  0xC7, 0xE3, 0xF3, 0xF8, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xC7, 0xE7, 0xE1, 0xFB, 0xF8,
  0x7E, 0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x0F, 0xEF, 0xC1, 0xF3, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xFB, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xF3, 0xF8, 0xFC, 0x3F, 0x3F, 0x87, 0xE7, 0xF0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xDF, 0xC1, 0xFB,
  0xF8, 0x3F, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xFC, 0x7F, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFB, 0xFE, 0x3F, 0x7F, 0x87, 0xE7, 0xE0, 0x01, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xC7, 0xE7, 0xE1,
  0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0xBF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x9F, 0xCF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x1F, 0x3F, 0x03, 0xFD, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF1, 0xFC, 0x7F, 0x8F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0x9F, 0xC1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xE7,
  0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x8F, 0xE7, 0xF7, 0xF0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x04, 0x3F, 0xC7, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFE,
  0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF1, 0xF8,
  0x3F, 0xEF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xE3,
  0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x1C, 0x1F, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFB, 0xE0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xF3, 0xF9, 0xFC, 0x3F, 0x3F,
  0x87, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x87, 0xF3, 0xF0, 0xFC, 0xFE,
  0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9, 0xF8,
  0x7E, 0x7F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE1,
  0xFC, 0x01, 0x80, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F,
  0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x00, 0x00,
  0x0C, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0xE0, 0xFC, 0x7F, 0x87, 0xF3, 0xFC, 0x1F, 0x9F, 0xE0, 0x7E,
  0x7F, 0x01, 0xFB, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x01, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC,
  0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0x0F, 0xDF, 0x07, 0xE0, 0x7D, 0xFE, 0x7F, 0x87, 0xFF,
  0xF7, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xE7, 0xF9,
  0xFC, 0x7E, 0x1F, 0x87, 0xE7, 0xF0, 0xFC, 0x3F, 0x3F, 0x87, 0xE1, 0xF9,
  0xF8, 0x7F, 0x0F, 0xCF, 0xC3, 0xF0, 0xFE, 0x7E, 0x1F, 0x87, 0xF3, 0xF0,
  0xFC, 0x3F, 0x3F, 0x87, 0xE1, 0xF9, 0xFC, 0x3F, 0x0F, 0xCF, 0xC3, 0xF8,
  0x7E, 0x7E, 0x1F, 0x87, 0xF3, 0xF0, 0xFC, 0x3F, 0x9F, 0x87, 0xE1, 0xF9,
  0xFC, 0x3F, 0x0F, 0xCF, 0xC1, 0xF8, 0x7E, 0x7E, 0x1F, 0xC3, 0xF3, 0xF0,
  0xFC, 0x3F, 0x80, 0x1F, 0x9F, 0x03, 0xF7, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3F, 0x9F, 0xCF, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x07,
  0xE7, 0xE0, 0xFC, 0xFC, 0x3F, 0x9F, 0x87, 0xE7, 0xF0, 0xFC, 0xFE, 0x1F,
  0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0xCF, 0xC3, 0xF3, 0xF8, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x0F, 0xE0, 0x01, 0xFC,
  0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xCF, 0xE7, 0xF7,
  0xF0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7E, 0xFC, 0x1F,
  0xBF, 0x8F, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00,
  0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x1F, 0xBF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x7E,
  0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7F, 0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x7F, 0xC0,
  0xFD, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE3, 0xE1, 0xFE, 0xFC, 0x7F,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE, 0x3F, 0xDF, 0x83, 0xF3, 0xF0,
  0x7E, 0xFE, 0x0F, 0xDF, 0x81, 0xFB, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF, 0xC1,
  0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x3F, 0x9F, 0xCF,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xDF,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x9E,
  0x3F, 0x7C, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xF8, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0xC7, 0xFF,
  0xF1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x3F, 0xFD, 0xFF, 0xCF, 0xFE, 0x7F,
  0xF7, 0xFF, 0x87, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x3F, 0x87, 0xE3, 0xF8,
  0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x7F,
  0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7,
  0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8,
  0xFC, 0x3F, 0x8F, 0xE7, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0x3F, 0x00, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFB, 0xF8, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xE1, 0xF9, 0xF8,
  0x7E, 0x7E, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x3E,
  0x1F, 0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x87, 0xEF, 0x8F, 0xC7, 0xE7, 0xC7,
  0xE3, 0xF3, 0xE7, 0xF1, 0xF1, 0xF3, 0xF9, 0xF8, 0xF9, 0xFC, 0xFC, 0x7D,
  0xFE, 0x7C, 0x3E, 0xFF, 0x7E, 0x1F, 0x7F, 0xBF, 0x0F, 0xFF, 0xDF, 0x07,
  0xFD, 0xFF, 0x83, 0xFE, 0xFF, 0xC1, 0xFF, 0x7F, 0xC0, 0xFF, 0x3F, 0xE0,
  0x7F, 0x8F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE1,
  0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x03, 0xF7, 0xF0,
  0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0x7E, 0x01,
  0xFD, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x07, 0xF0,
  0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xF1,
  0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x3F, 0x80, 0xFC, 0xFE, 0x03, 0xF3, 0xF0,
  0x0F, 0xDF, 0xC0, 0x3F, 0x7E, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x10, 0x03, 0x80, 0x3E, 0x03, 0xF0, 0x3F,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x3F, 0xC1, 0xFC,
  0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xC0, 0x0E, 0x00, 0x20,
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x00, 0x02, 0x00, 0x1C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xFE, 0x03, 0xF0, 0x0F, 0x01, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xC0,
  0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xE0, 0x06, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x0F, 0x3F, 0xE0, 0xF3,
  0xFF, 0x1F, 0x7F, 0xF9, 0xF7, 0xCF, 0xFE, 0x7C, 0x7F, 0xE7, 0x83, 0xFC,
  0xF8, 0x1F, 0xC0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 31, 11, 1, -31 },
  { 44, 13, 12, 13, 2, -32 },
  { 64, 22, 31, 22, 0, -31 },
  { 150, 20, 39, 21, 1, -35 },
  { 248, 20, 31, 27, 4, -31 },
  { 326, 22, 31, 25, 0, -31 },
  { 412, 7, 12, 7, 2, -32 },
  { 423, 13, 43, 14, 2, -34 },
  { 493, 14, 44, 13, -2, -34 },
  { 570, 19, 19, 19, 2, -31 },
  { 616, 18, 22, 20, 1, -25 },
  { 666, 9, 13, 11, -2, -5 },
  { 681, 11, 5, 16, 3, -16 },
  { 688, 7, 7, 12, 1, -7 },
  { 695, 19, 34, 13, -3, -31 },
  { 776, 18, 31, 21, 2, -31 },
  { 846, 13, 31, 21, 5, -31 },
  { 897, 21, 31, 21, 0, -31 },
  { 979, 21, 31, 21, 0, -31 },
  { 1061, 20, 31, 21, 1, -31 },
  { 1139, 20, 31, 21, 1, -31 },
  { 1217, 18, 31, 21, 2, -31 },
  { 1287, 20, 31, 21, 2, -31 },
  { 1365, 20, 31, 21, 1, -31 },
  { 1443, 17, 31, 21, 3, -31 },
  { 1509, 10, 24, 12, 1, -24 },
  { 1539, 13, 32, 11, -2, -24 },
  { 1591, 17, 20, 19, 1, -23 },
  { 1634, 18, 14, 21, 2, -20 },
  { 1666, 17, 20, 19, 1, -23 },
  { 1709, 16, 31, 19, 3, -31 },
  { 1771, 30, 40, 32, 1, -30 },
  { 1921, 24, 31, 25, -2, -31 },
  { 2014, 23, 31, 24, 0, -31 },
  { 2104, 23, 31, 24, 1, -31 },
  { 2194, 23, 31, 24, 0, -31 },
  { 2284, 23, 31, 20, 0, -31 },
  { 2374, 22, 31, 20, 0, -31 },
  { 2460, 22, 31, 25, 2, -31 },
  { 2546, 26, 31, 26, 0, -31 },
  { 2647, 12, 31, 11, 0, -31 },
  { 2694, 21, 31, 21, 0, -31 },
  { 2776, 27, 31, 23, 0, -31 },
  { 2881, 18, 31, 20, 0, -31 },
  { 2951, 33, 31, 32, 0, -31 },
  { 3079, 26, 31, 25, 0, -31 },
  { 3180, 23, 31, 25, 2, -31 },
  { 3270, 24, 31, 24, 0, -31 },
  { 3363, 23, 37, 25, 2, -31 },
  { 3470, 23, 31, 23, 0, -31 },
  { 3560, 22, 31, 23, 1, -31 },
  { 3646, 22, 31, 23, 3, -31 },
  { 3732, 24, 31, 24, 1, -31 },
  { 3825, 24, 31, 24, 3, -31 },
  { 3918, 29, 31, 31, 4, -31 },
  { 4031, 28, 31, 23, -2, -31 },
  { 4140, 23, 31, 23, 3, -31 },
  { 4230, 25, 31, 22, -1, -31 },
  { 4327, 15, 43, 11, -1, -36 },
  { 4408, 11, 34, 16, 3, -31 },
  { 4455, 15, 43, 11, -2, -36 },
  { 4536, 15, 15, 17, 1, -31 },
  { 4565, 17, 5, 17, -3, 0 },
  { 4576, 10, 7, 14, 4, -33 },
  { 4585, 18, 23, 20, 0, -23 },
  { 4637, 19, 32, 21, 0, -32 },
  { 4713, 18, 23, 19, 1, -23 },
  { 4765, 21, 32, 21, 1, -32 },
  { 4849, 18, 23, 20, 1, -23 },
  { 4901, 16, 32, 14, 1, -32 },
  { 4965, 21, 32, 21, 0, -23 },
  { 5049, 19, 32, 21, 0, -32 },
  { 5125, 11, 33, 11, 0, -33 },
  { 5171, 16, 42, 10, -5, -33 },
  { 5255, 22, 32, 20, 0, -32 },
  { 5343, 12, 32, 11, 0, -32 },
  { 5391, 29, 23, 31, 0, -23 },
  { 5475, 19, 23, 21, 0, -23 },
  { 5530, 18, 23, 21, 1, -23 },
  { 5582, 22, 32, 21, -2, -23 },
  { 5670, 19, 32, 21, 1, -23 },
  { 5746, 15, 23, 14, 0, -23 },
  { 5790, 18, 23, 19, 0, -23 },
  { 5842, 13, 28, 13, 1, -28 },
  { 5888, 20, 23, 21, 1, -23 },
  { 5946, 18, 23, 19, 2, -23 },
  { 5998, 25, 23, 26, 2, -23 },
  { 6070, 22, 23, 19, -2, -23 },
  { 6134, 22, 32, 19, -1, -23 },
  { 6222, 20, 23, 19, -1, -23 },
  { 6280, 13, 42, 12, 1, -34 },
  { 6349, 9, 37, 11, 1, -31 },
  { 6391, 13, 42, 12, -1, -34 },
  { 6460, 20, 10, 23, 1, -18 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC43PT7B_H_
