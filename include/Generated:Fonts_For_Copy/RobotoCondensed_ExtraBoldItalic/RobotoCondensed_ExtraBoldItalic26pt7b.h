#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC26PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x3C, 0x70, 0xE1, 0xC3,
  0x80, 0x00, 0x38, 0xF1, 0xE1, 0xC0, 0x77, 0x77, 0x77, 0x67, 0x66, 0x66,
  0xE6, 0x03, 0xB8, 0x19, 0x80, 0xCC, 0x06, 0xE0, 0x76, 0x03, 0x30, 0xFF,
  0xE7, 0xFF, 0x0C, 0xC0, 0x6E, 0x07, 0x70, 0xFF, 0xCF, 0xFE, 0x0D, 0xC0,
  0xEC, 0x06, 0x60, 0x37, 0x03, 0xB0, 0x19, 0x80, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x78, 0x1F, 0xC3, 0xFE, 0x3C, 0xE3, 0x8F, 0x38, 0xF3, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0xF1, 0xCF, 0x3C, 0xF3,
  0xCF, 0xF8, 0x7F, 0x83, 0xE0, 0x18, 0x01, 0x80, 0x3C, 0x03, 0xF0, 0x19,
  0x89, 0xCC, 0xEE, 0x66, 0x73, 0x63, 0xBF, 0x0F, 0xB0, 0x3B, 0x00, 0x38,
  0x03, 0xB8, 0x1F, 0xE1, 0xFB, 0x1D, 0x98, 0xCC, 0xCE, 0x66, 0x63, 0x70,
  0x1F, 0x80, 0x78, 0x03, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xBC, 0x1C, 0xF0,
  0x73, 0x81, 0xDE, 0x07, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFB, 0x9F, 0xEE,
  0x7B, 0xFB, 0xCF, 0xEF, 0x1F, 0x3E, 0x7C, 0x7F, 0xF1, 0xFF, 0xC1, 0xE7,
  0x80, 0x77, 0x77, 0x66, 0xE0, 0x01, 0x07, 0x07, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x10, 0x08, 0x0C, 0x0E, 0x0E, 0x06,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E,
  0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x70, 0xF0, 0xE0, 0x80, 0x03, 0x00, 0xE0,
  0x1C, 0x33, 0x37, 0xFE, 0x7F, 0x83, 0x80, 0xD8, 0x3B, 0x8E, 0x70, 0x84,
  0x00, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE1, 0xFF, 0xBF, 0xF7, 0xFE,
  0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x39, 0xCE, 0xF7, 0x7B, 0x88,
  0xFF, 0xFF, 0xC0, 0x73, 0xDE, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0x9E, 0xF7, 0x8E, 0xF1, 0xDE, 0x3B,
  0x87, 0x71, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xBC, 0xF7, 0x9C,
  0x7F, 0x8F, 0xE0, 0xF8, 0x00, 0x03, 0x0F, 0x7E, 0xFE, 0xFE, 0x9E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x78,
  0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC0,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x79, 0xE3,
  0xC7, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x73, 0xC7, 0x9F, 0x3C, 0x7F, 0xC3, 0xFC, 0x07, 0xC0,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x0E, 0xE0, 0xFE,
  0x1D, 0xE3, 0xDE, 0x39, 0xE7, 0x9C, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x1F, 0xF1, 0xFF, 0x3F, 0xE3, 0x80, 0x38,
  0x07, 0x80, 0x7F, 0x07, 0xF8, 0x7F, 0xC3, 0x3C, 0x01, 0xC0, 0x1E, 0x01,
  0xC0, 0x1C, 0xE3, 0xCF, 0x3C, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x01, 0xC0,
  0xF8, 0x3F, 0x0F, 0x83, 0xC0, 0x70, 0x1F, 0xE3, 0xFE, 0x7F, 0xDF, 0x3F,
  0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0xF7, 0x9E, 0x7F, 0x8F, 0xE0, 0x78,
  0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xFC, 0x3F, 0xE3, 0xDE,
  0x38, 0xE3, 0x8E, 0x39, 0xE3, 0x9E, 0x3F, 0xC3, 0xF8, 0x7F, 0x8F, 0x3C,
  0xF1, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x0F,
  0x0F, 0xE7, 0xFD, 0xEF, 0xF1, 0xFC, 0x7F, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0xFD, 0xFE, 0x3F, 0x81, 0xE0, 0xF0, 0xF8, 0xFE, 0x3E, 0x0F, 0x00, 0x39,
  0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3C, 0xF3, 0x80, 0x0E, 0x3C,
  0x78, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x87, 0x0E, 0x3C,
  0x71, 0xC1, 0x00, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xE7, 0xF0, 0xF8, 0x1E,
  0x07, 0xF0, 0x3F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x7F, 0xEF, 0xFD, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xBF, 0xF7, 0xFE, 0x20, 0x07, 0x00, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xC1, 0xF8, 0xFE, 0x7F, 0x0F, 0x81, 0xC0, 0x60, 0x00,
  0x1E, 0x1F, 0xEF, 0xFB, 0xCF, 0xF3, 0xC0, 0xE0, 0x78, 0x3E, 0x1F, 0x0F,
  0x83, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x07, 0x00,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x78, 0x78, 0x3C, 0x06, 0x0E, 0x00, 0xC7,
  0x1E, 0x33, 0x8F, 0xCC, 0xE7, 0x33, 0x33, 0x9C, 0xDC, 0xE7, 0x37, 0x71,
  0x8D, 0x9C, 0x63, 0x67, 0x38, 0xF9, 0xCE, 0x7E, 0x73, 0x9B, 0x9D, 0xEE,
  0xE7, 0xFF, 0x38, 0xE7, 0x86, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F,
  0x18, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x03, 0xDC, 0x07, 0x38, 0x1E,
  0x70, 0x3C, 0xF0, 0xF1, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x3E, 0x1E,
  0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xF8, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87,
  0x9F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3F, 0xF8, 0xFF, 0x87,
  0xFF, 0x1E, 0x1C, 0x78, 0x79, 0xE1, 0xE7, 0x8F, 0x9E, 0x7C, 0xFF, 0xF3,
  0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x38,
  0x39, 0xE0, 0xE7, 0x83, 0xDE, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC3, 0xCF, 0x0F, 0x3E, 0x7C, 0x7F, 0xE0, 0xFF, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF, 0x87, 0x9E, 0x3C, 0x38, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xE7, 0x87, 0x9E, 0x1E, 0x78,
  0x79, 0xE1, 0xE7, 0x8F, 0x1E, 0x7C, 0xFF, 0xE3, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xF8,
  0xFF, 0xC7, 0xFE, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F,
  0xE1, 0xFF, 0x1F, 0xF8, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E,
  0x3C, 0x3D, 0xE0, 0xF7, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC7, 0xEF, 0x1F,
  0xBC, 0xFE, 0xF0, 0x7B, 0xC3, 0xCF, 0x0F, 0x1E, 0x7C, 0x7F, 0xF0, 0xFF,
  0x81, 0xF8, 0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xFC, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xE3, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x78, 0xF3, 0xC7, 0x1E, 0x78,
  0x7F, 0x83, 0xFC, 0x07, 0x80, 0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x7C, 0x1E,
  0x78, 0x3C, 0xF8, 0x3D, 0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7D, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x79,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0x1F, 0x03,
  0xF1, 0xF0, 0x3E, 0x1F, 0x07, 0xE1, 0xF0, 0x7E, 0x3F, 0x87, 0xE3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x3B, 0x9D, 0xC3, 0xB9, 0xFC, 0x7B,
  0xBB, 0xC7, 0xBB, 0xBC, 0x7B, 0xF3, 0xC7, 0xBF, 0x78, 0x79, 0xF7, 0x87,
  0x9E, 0x78, 0xF1, 0xE7, 0x8F, 0x1C, 0x78, 0xF1, 0xC7, 0x80, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1F, 0x0F, 0x1F, 0x1E, 0x3F, 0x1E, 0x3F, 0x1E, 0x3F, 0x9E,
  0x3F, 0x9E, 0x3F, 0x9E, 0x3D, 0xBC, 0x79, 0xFC, 0x79, 0xFC, 0x79, 0xFC,
  0x78, 0xFC, 0x78, 0xFC, 0x78, 0xF8, 0xF0, 0xF8, 0xF0, 0x78, 0xF0, 0x78,
  0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83,
  0xDE, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1,
  0xEF, 0x0F, 0x3E, 0x7C, 0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xC7, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x7C, 0xFF, 0xE7, 0xFF, 0x1F, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x9E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0xF0, 0x3F,
  0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x1E, 0x7C,
  0x7F, 0xE0, 0xFF, 0x01, 0xFC, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x00, 0x1F,
  0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0x9F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x1F, 0x3C, 0xF8, 0xFF, 0xE7, 0xFE, 0x1F, 0xF8, 0x79, 0xE1, 0xE7, 0x87,
  0x9E, 0x1E, 0x7C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x00, 0x03, 0xE0, 0x3F,
  0xC1, 0xFF, 0x87, 0x9F, 0x3E, 0x3C, 0xF0, 0xF3, 0xE0, 0x07, 0xC0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF3, 0xC3, 0xC7, 0x8F, 0x1E,
  0x7C, 0x7F, 0xE0, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x78, 0x79, 0xE1,
  0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3E, 0x78, 0x7F, 0xE1, 0xFF, 0x01, 0xF0, 0x00,
  0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xBC, 0x3E, 0xF0, 0xF1, 0xE3, 0xC7, 0x9F,
  0x1E, 0x78, 0x79, 0xE1, 0xEF, 0x07, 0xBC, 0x1E, 0xE0, 0x7F, 0x81, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF1, 0xE3,
  0xFC, 0x78, 0xFF, 0x1E, 0x7B, 0xCF, 0x9E, 0xF3, 0xE7, 0xBC, 0xF9, 0xCF,
  0x7E, 0xF3, 0xDF, 0xBC, 0xF7, 0xEE, 0x3F, 0xFF, 0x8F, 0xEF, 0xE3, 0xFB,
  0xF0, 0xFE, 0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x00, 0x1F, 0x0F, 0x07, 0x8F, 0x83, 0xC7, 0x81,
  0xE7, 0xC0, 0xF3, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xF7, 0x80, 0x7B,
  0xC0, 0x78, 0xF0, 0x7C, 0x78, 0x3C, 0x3C, 0x3E, 0x1E, 0x00, 0xF0, 0x7B,
  0xC1, 0xE7, 0x8F, 0x1E, 0x3C, 0x79, 0xE1, 0xE7, 0x83, 0xBC, 0x0E, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0x87, 0xC3, 0xE1,
  0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C,
  0x7C, 0x00, 0xF1, 0xE3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC0, 0x0F, 0x0F, 0x87,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE1, 0xF0,
  0xF8, 0x7C, 0x00, 0x0E, 0x07, 0x07, 0xC3, 0xE3, 0xF1, 0x99, 0xCC, 0xC6,
  0xE3, 0x80, 0x7F, 0xDF, 0xFF, 0xFC, 0xF3, 0x9E, 0x70, 0x0F, 0x83, 0xF8,
  0xFF, 0x9C, 0xF0, 0x1E, 0x3F, 0xCF, 0xFB, 0xCE, 0xF1, 0xDE, 0x7B, 0xCF,
  0x7F, 0xE7, 0xFC, 0x77, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xCF, 0x78, 0xF7, 0x8F, 0x78,
  0xF7, 0x8F, 0x78, 0xE7, 0x1E, 0xF9, 0xEF, 0xFC, 0xFF, 0xCE, 0x78, 0x0F,
  0x83, 0xF8, 0xFF, 0x9C, 0xF7, 0x8E, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x0E,
  0x39, 0xCF, 0x3F, 0xE3, 0xF8, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x3B, 0xC7, 0xFE, 0x3F, 0xF3, 0xC7, 0x9E,
  0x3C, 0xF1, 0xC7, 0x1E, 0x38, 0xF3, 0xC7, 0x9E, 0x3C, 0x79, 0xE3, 0xFE,
  0x1F, 0xF0, 0x7B, 0x80, 0x1F, 0x07, 0xF1, 0xFF, 0x3C, 0xEF, 0x1D, 0xFF,
  0xBF, 0xF7, 0xFE, 0xE0, 0x1C, 0x03, 0xC4, 0x7F, 0xC7, 0xF8, 0x7C, 0x00,
  0x07, 0x87, 0xC7, 0xE7, 0xC3, 0xC1, 0xE3, 0xFD, 0xFE, 0xFE, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x0F,
  0x78, 0xFF, 0x8F, 0xFC, 0xF9, 0xE7, 0x8F, 0x3C, 0x79, 0xC3, 0xCE, 0x1C,
  0x71, 0xE3, 0x8F, 0x1E, 0x78, 0xFF, 0xC7, 0xFE, 0x1E, 0xE0, 0x0F, 0x08,
  0x78, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0x9E, 0x78, 0xF7, 0x8E,
  0x79, 0xE7, 0x9E, 0x71, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF, 0x3C,
  0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x80, 0x01, 0x80, 0xF0, 0x3C, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x0F, 0xC3, 0xE0,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF3, 0xE7, 0xBE, 0x3D, 0xE1, 0xDE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F,
  0xC1, 0xFE, 0x0F, 0x70, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE3, 0xC0, 0x1E,
  0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x71, 0xE3, 0xC7, 0x80, 0x3D, 0xC7, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xF7, 0xCF, 0x78, 0xE3, 0xDE, 0x78, 0xF7, 0x9E, 0x39, 0xE7, 0x9E, 0x79,
  0xE7, 0x9C, 0x79, 0xEF, 0x1C, 0x7B, 0xC7, 0x1E, 0xF3, 0xC7, 0x3C, 0xF3,
  0xC0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE3, 0xDE, 0x78, 0xF7, 0x8E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x1E, 0xF1, 0xEF, 0x1C, 0xF3, 0xCF, 0x3C, 0x0F, 0x81,
  0xFC, 0x3F, 0xE3, 0xCE, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x0F, 0x70, 0xE7,
  0x1E, 0x79, 0xE7, 0xFC, 0x3F, 0x81, 0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0xFC,
  0x3C, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x71, 0xC7, 0x9F,
  0x3C, 0xFF, 0xC7, 0xFE, 0x3D, 0xE1, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0x0E, 0x73, 0xFF, 0x3F, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x71,
  0xE7, 0x1E, 0xF1, 0xEF, 0x1E, 0x79, 0xE7, 0xFC, 0x7F, 0xC3, 0xFC, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x3F, 0x9F, 0xCF, 0xE7, 0xF7,
  0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x0F,
  0x83, 0xF8, 0xFF, 0xBC, 0xF7, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xDE,
  0x7B, 0xCF, 0x7F, 0xE7, 0xF8, 0x7C, 0x00, 0x3C, 0x78, 0xF7, 0xFF, 0xFF,
  0xDE, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1E, 0x3E, 0x3C, 0x78, 0x78, 0xEF,
  0x3D, 0xE7, 0xB8, 0xFF, 0x1F, 0xE3, 0xFC, 0xF7, 0x9E, 0xF3, 0xDC, 0x7B,
  0xDF, 0x7F, 0xCF, 0xF8, 0xF7, 0x00, 0xF1, 0xFE, 0x3D, 0xCF, 0x39, 0xE7,
  0x38, 0xEF, 0x1D, 0xE3, 0xB8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3E, 0x03, 0xC0,
  0x78, 0x00, 0xF3, 0x8E, 0x73, 0x9E, 0x73, 0x9E, 0x77, 0x9C, 0x77, 0xBC,
  0x7F, 0xFC, 0x7F, 0xF8, 0x7D, 0xF8, 0x7D, 0xF8, 0x7D, 0xF0, 0x79, 0xF0,
  0x79, 0xE0, 0x79, 0xE0, 0x71, 0xE0, 0x1C, 0x78, 0xF7, 0x87, 0xBC, 0x3F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0,
  0xF3, 0x87, 0x9E, 0x78, 0xF0, 0x3C, 0x79, 0xE3, 0xC7, 0x3C, 0x39, 0xE1,
  0xDE, 0x0E, 0xF0, 0x77, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x00,
  0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0xFC, 0xFF, 0x8F, 0xF8, 0x02, 0x1C, 0x78,
  0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x71, 0xE7, 0x8E, 0x1C, 0x3C, 0x38, 0x71,
  0xE3, 0xC7, 0x8E, 0x1C, 0x1C, 0x38, 0x30, 0x0C, 0x31, 0xC7, 0x18, 0x61,
  0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC3, 0x1C, 0x61, 0x86, 0x18, 0x63, 0x80,
  0x08, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F,
  0x07, 0x0F, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0xE0,
  0x40, 0x38, 0x77, 0xC7, 0x7E, 0x7E, 0x7E, 0xE7, 0xEE, 0x3C,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 8, 7, 8, 1, -20 },
  { 25, 13, 19, 13, 0, -19 },
  { 56, 12, 24, 13, 1, -22 },
  { 92, 13, 19, 16, 2, -19 },
  { 123, 14, 19, 15, 0, -19 },
  { 157, 4, 7, 4, 1, -20 },
  { 161, 8, 26, 8, 1, -20 },
  { 187, 8, 26, 8, -1, -20 },
  { 213, 11, 11, 12, 1, -19 },
  { 229, 11, 13, 12, 1, -15 },
  { 247, 5, 8, 6, -1, -3 },
  { 252, 6, 3, 10, 2, -9 },
  { 255, 5, 4, 7, 0, -4 },
  { 258, 12, 21, 8, -2, -19 },
  { 290, 11, 19, 13, 1, -19 },
  { 317, 8, 19, 13, 3, -19 },
  { 336, 12, 19, 13, 0, -19 },
  { 365, 13, 19, 13, 0, -19 },
  { 396, 12, 19, 13, 0, -19 },
  { 425, 12, 19, 13, 1, -19 },
  { 454, 11, 19, 13, 1, -19 },
  { 481, 12, 19, 13, 1, -19 },
  { 510, 12, 19, 13, 1, -19 },
  { 539, 10, 19, 13, 2, -19 },
  { 563, 6, 14, 7, 1, -14 },
  { 574, 7, 19, 7, -1, -14 },
  { 591, 11, 12, 11, 0, -14 },
  { 608, 11, 8, 13, 1, -12 },
  { 619, 11, 12, 11, 0, -14 },
  { 636, 10, 19, 11, 2, -19 },
  { 660, 18, 24, 19, 0, -18 },
  { 714, 15, 19, 15, -1, -19 },
  { 750, 14, 19, 14, 0, -19 },
  { 784, 14, 19, 14, 1, -19 },
  { 818, 14, 19, 14, 0, -19 },
  { 852, 14, 19, 12, 0, -19 },
  { 886, 13, 19, 12, 0, -19 },
  { 917, 14, 19, 15, 1, -19 },
  { 951, 16, 19, 15, 0, -19 },
  { 989, 7, 19, 7, 0, -19 },
  { 1006, 13, 19, 12, 0, -19 },
  { 1037, 16, 19, 14, 0, -19 },
  { 1075, 11, 19, 12, 0, -19 },
  { 1102, 20, 19, 19, 0, -19 },
  { 1150, 16, 19, 15, 0, -19 },
  { 1188, 14, 19, 15, 1, -19 },
  { 1222, 14, 19, 14, 0, -19 },
  { 1256, 14, 22, 15, 1, -19 },
  { 1295, 14, 19, 14, 0, -19 },
  { 1329, 14, 19, 14, 0, -19 },
  { 1363, 13, 19, 14, 2, -19 },
  { 1394, 14, 19, 14, 1, -19 },
  { 1428, 14, 19, 15, 2, -19 },
  { 1462, 18, 19, 19, 2, -19 },
  { 1505, 17, 19, 14, -1, -19 },
  { 1546, 14, 19, 14, 2, -19 },
  { 1580, 15, 19, 13, 0, -19 },
  { 1616, 9, 26, 7, -1, -22 },
  { 1646, 7, 21, 10, 2, -19 },
  { 1665, 9, 26, 7, -1, -22 },
  { 1695, 9, 9, 10, 1, -19 },
  { 1706, 10, 3, 10, -2, 0 },
  { 1710, 5, 4, 8, 3, -20 },
  { 1713, 11, 14, 12, 0, -14 },
  { 1733, 12, 20, 12, 0, -20 },
  { 1763, 11, 14, 12, 0, -14 },
  { 1783, 13, 20, 13, 0, -20 },
  { 1816, 11, 14, 12, 1, -14 },
  { 1836, 9, 20, 8, 1, -20 },
  { 1859, 13, 19, 13, 0, -14 },
  { 1890, 12, 20, 12, 0, -20 },
  { 1920, 7, 20, 6, 0, -20 },
  { 1938, 10, 25, 6, -3, -20 },
  { 1970, 13, 20, 12, 0, -20 },
  { 2003, 7, 20, 6, 0, -20 },
  { 2021, 18, 14, 19, 0, -14 },
  { 2053, 12, 14, 12, 0, -14 },
  { 2074, 12, 14, 13, 0, -14 },
  { 2095, 13, 19, 12, -1, -14 },
  { 2126, 12, 19, 13, 0, -14 },
  { 2155, 9, 14, 9, 0, -14 },
  { 2171, 11, 14, 11, 0, -14 },
  { 2191, 7, 17, 8, 1, -17 },
  { 2206, 11, 14, 12, 1, -14 },
  { 2226, 11, 14, 11, 1, -14 },
  { 2246, 16, 14, 16, 1, -14 },
  { 2274, 13, 14, 11, -1, -14 },
  { 2297, 13, 19, 11, -1, -14 },
  { 2328, 12, 14, 11, 0, -14 },
  { 2349, 7, 25, 7, 1, -20 },
  { 2371, 6, 22, 6, 0, -19 },
  { 2388, 8, 25, 7, -1, -20 },
  { 2413, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC26PT7B_H_
