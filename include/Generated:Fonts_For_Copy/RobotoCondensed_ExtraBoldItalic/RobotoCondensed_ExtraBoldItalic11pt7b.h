#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC11PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0x36, 0xB7, 0x00, 0x18, 0xA7, 0xCC, 0x53, 0xE6, 0x18,
  0x11, 0xDA, 0xD6, 0x1B, 0x6B, 0x71, 0x00, 0xE5, 0x6D, 0xC3, 0xB6, 0xA3,
  0x31, 0xA7, 0x8C, 0x7F, 0x6D, 0x9E, 0xE0, 0x12, 0x64, 0x44, 0x44, 0x44,
  0x40, 0x4C, 0x92, 0x5A, 0x52, 0x00, 0x22, 0xFE, 0xA0, 0x31, 0xBE, 0x46,
  0x00, 0x6B, 0x00, 0xC0, 0xF0, 0x08, 0xC4, 0x62, 0x11, 0x08, 0xC0, 0x3B,
  0x52, 0x95, 0xED, 0x4E, 0x3E, 0x26, 0x66, 0x64, 0x3B, 0xD2, 0x33, 0x33,
  0x1F, 0x3B, 0xC2, 0x33, 0x0F, 0x6E, 0x18, 0xCE, 0xF5, 0x7C, 0x46, 0x3B,
  0x18, 0xE1, 0x8F, 0x6E, 0x19, 0x98, 0xFD, 0xED, 0x6E, 0x7C, 0x21, 0x84,
  0x30, 0x86, 0x10, 0x3B, 0x5A, 0xF7, 0x6F, 0x6E, 0x7F, 0x9B, 0xF3, 0x6C,
  0x6C, 0x05, 0x80, 0x4C, 0x01, 0xB4, 0x1B, 0xB0, 0xE1, 0x00, 0x78, 0x1E,
  0x43, 0x85, 0xE8, 0x00, 0xEB, 0x36, 0x40, 0x8C, 0x1E, 0x22, 0x5D, 0x55,
  0xB5, 0xA9, 0xAA, 0xBE, 0x40, 0x78, 0x0C, 0x18, 0x70, 0xA3, 0x47, 0x99,
  0xB3, 0x79, 0xB6, 0xD3, 0x7B, 0x2D, 0xBE, 0x39, 0xB4, 0x50, 0xC3, 0x35,
  0x9C, 0x79, 0xB6, 0xD3, 0x4F, 0x2D, 0xBC, 0x7D, 0x86, 0x10, 0x7B, 0x0C,
  0x3E, 0x7D, 0x86, 0x10, 0x7B, 0x0C, 0x30, 0x39, 0xB6, 0x50, 0x5F, 0x34,
  0xDE, 0x66, 0xCD, 0x92, 0x27, 0xD9, 0xB3, 0x64, 0x6D, 0xA4, 0xB6, 0x08,
  0x21, 0x86, 0x18, 0x6D, 0x18, 0x6C, 0xD9, 0xE3, 0x87, 0x1B, 0x36, 0x6C,
  0x63, 0x18, 0x84, 0x63, 0x1E, 0x73, 0x73, 0x77, 0x57, 0x5F, 0xDA, 0xDA,
  0xD6, 0x66, 0xC9, 0xD2, 0xA5, 0xDB, 0xB7, 0x64, 0x39, 0xB6, 0x51, 0xCF,
  0x35, 0x9C, 0x79, 0xB6, 0xD3, 0x7B, 0x0C, 0x30, 0x39, 0xB6, 0x51, 0xCF,
  0x35, 0x9E, 0x08, 0x79, 0xB6, 0xD3, 0x7B, 0x6D, 0xB6, 0x39, 0xB6, 0x1C,
  0x1B, 0x2D, 0x9C, 0xF9, 0x18, 0xC6, 0x31, 0x08, 0x65, 0xB6, 0xD3, 0x4F,
  0x2D, 0x9C, 0xCF, 0x6D, 0xB4, 0xF3, 0xC6, 0x18, 0xD2, 0xF6, 0xF6, 0xF4,
  0xB4, 0xFC, 0xD8, 0xD8, 0x6C, 0xD8, 0xE1, 0xC3, 0x0F, 0x36, 0x6C, 0xCB,
  0x6D, 0x1C, 0x61, 0x84, 0x10, 0x7C, 0x31, 0x8C, 0x31, 0x8C, 0x3E, 0x66,
  0x66, 0x44, 0xCC, 0xCC, 0xC0, 0x9B, 0x6C, 0x92, 0x60, 0x33, 0x33, 0x22,
  0x26, 0x66, 0xE0, 0x33, 0x55, 0xF0, 0xC8, 0x72, 0xDF, 0xAD, 0x78, 0x63,
  0x18, 0xF5, 0xAF, 0x7B, 0xF0, 0x72, 0xF1, 0x8D, 0x38, 0x0C, 0x20, 0x9E,
  0x5B, 0x6D, 0xB4, 0x70, 0x72, 0xF7, 0xFD, 0x38, 0x36, 0x67, 0x64, 0x44,
  0xC0, 0x7A, 0xF7, 0xBD, 0xBA, 0xDC, 0x63, 0x18, 0xF5, 0xEF, 0x7A, 0xD0,
  0x2C, 0x34, 0xB6, 0xC0, 0x13, 0x03, 0x22, 0x66, 0x64, 0xC0, 0x61, 0x86,
  0x16, 0x53, 0xCF, 0x3C, 0xD0, 0x6D, 0xA4, 0xB6, 0xC0, 0x7E, 0xB5, 0x6E,
  0xDD, 0x7A, 0xC0, 0x7A, 0xF7, 0xBD, 0x68, 0x72, 0xF7, 0xBD, 0xB8, 0x7A,
  0xD7, 0xBD, 0xFA, 0x10, 0x6A, 0xF7, 0xBD, 0x38, 0xC6, 0x77, 0x4C, 0xCC,
  0x72, 0xD8, 0x6D, 0x38, 0x6E, 0x64, 0x4C, 0x60, 0x4A, 0xD7, 0xBD, 0xB8,
  0xBB, 0xAE, 0xCC, 0xAE, 0xAE, 0xBE, 0xF2, 0x40, 0x5B, 0x9C, 0xEF, 0x68,
  0x5A, 0xDC, 0xE6, 0x31, 0x18, 0x78, 0x8C, 0xCC, 0x78, 0x22, 0x66, 0x48,
  0x44, 0x44, 0x40, 0x49, 0x24, 0x94, 0x80, 0x4D, 0xB6, 0x52, 0xD2, 0x00,
  0x6E, 0xC0,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 3, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 10, 5, 0, -9 },
  { 19, 5, 8, 7, 1, -8 },
  { 24, 6, 8, 6, 0, -8 },
  { 30, 1, 3, 2, 1, -8 },
  { 31, 4, 11, 3, 0, -9 },
  { 37, 3, 11, 3, 0, -9 },
  { 42, 4, 5, 5, 1, -8 },
  { 45, 5, 5, 5, 0, -6 },
  { 49, 3, 3, 3, -1, -1 },
  { 51, 3, 1, 4, 1, -4 },
  { 52, 2, 2, 3, 0, -2 },
  { 53, 5, 9, 3, -1, -8 },
  { 59, 5, 8, 5, 0, -8 },
  { 64, 4, 8, 5, 1, -8 },
  { 68, 5, 8, 5, 0, -8 },
  { 73, 5, 8, 5, 0, -8 },
  { 78, 5, 8, 5, 0, -8 },
  { 83, 5, 8, 5, 0, -8 },
  { 88, 5, 8, 5, 0, -8 },
  { 93, 6, 8, 5, 0, -8 },
  { 99, 5, 8, 5, 0, -8 },
  { 104, 4, 8, 5, 1, -8 },
  { 108, 3, 6, 3, 0, -6 },
  { 111, 3, 8, 3, 0, -6 },
  { 114, 5, 5, 5, 0, -6 },
  { 118, 5, 3, 5, 0, -5 },
  { 120, 5, 5, 5, 0, -6 },
  { 124, 4, 8, 5, 1, -8 },
  { 128, 8, 10, 8, 0, -8 },
  { 138, 7, 8, 6, -1, -8 },
  { 145, 6, 8, 6, 0, -8 },
  { 151, 6, 8, 6, 0, -8 },
  { 157, 6, 8, 6, 0, -8 },
  { 163, 6, 8, 5, 0, -8 },
  { 169, 6, 8, 5, 0, -8 },
  { 175, 6, 8, 6, 0, -8 },
  { 181, 7, 8, 7, 0, -8 },
  { 188, 3, 8, 3, 0, -8 },
  { 191, 6, 8, 5, 0, -8 },
  { 197, 7, 8, 6, 0, -8 },
  { 204, 5, 8, 5, 0, -8 },
  { 209, 8, 8, 8, 0, -8 },
  { 217, 7, 8, 7, 0, -8 },
  { 224, 6, 8, 6, 0, -8 },
  { 230, 6, 8, 6, 0, -8 },
  { 236, 6, 9, 6, 0, -8 },
  { 243, 6, 8, 6, 0, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 5, 8, 6, 1, -8 },
  { 260, 6, 8, 6, 0, -8 },
  { 266, 6, 8, 6, 1, -8 },
  { 272, 8, 8, 8, 1, -8 },
  { 280, 7, 8, 6, 0, -8 },
  { 287, 6, 8, 6, 1, -8 },
  { 293, 6, 8, 6, 0, -8 },
  { 299, 4, 11, 3, 0, -9 },
  { 305, 3, 9, 4, 1, -8 },
  { 309, 4, 11, 3, -1, -9 },
  { 315, 4, 4, 4, 0, -8 },
  { 317, 5, 1, 4, -1, 0 },
  { 318, 3, 2, 4, 1, -9 },
  { 319, 5, 6, 5, 0, -6 },
  { 323, 5, 9, 5, 0, -9 },
  { 329, 5, 6, 5, 0, -6 },
  { 333, 6, 9, 5, 0, -9 },
  { 340, 5, 6, 5, 0, -6 },
  { 344, 4, 9, 4, 0, -9 },
  { 349, 5, 8, 5, 0, -6 },
  { 354, 5, 9, 5, 0, -9 },
  { 360, 3, 9, 3, 0, -9 },
  { 364, 4, 11, 3, -1, -9 },
  { 370, 6, 9, 5, 0, -9 },
  { 377, 3, 9, 3, 0, -9 },
  { 381, 7, 6, 8, 0, -6 },
  { 387, 5, 6, 5, 0, -6 },
  { 391, 5, 6, 5, 0, -6 },
  { 395, 5, 8, 5, 0, -6 },
  { 400, 5, 8, 5, 0, -6 },
  { 405, 4, 6, 4, 0, -6 },
  { 408, 5, 6, 5, 0, -6 },
  { 412, 4, 7, 3, 0, -7 },
  { 416, 5, 6, 5, 0, -6 },
  { 420, 4, 6, 5, 1, -6 },
  { 423, 6, 6, 7, 1, -6 },
  { 428, 5, 6, 5, 0, -6 },
  { 432, 5, 8, 5, 0, -6 },
  { 437, 5, 6, 5, 0, -6 },
  { 441, 4, 11, 3, 0, -9 },
  { 447, 3, 9, 3, 0, -8 },
  { 451, 3, 11, 3, 0, -9 },
  { 456, 5, 2, 6, 0, -4 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic11pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC11PT7B_H_
