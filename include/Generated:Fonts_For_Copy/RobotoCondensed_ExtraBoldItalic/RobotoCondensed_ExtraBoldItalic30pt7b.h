#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC30PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x00, 0x00, 0x70, 0x78, 0xF8, 0x78, 0x70, 0x39,
  0xCE, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xC6, 0x31, 0x9C, 0x01, 0xCC, 0x03,
  0xB8, 0x07, 0x70, 0x0C, 0xE0, 0x39, 0x80, 0x77, 0x07, 0xFF, 0x8F, 0xFF,
  0x3F, 0xFE, 0x0C, 0xE0, 0x39, 0x80, 0x77, 0x00, 0xEE, 0x0F, 0xFF, 0x1F,
  0xFE, 0x7F, 0xFC, 0x19, 0xC0, 0x73, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x30,
  0x0E, 0xE0, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xF8, 0x0F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x8F, 0x9E, 0x3C, 0x78, 0xF1, 0xF3, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xCF, 0x0F,
  0x3C, 0x3C, 0xF9, 0xF3, 0xFF, 0x87, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE1, 0x39, 0xCE, 0xE7,
  0x3B, 0x9D, 0xCE, 0xEE, 0x3F, 0xB8, 0xFD, 0xC1, 0xEE, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0xF0, 0x37, 0xE1, 0xFF, 0x8E, 0xE7, 0x33, 0x9D, 0xCE, 0x7E,
  0x39, 0x90, 0xFE, 0x03, 0xF8, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x0F, 0xF8, 0x0F, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x0E, 0xF8, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xCF, 0x3F, 0xCE, 0x7F, 0xFE, 0x79,
  0xFE, 0xF9, 0xFE, 0xF8, 0xFC, 0xF8, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0x3E, 0x77, 0xFF, 0xEE, 0xEE, 0x00, 0x80, 0x60, 0x3C, 0x1E,
  0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x00, 0x80, 0x08, 0x06,
  0x03, 0x80, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x1C, 0x1E, 0x1E, 0x0F, 0x0F, 0x07, 0x02, 0x00, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x17, 0x33, 0xBF, 0xFC, 0x7F, 0xC1, 0xE0, 0x1F, 0x81,
  0xEE, 0x1E, 0x70, 0x61, 0xC0, 0x08, 0x00, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x3C, 0x71, 0xE3, 0xC7,
  0x9E, 0x38, 0x20, 0xFF, 0xFE, 0xFE, 0xFE, 0x67, 0xBF, 0xE7, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x3F, 0xF3, 0xC7, 0x9E, 0x3D,
  0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF1, 0xFF, 0x8F, 0xFC,
  0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0xCF, 0x1F, 0xF8, 0xFF, 0x83, 0xF8,
  0x0F, 0x80, 0x00, 0x81, 0xE1, 0xF9, 0xFE, 0x7F, 0xBF, 0xEC, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0xC7,
  0xFF, 0x3E, 0x3C, 0xF8, 0xF3, 0xC3, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xF8, 0x07, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xC0, 0x03, 0xE0, 0x3F,
  0xE1, 0xFF, 0x87, 0xFF, 0x3E, 0x3C, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0xF8, 0x7B, 0xE3, 0xE7, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x7E, 0x00,
  0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x81, 0xDE, 0x0F, 0x78, 0x3B, 0xE1, 0xEF, 0x8F, 0x3C, 0x3C, 0xF1, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFE, 0xFF, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xDF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0xFE,
  0x1F, 0xF0, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x81, 0xFC, 0x1F,
  0xE1, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xFD,
  0xF1, 0xEF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE, 0x1E, 0xF0, 0xF7, 0xCF, 0x9F,
  0xF8, 0xFF, 0xC3, 0xFC, 0x0F, 0x80, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x3F, 0xF3, 0xE7, 0x9E, 0x3C, 0xF1, 0xE7,
  0x8F, 0x3C, 0xF8, 0xFF, 0x87, 0xF8, 0x7F, 0x87, 0xFE, 0x3C, 0xFB, 0xE3,
  0xDE, 0x1E, 0xF1, 0xF7, 0x8F, 0xBF, 0xF9, 0xFF, 0xC7, 0xFC, 0x0F, 0x80,
  0x07, 0x81, 0xFC, 0x3F, 0xE7, 0xFF, 0x78, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF9, 0xFF, 0xFF, 0x7F, 0xE7, 0xFE, 0x3D, 0xE0, 0x3C,
  0x07, 0xC0, 0xF8, 0x7F, 0x87, 0xF0, 0x7C, 0x07, 0x00, 0x18, 0x78, 0xF9,
  0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x1E, 0x3E, 0x78, 0x70,
  0x06, 0x0F, 0x1F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0xF0, 0xF0, 0x60, 0x00, 0x10,
  0x0E, 0x03, 0xE0, 0xFE, 0x3F, 0xEF, 0xF0, 0xFC, 0x0F, 0x80, 0xFE, 0x07,
  0xF8, 0x1F, 0xC0, 0x7C, 0x03, 0x80, 0x08, 0x3F, 0xF9, 0xFF, 0xDF, 0xFE,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F,
  0xF8, 0x10, 0x00, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xC0, 0x7E, 0x0F, 0xF3, 0xFE, 0x1F, 0xC0, 0xF8, 0x07, 0x00, 0x20, 0x00,
  0x1F, 0x87, 0xF9, 0xFF, 0xFF, 0xFF, 0x9F, 0xE3, 0xC0, 0x78, 0x1F, 0x07,
  0xC1, 0xF8, 0x7E, 0x0F, 0x81, 0xE0, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x06,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0x7E, 0xF8, 0x07, 0x80, 0xE0, 0x70, 0x03, 0x07, 0x00, 0x1C, 0x78,
  0xF8, 0xE3, 0x8F, 0xF3, 0x38, 0xFF, 0x19, 0xC7, 0x38, 0xCE, 0x71, 0xC6,
  0xE3, 0x8E, 0x37, 0x3C, 0xE3, 0xB9, 0xC7, 0x1D, 0xCE, 0x38, 0xFC, 0x71,
  0xC6, 0xE3, 0x9E, 0x77, 0x1C, 0xE3, 0xB8, 0xFF, 0xB9, 0xC7, 0xFF, 0x86,
  0x1C, 0x78, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x08,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xBC, 0x03, 0xDE, 0x03, 0xEF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF1,
  0xF0, 0x78, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F,
  0x03, 0xCF, 0x81, 0xEF, 0x80, 0xFF, 0xC0, 0x7C, 0x0F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFF, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C,
  0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x7C, 0x7F, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3E, 0x1E, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3C,
  0xF8, 0x3C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0x1E, 0x1E, 0x1F,
  0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E,
  0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x7C,
  0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0x8F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x0F,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0xFE, 0xF8, 0xFE,
  0xF8, 0xFE, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3C, 0x78, 0x7C, 0x7F, 0xFC,
  0x7F, 0xFC, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0x03, 0xC7, 0xC0, 0xF1, 0xF0,
  0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x78, 0xF8, 0x1E,
  0x3E, 0x0F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x1F,
  0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0x81,
  0xE3, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x80, 0x0F, 0x0F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x7C, 0x78,
  0xF8, 0xF1, 0xF3, 0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x00,
  0x0F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0,
  0x3C, 0xF8, 0x07, 0x9F, 0x01, 0xF7, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xBC, 0x03,
  0xE7, 0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x01, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x87, 0xC1, 0xF0, 0xFC, 0x00, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xC0, 0x7E, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFC, 0x3D, 0xC7, 0xF8, 0x7B, 0x8F, 0xF0, 0xF7, 0x1D, 0xE1, 0xEE, 0x7F,
  0xC3, 0xDC, 0xEF, 0x8F, 0xBB, 0xDE, 0x1F, 0x77, 0x3C, 0x3E, 0xFE, 0x78,
  0x78, 0xF9, 0xF0, 0xF1, 0xF3, 0xE1, 0xE3, 0xE7, 0xC7, 0xC7, 0x8F, 0x0F,
  0x8F, 0x1E, 0x1F, 0x1C, 0x3C, 0x00, 0x0F, 0x03, 0xC7, 0xE0, 0xF1, 0xF8,
  0x7C, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xE1, 0xF1, 0xFC, 0x78, 0xFF, 0x1E,
  0x3F, 0xCF, 0x8F, 0xF3, 0xE3, 0xEE, 0xF8, 0xF3, 0xBC, 0x3C, 0xEF, 0x1F,
  0x3B, 0xC7, 0xC7, 0xF1, 0xF1, 0xFC, 0x78, 0x7F, 0x1E, 0x1F, 0x87, 0x87,
  0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x0F, 0x7C, 0x1F,
  0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x7C, 0x1E, 0x3E, 0x1F, 0x1F,
  0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0x81, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E,
  0x1F, 0x3C, 0x1F, 0x7C, 0x0F, 0x7C, 0x0F, 0x78, 0x1F, 0x78, 0x1F, 0x78,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8,
  0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x20, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x1F, 0xFF, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x7C,
  0xF0, 0x7C, 0xF8, 0x78, 0xF8, 0x78, 0xF8, 0x78, 0x78, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3,
  0xE7, 0x87, 0xCF, 0x0F, 0x9F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xF1,
  0xF3, 0xFF, 0xE3, 0xFF, 0x83, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C,
  0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78,
  0x3E, 0x78, 0x3E, 0x78, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xF8,
  0x1F, 0xFC, 0x0F, 0x9E, 0x07, 0xCF, 0x07, 0xC7, 0x83, 0xE3, 0xC1, 0xE1,
  0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x7C, 0x1F, 0x3C, 0x07, 0xBE,
  0x03, 0xDF, 0x01, 0xEF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0xF1,
  0xFF, 0x1F, 0x1F, 0xF1, 0xF1, 0xEF, 0x1F, 0x1E, 0xF3, 0xF3, 0xEF, 0x3F,
  0x3C, 0xF3, 0xF3, 0xCF, 0x7F, 0x7C, 0xF7, 0xF7, 0xCF, 0x7F, 0x78, 0xFF,
  0xF7, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xEF, 0xF0, 0xFE, 0xFF, 0x0F,
  0xEF, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x0F, 0x87, 0x80, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x3E,
  0x07, 0xC7, 0xC0, 0x79, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x03, 0xE7, 0x80,
  0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x7C, 0x00, 0x78, 0x1F,
  0x78, 0x3E, 0x78, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0xF8, 0x3C, 0xF0,
  0x3D, 0xF0, 0x3D, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xC7, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC1, 0xF8, 0x00, 0xF8,
  0xF8, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x07,
  0xE0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x1F, 0x87,
  0xE3, 0x98, 0xE7, 0x71, 0xDC, 0x7F, 0x1C, 0x7F, 0xFF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xF8, 0xF0, 0xF1, 0xE1, 0xC0, 0x07, 0xC0, 0xFF, 0x87, 0xFC, 0x7D,
  0xF3, 0xCF, 0x80, 0x7C, 0x3F, 0xC7, 0xFE, 0x7F, 0xF3, 0xC7, 0xBE, 0x7D,
  0xF3, 0xEF, 0xBE, 0x7F, 0xF1, 0xFF, 0x87, 0xBC, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8,
  0xFF, 0xE3, 0xFF, 0x8F, 0x1F, 0x3C, 0x7D, 0xF1, 0xF7, 0xC7, 0x9E, 0x1E,
  0x78, 0x79, 0xE1, 0xE7, 0x8F, 0xBF, 0xFC, 0xFF, 0xF3, 0xDF, 0x8F, 0x3C,
  0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x7F, 0xF3, 0xC7, 0xBC, 0x3D, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x3C, 0xF3, 0xE7, 0xFE, 0x3F, 0xF0,
  0xFF, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x07, 0x9E, 0x1F, 0xBC, 0x7F, 0xF8, 0xFF, 0xF3,
  0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x7C, 0x78, 0xF8, 0xF1,
  0xE1, 0xE3, 0xC3, 0xFF, 0x87, 0xFF, 0x07, 0xFE, 0x07, 0xBC, 0x00, 0x0F,
  0xC1, 0xFE, 0x3F, 0xF7, 0xFF, 0x78, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x0F, 0x04, 0xFF, 0xC7, 0xFE, 0x7F, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x3F, 0x0F, 0xE1, 0xF0, 0x3C, 0x0F, 0x83, 0xFC, 0xFF, 0x9F,
  0xF0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0x07, 0xBC, 0x3F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE7, 0xC7, 0xCF, 0x8F, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF1, 0xE3, 0xE3, 0xC7, 0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F,
  0x78, 0x01, 0xF0, 0x83, 0xC1, 0xDF, 0x87, 0xFE, 0x0F, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x78, 0xF7, 0xC7, 0xBE, 0x3D,
  0xF1, 0xEF, 0x1F, 0x78, 0xFB, 0xC7, 0xBE, 0x3D, 0xF1, 0xEF, 0x8F, 0x78,
  0xFB, 0xC7, 0xC0, 0x06, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1E, 0x1E,
  0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8,
  0xF8, 0xF0, 0x00, 0x80, 0x3C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x3F, 0x3E, 0x7C, 0x7D,
  0xF0, 0xF7, 0xC1, 0xEF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x9F, 0x1E, 0x3E, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0xF8,
  0xF0, 0x1E, 0xF1, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3C,
  0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF7, 0xCF, 0x8F, 0x7C, 0xF9, 0xF7,
  0x8F, 0x9F, 0x78, 0xF1, 0xF7, 0x8F, 0x1E, 0xF8, 0xF1, 0xEF, 0x9F, 0x1E,
  0xF1, 0xF3, 0xEF, 0x1F, 0x3E, 0x3E, 0xF1, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3,
  0xC7, 0x9E, 0x3D, 0xF1, 0xEF, 0x8F, 0x78, 0xFB, 0xC7, 0xDE, 0x3D, 0xF1,
  0xEF, 0x8F, 0x7C, 0x7B, 0xC7, 0xDE, 0x3E, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC,
  0xFF, 0xE7, 0x8F, 0x7C, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC,
  0x3D, 0xE3, 0xEF, 0xFE, 0x7F, 0xE1, 0xFE, 0x03, 0xE0, 0x0F, 0xF8, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE3, 0xE7, 0xFF, 0x8F, 0xFF, 0x1E,
  0xFC, 0x3C, 0xF0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x7E, 0xF3, 0xFF, 0xCF, 0xFF, 0x7C, 0x79,
  0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF9, 0xE3, 0xE7, 0x8F, 0x1E, 0x3C,
  0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F,
  0x4F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x79, 0xF3, 0xCF, 0x9E, 0x00,
  0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x79, 0xE3, 0xCF, 0x9E, 0x3F,
  0xF1, 0xFF, 0x03, 0xE0, 0x1E, 0x0F, 0x0F, 0x87, 0xCF, 0xFF, 0xFB, 0xFC,
  0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xFC, 0x3E,
  0x1F, 0x07, 0x80, 0x7C, 0x7B, 0xE3, 0xDE, 0x1E, 0xF1, 0xF7, 0x8F, 0xBC,
  0x7B, 0xE3, 0xDF, 0x1E, 0xF1, 0xF7, 0x8F, 0xBC, 0x7D, 0xE3, 0xCF, 0xFE,
  0x7F, 0xF3, 0xFF, 0x87, 0xBC, 0x78, 0xFB, 0xC7, 0x9E, 0x3C, 0xF3, 0xE7,
  0x9E, 0x3C, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xFC, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF1, 0xC7, 0xF9, 0xE7, 0xFC,
  0xF3, 0xDE, 0xF9, 0xEF, 0x7D, 0xE7, 0xBE, 0xF3, 0xFF, 0x79, 0xFF, 0xB8,
  0xFF, 0xFC, 0x7E, 0xFE, 0x3F, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x87, 0xC7,
  0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0x1E, 0x3E, 0x3C, 0x78, 0x7D, 0xF0, 0x7B,
  0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x0F, 0x9E, 0x1E, 0x3C, 0x7C, 0x78, 0x1E,
  0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0xF3, 0xE1, 0xE7, 0x83, 0xDF, 0x07, 0xBC,
  0x0F, 0x78, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x01, 0x03, 0x83, 0xE1, 0xE1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x87, 0x87, 0x83, 0x81,
  0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x3C,
  0x0E, 0x02, 0x00, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x38,
  0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0x60, 0xC0, 0x0C, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x3E, 0x3C, 0x1E, 0x0E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x08, 0x00, 0x1C, 0x1D,
  0xF8, 0x77, 0xF3, 0xFF, 0xFE, 0xF3, 0xFB, 0x87, 0xC0, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 22, 8, 0, -22 },
  { 23, 10, 8, 9, 1, -23 },
  { 33, 15, 22, 15, 0, -22 },
  { 75, 14, 28, 15, 1, -25 },
  { 124, 14, 22, 19, 3, -22 },
  { 163, 16, 22, 17, 0, -22 },
  { 207, 4, 8, 5, 2, -23 },
  { 211, 10, 31, 9, 1, -24 },
  { 250, 9, 31, 9, -1, -24 },
  { 285, 13, 13, 13, 1, -22 },
  { 307, 12, 16, 14, 1, -18 },
  { 331, 7, 9, 7, -2, -4 },
  { 339, 8, 4, 11, 2, -11 },
  { 343, 5, 5, 9, 1, -5 },
  { 347, 13, 24, 9, -2, -22 },
  { 386, 13, 22, 15, 1, -22 },
  { 422, 10, 22, 15, 3, -22 },
  { 450, 14, 22, 15, 0, -22 },
  { 489, 14, 22, 15, 0, -22 },
  { 528, 14, 22, 15, 0, -22 },
  { 567, 14, 22, 15, 1, -22 },
  { 606, 13, 22, 15, 1, -22 },
  { 642, 15, 22, 15, 1, -22 },
  { 684, 13, 22, 15, 1, -22 },
  { 720, 12, 22, 15, 2, -22 },
  { 753, 7, 17, 8, 1, -17 },
  { 768, 8, 22, 8, -1, -17 },
  { 790, 12, 14, 13, 1, -16 },
  { 811, 13, 11, 15, 1, -15 },
  { 829, 13, 14, 13, 0, -16 },
  { 852, 11, 22, 13, 2, -22 },
  { 883, 21, 28, 22, 0, -21 },
  { 957, 17, 22, 17, -1, -22 },
  { 1004, 16, 22, 16, 0, -22 },
  { 1048, 16, 22, 17, 1, -22 },
  { 1092, 16, 22, 16, 0, -22 },
  { 1136, 16, 22, 14, 0, -22 },
  { 1180, 15, 22, 14, 0, -22 },
  { 1222, 16, 22, 17, 1, -22 },
  { 1266, 18, 22, 18, 0, -22 },
  { 1316, 8, 22, 8, 0, -22 },
  { 1338, 15, 22, 14, 0, -22 },
  { 1380, 19, 22, 16, 0, -22 },
  { 1433, 12, 22, 14, 0, -22 },
  { 1466, 23, 22, 22, 0, -22 },
  { 1530, 18, 22, 18, 0, -22 },
  { 1580, 16, 22, 18, 1, -22 },
  { 1624, 17, 22, 17, 0, -22 },
  { 1671, 16, 26, 18, 1, -22 },
  { 1723, 16, 22, 16, 0, -22 },
  { 1767, 15, 22, 16, 1, -22 },
  { 1809, 15, 22, 16, 2, -22 },
  { 1851, 16, 22, 17, 1, -22 },
  { 1895, 17, 22, 17, 2, -22 },
  { 1942, 20, 22, 22, 3, -22 },
  { 1997, 19, 22, 16, -1, -22 },
  { 2050, 16, 22, 16, 2, -22 },
  { 2094, 17, 22, 15, 0, -22 },
  { 2141, 11, 30, 8, -1, -25 },
  { 2183, 8, 24, 11, 2, -22 },
  { 2207, 11, 30, 8, -2, -25 },
  { 2249, 10, 11, 12, 1, -22 },
  { 2263, 12, 4, 12, -2, 0 },
  { 2269, 7, 5, 10, 3, -23 },
  { 2274, 13, 16, 14, 0, -16 },
  { 2300, 14, 23, 14, 0, -23 },
  { 2341, 13, 16, 13, 0, -16 },
  { 2367, 15, 23, 14, 0, -23 },
  { 2411, 12, 16, 14, 1, -16 },
  { 2435, 11, 23, 10, 1, -23 },
  { 2467, 15, 22, 15, 0, -16 },
  { 2509, 13, 23, 14, 0, -23 },
  { 2547, 8, 23, 7, 0, -23 },
  { 2570, 11, 29, 7, -3, -23 },
  { 2610, 15, 23, 14, 0, -23 },
  { 2654, 8, 23, 7, 0, -23 },
  { 2677, 20, 16, 22, 0, -16 },
  { 2717, 13, 16, 14, 0, -16 },
  { 2743, 13, 16, 14, 1, -16 },
  { 2769, 15, 22, 14, -1, -16 },
  { 2811, 14, 22, 14, 0, -16 },
  { 2850, 10, 16, 10, 0, -16 },
  { 2870, 13, 16, 13, 0, -16 },
  { 2896, 9, 20, 9, 1, -20 },
  { 2919, 13, 16, 14, 1, -16 },
  { 2945, 13, 16, 13, 1, -16 },
  { 2971, 17, 16, 18, 2, -16 },
  { 3005, 15, 16, 13, -1, -16 },
  { 3035, 15, 22, 13, -1, -16 },
  { 3077, 13, 16, 13, 0, -16 },
  { 3103, 9, 28, 9, 1, -23 },
  { 3135, 7, 26, 7, 0, -22 },
  { 3158, 9, 28, 9, -1, -23 },
  { 3190, 14, 7, 16, 1, -12 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC30PT7B_H_
