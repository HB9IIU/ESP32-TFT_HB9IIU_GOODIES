#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC29PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x00, 0x00, 0x70, 0x78, 0xF8, 0x78, 0x70, 0x3B, 0xB9,
  0xDC, 0xEE, 0x77, 0x33, 0xB9, 0x9C, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x06,
  0x60, 0x1D, 0xC0, 0x3B, 0x80, 0x66, 0x07, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC,
  0x1C, 0xC0, 0x3B, 0x80, 0x67, 0x00, 0xCC, 0x0F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xF8, 0x3B, 0x80, 0x77, 0x00, 0xCE, 0x03, 0x98, 0x07, 0x70, 0x00, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0x8F,
  0x3C, 0x79, 0xE3, 0xCF, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xE7, 0x8F, 0xBC, 0x7D, 0xE3, 0xCF, 0xBE, 0x3F, 0xE0, 0xFF,
  0x03, 0xE0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF0,
  0x1C, 0xC7, 0x63, 0x39, 0x9D, 0xC6, 0x77, 0x1F, 0xF8, 0x7F, 0xC0, 0xF6,
  0x00, 0x38, 0x01, 0xDC, 0x06, 0xF8, 0x3F, 0x71, 0xDD, 0xC6, 0xE7, 0x3B,
  0x9D, 0xCE, 0x72, 0x1F, 0xC0, 0x7E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7B, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x07, 0x78, 0x0F,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFE, 0xF7, 0xFD, 0xEF, 0x7F, 0xDE, 0x7F,
  0x7C, 0xFE, 0xF8, 0xF8, 0xFB, 0xF1, 0xFF, 0xE1, 0xFF, 0xE1, 0xF3, 0xC0,
  0x77, 0xFE, 0xEE, 0xEC, 0x00, 0x81, 0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0x70,
  0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0x00,
  0x80, 0x08, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0,
  0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x3C, 0x1C, 0x08, 0x00, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x07, 0x33, 0xBF, 0xFC, 0xFF, 0xC1, 0xE0, 0x1F,
  0x81, 0xEC, 0x1E, 0x70, 0xE3, 0x80, 0x08, 0x00, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7,
  0x1E, 0x38, 0x20, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0xE0, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7D, 0xE3, 0xC7, 0x9E, 0x3D, 0xE1, 0xEF,
  0x0F, 0x78, 0xFB, 0xC7, 0xDE, 0x3D, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3,
  0xDE, 0x3C, 0xF1, 0xE3, 0xDE, 0x1F, 0xF0, 0x7F, 0x01, 0xF0, 0x00, 0x01,
  0x83, 0xCF, 0xEF, 0xFF, 0xF7, 0xFA, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0x83,
  0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xC0, 0x03,
  0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0x3E, 0x7C, 0xF1, 0xF3, 0xC7, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF0,
  0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0x3E, 0x7C, 0xF0, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0xBE, 0x3E, 0xF8, 0xF1, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F,
  0x80, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x83, 0xFE, 0x0E, 0xF0, 0x7B, 0xC3, 0xCF, 0x0E, 0x3C, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xF3, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x70, 0x7F, 0xE3, 0xFF, 0x1E, 0x7C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xDE, 0x3E, 0xF1, 0xE7, 0xFF, 0x1F, 0xF0, 0xFF, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x3E, 0x0F, 0xE0, 0xFE, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0xBC, 0x7F, 0xE7, 0xFF, 0xFD, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF1, 0xF7, 0xFE, 0x7F, 0xC3, 0xF8, 0x1F, 0x00, 0x3F, 0xFC, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x7F, 0x87, 0xFC, 0x7F, 0xF3, 0xC7, 0x9E, 0x3C, 0xF3, 0xE7, 0x9E, 0x3F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xC7, 0x9E, 0x78, 0xF3, 0xC7, 0x9E, 0x3C,
  0xF1, 0xE7, 0xDF, 0x3F, 0xF0, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xFC,
  0x3F, 0xE7, 0xFE, 0x79, 0xEF, 0x8F, 0xF0, 0xFF, 0x1F, 0xF1, 0xFF, 0x1E,
  0xFB, 0xE7, 0xFE, 0x7F, 0xE3, 0xFE, 0x03, 0xC0, 0x7C, 0x0F, 0x87, 0xF0,
  0x7E, 0x07, 0xC0, 0x70, 0x00, 0x18, 0xF3, 0xCF, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x18, 0xF3, 0xCF, 0x18, 0x06, 0x0F, 0x1F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70,
  0xE0, 0x60, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xF3, 0xFD, 0xFE, 0x3F, 0x07,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7E, 0x07, 0xC0, 0x38, 0x01, 0x00, 0x3F, 0xF3,
  0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0x10, 0x01, 0xC0, 0x3E, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xF0,
  0x3F, 0x0F, 0xF7, 0xFC, 0x7F, 0x07, 0xC0, 0x70, 0x08, 0x00, 0x1F, 0x07,
  0xF9, 0xFF, 0x7F, 0xFF, 0x1F, 0xE3, 0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xF0,
  0x78, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x30, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFC, 0xF8, 0x0F,
  0x01, 0xC0, 0xF0, 0x07, 0x07, 0x00, 0x18, 0x70, 0xF0, 0xC3, 0x8F, 0xE6,
  0x38, 0xFF, 0x39, 0xCE, 0x39, 0xDC, 0x73, 0x8E, 0xE7, 0x1C, 0x67, 0x38,
  0xE3, 0x31, 0xC7, 0x1B, 0x8E, 0x71, 0xDC, 0xF3, 0x8C, 0xE3, 0x9C, 0xE7,
  0x1F, 0xEE, 0x38, 0xFB, 0xF0, 0xC3, 0x9E, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xDC, 0x03, 0xDC, 0x07, 0xDE, 0x07, 0x9E, 0x07, 0x9E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x7C, 0x1F,
  0x7C, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3E, 0x1E, 0x3E, 0x3E,
  0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7C, 0x3C, 0x7C, 0x3C, 0x7C, 0x3C,
  0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x83, 0xDF,
  0x07, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3C, 0x1F, 0x78, 0x3E, 0xF8, 0x78, 0xFF, 0xF1, 0xFF, 0xC1,
  0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1,
  0xE3, 0xE3, 0xC3, 0xCF, 0x87, 0x9F, 0x0F, 0x3E, 0x1E, 0x78, 0x3C, 0xF0,
  0x79, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0x9F, 0x0F, 0x3C, 0x3E, 0x78, 0x78,
  0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF1, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE1, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF,
  0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF3,
  0xE1, 0xE7, 0x83, 0xDF, 0x07, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE3,
  0xFF, 0xCF, 0xFF, 0x9F, 0xDF, 0x07, 0xBE, 0x0F, 0x7C, 0x3E, 0xF8, 0x7C,
  0xFF, 0xF9, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x07, 0xC7, 0xC1,
  0xF1, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7C,
  0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C, 0x00, 0x0F, 0x0F, 0x1F, 0x1F,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0xF8, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3E, 0x7C, 0xF9, 0xE3, 0xFF,
  0x87, 0xFC, 0x1F, 0xE0, 0x1F, 0x00, 0x1F, 0x0F, 0xC7, 0xC7, 0xE1, 0xF1,
  0xF0, 0x78, 0xF8, 0x1E, 0x7E, 0x07, 0x9F, 0x03, 0xEF, 0x80, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x0F, 0x87,
  0x83, 0xE1, 0xF0, 0xF0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0,
  0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE,
  0x3D, 0xC7, 0xF8, 0xF7, 0x3F, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC, 0x7D,
  0xDC, 0xF1, 0xF7, 0x77, 0xC7, 0x9F, 0xDE, 0x1E, 0x7E, 0x78, 0x79, 0xF9,
  0xE1, 0xE7, 0xC7, 0x8F, 0x8F, 0x3E, 0x3E, 0x38, 0xF8, 0xF0, 0xE3, 0xC0,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87,
  0xE3, 0xE3, 0xF8, 0xF8, 0xFF, 0x3E, 0x3F, 0xCF, 0x0F, 0x73, 0xC3, 0xDC,
  0xF0, 0xF3, 0xFC, 0x7C, 0xFF, 0x1F, 0x3F, 0xC7, 0xCF, 0xE1, 0xE1, 0xF8,
  0x78, 0x7E, 0x1E, 0x1F, 0x8F, 0x87, 0xE3, 0xE0, 0xF0, 0xF0, 0x3C, 0x00,
  0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x1E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF0, 0x3C, 0xF8, 0x3C, 0xF8, 0x78, 0x7F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1E, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x1E,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF0, 0x3C, 0xF8, 0x3C, 0xF8, 0x78, 0x7F, 0xF8,
  0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x20, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F,
  0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xF0, 0x7F, 0xF0, 0x7C, 0xF0, 0x7C, 0xF0, 0x78, 0xF8, 0x78, 0xF8,
  0x78, 0xF8, 0xF8, 0x78, 0xF8, 0x78, 0xF8, 0x7C, 0x03, 0xE0, 0x3F, 0xE1,
  0xFF, 0xCF, 0xFF, 0x3E, 0x3C, 0xF0, 0xF3, 0xC0, 0x0F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0xEF, 0x0F, 0xBC, 0x3E,
  0xF0, 0xFB, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78,
  0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0xF8, 0xFF,
  0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8,
  0x3E, 0x78, 0x3E, 0x78, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78,
  0xF8, 0x78, 0xF0, 0x79, 0xF0, 0x7D, 0xE0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1E,
  0x00, 0xF8, 0xF0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF1, 0xF7, 0x9F, 0x1E, 0x79,
  0xF1, 0xE7, 0x9F, 0x3E, 0x7B, 0xF3, 0xC7, 0xBF, 0x3C, 0x7B, 0xF7, 0xC7,
  0xFF, 0x78, 0x7F, 0xF7, 0x87, 0xF7, 0x78, 0x7F, 0x7F, 0x07, 0xF7, 0xF0,
  0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E,
  0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x00, 0x0F, 0x07, 0xC3, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x7C, 0x07, 0x9F, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0x07, 0xC3,
  0xC1, 0xF0, 0xF8, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0xF0, 0x7D, 0xE1, 0xF3,
  0xC3, 0xC7, 0xCF, 0x87, 0x9E, 0x0F, 0x7C, 0x1E, 0xF0, 0x3F, 0xE0, 0x3F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0xC1, 0xF0, 0xFC, 0x00, 0xF0, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC1, 0xF0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F,
  0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x07, 0x03, 0xC0, 0xF8, 0x7E, 0x1F, 0x8E,
  0xE3, 0xB9, 0xC6, 0x71, 0xF8, 0x70, 0x7F, 0xEF, 0xFF, 0xFF, 0x80, 0xF9,
  0xE3, 0xC7, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x3C, 0xF0, 0x0F, 0x0F,
  0xF3, 0xFF, 0x7F, 0xFF, 0x9F, 0xF9, 0xEF, 0x1E, 0xFB, 0xEF, 0xFE, 0x7F,
  0xE3, 0xDE, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x7F, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0x1E, 0x78, 0xF7, 0xC7, 0xBE,
  0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0xFB, 0xC7, 0xBF, 0xFD, 0xFF, 0xCF, 0x7E,
  0x7B, 0xE0, 0x07, 0xC0, 0xFF, 0x07, 0xFC, 0x7F, 0xE7, 0xCF, 0x3C, 0x79,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x3C, 0xF3, 0xC7, 0xFE, 0x3F,
  0xE0, 0xFF, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x83, 0xCF, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0xF1, 0xF1,
  0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x1F, 0x1E, 0x3C, 0x3C, 0x78, 0xF8, 0xF0,
  0xF1, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x07, 0xBC, 0x00, 0x0F, 0x81,
  0xFE, 0x3F, 0xE7, 0xDF, 0x78, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xC7, 0xFC, 0x7F, 0xC1, 0xF0, 0x03, 0xC3,
  0xF1, 0xFC, 0x7F, 0x1E, 0x0F, 0x8F, 0xFB, 0xFE, 0xFF, 0x0F, 0x03, 0xC1,
  0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x00, 0x0F, 0xBC, 0x7E, 0xF3, 0xFF, 0xCF, 0xBF, 0x7C, 0x79, 0xE1,
  0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF9, 0xE3, 0xE7, 0x8F, 0x1E, 0x3C, 0x7F,
  0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x01, 0xE1, 0x07, 0x87, 0x7E, 0x3F,
  0xF0, 0xFF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0xFF, 0xCF, 0x1E, 0x78,
  0xF7, 0xCF, 0xBC, 0x7D, 0xE3, 0xCF, 0x1E, 0x78, 0xF7, 0xC7, 0xBE, 0x7D,
  0xE3, 0xEF, 0x1E, 0x78, 0xF0, 0x0E, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1E,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78,
  0xF8, 0xF8, 0xF0, 0x01, 0xC0, 0x7C, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0xFE, 0x1F, 0x83, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x9F, 0x1F, 0x7E, 0x3C, 0xF8, 0x7B,
  0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xF7, 0xC3, 0xE7, 0x87, 0x8F, 0x0F, 0x1F, 0x1E, 0x3E, 0x00,
  0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0x3D, 0xE3,
  0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xE3, 0xEF, 0xFF, 0x3C, 0xF9, 0xF3, 0xCF,
  0x9F, 0x7C, 0xF9, 0xF7, 0xCF, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x78,
  0xF1, 0xE7, 0x8F, 0x3E, 0xF9, 0xF3, 0xEF, 0x9E, 0x3C, 0xF1, 0xE3, 0xCF,
  0x1E, 0x3C, 0x3D, 0xE1, 0xFF, 0x8F, 0xFE, 0x7F, 0xF3, 0xCF, 0xBE, 0x3D,
  0xF3, 0xEF, 0x1F, 0x78, 0xF3, 0xC7, 0x9E, 0x3D, 0xF1, 0xEF, 0x9F, 0x78,
  0xFB, 0xC7, 0x9E, 0x3C, 0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0xDF, 0x78, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0x1E, 0xFB, 0xEF,
  0xFC, 0x7F, 0x81, 0xF0, 0x1E, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x1E,
  0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF,
  0x1E, 0x7E, 0xF9, 0xFF, 0xC7, 0xBF, 0x1E, 0xF0, 0x78, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x3C, 0x7E, 0xF3, 0xFF,
  0x8F, 0xBE, 0x7C, 0x79, 0xE1, 0xE7, 0x8F, 0x9E, 0x3E, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x07, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3D, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3E, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF,
  0x3C, 0xF3, 0xC0, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xEF, 0x1E,
  0xF3, 0xE7, 0xFC, 0x7F, 0xC1, 0xF0, 0x1E, 0x3E, 0x3E, 0xFF, 0xFF, 0xFF,
  0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xFC, 0xFC, 0x7C,
  0x3C, 0x7C, 0x7B, 0xC7, 0xDE, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x7B, 0xE3,
  0xDE, 0x3E, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0xFE, 0x7F, 0xF3,
  0xFF, 0x0F, 0x78, 0xF8, 0xF3, 0xC7, 0x9E, 0x7C, 0xF3, 0xC7, 0x9E, 0x3D,
  0xE1, 0xEF, 0x0F, 0x78, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0xF3, 0x8F, 0xF3, 0x8F, 0xF3, 0xCF, 0xF7,
  0xDE, 0xE7, 0xDE, 0xEF, 0xDE, 0xEF, 0xFC, 0xEF, 0xFC, 0xFD, 0xFC, 0xFD,
  0xF8, 0xFD, 0xF8, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF1,
  0xE0, 0x1E, 0x3C, 0x3C, 0xF8, 0x79, 0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x03,
  0xDE, 0x0F, 0xBC, 0x1E, 0x3C, 0x7C, 0x78, 0x3E, 0x3E, 0x3C, 0x78, 0x79,
  0xF0, 0xF3, 0xC1, 0xEF, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE0, 0x3E, 0x01, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xFE, 0x7F, 0xF3,
  0xFF, 0x1F, 0xF8, 0x01, 0x07, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x78, 0xF0, 0xE0, 0xF0, 0x70, 0x70, 0x78, 0x70, 0x70,
  0xF0, 0xF0, 0xF0, 0x70, 0x78, 0x30, 0x10, 0x0E, 0x1C, 0x30, 0x60, 0xC3,
  0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3,
  0x87, 0x0C, 0x18, 0x30, 0x60, 0x0C, 0x07, 0x03, 0x81, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x3C, 0x3E, 0x3C, 0x1E,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x78, 0x38, 0x08,
  0x00, 0x3C, 0x3B, 0xF1, 0xDF, 0xCF, 0xFF, 0xFE, 0x3F, 0x71, 0xF8, 0x07,
  0x80,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 9, 8, 9, 1, -22 },
  { 31, 15, 21, 15, 0, -21 },
  { 71, 13, 27, 14, 1, -24 },
  { 115, 14, 21, 18, 2, -21 },
  { 152, 15, 21, 17, 0, -21 },
  { 192, 4, 8, 4, 2, -22 },
  { 196, 9, 29, 9, 1, -23 },
  { 229, 9, 29, 9, -1, -23 },
  { 262, 13, 13, 13, 1, -21 },
  { 284, 12, 15, 13, 1, -17 },
  { 307, 7, 9, 7, -2, -4 },
  { 315, 7, 4, 11, 2, -11 },
  { 319, 4, 5, 8, 1, -5 },
  { 322, 13, 23, 9, -2, -21 },
  { 360, 13, 21, 14, 1, -21 },
  { 395, 9, 21, 14, 3, -21 },
  { 419, 14, 21, 14, 0, -21 },
  { 456, 14, 21, 14, 0, -21 },
  { 493, 14, 21, 14, 0, -21 },
  { 530, 13, 21, 14, 1, -21 },
  { 565, 12, 21, 14, 1, -21 },
  { 597, 14, 21, 14, 1, -21 },
  { 634, 13, 21, 14, 1, -21 },
  { 669, 12, 21, 14, 2, -21 },
  { 701, 6, 16, 8, 1, -16 },
  { 713, 8, 21, 8, -1, -16 },
  { 734, 11, 14, 13, 1, -16 },
  { 754, 12, 10, 14, 1, -14 },
  { 769, 12, 14, 13, 0, -16 },
  { 790, 11, 21, 13, 2, -21 },
  { 819, 21, 26, 22, 0, -20 },
  { 888, 16, 21, 17, -1, -21 },
  { 930, 16, 21, 16, 0, -21 },
  { 972, 15, 21, 16, 1, -21 },
  { 1012, 15, 21, 16, 0, -21 },
  { 1052, 15, 21, 14, 0, -21 },
  { 1092, 15, 21, 13, 0, -21 },
  { 1132, 15, 21, 17, 1, -21 },
  { 1172, 18, 21, 17, 0, -21 },
  { 1220, 8, 21, 8, 0, -21 },
  { 1241, 14, 21, 14, 0, -21 },
  { 1278, 18, 21, 16, 0, -21 },
  { 1326, 12, 21, 13, 0, -21 },
  { 1358, 22, 21, 21, 0, -21 },
  { 1416, 18, 21, 17, 0, -21 },
  { 1464, 16, 21, 17, 1, -21 },
  { 1506, 16, 21, 16, 0, -21 },
  { 1548, 16, 25, 17, 1, -21 },
  { 1598, 16, 21, 16, 0, -21 },
  { 1640, 14, 21, 15, 1, -21 },
  { 1677, 15, 21, 15, 2, -21 },
  { 1717, 16, 21, 16, 1, -21 },
  { 1759, 16, 21, 16, 2, -21 },
  { 1801, 20, 21, 21, 2, -21 },
  { 1854, 18, 21, 16, -1, -21 },
  { 1902, 15, 21, 15, 2, -21 },
  { 1942, 16, 21, 15, 0, -21 },
  { 1984, 10, 29, 7, -1, -24 },
  { 2021, 8, 23, 11, 2, -21 },
  { 2044, 10, 29, 7, -2, -24 },
  { 2081, 10, 10, 11, 1, -21 },
  { 2094, 11, 3, 11, -2, 0 },
  { 2099, 6, 4, 9, 3, -21 },
  { 2102, 12, 16, 13, 0, -16 },
  { 2126, 13, 22, 14, 0, -22 },
  { 2162, 13, 16, 13, 0, -16 },
  { 2188, 15, 22, 14, 0, -22 },
  { 2230, 12, 16, 14, 1, -16 },
  { 2254, 10, 22, 9, 1, -22 },
  { 2282, 14, 22, 14, 0, -16 },
  { 2321, 13, 22, 14, 0, -22 },
  { 2357, 8, 22, 7, 0, -22 },
  { 2379, 11, 28, 7, -3, -22 },
  { 2418, 15, 22, 14, 0, -22 },
  { 2460, 8, 22, 7, 0, -22 },
  { 2482, 20, 16, 21, 0, -16 },
  { 2522, 13, 16, 14, 0, -16 },
  { 2548, 12, 16, 14, 1, -16 },
  { 2572, 14, 22, 14, -1, -16 },
  { 2611, 14, 22, 14, 0, -16 },
  { 2650, 10, 16, 10, 0, -16 },
  { 2670, 12, 16, 13, 0, -16 },
  { 2694, 8, 19, 9, 1, -19 },
  { 2713, 13, 16, 14, 1, -16 },
  { 2739, 13, 16, 13, 1, -16 },
  { 2765, 16, 16, 18, 2, -16 },
  { 2797, 15, 16, 13, -1, -16 },
  { 2827, 15, 22, 13, -1, -16 },
  { 2869, 13, 16, 13, 0, -16 },
  { 2895, 8, 28, 8, 1, -23 },
  { 2923, 7, 25, 7, 0, -21 },
  { 2945, 9, 28, 8, -1, -23 },
  { 2977, 13, 7, 15, 1, -12 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC29PT7B_H_
