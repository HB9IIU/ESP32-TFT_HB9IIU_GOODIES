#ifndef _ROBOTOCONDENSED_EXTRABOLDITALIC38PT7B_H_
#define _ROBOTOCONDENSED_EXTRABOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-ExtraBoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_ExtraBoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xE0, 0x00, 0x78, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C,
  0xF1, 0xCF, 0x3C, 0xF3, 0xCE, 0x38, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01,
  0xCF, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x0F,
  0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xE7, 0x00, 0x39,
  0xE0, 0x0F, 0x38, 0x01, 0xE7, 0x00, 0x39, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF1, 0xFF, 0xFC, 0x07, 0x38, 0x01, 0xE7, 0x00, 0x39, 0xE0, 0x07, 0x3C,
  0x01, 0xE7, 0x00, 0x39, 0xE0, 0x07, 0x3C, 0x01, 0xE7, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xE3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x87, 0xFF, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFC,
  0x01, 0xEF, 0x04, 0x71, 0xC3, 0xFC, 0x71, 0xEF, 0x1C, 0xF3, 0xC7, 0x38,
  0xF3, 0xDE, 0x1C, 0xFF, 0x07, 0xFB, 0x80, 0xFF, 0xE0, 0x1E, 0xF0, 0x00,
  0x78, 0x00, 0x1D, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xDE, 0xF0, 0xFF,
  0x1C, 0x7B, 0xC7, 0x1C, 0xF1, 0xCE, 0x3C, 0xF7, 0x8F, 0x3C, 0xC3, 0xCF,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7C, 0xF8, 0x07, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x1F, 0x1F, 0xF1, 0xF3, 0xFF, 0x9E, 0x3E,
  0xFB, 0xE7, 0xEF, 0xFE, 0x7C, 0x7F, 0xC7, 0xC7, 0xFC, 0x7C, 0x3F, 0xC7,
  0xC3, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x0F, 0xC7, 0xE0, 0x3D, 0xF7, 0x9E, 0x79, 0xE7, 0x3C, 0xF3, 0xC0, 0x00,
  0x20, 0x1C, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1E, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xC0, 0x10, 0x00, 0x02, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x70, 0x04,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x41, 0xC1, 0x71,
  0xC7, 0xFD, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x1E,
  0xE0, 0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0x78, 0x30, 0x70, 0x10, 0x20, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0xF8, 0xF0,
  0x20, 0x7F, 0xDF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFF, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F, 0x9F, 0x07,
  0xDF, 0x87, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF0, 0x7C, 0xF8,
  0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xC7, 0xC3, 0xE3,
  0xE3, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x30, 0x1F, 0x07, 0xE3, 0xFE, 0x7F, 0xE7, 0xFE, 0xFF, 0xEE,
  0x7E, 0x87, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xFB, 0xF0, 0x7C, 0xFC, 0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xF1, 0xFF,
  0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xE7, 0xC1, 0xF7, 0xE1,
  0xF3, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xBC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0x9F, 0x80, 0x43, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3F, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x7E, 0x01,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x78, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x7F, 0xFF, 0x7E,
  0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x3F, 0x7C,
  0x3F, 0x7C, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x07,
  0xC0, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF,
  0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F,
  0x1F, 0x8F, 0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFC, 0xFC, 0x7C, 0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x87,
  0xCF, 0xC3, 0xE7, 0xE3, 0xF3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F,
  0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE,
  0x3F, 0xFE, 0x3E, 0x3E, 0x7E, 0x3F, 0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F,
  0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFE, 0x0F, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x0E, 0x0F,
  0x8F, 0xE7, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0x87, 0x80, 0x03, 0xC0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x18,
  0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xC1, 0xFF,
  0x8F, 0xFE, 0x7F, 0xF0, 0xFF, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x40, 0x1F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE0, 0x10, 0x00, 0x70, 0x00, 0xF8,
  0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x7E,
  0x03, 0xF8, 0x1F, 0xF0, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x3F, 0x80, 0x7C,
  0x00, 0xE0, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xE7, 0xFF, 0xEF, 0xCF, 0xDF, 0x1F, 0xFE, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x00,
  0x78, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x0F,
  0x03, 0xC1, 0xE3, 0xC1, 0xFE, 0x1C, 0x78, 0x7F, 0xE3, 0x8E, 0x1F, 0x3C,
  0x73, 0xC7, 0xC7, 0x0E, 0x78, 0xF1, 0xE1, 0xDE, 0x3E, 0x3C, 0x3B, 0xC7,
  0x87, 0x8F, 0x78, 0xF0, 0xE1, 0xEF, 0x3E, 0x3C, 0x39, 0xC7, 0xC7, 0x87,
  0x38, 0xF0, 0xF1, 0xE7, 0x1E, 0x3C, 0x39, 0xE3, 0xC7, 0x87, 0x3C, 0x7D,
  0xF1, 0xC3, 0x87, 0xFF, 0xF8, 0x70, 0xFD, 0xFE, 0x0E, 0x0F, 0x0F, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xF3, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x01, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x07,
  0xE1, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE3, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x7F, 0x00, 0xFD,
  0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0x0F, 0x83, 0xF1,
  0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x87, 0xE1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0xFC, 0x3F, 0x07,
  0xC3, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xF8, 0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x1F, 0x3F, 0x01,
  0xF3, 0xE0, 0x1F, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xE1, 0xFC, 0x7F, 0xFF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8,
  0x7E, 0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3,
  0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFC,
  0x7E, 0x0F, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0,
  0xFF, 0xFE, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF1, 0xFC, 0x3F, 0x1F, 0x81,
  0xF3, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE3, 0xFF, 0x7E, 0x3F, 0xE7, 0xC3, 0xFE, 0x7C,
  0x3F, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x7E, 0x7E, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3,
  0xE1, 0xF8, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xC1,
  0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0x8F, 0xE0, 0x0F, 0x8F,
  0xC0, 0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x7F, 0x3F,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7C, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x01,
  0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC,
  0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xDE, 0x1E, 0xF8, 0x3E,
  0xF1, 0xFF, 0xC1, 0xF7, 0x8F, 0xFE, 0x1F, 0xBC, 0x7B, 0xE0, 0xFD, 0xE7,
  0xDF, 0x07, 0xEF, 0x3C, 0xF8, 0x3E, 0x7B, 0xEF, 0xC1, 0xF3, 0xDE, 0x7E,
  0x1F, 0x9E, 0xF3, 0xF0, 0xFC, 0xFF, 0x1F, 0x07, 0xE3, 0xF9, 0xF8, 0x3F,
  0x1F, 0xCF, 0xC1, 0xF8, 0xFC, 0x7E, 0x0F, 0x87, 0xE3, 0xF0, 0xFC, 0x3E,
  0x1F, 0x87, 0xE1, 0xF0, 0xF8, 0x3F, 0x0F, 0x0F, 0xC0, 0x07, 0xC0, 0x7E,
  0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE1,
  0xFE, 0x0F, 0x83, 0xFC, 0x3F, 0x0F, 0xF8, 0x7E, 0x1F, 0xF0, 0xFC, 0x3F,
  0xF1, 0xF8, 0x7F, 0xE3, 0xF0, 0xFB, 0xC7, 0xC1, 0xF3, 0x9F, 0x87, 0xE7,
  0xBF, 0x0F, 0xCF, 0x7E, 0x1F, 0x9E, 0xFC, 0x3F, 0x1D, 0xF0, 0x7C, 0x3F,
  0xE1, 0xF8, 0x7F, 0xC3, 0xF0, 0xFF, 0x87, 0xE1, 0xFF, 0x0F, 0xC1, 0xFE,
  0x1F, 0x83, 0xF8, 0x3E, 0x07, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E,
  0x3F, 0x01, 0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0,
  0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0xFC, 0x3F, 0x0F,
  0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xC0, 0xFC, 0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x7F,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x01,
  0xF9, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF7, 0xE0, 0x1F,
  0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0xFC, 0x3F, 0x0F, 0xE1, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x81,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x0F, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE,
  0x3F, 0x0F, 0xC7, 0xC1, 0xF9, 0xF8, 0x1F, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF,
  0xC1, 0xF9, 0xF8, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x0F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x3F, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07,
  0xE1, 0xF0, 0x3F, 0x0F, 0x83, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x00, 0xF9, 0xF0,
  0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x0F, 0xFF,
  0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3E, 0xFC, 0x7F, 0x1F,
  0xBF, 0x1F, 0xC7, 0xEF, 0xC7, 0xF1, 0xF3, 0xF3, 0xFC, 0xFC, 0xFC, 0xFF,
  0x3F, 0x3F, 0x3F, 0xCF, 0x8F, 0xDF, 0xF7, 0xE3, 0xF7, 0xFD, 0xF8, 0xFD,
  0xFF, 0x7C, 0x3F, 0xFF, 0xDF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0xE0,
  0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x3F,
  0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xE1, 0xFC,
  0x07, 0xE1, 0xF8, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xF0, 0x03, 0xF7, 0xE0,
  0x01, 0xF7, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xCF, 0x80,
  0x0F, 0xCF, 0x80, 0x1F, 0x8F, 0xC0, 0x3F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x7F, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xFF,
  0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xF8, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x03, 0xF8, 0x1F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0xC3, 0xCE, 0x3E, 0x71,
  0xE3, 0xDF, 0x1E, 0xF0, 0xFF, 0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x01, 0xF8, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x38, 0x3F, 0x00, 0x3F,
  0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0x3E, 0x7C, 0x7E, 0xFC, 0x7E,
  0xFC, 0x7E, 0xFC, 0xFE, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1E, 0x7E,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xDE, 0x07, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xFC, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E, 0x0F,
  0x9F, 0x07, 0xCF, 0x83, 0xEF, 0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF0,
  0x7C, 0xFC, 0x7E, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0x7F, 0x8F,
  0x9F, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF7, 0xFF, 0xEF,
  0x87, 0xDF, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x0F, 0xBE, 0x1F, 0x7F, 0xFE, 0xFF, 0xF8, 0xFF, 0xE0,
  0xFF, 0x80, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0xF3, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xE0,
  0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xC3,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xE7,
  0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFE, 0x7E,
  0x3F, 0x7C, 0x1F, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x18, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF8, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x81, 0xFF, 0xC7, 0xFF,
  0x1F, 0xFC, 0xFF, 0xE0, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xE7, 0xC3, 0xFD,
  0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0xCF, 0xC3, 0xF3, 0xE0, 0xF9,
  0xF8, 0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0, 0x7E, 0x7C,
  0x1F, 0x1F, 0x07, 0xC7, 0xE3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x3E, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC1,
  0xE7, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xDE, 0x07, 0xFF, 0xC3, 0xFF,
  0xE3, 0xFF, 0xF9, 0xFF, 0xFC, 0xFC, 0x7E, 0x7C, 0x3F, 0x3E, 0x1F, 0x9F,
  0x0F, 0xDF, 0x87, 0xCF, 0xC3, 0xE7, 0xE1, 0xF3, 0xE1, 0xF9, 0xF0, 0xFC,
  0xF8, 0x7E, 0xFC, 0x3E, 0x7E, 0x1F, 0x3F, 0x0F, 0x9F, 0x0F, 0xCF, 0x87,
  0xE0, 0x03, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x1F,
  0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0,
  0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF1, 0xFC, 0x7C, 0x7F, 0x0F, 0x8F, 0xC1, 0xF3, 0xF0, 0x7E, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBF, 0x03, 0xE7, 0xE0,
  0x7C, 0x7C, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xF0,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC0, 0x1F, 0x3E, 0x1F, 0x07, 0xDF, 0xDF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xCF, 0xC7, 0xE3, 0xF3,
  0xF1, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x3E, 0x1F, 0x0F, 0xCF, 0x87, 0xC3,
  0xE7, 0xE1, 0xF0, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x9F, 0x0F,
  0xC7, 0xE7, 0xC3, 0xE1, 0xF9, 0xF0, 0xF8, 0x7C, 0xFC, 0x3E, 0x1F, 0x3F,
  0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF3, 0xE1, 0xF8, 0xFC, 0x1F, 0x3E, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E,
  0x7C, 0x3F, 0x3E, 0x1F, 0xBF, 0x0F, 0x9F, 0x87, 0xCF, 0xC3, 0xE7, 0xC3,
  0xF3, 0xE1, 0xF9, 0xF0, 0xFD, 0xF8, 0x7C, 0xFC, 0x3E, 0x7E, 0x1F, 0x3E,
  0x1F, 0x9F, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFF, 0x7E, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x7E, 0xFF, 0xFC,
  0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x07, 0xCF, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x87, 0xC3, 0xF0,
  0xF8, 0x7E, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3E, 0x0F, 0x87, 0xC3, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xE7, 0xFF, 0xE7,
  0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7C, 0x1F,
  0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xE7, 0xC3, 0xF3, 0xE1, 0xF9, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x03, 0xDF, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x38, 0xFF, 0xC7, 0xFE, 0x3F, 0xF3, 0xFF, 0x9F,
  0xFC, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0x3F, 0x3E, 0x1F,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0xF8, 0x7E, 0xF8, 0x7E, 0xFC, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0xFF,
  0xDF, 0xFB, 0xFF, 0xFF, 0xE7, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xF0, 0xFE, 0x1F, 0xC1,
  0xF8, 0x1F, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0xCF, 0x87, 0xE7, 0xC3, 0xF7,
  0xE1, 0xF3, 0xF0, 0xF9, 0xF8, 0xFC, 0xF8, 0x7E, 0x7C, 0x3F, 0x3E, 0x1F,
  0x3F, 0x0F, 0x9F, 0x87, 0xCF, 0xC7, 0xE7, 0xC3, 0xF3, 0xF1, 0xF9, 0xFF,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xCF, 0x80, 0xFC, 0x3F,
  0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0xFC, 0xFC, 0xFC, 0x7C, 0xF8,
  0x7D, 0xF8, 0x7D, 0xF0, 0x7D, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0xF8, 0x78, 0x7F, 0xE1, 0xE3, 0xFF, 0x8F, 0x8F, 0xBE, 0x3E,
  0x3E, 0xF9, 0xF9, 0xFB, 0xE7, 0xE7, 0xCF, 0x9F, 0x9F, 0x3E, 0xFE, 0xF8,
  0xFB, 0xFB, 0xE3, 0xFE, 0xEF, 0x8F, 0xFB, 0xBC, 0x3F, 0xEF, 0xF0, 0xFF,
  0x3F, 0xC3, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7E, 0x3F,
  0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0, 0x1E, 0x0F, 0x80, 0x1F, 0x87, 0xC1,
  0xF1, 0xF8, 0x3E, 0x7E, 0x07, 0xCF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFB, 0xE0, 0x3E,
  0x7E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xE3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x03,
  0xEF, 0xC0, 0x7D, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF,
  0xF0, 0x00, 0x60, 0x1C, 0x07, 0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x1F, 0x83, 0xE0, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF0, 0x0E, 0x00, 0xC0, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x06, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0,
  0x3C, 0x0F, 0x83, 0xF0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xC0,
  0x70, 0x0C, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0xF3, 0xFC, 0x3D, 0xFF, 0x9F,
  0x7F, 0xFF, 0x9E, 0x3F, 0xEF, 0x8F, 0xF3, 0xC1, 0xFC, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_ExtraBoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 11, 27, 10, 0, -27 },
  { 39, 12, 10, 12, 2, -29 },
  { 54, 19, 27, 19, 0, -27 },
  { 119, 18, 35, 19, 1, -31 },
  { 198, 18, 27, 24, 3, -27 },
  { 259, 20, 27, 22, 0, -27 },
  { 327, 6, 10, 6, 2, -29 },
  { 335, 11, 38, 12, 2, -30 },
  { 388, 12, 38, 12, -2, -30 },
  { 445, 16, 17, 17, 2, -27 },
  { 479, 16, 19, 17, 1, -22 },
  { 517, 8, 12, 9, -2, -5 },
  { 529, 10, 5, 14, 2, -14 },
  { 536, 6, 6, 11, 1, -6 },
  { 541, 17, 29, 12, -3, -27 },
  { 603, 17, 27, 19, 1, -27 },
  { 661, 12, 27, 19, 4, -27 },
  { 702, 18, 27, 19, 0, -27 },
  { 763, 18, 27, 19, 0, -27 },
  { 824, 17, 27, 19, 1, -27 },
  { 882, 18, 27, 19, 1, -27 },
  { 943, 16, 27, 19, 1, -27 },
  { 997, 19, 27, 19, 1, -27 },
  { 1062, 17, 27, 19, 1, -27 },
  { 1120, 16, 27, 19, 2, -27 },
  { 1174, 9, 21, 11, 1, -21 },
  { 1198, 11, 28, 10, -2, -21 },
  { 1237, 15, 19, 17, 1, -21 },
  { 1273, 17, 14, 19, 1, -19 },
  { 1303, 15, 18, 17, 1, -20 },
  { 1337, 15, 27, 17, 2, -27 },
  { 1388, 27, 34, 28, 0, -26 },
  { 1503, 22, 27, 22, -2, -27 },
  { 1578, 20, 27, 21, 0, -27 },
  { 1646, 20, 27, 21, 1, -27 },
  { 1714, 20, 27, 21, 0, -27 },
  { 1782, 20, 27, 18, 0, -27 },
  { 1850, 19, 27, 18, 0, -27 },
  { 1915, 20, 27, 22, 1, -27 },
  { 1983, 23, 27, 23, 0, -27 },
  { 2061, 11, 27, 10, 0, -27 },
  { 2099, 19, 27, 18, 0, -27 },
  { 2164, 24, 27, 20, 0, -27 },
  { 2245, 16, 27, 18, 0, -27 },
  { 2299, 29, 27, 28, 0, -27 },
  { 2397, 23, 27, 23, 0, -27 },
  { 2475, 21, 27, 22, 1, -27 },
  { 2546, 21, 27, 21, 0, -27 },
  { 2617, 21, 32, 22, 1, -27 },
  { 2701, 21, 27, 21, 0, -27 },
  { 2772, 19, 27, 20, 1, -27 },
  { 2837, 19, 27, 20, 3, -27 },
  { 2902, 21, 27, 21, 1, -27 },
  { 2973, 21, 27, 21, 3, -27 },
  { 3044, 26, 27, 28, 3, -27 },
  { 3132, 24, 27, 21, -1, -27 },
  { 3213, 20, 27, 20, 3, -27 },
  { 3281, 22, 27, 20, -1, -27 },
  { 3356, 13, 38, 10, -1, -32 },
  { 3418, 9, 29, 14, 3, -27 },
  { 3451, 13, 38, 10, -2, -32 },
  { 3513, 13, 13, 15, 1, -27 },
  { 3535, 14, 4, 15, -2, 0 },
  { 3542, 8, 6, 12, 4, -29 },
  { 3548, 16, 20, 17, 0, -20 },
  { 3588, 17, 29, 18, 0, -29 },
  { 3650, 15, 20, 17, 1, -20 },
  { 3688, 19, 29, 18, 1, -29 },
  { 3757, 16, 20, 18, 1, -20 },
  { 3797, 14, 29, 12, 1, -29 },
  { 3848, 18, 28, 19, 0, -20 },
  { 3911, 17, 29, 18, 0, -29 },
  { 3973, 10, 28, 9, 0, -28 },
  { 4008, 14, 36, 9, -4, -28 },
  { 4071, 19, 29, 18, 0, -29 },
  { 4140, 11, 29, 9, 0, -29 },
  { 4180, 26, 20, 27, 0, -20 },
  { 4245, 17, 20, 18, 0, -20 },
  { 4288, 16, 20, 18, 1, -20 },
  { 4328, 19, 28, 18, -2, -20 },
  { 4395, 17, 28, 18, 1, -20 },
  { 4455, 13, 20, 12, 0, -20 },
  { 4488, 16, 20, 17, 0, -20 },
  { 4528, 11, 25, 11, 1, -25 },
  { 4563, 17, 20, 18, 1, -20 },
  { 4606, 16, 20, 17, 2, -20 },
  { 4646, 22, 20, 23, 2, -20 },
  { 4701, 19, 20, 17, -1, -20 },
  { 4749, 19, 28, 17, -1, -20 },
  { 4816, 18, 20, 17, -1, -20 },
  { 4861, 11, 37, 11, 1, -30 },
  { 4912, 8, 32, 9, 1, -27 },
  { 4944, 11, 37, 11, -1, -30 },
  { 4995, 18, 9, 20, 1, -16 },
};

const GFXfont RobotoCondensed_ExtraBoldItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_ExtraBoldItalic38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_ExtraBoldItalic38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_EXTRABOLDITALIC38PT7B_H_
