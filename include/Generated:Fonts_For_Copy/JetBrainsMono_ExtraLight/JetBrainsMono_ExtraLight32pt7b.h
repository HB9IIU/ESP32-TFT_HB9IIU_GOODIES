#ifndef _JETBRAINSMONO_EXTRALIGHT32PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight32pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x44, 0x44, 0x00, 0x00, 0xFF,
  0xE0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0x80,
  0x03, 0x06, 0x01, 0x83, 0x00, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x40, 0x30,
  0x21, 0xFF, 0xFE, 0xFF, 0xFF, 0x04, 0x0C, 0x06, 0x06, 0x03, 0x02, 0x01,
  0x83, 0x00, 0xC1, 0x80, 0x40, 0xC0, 0x60, 0x61, 0xFF, 0xFE, 0x18, 0x30,
  0x0C, 0x18, 0x04, 0x0C, 0x06, 0x06, 0x03, 0x02, 0x01, 0x83, 0x00, 0xC1,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x80, 0x7F, 0x87,
  0xBF, 0x18, 0xCE, 0xE3, 0x1B, 0x0C, 0x6C, 0x31, 0xB8, 0xC0, 0x63, 0x01,
  0xCC, 0x03, 0xB0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x33, 0x80, 0xC6,
  0x03, 0x18, 0x0C, 0x7C, 0x31, 0xF0, 0xC7, 0xC3, 0x19, 0x8C, 0xE7, 0xFF,
  0x07, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x5F,
  0x80, 0x6E, 0x70, 0x13, 0x0C, 0x0C, 0xC3, 0x06, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x60, 0xC3, 0x30, 0x1F, 0xC8, 0x07, 0xE6, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x63, 0x00, 0x33, 0xF0, 0x19, 0xC6, 0x06, 0x61, 0x83,
  0x18, 0x21, 0x86, 0x08, 0x61, 0x82, 0x30, 0x61, 0x98, 0x18, 0x64, 0x03,
  0xFB, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0xE0, 0x3C, 0xF0, 0x30, 0x30, 0x30,
  0x38, 0x30, 0x18, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x7E, 0x00, 0x67, 0x07, 0xC3, 0x06, 0xC1, 0x8E, 0xC1, 0xCC, 0xC0,
  0xDC, 0xC0, 0x78, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x78, 0xE0, 0xEC, 0x7F,
  0xC6, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0xC0, 0xF0, 0x78, 0x70,
  0x18, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0C, 0x80, 0x70,
  0x1E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x03, 0x83, 0x8F, 0x87, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x02, 0x06, 0x0B, 0xE2, 0x1E,
  0xFD, 0x3E, 0x0F, 0xFC, 0x00, 0x60, 0x00, 0x50, 0x00, 0x6C, 0x00, 0x63,
  0x00, 0x71, 0xC0, 0x70, 0x70, 0x30, 0x18, 0x08, 0x08, 0x00, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x3F, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x3C, 0xE3, 0x9C, 0x71, 0x86, 0x38, 0xC3, 0x00, 0xFF,
  0xFF, 0xFC, 0x37, 0xFF, 0xF7, 0x80, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x03,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x00, 0x07, 0x01, 0xFF,
  0x1E, 0x3C, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x87, 0x8E, 0x3C, 0x71, 0xE3, 0x8F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xB8, 0x38, 0xFF, 0xC3, 0xF8,
  0x07, 0x80, 0x7E, 0x03, 0x98, 0x1C, 0x60, 0xC1, 0x82, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0xFF, 0x87, 0x8F, 0x38, 0x0E,
  0xC0, 0x1B, 0x00, 0x6C, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x66, 0x07, 0x3F, 0xF0, 0x7F,
  0x00, 0x00, 0x70, 0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18,
  0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x06, 0x60, 0x36, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x7F, 0xF3, 0xFF, 0x98, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x6F, 0xE3, 0xFF, 0xBC, 0x0D, 0xC0, 0x7E, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x76,
  0x03, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xE0,
  0xFF, 0xE3, 0xC0, 0xE7, 0x00, 0xCC, 0x01, 0x98, 0x03, 0xF0, 0x03, 0x60,
  0x06, 0xC0, 0x1D, 0x80, 0x33, 0x80, 0x63, 0x81, 0x83, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x06, 0xC0, 0x1B, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xFF, 0x1E, 0x3C, 0xC0,
  0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0x60, 0x31, 0x83, 0x87, 0x38,
  0x1F, 0x00, 0xFC, 0x1C, 0x71, 0xC0, 0xDC, 0x07, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xB0, 0x1D, 0xFF, 0xC3, 0xF8, 0x03, 0x80, 0x3F,
  0xE0, 0xF1, 0xE1, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0x98, 0x01, 0xF0, 0x03,
  0x60, 0x06, 0xC0, 0x1D, 0x80, 0x33, 0x80, 0xE3, 0x83, 0xC3, 0xFF, 0x01,
  0xEE, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFB, 0xC0, 0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF3, 0x8E, 0x71, 0xC7, 0x18, 0xE3, 0x0C, 0x00,
  0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C,
  0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x80, 0x06, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x08, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x18, 0x00, 0x80, 0x00, 0xFF,
  0x1F, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x0E, 0x1F, 0x83, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x3C,
  0x3C, 0x70, 0x0C, 0x60, 0x06, 0xE0, 0x06, 0xC0, 0x06, 0xC0, 0x03, 0xC0,
  0x23, 0xC1, 0xFB, 0xC3, 0x8F, 0xC3, 0x07, 0xC3, 0x03, 0xC3, 0x03, 0xC3,
  0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC3, 0x07, 0xC3, 0x07, 0xC1,
  0xDB, 0xC1, 0xFB, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1B,
  0x00, 0x36, 0x00, 0x6C, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x60,
  0x18, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x07, 0x03, 0x0C, 0x06, 0x1F,
  0xFC, 0x30, 0x1C, 0xE0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0x80, 0xFF, 0xC3, 0xFF, 0xCC, 0x03, 0x30, 0x0E, 0xC0, 0x1B,
  0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x01, 0xCF, 0xFC, 0x3F, 0xF8,
  0xC0, 0x73, 0x00, 0x6C, 0x01, 0xB0, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xB0, 0x06, 0xC0, 0x7B, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0x80, 0xFF, 0x0E,
  0x3C, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x07, 0x80, 0x36, 0x01, 0xB8, 0x18, 0xFF, 0xC3, 0xF8, 0xFF,
  0xC7, 0xFF, 0x30, 0x1D, 0x80, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x6C, 0x0F, 0x7F, 0xF3, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEF, 0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x0E, 0x3C, 0xC0, 0x7E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x3F, 0xE1, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x36, 0x01, 0xB8, 0x18, 0xFF, 0xC3, 0xF8, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x6C, 0x01, 0xB8, 0x06, 0x70, 0x38, 0xFF, 0xC1,
  0xFC, 0x00, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0xE6, 0x01, 0x8C, 0x07, 0x18,
  0x0C, 0x30, 0x38, 0x60, 0x60, 0xC1, 0xC1, 0x83, 0x03, 0xFE, 0x07, 0xFC,
  0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60, 0x70, 0xC0, 0x61, 0x80, 0xE3,
  0x00, 0xC6, 0x01, 0xCC, 0x01, 0x98, 0x03, 0xB0, 0x03, 0x80, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0xE0, 0x3D, 0x01, 0xEC, 0x0B, 0xE0, 0xDD, 0x06, 0xEC, 0x27, 0x63, 0x39,
  0x1B, 0xCD, 0x9E, 0x6C, 0xF1, 0x67, 0x8E, 0x3C, 0x71, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x60, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xB0, 0x3D, 0x81, 0xEC, 0x0F,
  0x30, 0x79, 0x83, 0xC6, 0x1E, 0x30, 0xF1, 0x87, 0x86, 0x3C, 0x31, 0xE1,
  0x8F, 0x06, 0x78, 0x33, 0xC0, 0xDE, 0x06, 0xF0, 0x37, 0x80, 0xFC, 0x07,
  0xE0, 0x1F, 0x00, 0xE0, 0x07, 0x00, 0xFF, 0x1E, 0x3C, 0xC0, 0x6E, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x36, 0x03, 0xB8, 0x18, 0xFF, 0x83, 0xF8, 0xFF, 0xE3, 0xFF, 0xCC, 0x03,
  0xB0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x03, 0xBF, 0xFC, 0xFF, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x07, 0x00, 0x7F, 0x87, 0x8F, 0x18, 0x0C, 0xE0, 0x1B, 0x00, 0x6C, 0x01,
  0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00,
  0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0x60,
  0x39, 0xC0, 0xC3, 0xFE, 0x07, 0xF0, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x70, 0xFF, 0xE3, 0xFF, 0xCC, 0x03, 0xB0, 0x06,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x6C, 0x07,
  0x3F, 0xF8, 0xFF, 0x83, 0x06, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x63, 0x01,
  0x8C, 0x07, 0x30, 0x0C, 0xC0, 0x3B, 0x00, 0x6C, 0x01, 0xC0, 0x07, 0x00,
  0x7F, 0x87, 0x87, 0x18, 0x0E, 0xE0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x19, 0x80,
  0xE7, 0xFF, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x06, 0xC0, 0x77, 0x07, 0x1F, 0xF0,
  0x7F, 0x00, 0xC0, 0x07, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x00, 0xC6,
  0x01, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xC1,
  0x81, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30, 0x0E, 0x60, 0x0D, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0x2C, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC1, 0xC1,
  0xE0, 0xE0, 0xF0, 0x70, 0x6C, 0x28, 0x36, 0x16, 0x1B, 0x0B, 0x19, 0x85,
  0x8C, 0xC6, 0xC6, 0x63, 0x23, 0x31, 0x91, 0x98, 0x88, 0xC4, 0x44, 0x63,
  0x23, 0x31, 0x91, 0x90, 0xD8, 0xD8, 0x6C, 0x6C, 0x36, 0x16, 0x1A, 0x0B,
  0x0D, 0x05, 0x86, 0x82, 0xC1, 0x41, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0xE0,
  0x0E, 0x60, 0x0C, 0x30, 0x1C, 0x30, 0x18, 0x18, 0x30, 0x1C, 0x30, 0x0C,
  0x60, 0x0E, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0xC0, 0x06, 0xC0, 0x0E, 0x60, 0x0C, 0x60, 0x18, 0x30, 0x18, 0x38, 0x30,
  0x18, 0x30, 0x1C, 0x60, 0x0C, 0xE0, 0x0E, 0xC0, 0x07, 0xE0, 0x03, 0xB8,
  0x01, 0x8C, 0x01, 0x86, 0x00, 0xC1, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x60,
  0x18, 0x30, 0x06, 0x30, 0x03, 0x18, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x1F, 0xFF, 0x80, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0xFF, 0xFC, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x80, 0x07,
  0x00, 0x3C, 0x03, 0x60, 0x1B, 0x01, 0x8C, 0x0C, 0x60, 0xE1, 0x86, 0x0C,
  0x30, 0x33, 0x01, 0x98, 0x0F, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1,
  0xC3, 0x87, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x8C, 0x07, 0x70, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x1F, 0xFC, 0xFF, 0xF7, 0x00, 0xD8, 0x03, 0xE0,
  0x0F, 0x80, 0x36, 0x01, 0xDC, 0x0F, 0x3D, 0xEC, 0x7F, 0x30, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x63, 0xE3, 0x7F, 0x9A, 0x0E, 0xE0,
  0x3F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x7D, 0x03, 0x6F, 0xFB, 0x3F, 0x00,
  0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01, 0xE0, 0x0D, 0x80,
  0x6E, 0x06, 0x3F, 0xF0, 0xFE, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x87, 0x8C, 0xFF, 0x6E, 0x0B, 0x60, 0x3F, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xC0, 0x77, 0x07, 0x9F, 0xEC, 0x7E, 0x60, 0x0F, 0x81, 0xFF, 0x1C,
  0x1C, 0xC0, 0x6E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x6E, 0x06, 0x3F, 0xF0,
  0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0x19,
  0xFE, 0xDC, 0x16, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xB0, 0x1D, 0xC1, 0x67, 0xFB,
  0x0F, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x38, 0xFF, 0x87,
  0xF0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x63, 0xE3, 0x7F,
  0x9A, 0x0E, 0xE0, 0x37, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x60, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x40, 0x1C, 0x07, 0x80, 0x70, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0x60, 0x39, 0xFE, 0x3F, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x3E, 0x01, 0xB8, 0x0E, 0xE0, 0x33, 0x81, 0x8E,
  0x0E, 0x38, 0x70, 0xE1, 0x83, 0xFC, 0x0F, 0xF8, 0x38, 0x60, 0xE0, 0xC3,
  0x83, 0x8E, 0x06, 0x38, 0x0C, 0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xC0, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xCE, 0x39, 0xBE,
  0xFB, 0x8E, 0x3F, 0x0C, 0x3C, 0x18, 0x78, 0x30, 0xF0, 0x61, 0xE0, 0xC3,
  0xC1, 0x87, 0x83, 0x0F, 0x06, 0x1E, 0x0C, 0x3C, 0x18, 0x78, 0x30, 0xF0,
  0x61, 0xE0, 0xC3, 0xC1, 0x87, 0x83, 0x0C, 0xC7, 0xC6, 0xFF, 0x34, 0x1D,
  0xC0, 0x6E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xC0, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0D,
  0x80, 0xEE, 0x06, 0x3F, 0xE0, 0xFE, 0x00, 0xC7, 0xC6, 0xFF, 0x34, 0x1D,
  0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0xFA, 0x06, 0xDF, 0xF6, 0x7E,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x0F, 0x19,
  0xFE, 0xDC, 0x16, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0D, 0x80, 0xEE, 0x0F,
  0x3F, 0xD8, 0xFC, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0xCF, 0x86, 0xFF, 0x3C, 0x1D, 0xC0, 0x6C, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x9C, 0x0C,
  0xC0, 0x3E, 0x00, 0x70, 0x01, 0x80, 0x0F, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x1E, 0x00, 0x30, 0x01, 0x80, 0x0F, 0x00, 0x7C, 0x07, 0x7F, 0xF1, 0xFF,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xFF,
  0xFF, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x0D, 0x80, 0xEE, 0x0E, 0x3F, 0xE0, 0xFE, 0x00,
  0xC0, 0x06, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0x63, 0x00, 0xC6, 0x03, 0x0C,
  0x06, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x63, 0x00, 0xC6,
  0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x03, 0xC0, 0x07, 0x00, 0xC0, 0xC1,
  0xB0, 0xE0, 0xD8, 0x70, 0x4C, 0x28, 0x66, 0x14, 0x33, 0x0B, 0x19, 0x8D,
  0x8C, 0x46, 0x46, 0x33, 0x22, 0x19, 0x13, 0x0C, 0x89, 0x86, 0x46, 0xC3,
  0x63, 0x60, 0xB0, 0xB0, 0x70, 0x50, 0x38, 0x28, 0x1C, 0x1C, 0x0E, 0x0E,
  0x00, 0xE0, 0x0E, 0xE0, 0x18, 0xC0, 0x60, 0xC1, 0xC1, 0xC3, 0x01, 0x8C,
  0x01, 0xB8, 0x03, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1B, 0x00, 0x37, 0x00,
  0xC6, 0x03, 0x86, 0x0E, 0x0E, 0x18, 0x0C, 0x70, 0x0D, 0xC0, 0x1C, 0xE0,
  0x06, 0xC0, 0x1D, 0x80, 0x33, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x06, 0x06,
  0x0C, 0x18, 0x1C, 0x30, 0x18, 0xE0, 0x31, 0x80, 0x33, 0x00, 0x6E, 0x00,
  0xD8, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x80, 0x38, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x18, 0x07, 0xC0, 0x70, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x3C, 0x1F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x1E, 0x00, 0x3F, 0x07, 0x80, 0x30, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x03, 0xC0,
  0x7C, 0x03, 0x00, 0x00, 0x3E, 0x06, 0xFE, 0x0D, 0x8E, 0x1E, 0x0E, 0x7C,
  0x0F, 0xD8, 0x07, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 4, 23, 19, 8, -23 },
  { 13, 9, 9, 19, 5, -23 },
  { 24, 17, 23, 19, 1, -23 },
  { 73, 14, 32, 19, 3, -28 },
  { 129, 18, 24, 19, 1, -24 },
  { 183, 16, 24, 19, 2, -24 },
  { 231, 3, 9, 19, 8, -23 },
  { 235, 10, 31, 19, 6, -27 },
  { 274, 9, 31, 19, 4, -27 },
  { 309, 17, 17, 19, 1, -20 },
  { 346, 15, 15, 19, 2, -18 },
  { 375, 6, 10, 19, 6, -5 },
  { 383, 11, 2, 19, 4, -12 },
  { 386, 5, 5, 19, 7, -5 },
  { 390, 13, 31, 19, 3, -27 },
  { 441, 13, 24, 19, 3, -24 },
  { 480, 14, 23, 19, 3, -23 },
  { 521, 14, 24, 19, 3, -24 },
  { 563, 13, 23, 19, 3, -23 },
  { 601, 13, 23, 19, 3, -23 },
  { 639, 13, 23, 19, 3, -23 },
  { 677, 15, 23, 19, 2, -23 },
  { 721, 14, 23, 19, 3, -23 },
  { 762, 13, 24, 19, 3, -24 },
  { 801, 15, 24, 19, 2, -24 },
  { 846, 5, 18, 19, 7, -18 },
  { 858, 6, 23, 19, 6, -18 },
  { 876, 13, 17, 19, 3, -19 },
  { 904, 13, 9, 19, 3, -15 },
  { 919, 13, 17, 19, 3, -19 },
  { 947, 11, 23, 19, 5, -23 },
  { 979, 16, 30, 19, 2, -24 },
  { 1039, 15, 23, 19, 2, -23 },
  { 1083, 14, 23, 19, 3, -23 },
  { 1124, 13, 24, 19, 3, -24 },
  { 1163, 13, 23, 19, 3, -23 },
  { 1201, 12, 23, 19, 4, -23 },
  { 1236, 14, 23, 19, 3, -23 },
  { 1277, 13, 24, 19, 3, -24 },
  { 1316, 13, 23, 19, 3, -23 },
  { 1354, 12, 23, 19, 4, -23 },
  { 1389, 14, 23, 19, 2, -23 },
  { 1430, 15, 23, 19, 3, -23 },
  { 1474, 13, 23, 19, 4, -23 },
  { 1512, 13, 23, 19, 3, -23 },
  { 1550, 13, 23, 19, 3, -23 },
  { 1588, 13, 24, 19, 3, -24 },
  { 1627, 14, 23, 19, 3, -23 },
  { 1668, 14, 30, 19, 3, -24 },
  { 1721, 14, 23, 19, 3, -23 },
  { 1762, 14, 24, 19, 3, -24 },
  { 1804, 15, 23, 19, 2, -23 },
  { 1848, 13, 23, 19, 3, -23 },
  { 1886, 15, 23, 19, 2, -23 },
  { 1930, 17, 23, 19, 1, -23 },
  { 1979, 16, 23, 19, 2, -23 },
  { 2025, 17, 23, 19, 1, -23 },
  { 2074, 13, 23, 19, 3, -23 },
  { 2112, 7, 31, 19, 7, -27 },
  { 2140, 13, 31, 19, 3, -27 },
  { 2191, 7, 31, 19, 5, -27 },
  { 2219, 13, 12, 19, 3, -23 },
  { 2239, 15, 2, 19, 2, 1 },
  { 2243, 6, 4, 19, 6, -25 },
  { 2246, 14, 18, 19, 2, -18 },
  { 2278, 13, 23, 19, 3, -23 },
  { 2316, 13, 18, 19, 3, -18 },
  { 2346, 13, 23, 19, 3, -23 },
  { 2384, 13, 18, 19, 3, -18 },
  { 2414, 15, 23, 19, 2, -23 },
  { 2458, 13, 24, 19, 3, -18 },
  { 2497, 13, 23, 19, 3, -23 },
  { 2535, 14, 25, 19, 3, -25 },
  { 2579, 11, 31, 19, 3, -25 },
  { 2622, 14, 23, 19, 3, -23 },
  { 2663, 16, 23, 19, 1, -23 },
  { 2709, 15, 18, 19, 2, -18 },
  { 2743, 13, 18, 19, 3, -18 },
  { 2773, 13, 18, 19, 3, -18 },
  { 2803, 13, 24, 19, 3, -18 },
  { 2842, 13, 24, 19, 3, -18 },
  { 2881, 13, 18, 19, 4, -18 },
  { 2911, 13, 18, 19, 3, -18 },
  { 2941, 14, 23, 19, 2, -23 },
  { 2982, 13, 18, 19, 3, -18 },
  { 3012, 15, 18, 19, 2, -18 },
  { 3046, 17, 18, 19, 1, -18 },
  { 3085, 15, 18, 19, 2, -18 },
  { 3119, 15, 24, 19, 2, -18 },
  { 3164, 13, 18, 19, 3, -18 },
  { 3194, 13, 31, 19, 3, -27 },
  { 3245, 2, 31, 19, 9, -27 },
  { 3253, 13, 31, 19, 3, -27 },
  { 3304, 15, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_ExtraLight32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_EXTRALIGHT32PT7B_H_
