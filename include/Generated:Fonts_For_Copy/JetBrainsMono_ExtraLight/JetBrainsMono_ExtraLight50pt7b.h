#ifndef _JETBRAINSMONO_EXTRALIGHT50PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight50pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x7C, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xD8, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x1C, 0x01, 0x80, 0x07, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x60,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x30, 0x00,
  0xE0, 0x1C, 0x00, 0x30, 0x07, 0x00, 0x1C, 0x01, 0xC1, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xC0, 0x70, 0x0E, 0x00, 0x18, 0x03, 0x80, 0x0E, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x07, 0x00, 0x0C,
  0x01, 0xC0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x06, 0x00,
  0x1C, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF8, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xC0,
  0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x01,
  0xC0, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x81, 0xF3, 0x3F, 0x0F, 0x0C, 0x3C, 0x38, 0x30, 0x79, 0xE0, 0xC0,
  0xE7, 0x03, 0x03, 0x9C, 0x0C, 0x0E, 0x70, 0x30, 0x3D, 0xC0, 0xC0, 0x07,
  0x83, 0x00, 0x1E, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0xF8, 0xC0, 0x01, 0xF3,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0D, 0xF8, 0x00, 0x31, 0xF0, 0x00, 0xC3, 0xE0, 0x03, 0x07, 0x80,
  0x0C, 0x0E, 0x00, 0x30, 0x3C, 0x00, 0xC0, 0x70, 0x03, 0x01, 0xF8, 0x0C,
  0x07, 0xE0, 0x30, 0x1F, 0xC0, 0xC0, 0xF7, 0x03, 0x03, 0x9E, 0x0C, 0x1E,
  0x3E, 0x30, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x71, 0xFE,
  0x00, 0x06, 0x3F, 0xF0, 0x00, 0xE7, 0x87, 0x80, 0x1C, 0x70, 0x38, 0x03,
  0x8E, 0x01, 0x80, 0x38, 0xE0, 0x18, 0x07, 0x0E, 0x01, 0x80, 0xE0, 0xE0,
  0x18, 0x0E, 0x0E, 0x01, 0x81, 0xC0, 0xE0, 0x18, 0x38, 0x0E, 0x01, 0x83,
  0x00, 0x70, 0x38, 0x70, 0x07, 0x03, 0x8E, 0x00, 0x7F, 0xF0, 0xC0, 0x03,
  0xFE, 0x1C, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x04, 0x00, 0x01, 0xC7, 0xF8,
  0x00, 0x38, 0xFF, 0xC0, 0x07, 0x1E, 0x1E, 0x00, 0x61, 0xC0, 0xE0, 0x0E,
  0x1C, 0x07, 0x01, 0xC1, 0x80, 0x70, 0x38, 0x18, 0x07, 0x03, 0x81, 0x80,
  0x70, 0x70, 0x18, 0x07, 0x0E, 0x01, 0x80, 0x70, 0xE0, 0x18, 0x07, 0x1C,
  0x01, 0xC0, 0x63, 0x80, 0x1C, 0x0E, 0x30, 0x00, 0xF3, 0xE7, 0x00, 0x0F,
  0xFC, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xBC, 0x00, 0x0F, 0x1E, 0x00, 0xFF, 0x07, 0x80, 0xF7, 0x81,
  0xE0, 0x73, 0x80, 0x70, 0x79, 0xC0, 0x3C, 0x38, 0xE0, 0x0F, 0x3C, 0x70,
  0x03, 0xDC, 0x38, 0x00, 0xFE, 0x1C, 0x00, 0x7E, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x0F, 0x83, 0x80, 0x07, 0xC1, 0xE0, 0x07, 0xF0, 0x70, 0x07, 0xBC,
  0x3C, 0x07, 0x8F, 0x0F, 0xDF, 0x83, 0x87, 0xFF, 0x81, 0xE0, 0xFF, 0x80,
  0x78, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE,
  0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x60, 0x1E, 0x01, 0x9F, 0x03, 0x03, 0xEF, 0xF0, 0xC3, 0xFD,
  0xFF, 0x33, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x80, 0x04,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0,
  0xF8, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E,
  0x10, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8,
  0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9C, 0x00, 0x0E, 0x70,
  0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x78, 0x3F,
  0xC3, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC, 0x3F, 0x0F, 0xF0, 0x78, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0x38, 0x00,
  0xF8, 0xE0, 0x07, 0xC3, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x00,
  0xE0, 0x08, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC,
  0x0F, 0xC0, 0xF8, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x00, 0x07, 0xBC,
  0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x78, 0x00,
  0xF1, 0xE0, 0x0F, 0x07, 0xF7, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C,
  0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x0F, 0xE0, 0x73, 0xFF, 0x8F, 0x7F, 0xFC,
  0xFE, 0x07, 0xEF, 0xC0, 0x1E, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0x70, 0x01, 0xE7, 0xC0, 0x3E, 0x3F, 0xDF, 0xC1,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0xBF, 0xC0, 0x1D, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xE0, 0x1F, 0x1F,
  0x00, 0x3E, 0x78, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9E, 0x00, 0x1E, 0x3C,
  0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xFC, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xBC,
  0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF0,
  0xE0, 0x01, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xE7, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xF0, 0x03,
  0xC1, 0xE0, 0x1E, 0x03, 0xE1, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0x87, 0xC0, 0x78, 0x07, 0x83, 0xC0,
  0x0F, 0x1E, 0x00, 0x1E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xEF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9C,
  0x00, 0x0E, 0x78, 0x00, 0x78, 0xF8, 0x07, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE7,
  0x80, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0x70, 0x00, 0x39, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F,
  0xC0, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xF3, 0x80, 0x0F, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x10, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F,
  0xCF, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3F, 0x07, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x78, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x1F, 0x80, 0x7F, 0xEF, 0xC0, 0x7E, 0x77, 0xE0, 0x38, 0x0F, 0xF0,
  0x3C, 0x03, 0xF8, 0x1C, 0x01, 0xFC, 0x0E, 0x00, 0xFE, 0x07, 0x00, 0x7F,
  0x03, 0x80, 0x3F, 0x81, 0xC0, 0x1F, 0xC0, 0xE0, 0x0F, 0xE0, 0x70, 0x07,
  0xF0, 0x38, 0x03, 0xF8, 0x1C, 0x01, 0xFC, 0x0E, 0x00, 0xFE, 0x07, 0x80,
  0x7F, 0x03, 0xC0, 0x3F, 0x80, 0xF0, 0x3F, 0xC0, 0x7E, 0x77, 0xE0, 0x1F,
  0xF3, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xC3, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8E, 0x00, 0x3E, 0x70, 0x00,
  0xF3, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0x80, 0x07,
  0x9C, 0x00, 0x78, 0xE0, 0x1F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x8E, 0x00, 0x3E, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0xE0, 0x01, 0xF7,
  0x00, 0x3F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x0F, 0x87, 0x80, 0x1E,
  0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x78,
  0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x30, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0xE0, 0x07, 0xCE, 0x00, 0x3E, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0,
  0x03, 0xCE, 0x00, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCE,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xEF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x0F, 0x87, 0x80, 0x1E,
  0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x78,
  0x01, 0xE1, 0xE0, 0x1F, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x30, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xEE, 0x00, 0x0E,
  0x78, 0x00, 0xF1, 0xF0, 0x0F, 0x07, 0xF7, 0xF8, 0x1F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x10, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07,
  0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38,
  0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01,
  0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x3C, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3,
  0x80, 0x07, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80,
  0x01, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xEC, 0x00, 0xDF, 0xB8, 0x07, 0x7E,
  0xE0, 0x1D, 0xF9, 0x80, 0x67, 0xE7, 0x03, 0x9F, 0x9C, 0x0E, 0x7E, 0x30,
  0x31, 0xF8, 0xE1, 0xC7, 0xE3, 0x87, 0x1F, 0x86, 0x18, 0x7E, 0x1C, 0xE1,
  0xF8, 0x73, 0x87, 0xE0, 0xCC, 0x3F, 0x83, 0xF0, 0xFF, 0x0F, 0xC3, 0xFC,
  0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7E, 0xC0, 0x07, 0xEE, 0x00, 0x7E, 0xE0, 0x07, 0xE7, 0x00, 0x7E,
  0x70, 0x07, 0xE7, 0x00, 0x7E, 0x38, 0x07, 0xE3, 0x80, 0x7E, 0x1C, 0x07,
  0xE1, 0xC0, 0x7E, 0x1C, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0,
  0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x03, 0x87, 0xE0, 0x38, 0x7E, 0x03,
  0x87, 0xE0, 0x1C, 0x7E, 0x01, 0xC7, 0xE0, 0x1C, 0x7E, 0x00, 0xE7, 0xE0,
  0x0E, 0x7E, 0x00, 0x77, 0xE0, 0x07, 0x7E, 0x00, 0x77, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xE0, 0x01, 0xF3, 0x80,
  0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1E, 0xE0, 0x00, 0xFB, 0x80, 0x07, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C,
  0x0F, 0x87, 0x80, 0x1E, 0x38, 0x00, 0x73, 0xC0, 0x03, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0xC0, 0x03,
  0xDE, 0x00, 0x1E, 0x78, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0xEF, 0xF0, 0x3F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x37, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xE0, 0x01, 0xF3, 0x80, 0x03, 0xCE, 0x00, 0x07, 0xB8,
  0x00, 0x1E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x3C,
  0xE0, 0x01, 0xF3, 0x80, 0x0F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x03, 0x80, 0xF0, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x0F,
  0x03, 0x80, 0x3C, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0xC3,
  0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x38, 0x00, 0x78, 0xE0, 0x00, 0xF3, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0x00, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3C, 0x00, 0xF0,
  0xE0, 0x01, 0xE7, 0x80, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xF7, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xDC,
  0x00, 0x0E, 0x78, 0x00, 0x78, 0xF8, 0x03, 0xC1, 0xFE, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3F,
  0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1C,
  0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x38,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xE0,
  0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0xC3, 0xC0,
  0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xE3, 0x80, 0x00, 0xE7, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x1F, 0x80, 0x78,
  0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xB0, 0x1D, 0xC0,
  0xEC, 0x0E, 0x70, 0x33, 0x03, 0x9C, 0x0C, 0xC0, 0xE7, 0x03, 0x30, 0x39,
  0xC0, 0xCC, 0x0E, 0x70, 0x33, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x18,
  0x38, 0xE1, 0x86, 0x0C, 0x38, 0x61, 0x87, 0x0E, 0x18, 0x61, 0xC3, 0x86,
  0x18, 0x70, 0xE1, 0x86, 0x1C, 0x38, 0x61, 0xC7, 0x0E, 0x38, 0x71, 0xC3,
  0x8C, 0x0C, 0x70, 0xE3, 0x03, 0x1C, 0x1C, 0xC0, 0xC6, 0x07, 0x30, 0x33,
  0x81, 0xCC, 0x0C, 0xE0, 0x73, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xD8, 0x06, 0xE0, 0x76, 0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x00, 0x78, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x38, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x03, 0x87, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x3C, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0x80, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x81, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xDC, 0x00, 0x39, 0xC0,
  0x03, 0x9C, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0x70, 0x0E, 0x07,
  0x01, 0xE0, 0x78, 0x1C, 0x03, 0x81, 0xC0, 0x3C, 0x38, 0x01, 0xC3, 0x80,
  0x1C, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3E, 0x07, 0xC3, 0xC0, 0x0F, 0x1C, 0x00, 0x39, 0xE0, 0x01, 0xEE, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x3F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0x07, 0x70, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0x78, 0x01, 0xB9, 0xF8, 0x7D,
  0xC7, 0xFF, 0xCE, 0x1F, 0xF8, 0x70, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x0F, 0xC0, 0xE3, 0xFF,
  0x0E, 0x7F, 0xF8, 0xEE, 0x07, 0xCE, 0xC0, 0x1E, 0xF8, 0x00, 0xEF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xEE, 0xC0, 0x3E, 0xEF, 0x9F,
  0xCE, 0x7F, 0xF8, 0xE1, 0xFF, 0x00, 0x03, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x80, 0x1E, 0x3C, 0x03, 0xE3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x3F, 0x07, 0x0F, 0xFC,
  0x71, 0xFF, 0xE7, 0x3E, 0x07, 0x77, 0x80, 0x37, 0x70, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x37, 0x3F, 0x9F,
  0x71, 0xFF, 0xE7, 0x07, 0xF8, 0x70, 0x08, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x80, 0x0E, 0x3C, 0x03, 0xE3, 0xF1,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x70, 0xFF,
  0xC7, 0x1F, 0xFE, 0x73, 0xE0, 0x77, 0x78, 0x03, 0x77, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x01,
  0xF7, 0x80, 0x17, 0x3C, 0x07, 0x71, 0xFF, 0xE7, 0x0F, 0xFC, 0x70, 0x7F,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x0F, 0xC0, 0xE3, 0xFF, 0x0E, 0x7F, 0xF8, 0xEE,
  0x07, 0xCE, 0xC0, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0x20, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x02, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x3F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07,
  0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xF0, 0x3C, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x1E,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0xE7, 0xC1, 0xE3, 0xBF, 0x9F, 0xEF, 0xFF, 0x7F,
  0xBC, 0x3F, 0x0F, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x7E, 0x03, 0x01, 0xF8,
  0x0C, 0x07, 0xE0, 0x30, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C,
  0x07, 0xE0, 0x30, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C, 0x07,
  0xE0, 0x30, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C, 0x07, 0xE0,
  0x30, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C, 0x07, 0xE0, 0x30,
  0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C, 0x07, 0xE0, 0xFC, 0x0E,
  0x3F, 0xF0, 0xE7, 0xFF, 0x8E, 0xE0, 0x7C, 0xEC, 0x01, 0xEF, 0x80, 0x1E,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x01, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x0F, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xE0, 0xFC, 0x0E, 0x3F, 0xF0, 0xE7, 0xFF,
  0x8E, 0xE0, 0x7C, 0xEC, 0x01, 0xEF, 0x80, 0x0E, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x1E, 0xEC, 0x03, 0xEE, 0xF9, 0xFC, 0xE7, 0xFF,
  0x8E, 0x1F, 0xE0, 0xE0, 0x30, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x70, 0xFF, 0xC7, 0x1F, 0xFE, 0x73, 0xE0, 0x77,
  0x78, 0x01, 0x77, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7,
  0x80, 0x1F, 0x7C, 0x03, 0x73, 0xF1, 0xF7, 0x1F, 0xFE, 0x70, 0x7F, 0x87,
  0x00, 0x80, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0xE0,
  0xFC, 0x0E, 0x3F, 0xF0, 0xE7, 0xFF, 0x8E, 0xE0, 0x7C, 0xF8, 0x01, 0xEF,
  0x80, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xF8, 0x07, 0xC7, 0x80, 0x0F, 0x38, 0x00,
  0x7B, 0xC0, 0x01, 0xDE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xDE, 0x00, 0x0E,
  0x78, 0x00, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xF0, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70,
  0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x60, 0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x3C,
  0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0E,
  0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x01,
  0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x1E, 0x01, 0xF8, 0x07, 0x80, 0x77,
  0x01, 0xE0, 0x19, 0xC0, 0x78, 0x0E, 0x70, 0x1E, 0x03, 0x9C, 0x0F, 0xC0,
  0xE7, 0x03, 0x30, 0x39, 0xC0, 0xCC, 0x0E, 0x38, 0x33, 0x03, 0x0E, 0x0C,
  0xC1, 0xC3, 0x83, 0x30, 0x70, 0xE1, 0xCE, 0x1C, 0x38, 0x61, 0x87, 0x0E,
  0x18, 0x61, 0xC1, 0x86, 0x18, 0x60, 0x71, 0x86, 0x38, 0x1C, 0x61, 0xCE,
  0x07, 0x38, 0x73, 0x81, 0xCC, 0x0C, 0xE0, 0x73, 0x03, 0x38, 0x0C, 0xC0,
  0xCC, 0x03, 0xB0, 0x33, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78,
  0x0E, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0xC3, 0xC0, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x03, 0xC3, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78,
  0x1C, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78,
  0x0E, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0,
  0x07, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xC0,
  0x01, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x80,
  0x00, 0xF7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x30, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0x80, 0x1D, 0xFF, 0x00, 0x7F, 0x1E, 0x01, 0xF8, 0x3C, 0x07,
  0xE0, 0x78, 0x1F, 0x80, 0xF0, 0xFE, 0x01, 0xFF, 0xB8, 0x03, 0xFE, 0xE0,
  0x07, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 6, 37, 30, 12, -37 },
  { 29, 14, 16, 30, 8, -37 },
  { 57, 26, 37, 30, 2, -37 },
  { 178, 22, 51, 30, 4, -44 },
  { 319, 28, 37, 30, 1, -37 },
  { 449, 25, 38, 30, 3, -37 },
  { 568, 4, 16, 30, 13, -37 },
  { 576, 14, 48, 30, 10, -42 },
  { 660, 14, 48, 30, 6, -42 },
  { 744, 26, 26, 30, 2, -31 },
  { 829, 22, 23, 30, 4, -28 },
  { 893, 9, 16, 30, 9, -8 },
  { 911, 16, 3, 30, 7, -18 },
  { 917, 8, 8, 30, 11, -7 },
  { 925, 22, 48, 30, 4, -42 },
  { 1057, 22, 38, 30, 4, -37 },
  { 1162, 22, 37, 30, 5, -37 },
  { 1264, 22, 37, 30, 4, -37 },
  { 1366, 21, 38, 30, 4, -37 },
  { 1466, 20, 36, 30, 5, -36 },
  { 1556, 20, 38, 30, 5, -37 },
  { 1651, 22, 38, 30, 4, -37 },
  { 1756, 22, 37, 30, 4, -37 },
  { 1858, 22, 38, 30, 4, -37 },
  { 1963, 22, 37, 30, 4, -37 },
  { 2065, 8, 29, 30, 11, -28 },
  { 2094, 10, 36, 30, 9, -28 },
  { 2139, 22, 25, 30, 4, -29 },
  { 2208, 20, 15, 30, 5, -24 },
  { 2246, 22, 25, 30, 4, -29 },
  { 2315, 17, 37, 30, 8, -37 },
  { 2394, 25, 46, 30, 3, -37 },
  { 2538, 24, 37, 30, 3, -37 },
  { 2649, 21, 37, 30, 5, -37 },
  { 2747, 21, 38, 30, 5, -37 },
  { 2847, 20, 37, 30, 5, -37 },
  { 2940, 20, 37, 30, 6, -37 },
  { 3033, 21, 37, 30, 5, -37 },
  { 3131, 21, 38, 30, 5, -37 },
  { 3231, 20, 37, 30, 5, -37 },
  { 3324, 18, 37, 30, 6, -37 },
  { 3408, 21, 38, 30, 3, -37 },
  { 3508, 22, 37, 30, 5, -37 },
  { 3610, 20, 37, 30, 6, -37 },
  { 3703, 22, 37, 30, 4, -37 },
  { 3805, 20, 37, 30, 5, -37 },
  { 3898, 20, 38, 30, 5, -37 },
  { 3993, 22, 37, 30, 5, -37 },
  { 4095, 21, 46, 30, 5, -37 },
  { 4216, 22, 37, 30, 5, -37 },
  { 4318, 22, 38, 30, 4, -37 },
  { 4423, 24, 37, 30, 3, -37 },
  { 4534, 20, 38, 30, 5, -37 },
  { 4629, 24, 37, 30, 3, -37 },
  { 4740, 26, 37, 30, 2, -37 },
  { 4861, 26, 37, 30, 2, -37 },
  { 4982, 26, 37, 30, 2, -37 },
  { 5103, 22, 37, 30, 4, -37 },
  { 5205, 11, 48, 30, 11, -42 },
  { 5271, 22, 48, 30, 4, -42 },
  { 5403, 11, 48, 30, 8, -42 },
  { 5469, 20, 20, 30, 5, -37 },
  { 5519, 24, 3, 30, 3, 1 },
  { 5528, 9, 7, 30, 10, -39 },
  { 5536, 21, 29, 30, 4, -28 },
  { 5613, 20, 38, 30, 5, -37 },
  { 5708, 20, 29, 30, 5, -28 },
  { 5781, 20, 38, 30, 5, -37 },
  { 5876, 20, 29, 30, 5, -28 },
  { 5949, 23, 37, 30, 3, -37 },
  { 6056, 20, 37, 30, 5, -28 },
  { 6149, 20, 37, 30, 5, -37 },
  { 6242, 22, 39, 30, 5, -39 },
  { 6350, 18, 48, 30, 5, -39 },
  { 6458, 22, 37, 30, 5, -37 },
  { 6560, 25, 37, 30, 2, -37 },
  { 6676, 22, 28, 30, 4, -28 },
  { 6753, 20, 28, 30, 5, -28 },
  { 6823, 20, 28, 30, 5, -28 },
  { 6893, 20, 37, 30, 5, -28 },
  { 6986, 20, 37, 30, 5, -28 },
  { 7079, 20, 28, 30, 6, -28 },
  { 7149, 21, 28, 30, 5, -28 },
  { 7223, 23, 35, 30, 3, -35 },
  { 7324, 20, 29, 30, 5, -28 },
  { 7397, 24, 28, 30, 3, -28 },
  { 7481, 26, 28, 30, 2, -28 },
  { 7572, 24, 28, 30, 3, -28 },
  { 7656, 24, 37, 30, 3, -28 },
  { 7767, 20, 28, 30, 5, -28 },
  { 7837, 20, 48, 30, 5, -42 },
  { 7957, 4, 48, 30, 13, -42 },
  { 7981, 20, 48, 30, 5, -42 },
  { 8101, 22, 9, 30, 4, -22 },
};

const GFXfont JetBrainsMono_ExtraLight50pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight50pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _JETBRAINSMONO_EXTRALIGHT50PT7B_H_
