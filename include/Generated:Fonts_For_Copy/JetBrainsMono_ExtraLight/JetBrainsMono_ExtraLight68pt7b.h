#ifndef _JETBRAINSMONO_EXTRALIGHT68PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight68pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0x80, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xDF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x3C,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x07, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x00,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x38, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0x8E,
  0x3F, 0x80, 0xF8, 0x38, 0x3F, 0x07, 0xC0, 0xE0, 0x7C, 0x1E, 0x03, 0x80,
  0xF8, 0xF8, 0x0E, 0x03, 0xE3, 0xE0, 0x38, 0x07, 0x8F, 0x00, 0xE0, 0x1F,
  0x3C, 0x03, 0x80, 0x7C, 0xF0, 0x0E, 0x01, 0xF3, 0xC0, 0x38, 0x00, 0x0F,
  0x80, 0xE0, 0x00, 0x3E, 0x03, 0x80, 0x00, 0xF8, 0x0E, 0x00, 0x01, 0xF0,
  0x38, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x3F, 0x8E,
  0x00, 0x00, 0x7F, 0xB8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xBF, 0xC0, 0x00, 0x0E, 0x3F, 0x80, 0x00, 0x38, 0x3F, 0x00,
  0x00, 0xE0, 0x7E, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x38, 0x07, 0xC0, 0x00, 0xE0, 0x1F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x0E,
  0x00, 0xFF, 0x80, 0x38, 0x03, 0xFE, 0x00, 0xE0, 0x0F, 0x78, 0x03, 0x80,
  0x3D, 0xE0, 0x0E, 0x01, 0xF7, 0xC0, 0x38, 0x07, 0xDF, 0x00, 0xE0, 0x1F,
  0x3E, 0x03, 0x80, 0xF8, 0xFC, 0x0E, 0x07, 0xE1, 0xFC, 0x38, 0x7F, 0x03,
  0xFF, 0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x1F, 0xFC, 0x00,
  0x00, 0x78, 0x7F, 0xFC, 0x00, 0x01, 0xE1, 0xFF, 0xFC, 0x00, 0x03, 0x83,
  0xC0, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x03,
  0xC0, 0xE0, 0x00, 0xF8, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x1F, 0x0F, 0x00,
  0x01, 0xFF, 0xFC, 0x3C, 0x00, 0x01, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0xFF,
  0xC1, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x07,
  0xFC, 0x00, 0x00, 0x78, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0xFF, 0xFC, 0x00,
  0x03, 0xC3, 0xF0, 0xFC, 0x00, 0x0F, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x78, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x03,
  0xC0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x0F,
  0x07, 0x00, 0x01, 0xFC, 0x7E, 0x1E, 0x00, 0x01, 0xFF, 0xF8, 0x78, 0x00,
  0x01, 0xFF, 0xE1, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0x78, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x17, 0xC0,
  0xF8, 0x00, 0xF9, 0xF0, 0x1F, 0x00, 0x3E, 0xF8, 0x07, 0xC0, 0x1F, 0x3E,
  0x00, 0xF8, 0x07, 0x8F, 0x80, 0x1F, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x1F, 0x1E, 0x0F, 0x80, 0x03, 0xEF,
  0x83, 0xE0, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0x03,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x03, 0xFC, 0x0F, 0x80, 0x01, 0xFF, 0x81, 0xF0,
  0x00, 0xFD, 0xE0, 0x7C, 0x00, 0x7E, 0x7C, 0x1F, 0x80, 0x3F, 0x0F, 0x83,
  0xFC, 0x7F, 0x81, 0xF0, 0x7F, 0xFF, 0xC0, 0x3C, 0x0F, 0xFF, 0xE0, 0x0F,
  0x80, 0xFF, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xC0, 0x07, 0xC0, 0x07, 0x3F, 0x00, 0xF0, 0x07, 0xEF, 0xF8, 0x0E,
  0x07, 0xFF, 0xFF, 0xE1, 0xC3, 0xFF, 0xDF, 0xFE, 0x39, 0xFF, 0xF0, 0x7F,
  0xF7, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x07, 0xF1,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xC7, 0xF0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xE0,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x03, 0x80, 0x7F, 0xE0, 0x3E,
  0x03, 0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC0, 0xFE, 0x07,
  0xFE, 0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0x70, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFB, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xF0, 0xF8, 0x00,
  0x7F, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xE0,
  0x0F, 0x80, 0x0C, 0x00, 0x7C, 0x00, 0x40, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x03,
  0xC0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0,
  0x00, 0x3C, 0x7C, 0x00, 0x07, 0x9F, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x1E,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFE, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x3F, 0xFC, 0x07, 0xC7, 0xFF, 0xE0, 0x7C, 0xFF, 0xFF,
  0x87, 0xDF, 0xCF, 0xFC, 0x7F, 0xC0, 0x1F, 0xC7, 0xF8, 0x00, 0x7E, 0x7F,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x07,
  0xC1, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x7F, 0xC0, 0x01, 0xF3, 0xFF, 0xE0, 0x03,
  0xDF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3C, 0x00,
  0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x1F, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3E,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x1F,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xEF, 0x00, 0x3F, 0xFF, 0xBE, 0x00, 0x1F, 0xFC,
  0xF8, 0x00, 0x05, 0x81, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xF1, 0xFF, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x1F, 0xF3, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x7F, 0x03,
  0x80, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x3C, 0x3E,
  0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0xF9, 0xFE, 0x00, 0x3F, 0xFE,
  0xFF, 0x00, 0x3F, 0xFF, 0xBF, 0x80, 0x1F, 0x00, 0xDF, 0xC0, 0x1F, 0x00,
  0x3F, 0xE0, 0x0F, 0x00, 0x1F, 0xF0, 0x07, 0x80, 0x07, 0xF8, 0x03, 0xC0,
  0x03, 0xFC, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x78,
  0x00, 0x7F, 0x80, 0x3C, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x1F, 0xE0, 0x0F,
  0x00, 0x0F, 0xF0, 0x07, 0x80, 0x07, 0xF8, 0x03, 0xC0, 0x03, 0xFC, 0x01,
  0xE0, 0x01, 0xFE, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x7F, 0x80,
  0x3C, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x1F, 0xE0, 0x0F, 0x00, 0x1F, 0xF0,
  0x07, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x0D, 0xFC, 0x00, 0xFF, 0x3E, 0xFE,
  0x00, 0x3F, 0xFE, 0x7F, 0x00, 0x0F, 0xFE, 0x3F, 0x80, 0x03, 0xFE, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF8, 0x3C, 0x00,
  0x00, 0x78, 0x1F, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xE0, 0x07,
  0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0x00, 0x3F, 0xF0, 0x78, 0x00, 0x1F, 0xC3, 0xC0, 0x00, 0x3F, 0x1E, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x1F, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0xF8, 0x78, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x3F, 0xC1, 0xE0,
  0x00, 0x3F, 0x0F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x0F, 0x9E, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F,
  0xCF, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x3F, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F,
  0x00, 0xFF, 0xE1, 0xE0, 0x00, 0xFE, 0x3C, 0x00, 0x07, 0xE7, 0x80, 0x00,
  0x7C, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0x78,
  0x00, 0x0F, 0xCF, 0x00, 0x03, 0xF1, 0xE0, 0x03, 0xFC, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x80,
  0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0x9F,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0xE1, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xF0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8,
  0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x03,
  0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xC0,
  0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x3F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF8, 0x3C, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x1F, 0x0F, 0x00, 0x00,
  0x7E, 0x3C, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0x7E, 0xF0, 0x00, 0x7F, 0xF7, 0x80, 0x03, 0xFF, 0xDC, 0x00, 0x1D,
  0xFE, 0xF0, 0x01, 0xEF, 0xF7, 0x80, 0x0F, 0x7F, 0x9C, 0x00, 0x73, 0xFC,
  0xF0, 0x07, 0x9F, 0xE7, 0x80, 0x3C, 0xFF, 0x1C, 0x01, 0xC7, 0xF8, 0xF0,
  0x1E, 0x3F, 0xC7, 0x80, 0xF1, 0xFE, 0x1C, 0x07, 0x0F, 0xF0, 0xF0, 0x78,
  0x7F, 0x87, 0x83, 0x83, 0xFC, 0x1C, 0x1C, 0x1F, 0xE0, 0xF1, 0xE0, 0xFF,
  0x07, 0x8E, 0x07, 0xF8, 0x1C, 0x70, 0x3F, 0xC0, 0xF7, 0x81, 0xFE, 0x07,
  0xB8, 0x0F, 0xF0, 0x1D, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x03, 0xE0,
  0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xC0, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xBC, 0x00, 0x0F, 0xF7, 0x80, 0x01, 0xFE, 0xF0, 0x00, 0x3F, 0xCF,
  0x00, 0x07, 0xF9, 0xE0, 0x00, 0xFF, 0x1E, 0x00, 0x1F, 0xE3, 0xC0, 0x03,
  0xFC, 0x78, 0x00, 0x7F, 0x87, 0x80, 0x0F, 0xF0, 0xF0, 0x01, 0xFE, 0x0F,
  0x00, 0x3F, 0xC1, 0xE0, 0x07, 0xF8, 0x3C, 0x00, 0xFF, 0x03, 0xC0, 0x1F,
  0xE0, 0x78, 0x03, 0xFC, 0x0F, 0x00, 0x7F, 0x80, 0xF0, 0x0F, 0xF0, 0x1E,
  0x01, 0xFE, 0x01, 0xE0, 0x3F, 0xC0, 0x3C, 0x07, 0xF8, 0x07, 0x80, 0xFF,
  0x00, 0x78, 0x1F, 0xE0, 0x0F, 0x03, 0xFC, 0x01, 0xE0, 0x7F, 0x80, 0x1E,
  0x0F, 0xF0, 0x03, 0xC1, 0xFE, 0x00, 0x3C, 0x3F, 0xC0, 0x07, 0x87, 0xF8,
  0x00, 0xF0, 0xFF, 0x00, 0x0F, 0x1F, 0xE0, 0x01, 0xE3, 0xFC, 0x00, 0x3E,
  0x7F, 0x80, 0x03, 0xCF, 0xF0, 0x00, 0x79, 0xFE, 0x00, 0x07, 0xBF, 0xC0,
  0x00, 0xF7, 0xF8, 0x00, 0x1E, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x1F, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xF8, 0x7E, 0x00,
  0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00,
  0xFF, 0xC3, 0xC0, 0x00, 0x3F, 0x8F, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x03,
  0xF8, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x01, 0xF8, 0x0F, 0x80, 0x07,
  0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3D,
  0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F,
  0x7C, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1E, 0xF8,
  0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3D, 0xF0, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x0F, 0xC0,
  0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x0F, 0x00, 0x1F, 0xF8, 0x78, 0x00, 0x0F, 0xE3, 0xC0, 0x00,
  0x1F, 0x9E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x3F, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3F, 0x9E,
  0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF8, 0x07,
  0x80, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x0F, 0xDE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3E, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xBC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x0F,
  0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07,
  0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x0F, 0x78, 0x00,
  0xF8, 0x00, 0xF7, 0x80, 0x0F, 0xC0, 0x0F, 0x78, 0x01, 0xDC, 0x00, 0xF7,
  0x80, 0x1D, 0xC0, 0x0F, 0x78, 0x01, 0xDC, 0x00, 0xF7, 0x80, 0x1D, 0xC0,
  0x0F, 0x78, 0x01, 0xDC, 0x01, 0xF7, 0xC0, 0x1D, 0xC0, 0x1E, 0x3C, 0x01,
  0xDC, 0x01, 0xE3, 0xC0, 0x3C, 0xE0, 0x1E, 0x3C, 0x03, 0x8E, 0x01, 0xE3,
  0xC0, 0x38, 0xE0, 0x1E, 0x3C, 0x03, 0x8E, 0x01, 0xE3, 0xC0, 0x38, 0xE0,
  0x1E, 0x3C, 0x03, 0x8E, 0x01, 0xE3, 0xE0, 0x38, 0xE0, 0x3C, 0x3E, 0x03,
  0x8F, 0x03, 0xC1, 0xE0, 0x70, 0x70, 0x3C, 0x1E, 0x07, 0x07, 0x03, 0xC1,
  0xE0, 0x70, 0x70, 0x3C, 0x1E, 0x07, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x70,
  0x3C, 0x1E, 0x07, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x70, 0x38, 0x1F, 0x0F,
  0x07, 0x87, 0x80, 0xF0, 0xE0, 0x38, 0x78, 0x0F, 0x0E, 0x03, 0x87, 0x80,
  0xF0, 0xE0, 0x38, 0x78, 0x0F, 0x0E, 0x03, 0x87, 0x80, 0xF0, 0xE0, 0x38,
  0x78, 0x0F, 0x0E, 0x03, 0x87, 0x80, 0xF0, 0xE0, 0x38, 0x70, 0x0F, 0x9C,
  0x03, 0xC7, 0x00, 0x79, 0xC0, 0x1C, 0xF0, 0x07, 0x9C, 0x01, 0xCF, 0x00,
  0x79, 0xC0, 0x1C, 0xF0, 0x07, 0x9C, 0x01, 0xCF, 0x00, 0x79, 0xC0, 0x1C,
  0xF0, 0x07, 0x9C, 0x01, 0xCF, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x07, 0xB8,
  0x01, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x7C, 0x00,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x00,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0xF8, 0x3C,
  0x00, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF3, 0xFE,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0x79, 0xF8, 0x00,
  0x7B, 0xCF, 0xF8, 0x1F, 0x9E, 0x3F, 0xFF, 0xF8, 0xF0, 0x7F, 0xFF, 0x87,
  0x81, 0xFF, 0xF0, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x01, 0xFE, 0x01, 0xE0, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0x87, 0x9F,
  0xFF, 0xF8, 0xF7, 0xC0, 0x7F, 0x9E, 0xE0, 0x03, 0xF3, 0xD8, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03,
  0xEF, 0x60, 0x00, 0xFD, 0xEF, 0x00, 0x3F, 0x3C, 0xF8, 0x3F, 0xC7, 0x9F,
  0xFF, 0xF0, 0xF0, 0xFF, 0xFC, 0x1E, 0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x03, 0xF0, 0x7F, 0xC7, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3E, 0x07, 0xFF, 0x87,
  0xC3, 0xFF, 0xFC, 0xF8, 0xFF, 0xFF, 0xDF, 0x3F, 0x80, 0x7B, 0xE7, 0xC0,
  0x03, 0xFD, 0xF0, 0x00, 0x3F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xBE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x7F,
  0xC7, 0xF8, 0x3E, 0xF8, 0xFF, 0xFF, 0x9F, 0x07, 0xFF, 0xE3, 0xE0, 0x7F,
  0xF8, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x7C,
  0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x03,
  0xF0, 0x7F, 0x83, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x3F, 0xFF, 0xCF,
  0x8F, 0xFF, 0xFD, 0xF3, 0xF8, 0x07, 0xBE, 0x7E, 0x00, 0x3F, 0xDF, 0x00,
  0x03, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF8, 0xFF,
  0xDF, 0xDF, 0x0F, 0xFF, 0xF3, 0xE0, 0xFF, 0xFC, 0x7C, 0x07, 0xFE, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x01, 0xFE, 0x01, 0xE1,
  0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0x87, 0x9F, 0xFF, 0xF8, 0xF7, 0xC0, 0x7F,
  0x1E, 0xE0, 0x03, 0xF3, 0xD8, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xE0,
  0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xC0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xC1, 0xE7, 0xFC, 0x3F, 0xE3, 0xDF,
  0xFC, 0xFF, 0xE7, 0xBF, 0xF9, 0xFF, 0xEF, 0xC0, 0xFE, 0x07, 0xDF, 0x00,
  0xF8, 0x07, 0xBE, 0x01, 0xF0, 0x0F, 0xF8, 0x03, 0xE0, 0x1F, 0xF0, 0x07,
  0x80, 0x1F, 0xE0, 0x0F, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x7F, 0x80, 0x3C,
  0x00, 0xFF, 0x00, 0x78, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xE0,
  0x07, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x0F, 0x00,
  0x3F, 0xC0, 0x1E, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0xFF, 0x00, 0x78, 0x01,
  0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xE0, 0x07, 0xF8, 0x03, 0xC0, 0x0F,
  0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x0F, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x7F,
  0x80, 0x3C, 0x00, 0xFF, 0x00, 0x78, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xFC,
  0x01, 0xE0, 0x07, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0x07, 0x80, 0x1F, 0xE0,
  0x0F, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0xFF, 0x00,
  0x78, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x1E, 0x1F,
  0xFF, 0x03, 0xC7, 0xFF, 0xF8, 0x79, 0xFF, 0xFF, 0x8F, 0x3C, 0x07, 0xF1,
  0xEE, 0x00, 0x3F, 0x3D, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x87, 0xE0, 0x07, 0xF0, 0x7F,
  0x83, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0x40, 0x00, 0x00, 0x1F, 0xE0, 0x1E, 0x1F, 0xFF, 0x03, 0xC7,
  0xFF, 0xF8, 0x79, 0xFF, 0xFF, 0x8F, 0x7C, 0x07, 0xF9, 0xEE, 0x00, 0x3F,
  0x3D, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x3E, 0xF6, 0x00, 0x0F, 0x9E, 0xF0, 0x03, 0xF3, 0xCF,
  0x83, 0xFC, 0x79, 0xFF, 0xFF, 0x0F, 0x0F, 0xFF, 0xC1, 0xE0, 0xFF, 0xE0,
  0x3C, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x7C,
  0x3F, 0xFF, 0xCF, 0x8F, 0xFF, 0xFD, 0xF3, 0xF8, 0x07, 0xBE, 0x7C, 0x00,
  0x3F, 0xDF, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x07, 0xFC,
  0x7F, 0x83, 0xEF, 0x87, 0xFF, 0xF9, 0xF0, 0x7F, 0xFE, 0x3E, 0x07, 0xFF,
  0x87, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x0F, 0x87, 0xFF,
  0xC0, 0xF9, 0xFF, 0xFE, 0x0F, 0xBF, 0xFF, 0xF0, 0xFB, 0xC0, 0x3F, 0x8F,
  0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFC, 0x01,
  0xFE, 0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1E, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x07, 0xFC,
  0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xBF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3F,
  0x80, 0x3F, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xFE, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0x3C, 0x00, 0xF8,
  0x01, 0xE7, 0x80, 0x3B, 0x80, 0x3C, 0xF0, 0x07, 0x70, 0x07, 0x9E, 0x00,
  0xEE, 0x00, 0xF3, 0xC0, 0x1D, 0xC0, 0x1C, 0x7C, 0x03, 0xB8, 0x07, 0x87,
  0x80, 0xE7, 0x00, 0xF0, 0xF0, 0x1C, 0x70, 0x1E, 0x1E, 0x03, 0x8E, 0x03,
  0xC3, 0xC0, 0x71, 0xC0, 0x78, 0x78, 0x0E, 0x38, 0x0E, 0x0F, 0x01, 0xC7,
  0x03, 0xC0, 0xF0, 0x70, 0x60, 0x78, 0x1E, 0x0E, 0x0E, 0x0F, 0x03, 0xC1,
  0xC1, 0xC1, 0xE0, 0x78, 0x38, 0x38, 0x3C, 0x0F, 0x07, 0x07, 0x07, 0x01,
  0xE1, 0xC0, 0xE0, 0xE0, 0x1E, 0x38, 0x0E, 0x3C, 0x03, 0xC7, 0x01, 0xC7,
  0x80, 0x78, 0xE0, 0x38, 0xF0, 0x0F, 0x1C, 0x07, 0x1E, 0x01, 0xE3, 0x80,
  0xE3, 0x80, 0x3C, 0xE0, 0x1C, 0x70, 0x03, 0x9C, 0x01, 0xDE, 0x00, 0x7B,
  0x80, 0x3B, 0xC0, 0x0F, 0x70, 0x07, 0x78, 0x01, 0xEE, 0x00, 0xEF, 0x00,
  0x3D, 0xC0, 0x1D, 0xC0, 0x07, 0xF0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00,
  0xF9, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0xFF, 0xF0, 0x00, 0xF9, 0xFF,
  0xF0, 0x01, 0xF7, 0xE3, 0xF0, 0x03, 0xEF, 0x03, 0xF0, 0x07, 0xFE, 0x03,
  0xF0, 0x0F, 0xF8, 0x03, 0xE0, 0x1E, 0xF0, 0x03, 0xE0, 0x3D, 0xE0, 0x03,
  0xF1, 0xFB, 0xC0, 0x03, 0xFF, 0xE7, 0x80, 0x03, 0xFF, 0x8F, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x60, 0x00,
};

const GFXglyph JetBrainsMono_ExtraLight68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 9, 50, 41, 16, -50 },
  { 58, 19, 21, 41, 11, -50 },
  { 108, 36, 50, 41, 2, -50 },
  { 333, 30, 69, 41, 5, -59 },
  { 592, 39, 50, 41, 1, -50 },
  { 836, 34, 51, 41, 4, -50 },
  { 1053, 5, 21, 41, 18, -50 },
  { 1067, 20, 65, 41, 13, -57 },
  { 1230, 19, 65, 41, 8, -57 },
  { 1385, 35, 34, 41, 3, -41 },
  { 1534, 31, 31, 41, 5, -38 },
  { 1655, 13, 21, 41, 12, -10 },
  { 1690, 21, 4, 41, 10, -24 },
  { 1701, 11, 11, 41, 15, -10 },
  { 1717, 29, 63, 41, 6, -56 },
  { 1946, 29, 51, 41, 6, -50 },
  { 2131, 29, 50, 41, 7, -50 },
  { 2313, 31, 50, 41, 5, -50 },
  { 2507, 28, 51, 41, 6, -50 },
  { 2686, 27, 50, 41, 6, -50 },
  { 2855, 28, 51, 41, 6, -50 },
  { 3034, 31, 51, 41, 5, -50 },
  { 3232, 30, 50, 41, 6, -50 },
  { 3420, 29, 51, 41, 6, -50 },
  { 3605, 31, 50, 41, 5, -50 },
  { 3799, 11, 39, 41, 15, -38 },
  { 3853, 14, 49, 41, 12, -38 },
  { 3939, 29, 35, 41, 6, -40 },
  { 4066, 29, 19, 41, 6, -32 },
  { 4135, 29, 35, 41, 6, -40 },
  { 4262, 23, 50, 41, 11, -50 },
  { 4406, 33, 62, 41, 4, -50 },
  { 4662, 33, 50, 41, 4, -50 },
  { 4869, 29, 50, 41, 7, -50 },
  { 5051, 28, 51, 41, 7, -50 },
  { 5230, 27, 50, 41, 7, -50 },
  { 5399, 27, 50, 41, 8, -50 },
  { 5568, 29, 50, 41, 7, -50 },
  { 5750, 28, 51, 41, 7, -50 },
  { 5929, 27, 50, 41, 7, -50 },
  { 6098, 25, 50, 41, 8, -50 },
  { 6255, 29, 51, 41, 4, -50 },
  { 6440, 30, 50, 41, 7, -50 },
  { 6628, 28, 50, 41, 8, -50 },
  { 6803, 29, 50, 41, 6, -50 },
  { 6985, 27, 50, 41, 7, -50 },
  { 7154, 27, 51, 41, 7, -50 },
  { 7327, 30, 50, 41, 7, -50 },
  { 7515, 29, 62, 41, 6, -50 },
  { 7740, 29, 50, 41, 7, -50 },
  { 7922, 30, 51, 41, 5, -50 },
  { 8114, 33, 50, 41, 4, -50 },
  { 8321, 27, 51, 41, 7, -50 },
  { 8494, 33, 50, 41, 4, -50 },
  { 8701, 36, 50, 41, 2, -50 },
  { 8926, 35, 50, 41, 3, -50 },
  { 9145, 35, 50, 41, 3, -50 },
  { 9364, 29, 50, 41, 6, -50 },
  { 9546, 15, 63, 41, 15, -56 },
  { 9665, 29, 63, 41, 6, -56 },
  { 9894, 16, 63, 41, 10, -56 },
  { 10020, 29, 27, 41, 6, -50 },
  { 10118, 33, 4, 41, 4, 2 },
  { 10135, 13, 9, 41, 13, -53 },
  { 10150, 29, 39, 41, 5, -38 },
  { 10292, 27, 51, 41, 7, -50 },
  { 10465, 27, 39, 41, 7, -38 },
  { 10597, 27, 51, 41, 7, -50 },
  { 10770, 27, 39, 41, 7, -38 },
  { 10902, 32, 50, 41, 4, -50 },
  { 11102, 27, 50, 41, 7, -38 },
  { 11271, 27, 50, 41, 7, -50 },
  { 11440, 31, 52, 41, 6, -52 },
  { 11642, 25, 64, 41, 6, -52 },
  { 11842, 30, 50, 41, 7, -50 },
  { 12030, 34, 50, 41, 3, -50 },
  { 12243, 31, 38, 41, 5, -38 },
  { 12391, 27, 38, 41, 7, -38 },
  { 12520, 27, 39, 41, 7, -38 },
  { 12652, 27, 50, 41, 7, -38 },
  { 12821, 27, 50, 41, 7, -38 },
  { 12990, 28, 38, 41, 8, -38 },
  { 13123, 29, 39, 41, 6, -38 },
  { 13265, 31, 48, 41, 4, -48 },
  { 13451, 27, 38, 41, 7, -37 },
  { 13580, 31, 37, 41, 5, -37 },
  { 13724, 35, 37, 41, 3, -37 },
  { 13886, 32, 37, 41, 4, -37 },
  { 14034, 31, 49, 41, 5, -37 },
  { 14224, 27, 37, 41, 7, -37 },
  { 14349, 28, 63, 41, 6, -56 },
  { 14570, 5, 63, 41, 18, -56 },
  { 14610, 28, 63, 41, 6, -56 },
  { 14831, 31, 14, 41, 5, -31 },
};

const GFXfont JetBrainsMono_ExtraLight68pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight68pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _JETBRAINSMONO_EXTRALIGHT68PT7B_H_
