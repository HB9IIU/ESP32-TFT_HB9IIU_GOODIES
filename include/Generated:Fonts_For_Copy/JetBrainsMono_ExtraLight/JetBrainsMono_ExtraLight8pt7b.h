#ifndef _JETBRAINSMONO_EXTRALIGHT8PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x52, 0x9E, 0xAF, 0x30, 0x5F, 0xE7, 0xFA, 0xCD,
  0xB8, 0x66, 0xDC, 0x62, 0x91, 0x69, 0x3C, 0xE0, 0x6A, 0xA9, 0x95, 0x56,
  0x2F, 0x25, 0x4B, 0xA0, 0x60, 0xE0, 0x80, 0x24, 0xA5, 0x24, 0xF6, 0xFB,
  0xC0, 0x59, 0x25, 0xC0, 0xF4, 0xA9, 0xC0, 0xE9, 0x1B, 0xC0, 0x2A, 0x5E,
  0x40, 0xF3, 0x93, 0xC0, 0x4B, 0x5B, 0xC0, 0xF4, 0xA4, 0x80, 0xF6, 0xFB,
  0xC0, 0xF6, 0xF4, 0x80, 0x90, 0x41, 0x80, 0x2A, 0x30, 0xE3, 0x80, 0x88,
  0xE0, 0xC4, 0xA0, 0x80, 0x79, 0xBB, 0xB9, 0x60, 0x26, 0x55, 0x79, 0xF7,
  0xDB, 0xC0, 0xF6, 0x4B, 0xC0, 0xD6, 0xDB, 0xC0, 0xF3, 0xC9, 0xC0, 0xF2,
  0x79, 0x00, 0xF6, 0x7B, 0xC0, 0xB7, 0xDB, 0x40, 0xE9, 0x25, 0xC0, 0x31,
  0x11, 0x97, 0xB7, 0x6B, 0x40, 0x92, 0x49, 0xC0, 0xB7, 0xDB, 0x40, 0xB6,
  0xFB, 0x40, 0xF6, 0xDB, 0xC0, 0xF6, 0xE9, 0x00, 0xF6, 0xDB, 0xC8, 0xF6,
  0xEB, 0x40, 0xF6, 0x3B, 0xC0, 0xF2, 0x22, 0x22, 0xB6, 0xDB, 0xC0, 0x95,
  0x55, 0x62, 0xAD, 0x7B, 0xE5, 0x28, 0x95, 0x22, 0x59, 0x95, 0x52, 0x22,
  0xE5, 0x29, 0xC0, 0xEA, 0xAB, 0x92, 0x24, 0x89, 0xD5, 0x57, 0x56, 0x80,
  0xF0, 0x80, 0xEE, 0xF0, 0x9A, 0xDB, 0xC0, 0xF2, 0x70, 0x2E, 0xDB, 0xC0,
  0xFE, 0x70, 0x6B, 0xA4, 0x80, 0xF6, 0xFE, 0x9A, 0xDB, 0x40, 0x51, 0x25,
  0xC0, 0x38, 0x92, 0x78, 0x92, 0xEB, 0x40, 0xC2, 0x22, 0x23, 0xFF, 0xF0,
  0xF6, 0xD0, 0xF6, 0xF0, 0xF6, 0xF8, 0xF6, 0xF2, 0xF2, 0x40, 0xF8, 0xF0,
  0x5D, 0x24, 0xC0, 0xB6, 0xF0, 0xB6, 0xA0, 0xBF, 0x75, 0xAB, 0x50, 0xB7,
  0x24, 0xEA, 0x70, 0x29, 0x2C, 0x91, 0xFF, 0x89, 0x26, 0x94, 0xBC,
};

const GFXglyph JetBrainsMono_ExtraLight8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 3, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 3, 5, 2, -6 },
  { 20, 2, 8, 5, 2, -7 },
  { 22, 2, 8, 5, 1, -7 },
  { 24, 4, 4, 5, 0, -5 },
  { 26, 3, 4, 5, 1, -5 },
  { 28, 2, 2, 5, 1, -1 },
  { 29, 3, 1, 5, 1, -3 },
  { 30, 1, 1, 5, 2, -1 },
  { 31, 3, 8, 5, 1, -7 },
  { 34, 3, 6, 5, 1, -6 },
  { 37, 3, 6, 5, 1, -6 },
  { 40, 3, 6, 5, 1, -6 },
  { 43, 3, 6, 5, 1, -6 },
  { 46, 3, 6, 5, 1, -6 },
  { 49, 3, 6, 5, 1, -6 },
  { 52, 3, 6, 5, 1, -6 },
  { 55, 3, 6, 5, 1, -6 },
  { 58, 3, 6, 5, 1, -6 },
  { 61, 3, 6, 5, 1, -6 },
  { 64, 1, 4, 5, 2, -4 },
  { 65, 2, 5, 5, 1, -4 },
  { 67, 3, 4, 5, 1, -5 },
  { 69, 3, 3, 5, 1, -4 },
  { 71, 3, 4, 5, 1, -5 },
  { 73, 3, 6, 5, 1, -6 },
  { 76, 4, 7, 5, 0, -6 },
  { 80, 4, 6, 5, 0, -6 },
  { 83, 3, 6, 5, 1, -6 },
  { 86, 3, 6, 5, 1, -6 },
  { 89, 3, 6, 5, 1, -6 },
  { 92, 3, 6, 5, 1, -6 },
  { 95, 3, 6, 5, 1, -6 },
  { 98, 3, 6, 5, 1, -6 },
  { 101, 3, 6, 5, 1, -6 },
  { 104, 3, 6, 5, 1, -6 },
  { 107, 4, 6, 5, 0, -6 },
  { 110, 3, 6, 5, 1, -6 },
  { 113, 3, 6, 5, 1, -6 },
  { 116, 3, 6, 5, 1, -6 },
  { 119, 3, 6, 5, 1, -6 },
  { 122, 3, 6, 5, 1, -6 },
  { 125, 3, 6, 5, 1, -6 },
  { 128, 3, 7, 5, 1, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 3, 6, 5, 1, -6 },
  { 137, 4, 6, 5, 0, -6 },
  { 140, 3, 6, 5, 1, -6 },
  { 143, 4, 6, 5, 0, -6 },
  { 146, 5, 6, 5, 0, -6 },
  { 150, 4, 6, 5, 0, -6 },
  { 153, 4, 6, 5, 0, -6 },
  { 156, 3, 6, 5, 1, -6 },
  { 159, 2, 8, 5, 2, -7 },
  { 161, 3, 8, 5, 1, -7 },
  { 164, 2, 8, 5, 1, -7 },
  { 166, 3, 3, 5, 1, -6 },
  { 168, 4, 1, 5, 0, 0 },
  { 169, 1, 1, 5, 2, -6 },
  { 170, 3, 4, 5, 1, -4 },
  { 172, 3, 6, 5, 1, -6 },
  { 175, 3, 4, 5, 1, -4 },
  { 177, 3, 6, 5, 1, -6 },
  { 180, 3, 4, 5, 1, -4 },
  { 182, 3, 6, 5, 1, -6 },
  { 185, 3, 5, 5, 1, -4 },
  { 187, 3, 6, 5, 1, -6 },
  { 190, 3, 6, 5, 1, -6 },
  { 193, 3, 7, 5, 1, -6 },
  { 196, 3, 6, 5, 1, -6 },
  { 199, 4, 6, 5, 0, -6 },
  { 202, 3, 4, 5, 1, -4 },
  { 204, 3, 4, 5, 1, -4 },
  { 206, 3, 4, 5, 1, -4 },
  { 208, 3, 5, 5, 1, -4 },
  { 210, 3, 5, 5, 1, -4 },
  { 212, 3, 4, 5, 1, -4 },
  { 214, 3, 4, 5, 1, -4 },
  { 216, 3, 6, 5, 1, -6 },
  { 219, 3, 4, 5, 1, -4 },
  { 221, 3, 4, 5, 1, -4 },
  { 223, 4, 4, 5, 0, -4 },
  { 225, 3, 4, 5, 1, -4 },
  { 227, 3, 5, 5, 1, -4 },
  { 229, 3, 4, 5, 1, -4 },
  { 231, 3, 8, 5, 1, -7 },
  { 234, 1, 8, 5, 2, -7 },
  { 235, 3, 8, 5, 1, -7 },
  { 238, 3, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_ExtraLight8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_EXTRALIGHT8PT7B_H_
