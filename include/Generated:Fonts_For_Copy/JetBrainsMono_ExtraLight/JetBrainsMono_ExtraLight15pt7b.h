#ifndef _JETBRAINSMONO_EXTRALIGHT15PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight15pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x2C, 0xDE, 0xF7, 0x18, 0x80, 0x22, 0x48, 0x97, 0xF4,
  0x48, 0x91, 0x7F, 0x48, 0x92, 0x20, 0x10, 0x20, 0xF2, 0xA9, 0x2A, 0x1C,
  0x1C, 0x14, 0x26, 0x4E, 0xB7, 0xC2, 0x04, 0x00, 0x71, 0xC8, 0xA4, 0x92,
  0x87, 0x40, 0x40, 0x5C, 0x29, 0x24, 0xA2, 0x71, 0xC0, 0x78, 0x89, 0x02,
  0x06, 0x1C, 0x24, 0xC6, 0x85, 0x19, 0xC8, 0xF8, 0x13, 0x4C, 0x88, 0x88,
  0x88, 0x88, 0x42, 0x10, 0x8C, 0x23, 0x11, 0x11, 0x11, 0x11, 0x24, 0x80,
  0x10, 0x22, 0x4B, 0xE1, 0x05, 0x11, 0x22, 0x10, 0x20, 0x47, 0xF1, 0x02,
  0x04, 0x00, 0x7A, 0xF8, 0xFC, 0x06, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08,
  0x20, 0x40, 0x82, 0x04, 0x10, 0x00, 0x7C, 0x8A, 0x0C, 0x18, 0x32, 0x60,
  0xC1, 0x82, 0x89, 0xF0, 0x10, 0xE2, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x23, 0xF8, 0x7C, 0x8A, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x83, 0xF8,
  0x7C, 0x10, 0x84, 0x38, 0x10, 0x41, 0x85, 0x17, 0x80, 0x0C, 0x21, 0x04,
  0x21, 0x14, 0x61, 0xFC, 0x10, 0x40, 0x7C, 0x81, 0x02, 0x07, 0xC8, 0x80,
  0x81, 0x82, 0x89, 0xF0, 0x08, 0x20, 0x81, 0x05, 0x8C, 0xA0, 0xC1, 0x82,
  0x89, 0xF0, 0xFF, 0x06, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x20, 0x80,
  0x3C, 0x89, 0x0A, 0x26, 0xC7, 0x11, 0x41, 0x82, 0x89, 0xF0, 0x38, 0x8A,
  0x0C, 0x18, 0x28, 0x8F, 0x04, 0x08, 0x20, 0x80, 0xE8, 0x00, 0x3F, 0xE8,
  0x00, 0x16, 0x90, 0x02, 0x18, 0xC6, 0x0C, 0x06, 0x03, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x80, 0xC0, 0x60, 0x30, 0x63, 0x18, 0x40, 0xF0, 0x42, 0x10,
  0xB9, 0x08, 0x03, 0x18, 0x3C, 0x86, 0x0C, 0x19, 0xF2, 0x64, 0xC9, 0x93,
  0x3E, 0x04, 0x04, 0x07, 0x00, 0x10, 0x50, 0xA1, 0x42, 0x88, 0x91, 0x3E,
  0x45, 0x06, 0x08, 0xF2, 0x28, 0x61, 0x8B, 0xC8, 0xA1, 0x86, 0x2F, 0x80,
  0x3C, 0x8A, 0x0C, 0x08, 0x10, 0x20, 0x40, 0x82, 0x88, 0xF0, 0xF2, 0x28,
  0xA1, 0x86, 0x18, 0x61, 0x8A, 0x2F, 0x00, 0xFE, 0x08, 0x20, 0x83, 0xE8,
  0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x08,
  0x00, 0x3C, 0x8A, 0x0C, 0x08, 0x10, 0x27, 0xC1, 0x82, 0x88, 0xF0, 0x8C,
  0x63, 0x18, 0xFE, 0x31, 0x8C, 0x62, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x3E, 0x1C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x86, 0x17, 0x80, 0x86, 0x28,
  0xA4, 0x93, 0xC9, 0x26, 0x8A, 0x28, 0x40, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0F, 0xC0, 0xC7, 0x8E, 0xAD, 0x5A, 0xB2, 0x60, 0xC1, 0x83,
  0x06, 0x08, 0x8C, 0x73, 0x9A, 0xD6, 0xB3, 0x9C, 0x62, 0x38, 0x8A, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x82, 0x89, 0xF0, 0xFA, 0x38, 0x61, 0x87, 0xE8,
  0x20, 0x82, 0x08, 0x00, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82,
  0x89, 0xF0, 0x40, 0x40, 0xC0, 0xFA, 0x38, 0x61, 0x8F, 0xE9, 0x24, 0x8A,
  0x28, 0x40, 0x3C, 0x8A, 0x0A, 0x06, 0x07, 0x01, 0x01, 0x83, 0x8D, 0xF0,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x5E, 0x83, 0x05, 0x12, 0x24, 0x48, 0x8A, 0x14,
  0x28, 0x50, 0x40, 0x93, 0x26, 0xAD, 0x5A, 0xB5, 0x6A, 0xD5, 0xAA, 0x99,
  0x10, 0x82, 0x89, 0x11, 0x42, 0x82, 0x0A, 0x14, 0x44, 0x8A, 0x08, 0x83,
  0x05, 0x12, 0x22, 0x85, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFC, 0x08, 0x10,
  0x41, 0x82, 0x08, 0x10, 0x40, 0x83, 0xF8, 0xF8, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x8F, 0xC0, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0x40, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x50,
  0xA2, 0x24, 0x58, 0xC0, 0xFE, 0x8C, 0x7D, 0x10, 0x4F, 0xC6, 0x18, 0x5F,
  0x82, 0x08, 0x3E, 0x8A, 0x18, 0x61, 0x86, 0x2F, 0x80, 0x7C, 0x8A, 0x0C,
  0x08, 0x10, 0x51, 0x3E, 0x04, 0x10, 0x5F, 0x46, 0x18, 0x61, 0x85, 0x17,
  0xC0, 0x7C, 0x8A, 0x0F, 0xF8, 0x10, 0x11, 0xBE, 0x1E, 0x20, 0x81, 0x0F,
  0xE4, 0x08, 0x10, 0x20, 0x40, 0x80, 0x7D, 0x18, 0x61, 0x85, 0x16, 0xC5,
  0x04, 0x13, 0x80, 0x84, 0x21, 0xF8, 0xC6, 0x31, 0x8C, 0x62, 0x10, 0x30,
  0x00, 0x07, 0x02, 0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x08, 0x30, 0x00,
  0x78, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x2F, 0x00, 0x82, 0x08, 0x23,
  0x8A, 0x4E, 0x24, 0x92, 0x28, 0x40, 0xE0, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x78, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xFC,
  0x63, 0x18, 0xC6, 0x31, 0x7C, 0x8A, 0x0C, 0x18, 0x30, 0x51, 0x3E, 0xFA,
  0x28, 0x61, 0x86, 0x18, 0xBE, 0x82, 0x08, 0x00, 0x7D, 0x18, 0x61, 0x86,
  0x14, 0x5F, 0x04, 0x10, 0x40, 0xFA, 0x18, 0x60, 0x82, 0x08, 0x20, 0x7C,
  0x85, 0x03, 0xC0, 0x40, 0x70, 0xBE, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x78, 0x8C, 0x63, 0x18, 0xC6, 0x2E, 0x82, 0x89, 0x12,
  0x22, 0x85, 0x0A, 0x08, 0x93, 0x26, 0xAD, 0x5A, 0xAD, 0x91, 0x22, 0xC6,
  0x88, 0xA0, 0x82, 0x85, 0x11, 0x41, 0x82, 0x89, 0x11, 0x22, 0x85, 0x04,
  0x08, 0x10, 0x40, 0x80, 0x7C, 0x08, 0x20, 0x82, 0x04, 0x10, 0x7F, 0x0E,
  0x20, 0x40, 0x80, 0x82, 0x3C, 0x08, 0x08, 0x20, 0x40, 0x80, 0x80, 0xC0,
  0xFF, 0xFC, 0xE0, 0x20, 0x40, 0x82, 0x02, 0x07, 0x88, 0x20, 0x20, 0x40,
  0x82, 0x18, 0x00, 0x63, 0x26, 0x38,
};

const GFXglyph JetBrainsMono_ExtraLight15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 11, 9, 4, -11 },
  { 4, 5, 5, 9, 2, -11 },
  { 8, 7, 11, 9, 1, -11 },
  { 18, 7, 15, 9, 1, -13 },
  { 32, 9, 11, 9, 0, -11 },
  { 45, 7, 11, 9, 1, -11 },
  { 55, 1, 5, 9, 4, -11 },
  { 56, 4, 15, 9, 3, -13 },
  { 64, 4, 15, 9, 2, -13 },
  { 72, 7, 8, 9, 1, -9 },
  { 79, 7, 7, 9, 1, -8 },
  { 86, 2, 4, 9, 3, -2 },
  { 87, 5, 1, 9, 2, -5 },
  { 88, 3, 2, 9, 3, -2 },
  { 89, 7, 14, 9, 1, -12 },
  { 102, 7, 11, 9, 1, -11 },
  { 112, 7, 11, 9, 1, -11 },
  { 122, 7, 11, 9, 1, -11 },
  { 132, 6, 11, 9, 1, -11 },
  { 141, 6, 11, 9, 1, -11 },
  { 150, 7, 11, 9, 1, -11 },
  { 160, 7, 11, 9, 1, -11 },
  { 170, 7, 11, 9, 1, -11 },
  { 180, 7, 11, 9, 1, -11 },
  { 190, 7, 11, 9, 1, -11 },
  { 200, 3, 8, 9, 3, -8 },
  { 203, 3, 10, 9, 3, -8 },
  { 207, 7, 8, 9, 1, -9 },
  { 214, 7, 4, 9, 1, -7 },
  { 218, 7, 8, 9, 1, -9 },
  { 225, 5, 11, 9, 2, -11 },
  { 232, 7, 14, 9, 1, -11 },
  { 245, 7, 11, 9, 1, -11 },
  { 255, 6, 11, 9, 2, -11 },
  { 264, 7, 11, 9, 1, -11 },
  { 274, 6, 11, 9, 2, -11 },
  { 283, 6, 11, 9, 2, -11 },
  { 292, 6, 11, 9, 2, -11 },
  { 301, 7, 11, 9, 1, -11 },
  { 311, 5, 11, 9, 2, -11 },
  { 318, 5, 11, 9, 2, -11 },
  { 325, 6, 11, 9, 1, -11 },
  { 334, 6, 11, 9, 2, -11 },
  { 343, 6, 11, 9, 2, -11 },
  { 352, 7, 11, 9, 1, -11 },
  { 362, 5, 11, 9, 2, -11 },
  { 369, 7, 11, 9, 1, -11 },
  { 379, 6, 11, 9, 2, -11 },
  { 388, 7, 14, 9, 1, -11 },
  { 401, 6, 11, 9, 2, -11 },
  { 410, 7, 11, 9, 1, -11 },
  { 420, 7, 11, 9, 1, -11 },
  { 430, 5, 11, 9, 2, -11 },
  { 437, 7, 11, 9, 1, -11 },
  { 447, 7, 11, 9, 1, -11 },
  { 457, 7, 11, 9, 1, -11 },
  { 467, 7, 11, 9, 1, -11 },
  { 477, 7, 11, 9, 1, -11 },
  { 487, 4, 14, 9, 3, -12 },
  { 494, 7, 14, 9, 1, -12 },
  { 507, 4, 14, 9, 2, -12 },
  { 514, 7, 6, 9, 1, -11 },
  { 520, 7, 1, 9, 1, 0 },
  { 521, 3, 2, 9, 3, -12 },
  { 522, 6, 8, 9, 1, -8 },
  { 528, 6, 11, 9, 2, -11 },
  { 537, 7, 8, 9, 1, -8 },
  { 544, 6, 11, 9, 1, -11 },
  { 553, 7, 8, 9, 1, -8 },
  { 560, 7, 11, 9, 1, -11 },
  { 570, 6, 11, 9, 1, -8 },
  { 579, 5, 11, 9, 2, -11 },
  { 586, 7, 12, 9, 1, -12 },
  { 597, 6, 15, 9, 1, -12 },
  { 609, 6, 11, 9, 2, -11 },
  { 618, 7, 11, 9, 1, -11 },
  { 628, 7, 8, 9, 1, -8 },
  { 635, 5, 8, 9, 2, -8 },
  { 640, 7, 8, 9, 1, -8 },
  { 647, 6, 11, 9, 2, -8 },
  { 656, 6, 11, 9, 1, -8 },
  { 665, 6, 8, 9, 2, -8 },
  { 671, 7, 8, 9, 1, -8 },
  { 678, 7, 11, 9, 1, -11 },
  { 688, 5, 8, 9, 2, -8 },
  { 693, 7, 8, 9, 1, -8 },
  { 700, 7, 8, 9, 1, -8 },
  { 707, 7, 8, 9, 1, -8 },
  { 714, 7, 11, 9, 1, -8 },
  { 724, 7, 8, 9, 1, -8 },
  { 731, 7, 14, 9, 1, -12 },
  { 744, 1, 14, 9, 4, -12 },
  { 746, 7, 14, 9, 1, -12 },
  { 759, 7, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_ExtraLight15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_EXTRALIGHT15PT7B_H_
