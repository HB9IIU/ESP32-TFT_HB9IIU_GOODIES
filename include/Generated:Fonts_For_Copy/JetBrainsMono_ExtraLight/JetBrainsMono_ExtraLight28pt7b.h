#ifndef _JETBRAINSMONO_EXTRALIGHT28PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xB6, 0x49, 0x24, 0x80, 0x1F, 0xF0, 0xE3, 0xE3, 0x63,
  0x63, 0x63, 0x63, 0x43, 0x43, 0x06, 0x08, 0x0C, 0x30, 0x10, 0x60, 0x20,
  0xC0, 0xC1, 0x0F, 0xFF, 0xDF, 0xFF, 0x84, 0x18, 0x08, 0x30, 0x30, 0x40,
  0x60, 0x80, 0xC1, 0x01, 0x06, 0x1F, 0xFF, 0x8C, 0x18, 0x18, 0x20, 0x30,
  0x40, 0x41, 0x80, 0x83, 0x03, 0x06, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x0E, 0x01, 0xFC, 0x19, 0x31, 0x88, 0xCC, 0x46, 0x62, 0x33, 0x10, 0x18,
  0x80, 0x64, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x4E, 0x02, 0x30, 0x11,
  0x80, 0x87, 0x84, 0x3C, 0x23, 0x31, 0x18, 0xEB, 0x83, 0xF8, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x08, 0x00, 0x3E, 0x03, 0x63, 0x06, 0x43,
  0x04, 0x41, 0x0C, 0x41, 0x18, 0x43, 0x10, 0x63, 0x20, 0x7E, 0x60, 0x1C,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x3E, 0x02, 0x67, 0x06, 0x43, 0x0C,
  0x43, 0x08, 0x43, 0x18, 0x43, 0x30, 0x43, 0x20, 0x67, 0xC0, 0x3E, 0x0F,
  0x00, 0xFE, 0x03, 0x0C, 0x18, 0x18, 0x60, 0x61, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0xC0, 0x31, 0x86, 0xC6, 0x1B, 0x0C, 0xCC,
  0x1B, 0x30, 0x38, 0xC0, 0xC3, 0x03, 0x8C, 0x1B, 0x3D, 0xC6, 0x7E, 0x1C,
  0xFF, 0xFF, 0x01, 0x07, 0x1E, 0x38, 0x70, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1F, 0x07, 0x80, 0xE0, 0x70, 0x1C, 0x0C, 0x06, 0x06,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x06, 0x06, 0x0C, 0x18, 0xF0, 0xE0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x04, 0x10, 0x5F, 0x27, 0xCF, 0x7E, 0x03, 0xE0, 0x02,
  0x80, 0x0D, 0x80, 0x33, 0x80, 0xE3, 0x01, 0x83, 0x06, 0x07, 0x00, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x39, 0x8C, 0xE6,
  0x31, 0x18, 0xFF, 0xFF, 0xC0, 0x77, 0xBE, 0xE0, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x07,
  0x03, 0xFC, 0x30, 0xE6, 0x03, 0x60, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x23, 0xC7, 0x3C, 0x73, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40,
  0x36, 0x03, 0x70, 0x73, 0xDE, 0x1F, 0xC0, 0x1E, 0x03, 0xE0, 0x76, 0x0C,
  0x60, 0x86, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0x07, 0x01, 0xFE, 0x1C, 0x18, 0xC0, 0x6C, 0x03, 0x60, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00, 0xFF, 0xF7, 0xFF, 0x80,
  0x7F, 0xF0, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xF8,
  0x0F, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03,
  0x60, 0x36, 0x06, 0x39, 0xE1, 0xF8, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x6C, 0x0D, 0x81, 0xE0, 0x38, 0x07,
  0x00, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xF8,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0xFC, 0xF1, 0xDC, 0x1F,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0xC0, 0x78, 0x19, 0xCF,
  0x1F, 0xC0, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x3F, 0xC3, 0x87, 0x18, 0x0D, 0xC0, 0x6C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x02, 0x60, 0x33, 0x03, 0x8F, 0x78, 0x3F, 0x80, 0xFF,
  0xFE, 0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0x07, 0x01, 0xFC, 0x30,
  0x66, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x03, 0x30, 0xE1, 0xDC, 0x07,
  0x01, 0xDC, 0x30, 0x66, 0x03, 0x40, 0x3C, 0x01, 0xC0, 0x16, 0x03, 0x60,
  0x33, 0xDE, 0x1F, 0xC0, 0x07, 0x00, 0xFE, 0x0C, 0x18, 0xC0, 0x6C, 0x03,
  0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x33, 0x01, 0x9C, 0x1C, 0x7F, 0xC1,
  0xF6, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x00, 0x67, 0xBE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7B,
  0xEE, 0x39, 0xE7, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0xE3,
  0x1C, 0x61, 0x84, 0x30, 0x00, 0x10, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x07,
  0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x08, 0x00, 0xFE, 0x01, 0xE0,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0x8F, 0xC3, 0xE0, 0xC0,
  0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x80, 0xE0, 0x07, 0x80,
  0xFF, 0x1C, 0x0C, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x30, 0x11, 0x83,
  0xEC, 0x30, 0xE1, 0x83, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x18, 0x30, 0xC1,
  0x86, 0x1C, 0x30, 0xE0, 0xFB, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x3F, 0x80, 0x7C, 0x00, 0x07, 0x00, 0x38, 0x03, 0x40, 0x1B, 0x00,
  0xD8, 0x04, 0xC0, 0x62, 0x03, 0x18, 0x18, 0xC0, 0x86, 0x0C, 0x18, 0x60,
  0xC3, 0x06, 0x3F, 0xF1, 0x80, 0xCC, 0x06, 0x40, 0x36, 0x00, 0xB0, 0x07,
  0x80, 0x30, 0xFF, 0x8C, 0x1C, 0xC0, 0xEC, 0x06, 0xC0, 0x6C, 0x06, 0xC0,
  0x6C, 0x0C, 0xC3, 0xCF, 0xF0, 0xC1, 0xCC, 0x06, 0xC0, 0x6C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xF0, 0x0E, 0x07, 0xF1, 0x83,
  0x60, 0x3C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xBD, 0xE3,
  0xF8, 0xFF, 0x18, 0x7B, 0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x3B, 0xFE, 0x7F, 0x00, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xFF, 0xDF, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE,
  0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x0E, 0x07, 0xF1, 0x83, 0x60, 0x3C, 0x07, 0x80, 0xF0,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x63, 0xFC, 0x7F, 0x80, 0x70, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x83, 0xBD, 0xE3, 0xF8, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30,
  0xFF, 0xE1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x83, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6E, 0x06, 0x7B, 0xC3, 0xF8, 0xC0, 0x3C,
  0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x30, 0xC3, 0x0F,
  0xE0, 0xC3, 0x0C, 0x30, 0xC1, 0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0xEC,
  0x06, 0xC0, 0x7C, 0x03, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0x07, 0xF0, 0x5D, 0x0D, 0xD8, 0xDC, 0x89, 0xC9, 0x9C, 0xD9, 0xC5, 0x1C,
  0x71, 0xC7, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3D, 0x07, 0xB0,
  0xF6, 0x1E, 0x43, 0xCC, 0x79, 0x8F, 0x19, 0xE3, 0x3C, 0x27, 0x86, 0xF0,
  0xDE, 0x0B, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x70, 0x0E, 0x07, 0xF1, 0x83,
  0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0x3D, 0xE3,
  0xF8, 0xFF, 0xCC, 0x0E, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x6C, 0x3E, 0xFF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0E, 0x07, 0xF1, 0x83, 0x60,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0x3D, 0xE3, 0xF8,
  0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0xFF, 0x8C, 0x1E, 0xC0, 0x6C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xC0, 0xEF, 0xFC, 0xFF, 0x8C,
  0x30, 0xC3, 0x0C, 0x18, 0xC1, 0x8C, 0x0C, 0xC0, 0xCC, 0x06, 0xC0, 0x6C,
  0x03, 0x07, 0x00, 0xFE, 0x0C, 0x18, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0xC0, 0x1E, 0x01, 0x98, 0x0C, 0x7B, 0xC1, 0xFC, 0x00,
  0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x19, 0xEF, 0x1F,
  0xC0, 0xC0, 0x1E, 0x00, 0xF0, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x18, 0x81,
  0x86, 0x0C, 0x30, 0x61, 0x82, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x40,
  0x36, 0x01, 0xB0, 0x0D, 0x80, 0x68, 0x01, 0xC0, 0x0E, 0x00, 0xC3, 0x87,
  0x85, 0x0F, 0x0A, 0x1E, 0x14, 0x24, 0x28, 0x48, 0x51, 0x91, 0xA3, 0x33,
  0x66, 0x64, 0xCC, 0xC8, 0x99, 0x91, 0x33, 0x22, 0x42, 0x44, 0x84, 0x89,
  0x0B, 0x16, 0x1E, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xE1, 0xC1, 0x80,
  0x60, 0x0C, 0xC0, 0x63, 0x03, 0x06, 0x0C, 0x08, 0x60, 0x31, 0x80, 0x6C,
  0x01, 0xB0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xB0, 0x06, 0xC0, 0x31,
  0x81, 0x86, 0x06, 0x0C, 0x30, 0x30, 0xC0, 0x66, 0x00, 0xF8, 0x03, 0xE0,
  0x0E, 0xC0, 0x18, 0xC0, 0x61, 0x80, 0xC1, 0x83, 0x03, 0x06, 0x03, 0x18,
  0x06, 0x30, 0x06, 0xC0, 0x0D, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x7F, 0xF0, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFC, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0xFE, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xFC, 0x0E, 0x01, 0x40, 0x6C,
  0x0D, 0x83, 0x18, 0x63, 0x18, 0x23, 0x06, 0xC0, 0xD8, 0x0C, 0xFF, 0xF8,
  0xE0, 0xC3, 0x07, 0x07, 0x01, 0xFC, 0x30, 0x66, 0x03, 0x60, 0x30, 0x03,
  0x00, 0x31, 0xFF, 0x7F, 0xF6, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07,
  0x70, 0xF3, 0xFB, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x61, 0xBF, 0x38,
  0x36, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x1F, 0xC7, 0x6F, 0xC0, 0x0E, 0x07, 0xF1, 0x83, 0x60,
  0x3C, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x3C,
  0x07, 0xC1, 0xDE, 0xF1, 0xFC, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xC6,
  0xFE, 0xD8, 0x7E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1D, 0xCF, 0x9F, 0xB0, 0x0E, 0x07, 0xF1,
  0x83, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0x00,
  0x60, 0x0C, 0x07, 0x81, 0xDC, 0x71, 0xFC, 0x03, 0xF8, 0x30, 0x01, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x0C, 0x0F, 0xED, 0x87, 0xE0, 0x7C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x0E, 0xFE, 0xC7,
  0x98, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x9F, 0xE3, 0xF8, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x61, 0xBF, 0x38, 0x36, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x30, 0x04, 0x00, 0xE0, 0x0F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x01, 0x00,
  0xF0, 0x3C, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x3F, 0xCF, 0xC0, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x06, 0xC0, 0x6C, 0x0C, 0xC1, 0x8C, 0x38, 0xC3,
  0x0F, 0xE0, 0xFE, 0x0C, 0x30, 0xC3, 0x8C, 0x18, 0xC0, 0xCC, 0x0E, 0xC0,
  0x6C, 0x03, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xC0,
  0x7F, 0x18, 0x67, 0xF7, 0xB1, 0xC7, 0x84, 0x3C, 0x21, 0xE1, 0x0F, 0x08,
  0x78, 0x43, 0xC2, 0x1E, 0x10, 0xF0, 0x87, 0x84, 0x3C, 0x21, 0xE1, 0x0F,
  0x08, 0x78, 0x43, 0x0E, 0x1B, 0xF3, 0x83, 0x60, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x0E, 0x07, 0xF1, 0x83, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC1, 0x9E, 0xF1, 0xFC, 0x06,
  0x1B, 0xF3, 0x83, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC1, 0xBC, 0x76, 0xFC, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0x0C, 0x0F, 0xED, 0x87, 0xE0, 0x7C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC1, 0xDC,
  0xF9, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x06, 0x0D, 0xFC,
  0xF0, 0xEE, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x1E, 0x0F, 0xFB,
  0x83, 0xE0, 0x3C, 0x01, 0x80, 0x38, 0x03, 0xF8, 0x1F, 0xC0, 0x1C, 0x01,
  0x80, 0x38, 0x07, 0x80, 0xDC, 0x79, 0xFC, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x0F, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x07, 0xF0,
  0x3F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x0C, 0xF7, 0x8F, 0xE0, 0xC0, 0x1A,
  0x01, 0x98, 0x0C, 0xC0, 0x62, 0x06, 0x18, 0x30, 0xC1, 0x82, 0x18, 0x18,
  0xC0, 0xC6, 0x02, 0x60, 0x1B, 0x00, 0xD0, 0x03, 0x80, 0x1C, 0x00, 0xC3,
  0x06, 0x87, 0x09, 0x0A, 0x33, 0x14, 0x66, 0x28, 0xCC, 0xD1, 0x99, 0x32,
  0x12, 0x24, 0x24, 0x48, 0x48, 0xB0, 0xD1, 0x61, 0xE2, 0xC3, 0x87, 0x03,
  0x0E, 0x06, 0x0C, 0x00, 0xE0, 0x3B, 0x83, 0x0C, 0x18, 0x31, 0x80, 0xD8,
  0x06, 0xC0, 0x1C, 0x00, 0xE0, 0x0D, 0x00, 0x6C, 0x06, 0x30, 0x61, 0xC3,
  0x06, 0x30, 0x1B, 0x00, 0xE0, 0xC0, 0x1B, 0x01, 0x98, 0x0C, 0xC0, 0xC3,
  0x06, 0x18, 0x30, 0x63, 0x03, 0x18, 0x18, 0xC0, 0x6C, 0x03, 0x60, 0x0A,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x00, 0xFF, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0x70, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x40, 0x18, 0x03, 0x0F, 0xC1, 0xF8, 0x01, 0x80, 0x30, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0xE0, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0x7E,
  0x0F, 0xC3, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0xF8, 0x1E, 0x00, 0x10, 0x1B, 0xE0, 0xF1, 0x87, 0x86,
  0x3C, 0x1F, 0x60, 0x70,
};

const GFXglyph JetBrainsMono_ExtraLight28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 3, 20, 17, 7, -20 },
  { 9, 8, 8, 17, 4, -20 },
  { 17, 15, 20, 17, 1, -20 },
  { 55, 13, 28, 17, 2, -24 },
  { 101, 16, 21, 17, 0, -21 },
  { 143, 14, 21, 17, 2, -21 },
  { 180, 2, 8, 17, 7, -20 },
  { 182, 8, 27, 17, 6, -24 },
  { 209, 8, 27, 17, 3, -24 },
  { 236, 15, 14, 17, 1, -17 },
  { 263, 13, 13, 17, 2, -16 },
  { 285, 5, 8, 17, 5, -4 },
  { 290, 9, 2, 17, 4, -10 },
  { 293, 5, 4, 17, 6, -4 },
  { 296, 12, 26, 17, 2, -23 },
  { 335, 12, 21, 17, 2, -21 },
  { 367, 12, 20, 17, 3, -20 },
  { 397, 13, 21, 17, 2, -21 },
  { 432, 12, 20, 17, 2, -20 },
  { 462, 11, 20, 17, 3, -20 },
  { 490, 11, 20, 17, 3, -20 },
  { 518, 13, 20, 17, 2, -20 },
  { 551, 13, 20, 17, 2, -20 },
  { 584, 12, 21, 17, 2, -21 },
  { 616, 13, 21, 17, 2, -21 },
  { 651, 5, 16, 17, 6, -16 },
  { 661, 6, 20, 17, 5, -16 },
  { 676, 12, 14, 17, 2, -16 },
  { 697, 11, 8, 17, 3, -13 },
  { 708, 12, 14, 17, 2, -16 },
  { 729, 10, 20, 17, 4, -20 },
  { 754, 13, 26, 17, 2, -21 },
  { 797, 13, 20, 17, 2, -20 },
  { 830, 12, 20, 17, 3, -20 },
  { 860, 11, 21, 17, 3, -21 },
  { 889, 11, 20, 17, 3, -20 },
  { 917, 11, 20, 17, 3, -20 },
  { 945, 12, 20, 17, 3, -20 },
  { 975, 11, 21, 17, 3, -21 },
  { 1004, 11, 20, 17, 3, -20 },
  { 1032, 11, 20, 17, 3, -20 },
  { 1060, 12, 20, 17, 2, -20 },
  { 1090, 12, 20, 17, 3, -20 },
  { 1120, 12, 20, 17, 3, -20 },
  { 1150, 12, 20, 17, 2, -20 },
  { 1180, 11, 20, 17, 3, -20 },
  { 1208, 11, 21, 17, 3, -21 },
  { 1237, 12, 20, 17, 3, -20 },
  { 1267, 11, 26, 17, 3, -21 },
  { 1303, 12, 20, 17, 3, -20 },
  { 1333, 13, 21, 17, 2, -21 },
  { 1368, 13, 20, 17, 2, -20 },
  { 1401, 11, 20, 17, 3, -20 },
  { 1429, 13, 20, 17, 2, -20 },
  { 1462, 15, 20, 17, 1, -20 },
  { 1500, 14, 20, 17, 1, -20 },
  { 1535, 15, 20, 17, 1, -20 },
  { 1573, 12, 20, 17, 2, -20 },
  { 1603, 7, 26, 17, 6, -23 },
  { 1626, 12, 26, 17, 2, -23 },
  { 1665, 7, 26, 17, 4, -23 },
  { 1688, 11, 10, 17, 3, -20 },
  { 1702, 13, 1, 17, 2, 1 },
  { 1704, 6, 4, 17, 5, -22 },
  { 1707, 12, 16, 17, 2, -16 },
  { 1731, 11, 20, 17, 3, -20 },
  { 1759, 11, 16, 17, 3, -16 },
  { 1781, 11, 20, 17, 3, -20 },
  { 1809, 11, 16, 17, 3, -16 },
  { 1831, 13, 20, 17, 2, -20 },
  { 1864, 11, 21, 17, 3, -16 },
  { 1893, 11, 20, 17, 3, -20 },
  { 1921, 12, 22, 17, 3, -22 },
  { 1954, 10, 27, 17, 3, -22 },
  { 1988, 12, 20, 17, 3, -20 },
  { 2018, 14, 20, 17, 1, -20 },
  { 2053, 13, 16, 17, 2, -16 },
  { 2079, 11, 16, 17, 3, -16 },
  { 2101, 11, 16, 17, 3, -16 },
  { 2123, 11, 21, 17, 3, -16 },
  { 2152, 11, 21, 17, 3, -16 },
  { 2181, 12, 16, 17, 3, -16 },
  { 2205, 11, 16, 17, 3, -16 },
  { 2227, 12, 20, 17, 2, -20 },
  { 2257, 11, 15, 17, 3, -15 },
  { 2278, 13, 15, 17, 2, -15 },
  { 2303, 15, 15, 17, 1, -15 },
  { 2332, 13, 15, 17, 2, -15 },
  { 2357, 13, 20, 17, 2, -15 },
  { 2390, 11, 15, 17, 3, -15 },
  { 2411, 11, 26, 17, 3, -23 },
  { 2447, 2, 26, 17, 7, -23 },
  { 2454, 11, 26, 17, 3, -23 },
  { 2490, 13, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_ExtraLight28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_EXTRALIGHT28PT7B_H_
