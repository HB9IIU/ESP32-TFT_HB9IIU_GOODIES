#ifndef _JETBRAINSMONO_EXTRALIGHT10PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight10pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0x8C, 0xFC, 0x28, 0xA5, 0xD2, 0xF9, 0x45, 0x00, 0x26, 0xBB,
  0xA6, 0x3B, 0xF2, 0xEE, 0xAF, 0x0A, 0x35, 0x59, 0xC0, 0xF4, 0x21, 0x9B,
  0x4B, 0xE0, 0xE0, 0x72, 0x49, 0x24, 0x60, 0xC4, 0x92, 0x49, 0xC0, 0x22,
  0x97, 0x8C, 0x48, 0x44, 0xF4, 0x40, 0x6A, 0xF0, 0xC0, 0x11, 0x22, 0x44,
  0x48, 0x80, 0xF9, 0x9F, 0x99, 0xF0, 0x6A, 0x22, 0x22, 0xF0, 0xF9, 0x11,
  0x24, 0xF0, 0xF2, 0x61, 0x19, 0xE0, 0x32, 0x49, 0x97, 0x10, 0xF8, 0xE9,
  0x19, 0xF0, 0x24, 0xE9, 0x99, 0xF0, 0xF9, 0x12, 0x24, 0x40, 0xF9, 0x96,
  0x99, 0xF0, 0xF9, 0x9D, 0x22, 0x40, 0xB0, 0x30, 0xB0, 0x6A, 0x16, 0x84,
  0x30, 0xF0, 0xF0, 0x86, 0x12, 0xC0, 0xE4, 0xE8, 0x20, 0xF4, 0x6F, 0x9C,
  0xE6, 0xD0, 0x60, 0x66, 0x69, 0xF9, 0x90, 0xF9, 0x9F, 0x99, 0xF0, 0xF9,
  0x88, 0x89, 0xF0, 0xF9, 0x99, 0x99, 0xE0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8,
  0x8F, 0x88, 0x80, 0xF9, 0x8B, 0x99, 0xF0, 0x99, 0x9F, 0x99, 0x90, 0xF2,
  0x22, 0x22, 0xF0, 0x71, 0x11, 0x19, 0xE0, 0x99, 0xAE, 0xA9, 0x90, 0x88,
  0x88, 0x88, 0xF0, 0x9B, 0xFD, 0x99, 0x90, 0x9D, 0xDB, 0xB9, 0x90, 0xF9,
  0x99, 0x99, 0xF0, 0xF9, 0x9F, 0x88, 0x80, 0xF9, 0x99, 0x99, 0xF2, 0x10,
  0xF9, 0x9E, 0xA9, 0x90, 0xF9, 0x86, 0x19, 0xF0, 0xF2, 0x22, 0x22, 0x20,
  0x99, 0x99, 0x99, 0x70, 0x99, 0x99, 0x66, 0x60, 0x96, 0xDB, 0x5E, 0x59,
  0x24, 0x80, 0x49, 0x23, 0x0C, 0x31, 0x2C, 0xC0, 0xCD, 0x23, 0x0C, 0x20,
  0x82, 0x00, 0xF1, 0x24, 0x48, 0xF0, 0xEA, 0xAA, 0xC0, 0x88, 0x44, 0x22,
  0x21, 0x10, 0xD5, 0x55, 0xC0, 0x66, 0x99, 0xF0, 0x90, 0x69, 0x1F, 0x9F,
  0x8E, 0x99, 0x99, 0xF0, 0x69, 0x88, 0x9F, 0x17, 0x99, 0x99, 0xF0, 0x69,
  0x9E, 0x8F, 0x74, 0xF4, 0x44, 0x40, 0x79, 0x99, 0x97, 0x16, 0x8E, 0x99,
  0x99, 0x90, 0x20, 0xE2, 0x22, 0x2F, 0x30, 0xE2, 0x22, 0x22, 0x2C, 0x89,
  0x9A, 0xE9, 0x90, 0xE1, 0x08, 0x42, 0x10, 0xE0, 0xFD, 0xDD, 0xDD, 0xE9,
  0x99, 0x99, 0x69, 0x99, 0x9F, 0xE9, 0x99, 0x9F, 0x88, 0x79, 0x99, 0x9F,
  0x11, 0xE9, 0x98, 0x88, 0x69, 0x87, 0x1F, 0x4F, 0x44, 0x44, 0x70, 0x99,
  0x99, 0x96, 0x99, 0x96, 0x66, 0x96, 0x57, 0x9E, 0x49, 0x20, 0x99, 0x66,
  0x69, 0x99, 0x96, 0x62, 0x44, 0xF1, 0x24, 0x8F, 0x32, 0x22, 0xC2, 0x22,
  0x30, 0xFF, 0x80, 0xC4, 0x44, 0x34, 0x44, 0xC0, 0xF0,
};

const GFXglyph JetBrainsMono_ExtraLight10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 2, 3, 6, 2, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 4, 10, 6, 1, -9 },
  { 15, 6, 7, 6, 0, -7 },
  { 21, 5, 7, 6, 1, -7 },
  { 26, 1, 3, 6, 2, -7 },
  { 27, 3, 9, 6, 2, -8 },
  { 31, 3, 9, 6, 1, -8 },
  { 35, 6, 5, 6, 0, -6 },
  { 39, 4, 5, 6, 1, -6 },
  { 42, 2, 4, 6, 2, -2 },
  { 43, 4, 1, 6, 1, -4 },
  { 44, 2, 1, 6, 2, -1 },
  { 45, 4, 9, 6, 1, -8 },
  { 50, 4, 7, 6, 1, -7 },
  { 54, 4, 7, 6, 1, -7 },
  { 58, 4, 7, 6, 1, -7 },
  { 62, 4, 7, 6, 1, -7 },
  { 66, 4, 7, 6, 1, -7 },
  { 70, 4, 7, 6, 1, -7 },
  { 74, 4, 7, 6, 1, -7 },
  { 78, 4, 7, 6, 1, -7 },
  { 82, 4, 7, 6, 1, -7 },
  { 86, 4, 7, 6, 1, -7 },
  { 90, 2, 6, 6, 2, -6 },
  { 92, 2, 8, 6, 2, -6 },
  { 94, 4, 5, 6, 1, -6 },
  { 97, 4, 3, 6, 1, -5 },
  { 99, 4, 5, 6, 1, -6 },
  { 102, 3, 7, 6, 2, -7 },
  { 105, 5, 9, 6, 1, -7 },
  { 111, 4, 7, 6, 1, -7 },
  { 115, 4, 7, 6, 1, -7 },
  { 119, 4, 7, 6, 1, -7 },
  { 123, 4, 7, 6, 1, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 4, 7, 6, 1, -7 },
  { 139, 4, 7, 6, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 4, 7, 6, 1, -7 },
  { 155, 4, 7, 6, 1, -7 },
  { 159, 4, 7, 6, 1, -7 },
  { 163, 4, 7, 6, 1, -7 },
  { 167, 4, 7, 6, 1, -7 },
  { 171, 4, 7, 6, 1, -7 },
  { 175, 4, 9, 6, 1, -7 },
  { 180, 4, 7, 6, 1, -7 },
  { 184, 4, 7, 6, 1, -7 },
  { 188, 4, 7, 6, 1, -7 },
  { 192, 4, 7, 6, 1, -7 },
  { 196, 4, 7, 6, 1, -7 },
  { 200, 6, 7, 6, 0, -7 },
  { 206, 6, 7, 6, 0, -7 },
  { 212, 6, 7, 6, 0, -7 },
  { 218, 4, 7, 6, 1, -7 },
  { 222, 2, 9, 6, 2, -8 },
  { 225, 4, 9, 6, 1, -8 },
  { 230, 2, 9, 6, 2, -8 },
  { 233, 4, 4, 6, 1, -7 },
  { 235, 4, 1, 6, 1, 0 },
  { 236, 2, 2, 6, 2, -8 },
  { 237, 4, 6, 6, 1, -6 },
  { 240, 4, 7, 6, 1, -7 },
  { 244, 4, 6, 6, 1, -6 },
  { 247, 4, 7, 6, 1, -7 },
  { 251, 4, 6, 6, 1, -6 },
  { 254, 4, 7, 6, 1, -7 },
  { 258, 4, 8, 6, 1, -6 },
  { 262, 4, 7, 6, 1, -7 },
  { 266, 4, 8, 6, 1, -8 },
  { 270, 4, 10, 6, 1, -8 },
  { 275, 4, 7, 6, 1, -7 },
  { 279, 5, 7, 6, 0, -7 },
  { 284, 4, 6, 6, 1, -6 },
  { 287, 4, 6, 6, 1, -6 },
  { 290, 4, 6, 6, 1, -6 },
  { 293, 4, 8, 6, 1, -6 },
  { 297, 4, 8, 6, 1, -6 },
  { 301, 4, 6, 6, 1, -6 },
  { 304, 4, 6, 6, 1, -6 },
  { 307, 4, 7, 6, 1, -7 },
  { 311, 4, 6, 6, 1, -6 },
  { 314, 4, 6, 6, 1, -6 },
  { 317, 6, 6, 6, 0, -6 },
  { 322, 4, 6, 6, 1, -6 },
  { 325, 4, 8, 6, 1, -6 },
  { 329, 4, 6, 6, 1, -6 },
  { 332, 4, 9, 6, 1, -8 },
  { 337, 1, 9, 6, 3, -8 },
  { 339, 4, 9, 6, 1, -8 },
  { 344, 4, 1, 6, 1, -4 },
};

const GFXfont JetBrainsMono_ExtraLight10pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight10pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _JETBRAINSMONO_EXTRALIGHT10PT7B_H_
