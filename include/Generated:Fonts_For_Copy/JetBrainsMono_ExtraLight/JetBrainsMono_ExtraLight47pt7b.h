#ifndef _JETBRAINSMONO_EXTRALIGHT47PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT47PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight47pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3,
  0x8E, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFD, 0xE0, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x18, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x07, 0x00, 0xE0,
  0x03, 0x80, 0x70, 0x01, 0xC0, 0x30, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x06, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0,
  0x38, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x70, 0x0E, 0x03, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x0E, 0x01, 0x80, 0x06, 0x00, 0xC0, 0x03,
  0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x18, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83,
  0xE6, 0x7C, 0x3C, 0x61, 0xE7, 0x86, 0x0E, 0x70, 0x60, 0xF7, 0x06, 0x07,
  0x70, 0x60, 0x77, 0x06, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x78, 0x60,
  0x03, 0xC6, 0x00, 0x3E, 0x60, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0x06, 0xFC, 0x00, 0x63, 0xE0, 0x06, 0x1E, 0x00,
  0x60, 0xF0, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x07, 0xE0, 0x60, 0x7E,
  0x06, 0x07, 0xE0, 0x60, 0x7F, 0x06, 0x07, 0x70, 0x60, 0xF7, 0xC6, 0x1E,
  0x3F, 0x6F, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x73, 0xFE, 0x00, 0x39, 0xC1,
  0xC0, 0x0C, 0x60, 0x70, 0x07, 0x38, 0x0C, 0x03, 0x8E, 0x03, 0x80, 0xC3,
  0x80, 0xE0, 0x70, 0xE0, 0x38, 0x38, 0x38, 0x0E, 0x0C, 0x0E, 0x03, 0x87,
  0x03, 0x80, 0xC3, 0x80, 0x70, 0x71, 0xC0, 0x1E, 0x3C, 0x60, 0x03, 0xFE,
  0x38, 0x00, 0x7F, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x60, 0x40, 0x00, 0x38, 0xFF, 0x00, 0x1C, 0x7F,
  0xE0, 0x06, 0x3C, 0x38, 0x03, 0x8E, 0x07, 0x01, 0xC3, 0x01, 0xC0, 0xE0,
  0xC0, 0x70, 0x30, 0x30, 0x1C, 0x1C, 0x0C, 0x07, 0x0E, 0x03, 0x01, 0xC3,
  0x00, 0xC0, 0x71, 0xC0, 0x30, 0x1C, 0xE0, 0x0E, 0x07, 0x30, 0x03, 0xC7,
  0x9C, 0x00, 0x7F, 0xCE, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x38,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFB, 0xC0, 0x01, 0xC3,
  0x80, 0x3F, 0x83, 0x80, 0xEE, 0x07, 0x83, 0xDC, 0x07, 0x87, 0x38, 0x07,
  0x1E, 0x70, 0x0F, 0x38, 0xE0, 0x0F, 0xE1, 0xC0, 0x0F, 0xC3, 0x80, 0x0F,
  0x07, 0x00, 0x1E, 0x0E, 0x00, 0x3E, 0x1C, 0x00, 0xFC, 0x3C, 0x03, 0xDC,
  0x38, 0x0F, 0x3C, 0x7E, 0x7C, 0x3C, 0x7F, 0xF0, 0x38, 0x7F, 0xC0, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x66, 0x00, 0x1C, 0x01, 0xF0, 0x1F,
  0xC0, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0x00, 0x04, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x40, 0x1C, 0x01, 0xF0, 0x1C, 0x0F,
  0xFE, 0x18, 0x7F, 0xFF, 0x99, 0xFF, 0x1F, 0xFB, 0xF8, 0x03, 0xFF, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x76, 0x00, 0x00, 0xE7, 0x00,
  0x01, 0xE3, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x06, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x87,
  0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x7E, 0x7F,
  0xFF, 0x7F, 0x7E, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x1F,
  0xFF, 0x83, 0xF0, 0x7C, 0x3C, 0x03, 0xE7, 0x80, 0x1E, 0x70, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x06, 0x07, 0xE0, 0xF0,
  0x7E, 0x0F, 0x87, 0xE0, 0xF8, 0x7E, 0x0F, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78, 0x01, 0xE3,
  0xC0, 0x3C, 0x1F, 0x9F, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xF7, 0x00, 0x7C, 0x70, 0x0F, 0x87,
  0x00, 0xF0, 0x70, 0x0C, 0x07, 0x00, 0x80, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x0F, 0x87, 0x80, 0x1E,
  0x38, 0x00, 0x73, 0xC0, 0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x1E, 0xE0, 0x03, 0x9E, 0x00, 0xF1, 0xF8, 0xFC, 0x1F,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x38, 0x70, 0x07, 0x1E, 0x00, 0xE7, 0x80, 0x1C, 0xE0,
  0x03, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x01, 0x00, 0x71, 0xFF, 0x07, 0x7F, 0xF8,
  0x77, 0x0F, 0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xF9, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x3E, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x7E, 0x03, 0xC3, 0xC0,
  0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00,
  0x1D, 0xC0, 0x00, 0xE7, 0x00, 0x0F, 0x3C, 0x00, 0xF0, 0xF0, 0x0F, 0x03,
  0xE1, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x3B,
  0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C,
  0x3C, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0F, 0x70, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x80, 0x0E, 0x38, 0x01, 0xE1, 0xC0,
  0x3C, 0x1E, 0x07, 0x80, 0x79, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xFE, 0x00, 0xF0, 0xF8, 0x3C, 0x03, 0xC3, 0x80, 0x1E, 0x70, 0x00, 0xE7,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0xC0, 0x1E, 0x3F, 0x8F,
  0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0xE0, 0x7C, 0x0F, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x73, 0xC0, 0x03,
  0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDE, 0x00, 0x1E,
  0x70, 0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x81, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xBC, 0x00, 0x61, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x3E, 0x7E, 0x7F, 0xFF, 0x7E, 0x7E, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7E,
  0x7F, 0xFF, 0x7E, 0x7E, 0x3F, 0x1F, 0x9F, 0xEF, 0xF3, 0xF9, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07,
  0x03, 0x83, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x83, 0xC0, 0x07, 0x87, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0xFC, 0x03, 0xFD, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3C, 0x0F, 0xE0, 0x70, 0x1F, 0xC0, 0xE0, 0x1F, 0x83, 0x80,
  0x3F, 0x07, 0x00, 0x7E, 0x0E, 0x00, 0xFC, 0x1C, 0x01, 0xF8, 0x38, 0x03,
  0xF0, 0x70, 0x07, 0xE0, 0xE0, 0x0F, 0xC1, 0xC0, 0x1F, 0x83, 0xC0, 0x3F,
  0x03, 0x80, 0x7E, 0x07, 0x01, 0xFC, 0x0F, 0x07, 0xF8, 0x0F, 0xFB, 0xF0,
  0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xEC, 0x00,
  0x03, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xC6, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x1C, 0x0E,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x1E, 0x70, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x8E, 0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE,
  0x00, 0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x0F, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xE0, 0x01,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x3C, 0xE0,
  0x07, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0x80, 0x3D, 0xE0, 0x03, 0xB8,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0x9C, 0x00, 0xF3, 0xC0,
  0x3E, 0x3F, 0x1F, 0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x07, 0xCE, 0x00, 0x79, 0xC0, 0x07, 0xB8,
  0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0x38, 0x07, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0x07, 0xC7, 0x80, 0x3D, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0x9C, 0x00, 0xF3, 0xC0, 0x3E, 0x3F, 0x1F, 0x83, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E,
  0xF0, 0x00, 0xE7, 0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xF9, 0xF8, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x38, 0x00, 0x79, 0xC0,
  0x03, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE0,
  0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x07, 0x81, 0xC0, 0x38, 0x0E, 0x03,
  0xC0, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0F,
  0x03, 0x80, 0x38, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x38,
  0x01, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x70, 0x00, 0xF3, 0x80, 0x07,
  0x9C, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xD8,
  0x01, 0xBF, 0xC0, 0x1B, 0xFC, 0x03, 0xBE, 0xC0, 0x33, 0xEE, 0x03, 0x7E,
  0x60, 0x77, 0xE6, 0x06, 0x7E, 0x70, 0xE7, 0xE3, 0x0E, 0x7E, 0x30, 0xC7,
  0xE3, 0x9C, 0x7E, 0x19, 0xC7, 0xE1, 0xD8, 0x7E, 0x1D, 0x87, 0xE0, 0xF8,
  0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7E, 0xE0, 0x1F, 0xB8,
  0x07, 0xE6, 0x01, 0xF9, 0xC0, 0x7E, 0x70, 0x1F, 0x8E, 0x07, 0xE3, 0x81,
  0xF8, 0xE0, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE0, 0xC1, 0xF8, 0x38, 0x7E,
  0x0E, 0x1F, 0x81, 0xC7, 0xE0, 0x71, 0xF8, 0x1C, 0x7E, 0x03, 0x9F, 0x80,
  0xE7, 0xE0, 0x19, 0xF8, 0x07, 0x7E, 0x01, 0xDF, 0x80, 0x3B, 0xE0, 0x0E,
  0xF8, 0x01, 0xBE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xF0,
  0x03, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x1E, 0x07, 0xC7, 0x80, 0x79,
  0xE0, 0x07, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x03, 0xBC,
  0x00, 0xF3, 0xC0, 0x3C, 0x3F, 0x3F, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCE, 0x00, 0x3E, 0xE0, 0x01,
  0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xEE, 0x00, 0x3E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x3C,
  0x01, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x1F, 0x9F, 0x80,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8E, 0x00, 0x3C, 0xE0,
  0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x1E,
  0xE0, 0x01, 0xEE, 0x00, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xE0, 0x1C, 0x0E, 0x01,
  0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0xE0,
  0x03, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xEE,
  0x00, 0x0F, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C,
  0x3C, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xF7, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0xF7, 0xC0, 0x1E, 0x3F, 0x8F,
  0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0xF7,
  0x80, 0x78, 0xFC, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x77, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xE0,
  0x00, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xF0, 0x01,
  0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0xE0, 0x07, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x70,
  0x00, 0xE1, 0xC0, 0x03, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x03, 0xF0, 0x1E,
  0x01, 0xB8, 0x0F, 0x01, 0xDC, 0x07, 0xC0, 0xEE, 0x03, 0x60, 0x77, 0x01,
  0xB0, 0x3B, 0x80, 0xD8, 0x1C, 0xC0, 0xEC, 0x0E, 0x70, 0x66, 0x07, 0x38,
  0x33, 0x03, 0x1C, 0x19, 0x81, 0x8E, 0x0C, 0xE1, 0xC7, 0x06, 0x30, 0xE3,
  0x83, 0x18, 0x71, 0xC3, 0x8C, 0x38, 0xE1, 0x86, 0x1C, 0x30, 0xC3, 0x0E,
  0x1C, 0x61, 0x86, 0x0E, 0x30, 0xC3, 0x07, 0x18, 0x71, 0x83, 0x8C, 0x19,
  0xC1, 0xCE, 0x0C, 0xE0, 0xE6, 0x06, 0x70, 0x73, 0x03, 0x38, 0x19, 0x81,
  0x9C, 0x0E, 0xC0, 0xCC, 0x07, 0x60, 0x66, 0x03, 0xB0, 0x3B, 0x01, 0xD8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x00, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C,
  0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xC0,
  0x01, 0xC3, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xE3, 0x80,
  0x01, 0xC3, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x81, 0xC0,
  0x03, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xE3, 0x80, 0x00, 0xE7, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1D, 0x80, 0x03, 0x9C, 0x00,
  0x39, 0xC0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x70,
  0x0E, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x1C, 0x38, 0x01,
  0xC7, 0x80, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0x7E, 0x1E, 0x01, 0xE3, 0x80,
  0x1E, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xDE, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFB, 0xE0, 0x77, 0x3F, 0xFE,
  0xE1, 0xFF, 0x1C, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE3, 0xFC,
  0x1C, 0xFF, 0xE3, 0xBC, 0xFE, 0x7C, 0x03, 0xCF, 0x00, 0x3D, 0xE0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xEF, 0x00, 0x1D,
  0xE0, 0x07, 0xBE, 0x01, 0xE7, 0x78, 0xFC, 0xE7, 0xFF, 0x1C, 0x7F, 0x80,
  0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFE, 0x3C, 0x03, 0xC7, 0x00, 0x3D,
  0xC0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1D, 0xE0, 0x07, 0x9E, 0x01, 0xE1, 0xF9, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x0F, 0xF1, 0xC7, 0xFE,
  0x73, 0xF3, 0xDD, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xF7, 0x80, 0x7C,
  0xF8, 0x77, 0x3F, 0xFD, 0xC3, 0xFC, 0x70, 0x07, 0xF8, 0x03, 0xFF, 0xC0,
  0xFC, 0xFC, 0x3C, 0x03, 0xC7, 0x00, 0x3D, 0xC0, 0x03, 0xB8, 0x00, 0x77,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x1D, 0xE0, 0x03, 0x9E,
  0x00, 0xE1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF1, 0xC7, 0xFE, 0x73,
  0xF3, 0xDD, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x07, 0xCF, 0xFF, 0x71, 0xFF, 0x9C, 0x3F,
  0xC7, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0x80,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE3, 0xFC, 0x39, 0xFF, 0x8E, 0xF3,
  0xF3, 0xE0, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x3C,
  0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xE0, 0x1C,
  0x0E, 0x03, 0xC0, 0xE0, 0x78, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xE0,
  0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xE0, 0x03, 0xCE,
  0x00, 0x1E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE7, 0xC3, 0xE3, 0xBF, 0x9F, 0xCE, 0x8F, 0x47, 0xBC, 0x1E, 0x0E,
  0xF0, 0x38, 0x1F, 0x80, 0xE0, 0x7E, 0x03, 0x01, 0xF8, 0x0C, 0x07, 0xE0,
  0x30, 0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C, 0x07, 0xE0, 0x30,
  0x1F, 0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C, 0x07, 0xE0, 0x30, 0x1F,
  0x80, 0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C, 0x07, 0xE0, 0x30, 0x1F, 0x80,
  0xC0, 0x7E, 0x03, 0x01, 0xF8, 0x0C, 0x07, 0xE0, 0x30, 0x1F, 0x80, 0xC0,
  0x70, 0xE3, 0xFC, 0x39, 0xFF, 0x8E, 0xF3, 0xF3, 0xE0, 0x1E, 0xF0, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70,
  0x07, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3C, 0x03, 0xC7, 0x00, 0x3D,
  0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xEE,
  0x00, 0x1D, 0xE0, 0x07, 0x9E, 0x01, 0xE1, 0xF9, 0xF8, 0x1F, 0xFE, 0x01,
  0xFF, 0x80, 0xE3, 0xFC, 0x1C, 0xFF, 0xE3, 0xBC, 0xFE, 0x7C, 0x03, 0xCF,
  0x00, 0x3D, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x07, 0xBE, 0x01, 0xE7, 0x78, 0xFC, 0xE7,
  0xFF, 0x1C, 0x7F, 0x83, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xF1, 0xC7, 0xFE, 0x73, 0xF3, 0xDD, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0xF7, 0x80, 0x7C, 0xF8, 0x77, 0x1F, 0xFD, 0xC3, 0xFC, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0xE3, 0xFC, 0x1C, 0xFF, 0xC3, 0xBC, 0xFC, 0x7C,
  0x03, 0xCF, 0x00, 0x3D, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC3, 0xC0, 0x1E, 0x78, 0x00, 0xE7, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00,
  0x0F, 0x78, 0x00, 0xE3, 0xF0, 0x7E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x1F, 0xF8, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xDC, 0x00, 0xF7, 0x80, 0x78, 0xFC, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9E, 0x00, 0x0E,
  0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x07, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x78, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0x01,
  0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x03,
  0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x1C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0x60, 0x3C,
  0x07, 0x70, 0x3C, 0x06, 0x70, 0x36, 0x06, 0x70, 0x66, 0x0E, 0x70, 0x66,
  0x0E, 0x70, 0x66, 0x0E, 0x30, 0x66, 0x0E, 0x38, 0x67, 0x0C, 0x38, 0x63,
  0x0C, 0x38, 0xC3, 0x1C, 0x38, 0xC3, 0x1C, 0x38, 0xC3, 0x1C, 0x18, 0xC3,
  0x1C, 0x1C, 0xC3, 0x98, 0x1D, 0xC1, 0x98, 0x1D, 0x81, 0xB8, 0x1D, 0x81,
  0xB8, 0x1D, 0x81, 0xB8, 0x0D, 0x81, 0xB8, 0x0D, 0x81, 0xF0, 0x0D, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0xE0, 0x01,
  0xE3, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x0E, 0x01, 0xE0, 0x3C, 0x0F, 0x00,
  0x70, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7B, 0x80, 0x01, 0xCF, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x38, 0x01,
  0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x78, 0x03, 0x83, 0xC0, 0x0F, 0x0E, 0x00,
  0x1C, 0x78, 0x00, 0x3B, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1D, 0xC0, 0x00,
  0xF7, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xC1,
  0xC0, 0x0F, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xF0,
  0x1C, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x38, 0x78,
  0x00, 0xF1, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3B, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xC3, 0xC0, 0x7E, 0x0F, 0x03, 0xE0, 0x3C, 0x3B, 0x00, 0xFF, 0xD8, 0x03,
  0xFC, 0xC0, 0x07, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraLight47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 6, 34, 28, 11, -34 },
  { 27, 13, 14, 28, 8, -34 },
  { 50, 25, 34, 28, 2, -34 },
  { 157, 20, 48, 28, 4, -41 },
  { 277, 26, 35, 28, 1, -35 },
  { 391, 23, 35, 28, 3, -35 },
  { 492, 4, 14, 28, 12, -34 },
  { 499, 14, 45, 28, 9, -39 },
  { 578, 14, 45, 28, 5, -39 },
  { 657, 24, 24, 28, 2, -29 },
  { 729, 22, 22, 28, 3, -27 },
  { 790, 9, 15, 28, 8, -7 },
  { 807, 15, 3, 28, 7, -17 },
  { 813, 8, 7, 28, 10, -7 },
  { 820, 20, 44, 28, 4, -39 },
  { 930, 20, 35, 28, 4, -35 },
  { 1018, 20, 34, 28, 5, -34 },
  { 1103, 21, 35, 28, 4, -35 },
  { 1195, 19, 34, 28, 4, -34 },
  { 1276, 19, 34, 28, 4, -34 },
  { 1357, 20, 34, 28, 4, -34 },
  { 1442, 21, 34, 28, 4, -34 },
  { 1532, 21, 34, 28, 4, -34 },
  { 1622, 20, 35, 28, 4, -35 },
  { 1710, 21, 35, 28, 4, -35 },
  { 1802, 8, 26, 28, 10, -26 },
  { 1828, 9, 34, 28, 9, -26 },
  { 1867, 20, 25, 28, 4, -28 },
  { 1930, 20, 13, 28, 4, -22 },
  { 1963, 20, 25, 28, 4, -28 },
  { 2026, 16, 34, 28, 7, -34 },
  { 2094, 23, 43, 28, 3, -35 },
  { 2218, 22, 34, 28, 3, -34 },
  { 2312, 20, 34, 28, 5, -34 },
  { 2397, 19, 35, 28, 5, -35 },
  { 2481, 19, 34, 28, 5, -34 },
  { 2562, 19, 34, 28, 5, -34 },
  { 2643, 20, 34, 28, 5, -34 },
  { 2728, 19, 35, 28, 5, -35 },
  { 2812, 18, 34, 28, 5, -34 },
  { 2889, 18, 34, 28, 5, -34 },
  { 2966, 20, 34, 28, 3, -34 },
  { 3051, 21, 34, 28, 5, -34 },
  { 3141, 19, 34, 28, 6, -34 },
  { 3222, 20, 34, 28, 4, -34 },
  { 3307, 18, 34, 28, 5, -34 },
  { 3384, 19, 35, 28, 5, -35 },
  { 3468, 20, 34, 28, 5, -34 },
  { 3553, 20, 43, 28, 4, -35 },
  { 3661, 20, 34, 28, 5, -34 },
  { 3746, 20, 35, 28, 4, -35 },
  { 3834, 22, 34, 28, 3, -34 },
  { 3928, 18, 34, 28, 5, -34 },
  { 4005, 22, 34, 28, 3, -34 },
  { 4099, 25, 34, 28, 2, -34 },
  { 4206, 24, 34, 28, 2, -34 },
  { 4308, 24, 34, 28, 2, -34 },
  { 4410, 20, 34, 28, 4, -34 },
  { 4495, 11, 44, 28, 10, -39 },
  { 4556, 20, 44, 28, 4, -39 },
  { 4666, 11, 44, 28, 7, -39 },
  { 4727, 20, 18, 28, 4, -34 },
  { 4772, 22, 3, 28, 3, 1 },
  { 4781, 9, 7, 28, 9, -37 },
  { 4789, 19, 26, 28, 4, -26 },
  { 4851, 19, 34, 28, 5, -34 },
  { 4932, 19, 26, 28, 5, -26 },
  { 4994, 18, 34, 28, 5, -34 },
  { 5071, 19, 26, 28, 5, -26 },
  { 5133, 22, 34, 28, 3, -34 },
  { 5227, 18, 34, 28, 5, -26 },
  { 5304, 18, 34, 28, 5, -34 },
  { 5381, 22, 36, 28, 4, -36 },
  { 5480, 17, 44, 28, 4, -36 },
  { 5574, 20, 34, 28, 5, -34 },
  { 5659, 24, 34, 28, 2, -34 },
  { 5761, 22, 26, 28, 3, -26 },
  { 5833, 18, 26, 28, 5, -26 },
  { 5892, 19, 26, 28, 5, -26 },
  { 5954, 19, 34, 28, 5, -26 },
  { 6035, 18, 34, 28, 5, -26 },
  { 6112, 19, 26, 28, 6, -26 },
  { 6174, 20, 26, 28, 4, -26 },
  { 6239, 21, 33, 28, 3, -33 },
  { 6326, 18, 26, 28, 5, -26 },
  { 6385, 22, 26, 28, 3, -26 },
  { 6457, 24, 26, 28, 2, -26 },
  { 6535, 22, 26, 28, 3, -26 },
  { 6607, 22, 34, 28, 3, -26 },
  { 6701, 19, 26, 28, 5, -26 },
  { 6763, 20, 44, 28, 4, -39 },
  { 6873, 3, 44, 28, 13, -39 },
  { 6890, 20, 44, 28, 4, -39 },
  { 7000, 21, 9, 28, 4, -21 },
};

const GFXfont JetBrainsMono_ExtraLight47pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight47pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight47pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _JETBRAINSMONO_EXTRALIGHT47PT7B_H_
