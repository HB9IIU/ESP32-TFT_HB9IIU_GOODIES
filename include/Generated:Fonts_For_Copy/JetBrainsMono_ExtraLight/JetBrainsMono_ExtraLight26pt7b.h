#ifndef _JETBRAINSMONO_EXTRALIGHT26PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight26pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x64, 0x44, 0x00, 0x6F, 0xE0, 0xC7,
  0x8F, 0x1E, 0x3C, 0x38, 0x70, 0xE1, 0x04, 0x10, 0x10, 0x40, 0xC3, 0x03,
  0x0C, 0x08, 0x21, 0xFF, 0xF7, 0xFF, 0xC6, 0x18, 0x18, 0x60, 0x61, 0x81,
  0x04, 0x04, 0x10, 0xFF, 0xFB, 0xFF, 0xE3, 0x0C, 0x08, 0x20, 0x20, 0x80,
  0x82, 0x06, 0x18, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x1F, 0x83,
  0xFC, 0x66, 0x64, 0x66, 0x46, 0x24, 0x60, 0x66, 0x07, 0x60, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x66, 0x06, 0x60, 0x62, 0xC6, 0x3C, 0x62, 0x66, 0x67,
  0x7C, 0x1F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x06, 0xCC,
  0x09, 0x08, 0x22, 0x18, 0xC4, 0x31, 0x08, 0x64, 0x10, 0x98, 0x3F, 0x60,
  0x08, 0x80, 0x03, 0x00, 0x0C, 0x40, 0x13, 0xE0, 0x4C, 0x61, 0x98, 0xC2,
  0x31, 0x88, 0x63, 0x30, 0xC6, 0xC1, 0x8B, 0x01, 0xF0, 0x1F, 0x01, 0x9C,
  0x18, 0x30, 0xC1, 0x86, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x78, 0x07,
  0x60, 0x33, 0x0D, 0x0C, 0x48, 0x36, 0x40, 0xE2, 0x07, 0x10, 0x38, 0xC1,
  0xE7, 0x39, 0x9F, 0x8E, 0xFF, 0xFF, 0x03, 0x0F, 0x1C, 0x30, 0x70, 0x60,
  0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x40, 0x60, 0x60, 0x30, 0x18, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0xC0, 0xC0,
  0xC1, 0x83, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x18,
  0x30, 0xC3, 0x8E, 0x78, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xC3, 0x0B, 0xE9, 0xF3, 0xFE, 0x00, 0xC0, 0x05, 0x80, 0x32, 0x01, 0xCC,
  0x06, 0x18, 0x30, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x37, 0x66,
  0x6C, 0xC8, 0xFF, 0x6F, 0xFE, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18,
  0x03, 0x00, 0xC0, 0x00, 0x1F, 0x87, 0x39, 0x81, 0xE0, 0x3C, 0x07, 0x80,
  0x70, 0x0E, 0x01, 0xC6, 0x39, 0xC7, 0x18, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0x60, 0x6F, 0x38, 0x7E, 0x00, 0x06, 0x01, 0xE0, 0x32, 0x06,
  0x20, 0x42, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0x87, 0x1C, 0x60, 0x6C, 0x06, 0xC0, 0x20, 0x02, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xEF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x78, 0x0F, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xF0, 0x1E, 0x03, 0x60, 0xCE, 0x38, 0xFE, 0x00, 0x00, 0xC0, 0x30, 0x0C,
  0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x66, 0x0D, 0x81, 0xE0,
  0x3C, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x7F,
  0xEF, 0xFD, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xFC, 0x70, 0xCC,
  0x0D, 0x81, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1A, 0x03, 0x60, 0x66, 0x38,
  0x7E, 0x00, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30,
  0x03, 0x20, 0x7F, 0xC7, 0x0E, 0xE0, 0x6C, 0x02, 0xC0, 0x3C, 0x03, 0xC0,
  0x2C, 0x06, 0x60, 0x63, 0x9C, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x2C,
  0x06, 0xC0, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x00,
  0x1F, 0x86, 0x39, 0x81, 0xA0, 0x34, 0x06, 0xC0, 0xD8, 0x19, 0x86, 0x1F,
  0x01, 0xE0, 0xE6, 0x30, 0x64, 0x07, 0x80, 0x70, 0x0E, 0x03, 0x60, 0x6E,
  0x38, 0x7E, 0x00, 0x1F, 0x83, 0x9C, 0x60, 0x6C, 0x06, 0xC0, 0x2C, 0x03,
  0xC0, 0x3C, 0x02, 0xC0, 0x66, 0x0E, 0x3F, 0xC0, 0xCC, 0x01, 0x80, 0x18,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x1C, 0x00, 0x4F, 0xFE, 0x00, 0x00,
  0x00, 0x04, 0xFF, 0xE0, 0x23, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x67,
  0x39, 0x8C, 0xC6, 0x20, 0x00, 0x20, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0,
  0x30, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x02, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x08, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x08, 0x00, 0xFC, 0x7F, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x1F, 0x0E, 0x06, 0x03, 0x01, 0x80, 0x00, 0x00, 0x30, 0x38, 0x1C, 0x00,
  0x0F, 0xC0, 0xC3, 0x8C, 0x0C, 0xC0, 0x36, 0x01, 0xA0, 0x07, 0x03, 0x38,
  0x7D, 0xC2, 0x1E, 0x30, 0x71, 0x83, 0x8C, 0x1C, 0x60, 0xE3, 0x07, 0x18,
  0x38, 0x63, 0xC3, 0xEA, 0x04, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x1C, 0x00,
  0x7E, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0F, 0x00, 0xB0, 0x1B, 0x01, 0x90,
  0x19, 0x81, 0x18, 0x30, 0x83, 0x08, 0x30, 0xC2, 0x0C, 0x7F, 0xC7, 0xFE,
  0x40, 0x64, 0x06, 0xC0, 0x2C, 0x03, 0x80, 0x30, 0xFE, 0x1F, 0xF2, 0x07,
  0x40, 0x68, 0x0D, 0x01, 0xA0, 0x34, 0x0C, 0xFF, 0x1F, 0xE2, 0x06, 0x40,
  0x68, 0x05, 0x00, 0xE0, 0x1C, 0x06, 0x80, 0xDF, 0xF3, 0xFC, 0x00, 0x3F,
  0x1C, 0xEC, 0x0F, 0x03, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x06, 0x03, 0xC0, 0xDC, 0xE3, 0xF0, 0xFE,
  0x3F, 0xC8, 0x1A, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xBF, 0xCF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xBF, 0xEC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F,
  0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x00, 0x3F, 0x1C, 0xEC, 0x0F, 0x03, 0x80, 0x60, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0xC0, 0xDC,
  0xE3, 0xF0, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0xFF, 0xFF, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F,
  0xFF, 0xFC, 0x0F, 0xE1, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1E, 0x02,
  0xC0, 0xCE, 0x70, 0xFC, 0x00, 0x80, 0x70, 0x1A, 0x03, 0x40, 0xC8, 0x19,
  0x06, 0x20, 0xC4, 0x30, 0xFE, 0x1F, 0xC2, 0x18, 0x41, 0x88, 0x31, 0x03,
  0x20, 0x64, 0x06, 0x80, 0xD0, 0x0E, 0x01, 0x80, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xE0,
  0x7C, 0x1F, 0x83, 0xF8, 0x5D, 0x1B, 0xB3, 0x76, 0x4E, 0x59, 0xCE, 0x38,
  0xC7, 0x18, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x80, 0xC0, 0xF8, 0x3E, 0x0E, 0x83, 0xB0, 0xE4, 0x39, 0x0E, 0x63,
  0x88, 0xE3, 0x38, 0xCE, 0x13, 0x86, 0xE0, 0xB8, 0x3E, 0x0F, 0x81, 0xE0,
  0x78, 0x1C, 0x3F, 0x1C, 0xEC, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xD8,
  0xE3, 0xF0, 0xFF, 0x1F, 0xFA, 0x03, 0x40, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xDF, 0xF3, 0xFC, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x00, 0x1F, 0x87, 0x39, 0x81, 0xA0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1A, 0x03, 0x60, 0x67, 0x38, 0x7E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x03, 0xFF, 0x1F, 0xF2, 0x03, 0x40, 0x28, 0x07, 0x00, 0xE0, 0x1C,
  0x06, 0x81, 0xDF, 0xF3, 0xF8, 0x43, 0x08, 0x31, 0x06, 0x20, 0x64, 0x0C,
  0x80, 0xD0, 0x1A, 0x01, 0x80, 0x1F, 0x83, 0x1C, 0x60, 0x64, 0x06, 0x40,
  0x24, 0x00, 0x60, 0x07, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xC0, 0x06, 0x00,
  0x60, 0x02, 0xC0, 0x3C, 0x02, 0x60, 0x67, 0x0C, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0,
  0x9C, 0xE3, 0xF0, 0xC0, 0x3C, 0x03, 0xC0, 0x24, 0x06, 0x60, 0x66, 0x06,
  0x60, 0x42, 0x0C, 0x30, 0xC3, 0x08, 0x30, 0x81, 0x18, 0x19, 0x81, 0x90,
  0x1B, 0x00, 0xB0, 0x0F, 0x00, 0xE0, 0x06, 0x00, 0xC3, 0x0F, 0x0C, 0x3C,
  0x30, 0xB1, 0xC2, 0xC5, 0x09, 0x16, 0x64, 0x49, 0x91, 0x26, 0x44, 0x99,
  0x92, 0x66, 0xC9, 0x1B, 0x24, 0x68, 0x90, 0xA3, 0x42, 0x87, 0x0A, 0x1C,
  0x28, 0x70, 0xA1, 0xC3, 0x86, 0x00, 0x60, 0x1B, 0x01, 0x8C, 0x0C, 0x20,
  0xC1, 0x84, 0x06, 0x60, 0x32, 0x00, 0xF0, 0x07, 0x00, 0x18, 0x01, 0xE0,
  0x1B, 0x00, 0xCC, 0x0C, 0x60, 0x61, 0x86, 0x04, 0x30, 0x33, 0x00, 0xF0,
  0x06, 0xC0, 0x1B, 0x00, 0xD8, 0x0C, 0x60, 0x63, 0x06, 0x0C, 0x30, 0x61,
  0x01, 0x98, 0x0C, 0x80, 0x3C, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFF, 0xFF, 0xFC, 0x01,
  0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x3F, 0xFC, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x60, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xFC,
  0x06, 0x01, 0xC0, 0x2C, 0x0C, 0x81, 0x98, 0x63, 0x0C, 0x31, 0x06, 0x60,
  0x58, 0x0C, 0xFF, 0xF0, 0xE1, 0x8E, 0x04, 0x07, 0xF1, 0xC3, 0x30, 0x30,
  0x06, 0x00, 0xC0, 0x19, 0xFF, 0x60, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06,
  0xC3, 0xCF, 0xD8, 0x80, 0x20, 0x08, 0x02, 0x00, 0x84, 0x2F, 0xCA, 0x1B,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0,
  0xE8, 0xE9, 0xF0, 0x08, 0x1F, 0xCE, 0x1B, 0x03, 0x80, 0xE0, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x0E, 0x03, 0xC0, 0xDC, 0xE3, 0xF0, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x18, 0xDF, 0xBE, 0x1F, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC1, 0xD8, 0xF3, 0xEC, 0x08, 0x1F,
  0xCE, 0x1B, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0x80, 0x20, 0x08, 0x02,
  0x03, 0xC0, 0xD8, 0xE3, 0xF0, 0x03, 0xF0, 0x7F, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x08, 0x1F,
  0xBE, 0x1F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F,
  0x07, 0x7F, 0xCF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x77, 0xF9, 0xF8, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x84, 0x2F, 0xCA, 0x1B, 0x03, 0xC0, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x06,
  0x00, 0x70, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0xF0, 0x18, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x33, 0xF8, 0xFC,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x01, 0xE0, 0x34, 0x0C,
  0x83, 0x10, 0x62, 0x18, 0x7E, 0x08, 0x61, 0x0C, 0x20, 0xC4, 0x0C, 0x81,
  0x90, 0x1A, 0x01, 0x80, 0xFC, 0x07, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x06, 0x00, 0x3F, 0xC0, 0xFE, 0x18,
  0x8B, 0xDE, 0xC6, 0x2C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x30, 0x04, 0x2F,
  0xCA, 0x1B, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x0C, 0x1F, 0xCE, 0x1B, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xD8, 0xE3, 0xF0,
  0x04, 0x2F, 0xCA, 0x1B, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0F, 0x03, 0xC0, 0xE8, 0xE9, 0xF2, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x18, 0x1F, 0xBE, 0x1F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xC1, 0xD8, 0xF3, 0xEC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x06, 0x1B, 0xF3, 0x87, 0x60, 0x6C, 0x07, 0x80, 0xF0, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x06,
  0x07, 0xF9, 0xC3, 0xB0, 0x36, 0x00, 0xC0, 0x1C, 0x01, 0xFC, 0x03, 0xC0,
  0x0C, 0x01, 0xE0, 0x16, 0x06, 0xE1, 0xCF, 0xF0, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x0F, 0xFE, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x0F, 0xE0, 0xFC, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x06,
  0x73, 0x8F, 0xC0, 0xC0, 0x3C, 0x06, 0x40, 0x66, 0x06, 0x60, 0xC2, 0x0C,
  0x30, 0xC3, 0x18, 0x11, 0x81, 0x90, 0x1B, 0x00, 0xB0, 0x0E, 0x00, 0x60,
  0xC3, 0x0E, 0x18, 0x51, 0xC6, 0x8A, 0x34, 0x59, 0xB2, 0x49, 0x92, 0x4C,
  0x92, 0x2C, 0x91, 0x45, 0x8A, 0x3C, 0x70, 0xC3, 0x86, 0x1C, 0x30, 0xE0,
  0x76, 0x0C, 0x30, 0xC1, 0x98, 0x1B, 0x00, 0xF0, 0x06, 0x00, 0xE0, 0x1B,
  0x01, 0x98, 0x30, 0x86, 0x0C, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x06, 0x60,
  0x66, 0x04, 0x30, 0xC3, 0x0C, 0x30, 0x81, 0x98, 0x19, 0x80, 0xB0, 0x0F,
  0x00, 0xE0, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x00, 0xFF, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x0C, 0x06, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x3C, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x0F,
  0xC0, 0x1C, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0xC0, 0x1F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xC0, 0x1F, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x3E, 0x0E, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xC0, 0xF0, 0x00,
  0x30, 0x37, 0xC3, 0xCE, 0x3C, 0x72, 0xC3, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 7, 8, 16, 4, -19 },
  { 18, 14, 19, 16, 1, -19 },
  { 52, 12, 27, 16, 2, -23 },
  { 93, 15, 19, 16, 0, -19 },
  { 129, 13, 19, 16, 2, -19 },
  { 160, 2, 8, 16, 7, -19 },
  { 162, 8, 25, 16, 5, -22 },
  { 187, 7, 25, 16, 3, -22 },
  { 209, 14, 13, 16, 1, -16 },
  { 232, 12, 12, 16, 2, -15 },
  { 250, 4, 8, 16, 5, -4 },
  { 254, 8, 1, 16, 4, -9 },
  { 255, 4, 4, 16, 6, -4 },
  { 257, 11, 25, 16, 2, -22 },
  { 292, 11, 19, 16, 2, -19 },
  { 319, 12, 19, 16, 2, -19 },
  { 348, 12, 19, 16, 2, -19 },
  { 377, 11, 19, 16, 2, -19 },
  { 404, 11, 19, 16, 2, -19 },
  { 431, 11, 19, 16, 2, -19 },
  { 458, 12, 19, 16, 2, -19 },
  { 487, 12, 19, 16, 2, -19 },
  { 516, 11, 19, 16, 2, -19 },
  { 543, 12, 19, 16, 2, -19 },
  { 572, 4, 15, 16, 6, -15 },
  { 580, 5, 19, 16, 5, -15 },
  { 592, 11, 13, 16, 2, -15 },
  { 610, 11, 7, 16, 2, -12 },
  { 620, 11, 13, 16, 2, -15 },
  { 638, 9, 19, 16, 4, -19 },
  { 660, 13, 24, 16, 1, -19 },
  { 699, 12, 19, 16, 2, -19 },
  { 728, 11, 19, 16, 3, -19 },
  { 755, 10, 19, 16, 3, -19 },
  { 779, 10, 19, 16, 3, -19 },
  { 803, 10, 19, 16, 3, -19 },
  { 827, 11, 19, 16, 3, -19 },
  { 854, 10, 19, 16, 3, -19 },
  { 878, 10, 19, 16, 3, -19 },
  { 902, 10, 19, 16, 3, -19 },
  { 926, 11, 19, 16, 2, -19 },
  { 953, 11, 19, 16, 3, -19 },
  { 980, 11, 19, 16, 3, -19 },
  { 1007, 11, 19, 16, 2, -19 },
  { 1034, 10, 19, 16, 3, -19 },
  { 1058, 10, 19, 16, 3, -19 },
  { 1082, 11, 19, 16, 3, -19 },
  { 1109, 11, 24, 16, 2, -19 },
  { 1142, 11, 19, 16, 3, -19 },
  { 1169, 12, 19, 16, 2, -19 },
  { 1198, 12, 19, 16, 2, -19 },
  { 1227, 10, 19, 16, 3, -19 },
  { 1251, 12, 19, 16, 2, -19 },
  { 1280, 14, 19, 16, 1, -19 },
  { 1314, 13, 19, 16, 1, -19 },
  { 1345, 13, 19, 16, 1, -19 },
  { 1376, 11, 19, 16, 2, -19 },
  { 1403, 6, 25, 16, 6, -22 },
  { 1422, 11, 25, 16, 2, -22 },
  { 1457, 6, 25, 16, 4, -22 },
  { 1476, 11, 10, 16, 2, -19 },
  { 1490, 12, 1, 16, 2, 1 },
  { 1492, 5, 3, 16, 5, -20 },
  { 1494, 11, 15, 16, 2, -15 },
  { 1515, 10, 19, 16, 3, -19 },
  { 1539, 10, 15, 16, 3, -15 },
  { 1558, 10, 19, 16, 3, -19 },
  { 1582, 10, 15, 16, 3, -15 },
  { 1601, 12, 19, 16, 2, -19 },
  { 1630, 10, 20, 16, 3, -15 },
  { 1655, 10, 19, 16, 3, -19 },
  { 1679, 12, 20, 16, 2, -20 },
  { 1709, 10, 25, 16, 2, -20 },
  { 1741, 11, 19, 16, 3, -19 },
  { 1768, 13, 19, 16, 1, -19 },
  { 1799, 12, 15, 16, 2, -15 },
  { 1822, 10, 15, 16, 3, -15 },
  { 1841, 10, 15, 16, 3, -15 },
  { 1860, 10, 20, 16, 3, -15 },
  { 1885, 10, 20, 16, 3, -15 },
  { 1910, 11, 15, 16, 3, -15 },
  { 1931, 11, 15, 16, 2, -15 },
  { 1952, 11, 18, 16, 2, -18 },
  { 1977, 10, 14, 16, 3, -14 },
  { 1995, 12, 14, 16, 2, -14 },
  { 2016, 13, 14, 16, 1, -14 },
  { 2039, 12, 14, 16, 2, -14 },
  { 2060, 12, 19, 16, 2, -14 },
  { 2089, 10, 14, 16, 3, -14 },
  { 2107, 11, 25, 16, 2, -22 },
  { 2142, 2, 25, 16, 7, -22 },
  { 2149, 11, 25, 16, 2, -22 },
  { 2184, 12, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_ExtraLight26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_EXTRALIGHT26PT7B_H_
