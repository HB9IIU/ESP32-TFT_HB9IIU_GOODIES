#ifndef _JETBRAINSMONO_EXTRALIGHT54PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight54pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xC1, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xF7, 0xFF, 0xFF, 0xDF, 0x00,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x77, 0x80, 0xEF, 0x01,
  0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0,
  0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x38,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x38,
  0x07, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0,
  0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xDD,
  0xF8, 0x1F, 0x1C, 0x7C, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x1E, 0x38, 0x1C,
  0x0E, 0x78, 0x1C, 0x0E, 0x78, 0x1C, 0x0F, 0x78, 0x1C, 0x00, 0x78, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1C,
  0x00, 0x1F, 0x9C, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1D, 0xF8, 0x00, 0x1C,
  0x7C, 0x00, 0x1C, 0x3E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x1C,
  0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0xF0, 0x1C, 0x0F, 0xF0, 0x1C,
  0x0F, 0x70, 0x1C, 0x0F, 0x78, 0x1C, 0x0F, 0x78, 0x1C, 0x1E, 0x3C, 0x1C,
  0x3E, 0x3F, 0x1C, 0x7C, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x73, 0xFF, 0x80, 0x03,
  0x9F, 0x1F, 0x00, 0x1C, 0x70, 0x1C, 0x00, 0x71, 0xC0, 0x70, 0x03, 0x8F,
  0x00, 0xE0, 0x1C, 0x38, 0x03, 0x80, 0x70, 0xE0, 0x0E, 0x03, 0x83, 0x80,
  0x38, 0x1C, 0x0E, 0x00, 0xE0, 0xF0, 0x38, 0x03, 0x83, 0x80, 0x70, 0x1E,
  0x1C, 0x01, 0xC0, 0x70, 0xE0, 0x07, 0x81, 0xC3, 0x80, 0x0F, 0xBE, 0x1C,
  0x00, 0x3F, 0xF8, 0xE0, 0x00, 0x3F, 0x83, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x07, 0x0F, 0xF8, 0x00, 0x1C, 0x7F, 0xF0, 0x00,
  0xE1, 0xE1, 0xE0, 0x07, 0x0E, 0x03, 0x80, 0x1C, 0x38, 0x07, 0x00, 0xE0,
  0xE0, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0x38,
  0x07, 0x07, 0x00, 0xE0, 0x1C, 0x3C, 0x03, 0x80, 0x70, 0xE0, 0x0E, 0x01,
  0xC7, 0x00, 0x38, 0x0F, 0x38, 0x00, 0xF0, 0x38, 0xE0, 0x01, 0xFF, 0xE7,
  0x00, 0x03, 0xFF, 0x38, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xF0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xC7, 0x80, 0x02, 0xF0, 0x78, 0x03, 0x9C, 0x0F, 0x80,
  0xF7, 0x80, 0xF0, 0x1C, 0xF0, 0x0F, 0x07, 0x9E, 0x00, 0xF1, 0xE3, 0xC0,
  0x1E, 0x3C, 0x78, 0x01, 0xEF, 0x0F, 0x00, 0x1F, 0xE1, 0xE0, 0x01, 0xF8,
  0x3C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x1E, 0x00,
  0x1F, 0xC1, 0xC0, 0x07, 0xF8, 0x3C, 0x01, 0xE7, 0x87, 0xC0, 0x7C, 0x78,
  0x7F, 0xFF, 0x07, 0x87, 0xFF, 0x80, 0xF0, 0x7F, 0xE0, 0x0F, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x00, 0x0E,
  0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x38, 0xE0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x60, 0x0F, 0x00, 0x27,
  0x80, 0x70, 0x1F, 0xFF, 0x07, 0x0F, 0xFF, 0xFC, 0x63, 0xFF, 0x1F, 0xF6,
  0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x03,
  0x00, 0x0E, 0x00, 0x10, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x81, 0xFC, 0x3F, 0x83, 0xE0, 0x0F, 0x8F,
  0x80, 0x0F, 0x1E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xE0,
  0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x70,
  0x3F, 0x81, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0x83,
  0xF8, 0x1E, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x79, 0xE0,
  0x01, 0xF3, 0xE0, 0x07, 0xC3, 0xF0, 0x1F, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0x9E, 0x00, 0x3E, 0x1E,
  0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0xC0, 0x1E,
  0x00, 0x80, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x03, 0xF8, 0x3F, 0x03, 0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xDC,
  0x00, 0x07, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0,
  0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C,
  0x00, 0x3D, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x9E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE1, 0xFC, 0x07, 0x9F, 0xFC, 0x1E, 0xFF, 0xF8,
  0x77, 0xC7, 0xF1, 0xD8, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x0F, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xE0,
  0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x3F, 0x80, 0x1E, 0xFF, 0xE0, 0x1D, 0xFF, 0xF8,
  0x3F, 0x81, 0xFC, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x3E, 0x00, 0x3C, 0x1F, 0x00, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFC, 0x3F, 0x83, 0xE0, 0x0F, 0x8F, 0x80,
  0x0F, 0x1E, 0x00, 0x0F, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x03, 0xE0, 0x0F, 0x9F, 0x80,
  0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xF8, 0x07,
  0xC0, 0xF8, 0x1F, 0x00, 0x78, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0x7B, 0xC0,
  0x00, 0xF7, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xC0, 0x00,
  0xF3, 0xC0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0x3C,
  0x7C, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x1F, 0xE3, 0xFC,
  0x0F, 0xFF, 0xB8, 0x03, 0xFF, 0x78, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E,
  0x08, 0x1F, 0x8F, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x78,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38,
  0x0E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x07,
  0xFC, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0xE7, 0xE0, 0x1F, 0xFE, 0xFC, 0x03,
  0xC0, 0x5F, 0x80, 0x70, 0x07, 0xF0, 0x1E, 0x00, 0xFE, 0x03, 0xC0, 0x1F,
  0xC0, 0x70, 0x03, 0xF8, 0x0E, 0x00, 0x7F, 0x01, 0xC0, 0x0F, 0xE0, 0x38,
  0x01, 0xFC, 0x07, 0x00, 0x3F, 0x80, 0xE0, 0x07, 0xF0, 0x1C, 0x00, 0xFE,
  0x03, 0x80, 0x1F, 0xC0, 0x70, 0x03, 0xF8, 0x0F, 0x00, 0x7F, 0x01, 0xE0,
  0x0F, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0xE0, 0xDF, 0x80, 0x3F, 0xFB, 0xF0,
  0x03, 0xFE, 0x7F, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x38,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0E,
  0x1C, 0x00, 0x03, 0x87, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00,
  0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1C,
  0x00, 0x38, 0x07, 0x80, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1E, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x3C, 0x00,
  0x07, 0x0E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x78,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0xF8, 0xE0, 0x01, 0xF3, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xEE,
  0x00, 0x0F, 0x38, 0x00, 0x7C, 0xE0, 0x03, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0xE0, 0x07, 0xE3, 0x80, 0x07, 0xCE, 0x00, 0x07,
  0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xEE, 0x00, 0x1F, 0x38, 0x01, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xE0, 0x0F, 0x8F,
  0x80, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xF0, 0x1F, 0x83, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE1, 0xC0, 0x0F, 0x8E, 0x00, 0x3E, 0x70, 0x00, 0xFB, 0x80,
  0x03, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x0F,
  0x38, 0x00, 0xF9, 0xC0, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFC,
  0x1F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x70, 0x00,
  0x1C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xF0, 0x1F,
  0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0xF0,
  0x01, 0xF1, 0xF8, 0x07, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xC0, 0xE0, 0x03,
  0xC0, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0xE0, 0x0F,
  0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x3E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1F,
  0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x07,
  0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x01,
  0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x70, 0x01, 0xFE, 0xE0, 0x07, 0x7F, 0xC0, 0x0E, 0xFD, 0xC0, 0x1D, 0xFB,
  0x80, 0x73, 0xF7, 0x00, 0xE7, 0xE7, 0x01, 0xCF, 0xCE, 0x07, 0x1F, 0x9C,
  0x0E, 0x3F, 0x1C, 0x1C, 0xFE, 0x38, 0x71, 0xFC, 0x30, 0xE3, 0xF8, 0x71,
  0xC7, 0xF0, 0xE7, 0x0F, 0xE0, 0xCE, 0x1F, 0xC1, 0xDC, 0x3F, 0x83, 0xF0,
  0x7F, 0x03, 0xE0, 0xFE, 0x07, 0xC1, 0xFC, 0x0F, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x80, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xB8, 0x01, 0xFD, 0xC0, 0x0F, 0xE7, 0x00, 0x7F, 0x38,
  0x03, 0xF9, 0xC0, 0x1F, 0xC7, 0x00, 0xFE, 0x38, 0x07, 0xF1, 0xE0, 0x3F,
  0x87, 0x01, 0xFC, 0x38, 0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x3C,
  0x1F, 0xC0, 0xE0, 0xFE, 0x07, 0x07, 0xF0, 0x3C, 0x3F, 0x80, 0xE1, 0xFC,
  0x07, 0x0F, 0xE0, 0x1C, 0x7F, 0x00, 0xE3, 0xF8, 0x07, 0x9F, 0xC0, 0x1C,
  0xFE, 0x00, 0xE7, 0xF0, 0x07, 0xBF, 0x80, 0x1C, 0xFC, 0x00, 0xF7, 0xE0,
  0x03, 0xBF, 0x00, 0x1D, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xE1, 0xFC, 0x3E, 0x00, 0xF1, 0xF0, 0x01, 0xE7, 0x80,
  0x07, 0x9C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0x8F, 0x00, 0x3E, 0x3E, 0x01, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0x00, 0x0F, 0xCE, 0x00,
  0x07, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x3D,
  0xC0, 0x01, 0xF3, 0x80, 0x0F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFC, 0x3F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x0F, 0x1E, 0x00, 0x0E,
  0x38, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77,
  0x80, 0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78,
  0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00,
  0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80, 0x00,
  0xEF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xE1, 0xE0, 0x07, 0xC3,
  0xE0, 0x1F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00,
  0x17, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0x00, 0x0F, 0x8E, 0x00, 0x0F, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x0F,
  0x70, 0x00, 0x1E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70,
  0x00, 0x3E, 0xE0, 0x00, 0x79, 0xC0, 0x03, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x3C,
  0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x70, 0x00, 0xF0,
  0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xE3, 0x80, 0x01, 0xE7, 0x00, 0x03, 0xCE,
  0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x00, 0x7C,
  0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3F, 0x00, 0x7C,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78,
  0x00, 0x39, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1C,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x78,
  0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00,
  0xF0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x0E,
  0x01, 0xE0, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x07, 0x00,
  0x07, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0x87, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x07,
  0x3C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0x7C, 0x03, 0xBC,
  0x03, 0xE0, 0x1D, 0xE0, 0x1F, 0x00, 0xEF, 0x00, 0xD8, 0x07, 0x38, 0x0E,
  0xC0, 0x39, 0xC0, 0x76, 0x03, 0xCE, 0x03, 0xB0, 0x1E, 0x70, 0x1D, 0xC0,
  0xE3, 0x80, 0xCE, 0x07, 0x1C, 0x06, 0x70, 0x38, 0xF0, 0x33, 0x81, 0xC7,
  0x81, 0x8C, 0x0E, 0x1C, 0x1C, 0x60, 0x70, 0xE0, 0xE3, 0x03, 0x87, 0x07,
  0x18, 0x3C, 0x38, 0x30, 0xE1, 0xE1, 0xC1, 0x87, 0x0E, 0x0E, 0x0C, 0x38,
  0x70, 0x78, 0x60, 0xC3, 0x83, 0xC7, 0x06, 0x1C, 0x1E, 0x38, 0x30, 0xE0,
  0x71, 0xC1, 0x87, 0x03, 0x8C, 0x0C, 0x38, 0x1C, 0x60, 0x73, 0xC0, 0xE3,
  0x03, 0x9C, 0x07, 0x18, 0x1C, 0xE0, 0x38, 0xC0, 0x67, 0x01, 0xEE, 0x03,
  0x38, 0x0F, 0x70, 0x19, 0xC0, 0x3B, 0x00, 0xCE, 0x01, 0xD8, 0x06, 0x70,
  0x0E, 0xC0, 0x3B, 0x80, 0x76, 0x01, 0xF8, 0x03, 0xB0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0E, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0x1C, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x38,
  0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x0E,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x01, 0xEE, 0x00, 0x07, 0x3C, 0x00,
  0x3C, 0x70, 0x00, 0xE1, 0xE0, 0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x70,
  0x3C, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xE0, 0x78, 0x03, 0x81, 0xC0, 0x0F,
  0x0F, 0x00, 0x1C, 0x38, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xBC,
  0x00, 0x0F, 0xF0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7C, 0x07, 0xC1,
  0xE0, 0x07, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x07, 0x9C, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3E, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0xFD, 0xF8, 0x03, 0xF9, 0xFF, 0xFE, 0xF1, 0xFF, 0xF9, 0xE0,
  0xFF, 0xC3, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x0F, 0xF0, 0x38, 0xFF, 0xE1, 0xCF,
  0xFF, 0x8E, 0xE0, 0x3E, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xDE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xBE,
  0x00, 0x3D, 0xD8, 0x07, 0xCE, 0xFF, 0xFE, 0x73, 0xFF, 0xE3, 0x87, 0xFC,
  0x00, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xC0, 0xFC, 0x3C, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xDC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x77, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3C,
  0xF0, 0x01, 0xE3, 0xF0, 0x1F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0xF0, 0xF0, 0xFF, 0xF3, 0xC7,
  0xFF, 0xEF, 0x3F, 0x03, 0xFC, 0xF0, 0x03, 0xF7, 0x80, 0x07, 0xDE, 0x00,
  0x1F, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x3D,
  0xE0, 0x01, 0xF7, 0xC0, 0x0F, 0xCF, 0x80, 0x7F, 0x1F, 0xFF, 0xBC, 0x3F,
  0xFC, 0xF0, 0x7F, 0xE3, 0xC0, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xC0, 0x7C, 0x3C, 0x00, 0xF9, 0xE0, 0x01, 0xE7,
  0x80, 0x03, 0x9C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xFC, 0x3C, 0x3F, 0xFC, 0xF1, 0xFF, 0xFB, 0xCF, 0xC0, 0xFF, 0x3C, 0x00,
  0xFD, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xE0, 0x01, 0xF7,
  0xC0, 0x07, 0xCF, 0x80, 0x3F, 0x1F, 0x83, 0xBC, 0x7F, 0xFE, 0xF0, 0x7F,
  0xE3, 0xC0, 0x7E, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x0F, 0xF0, 0x38, 0xFF, 0xE1, 0xCF, 0xFF, 0x8E, 0xE0, 0x3E, 0x7C,
  0x00, 0xFB, 0xE0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xF7, 0x00, 0x03, 0xEE, 0x00, 0x07, 0x9C, 0x00, 0x1E, 0x38, 0x00,
  0x78, 0x70, 0x01, 0xF0, 0xE0, 0x03, 0xC1, 0xC0, 0x0F, 0x03, 0x80, 0x3E,
  0x07, 0x00, 0x78, 0x0E, 0x01, 0xE0, 0x1C, 0x07, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xC0, 0x78, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xF8, 0x0E, 0x00, 0xF0, 0x1C, 0x00, 0xF0, 0x38, 0x01, 0xF0, 0x70,
  0x01, 0xE0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xE3, 0x80, 0x03, 0xC7, 0x00,
  0x03, 0xCE, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x80, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xE3,
  0xE0, 0xFC, 0xEF, 0xF1, 0xFE, 0xEF, 0xFB, 0xFE, 0xF8, 0x7A, 0x0F, 0xF0,
  0x3C, 0x07, 0xF0, 0x3C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0,
  0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0,
  0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0,
  0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0,
  0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0,
  0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE0,
  0x1C, 0x07, 0xE0, 0x1C, 0x07, 0xE1, 0xFE, 0x07, 0x1F, 0xFC, 0x39, 0xFF,
  0xF1, 0xDC, 0x07, 0xCF, 0xC0, 0x1F, 0x7C, 0x00, 0x7B, 0xC0, 0x01, 0xDE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3C,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3C,
  0x00, 0xF9, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0x9C, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x78, 0xF0, 0x03, 0xE3,
  0xE0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xE1,
  0xFE, 0x07, 0x1F, 0xFC, 0x39, 0xFF, 0xF1, 0xDC, 0x07, 0xCF, 0x80, 0x1F,
  0x7C, 0x00, 0x7B, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xBB, 0x00, 0xF9, 0xDF, 0xFF,
  0xCE, 0x7F, 0xF8, 0x70, 0xFF, 0x83, 0x80, 0x60, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFC, 0x3C, 0x3F,
  0xFC, 0xF1, 0xFF, 0xFB, 0xCF, 0xC0, 0xFF, 0x3C, 0x00, 0xFD, 0xE0, 0x01,
  0xF7, 0x80, 0x07, 0xDC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE,
  0x00, 0x0F, 0x78, 0x00, 0x7C, 0xF0, 0x03, 0xF3, 0xE0, 0x1F, 0xC7, 0xFF,
  0xEF, 0x0F, 0xFF, 0x3C, 0x1F, 0xF8, 0xF0, 0x06, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE1, 0xFE,
  0x07, 0x1F, 0xFC, 0x39, 0xFF, 0xF1, 0xDC, 0x07, 0xCF, 0x80, 0x1F, 0x7C,
  0x00, 0x7B, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC1, 0xF0, 0x0F, 0xC7, 0xC0, 0x07, 0xCF, 0x00, 0x07, 0x9E, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x79, 0xF0, 0x01, 0xE1, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00,
  0x0E, 0x78, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xE0, 0x1F, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0xE3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00,
  0x3C, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x0F, 0x00, 0xE0,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x07,
  0x80, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x38, 0x00,
  0x1C, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x77, 0x00,
  0xF0, 0x07, 0x70, 0x0F, 0x00, 0xF7, 0x00, 0xF8, 0x0F, 0x70, 0x0F, 0x80,
  0xE7, 0x00, 0xD8, 0x0E, 0x78, 0x1D, 0x80, 0xE3, 0x81, 0xD8, 0x0E, 0x38,
  0x19, 0x80, 0xE3, 0x81, 0x9C, 0x1C, 0x38, 0x19, 0xC1, 0xC3, 0x83, 0x8C,
  0x1C, 0x3C, 0x38, 0xC1, 0xC1, 0xC3, 0x0C, 0x1C, 0x1C, 0x30, 0xE1, 0xC1,
  0xC3, 0x0E, 0x38, 0x1C, 0x30, 0xE3, 0x81, 0xC7, 0x06, 0x38, 0x1E, 0x70,
  0x63, 0x80, 0xE6, 0x06, 0x38, 0x0E, 0x60, 0x73, 0x80, 0xE6, 0x07, 0x30,
  0x0E, 0xE0, 0x77, 0x00, 0xEE, 0x03, 0x70, 0x0E, 0xE0, 0x37, 0x00, 0x7C,
  0x03, 0x70, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E,
  0x00, 0x7C, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF7, 0x80,
  0x00, 0x7C, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xCF,
  0x00, 0x01, 0xE7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70,
  0x38, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03,
  0x80, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0x3F, 0xE0, 0x07, 0x7F, 0xF0, 0x07, 0x70,
  0x78, 0x07, 0xF0, 0x3C, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x1F, 0x0F, 0xE0,
  0x0F, 0xFE, 0xE0, 0x07, 0xFE, 0xE0, 0x01, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraLight54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 7, 39, 32, 13, -39 },
  { 36, 15, 16, 32, 9, -39 },
  { 66, 29, 39, 32, 2, -39 },
  { 208, 24, 55, 32, 4, -47 },
  { 373, 30, 40, 32, 1, -40 },
  { 523, 27, 41, 32, 3, -40 },
  { 662, 4, 16, 32, 14, -39 },
  { 670, 15, 51, 32, 11, -45 },
  { 766, 16, 51, 32, 6, -45 },
  { 868, 28, 28, 32, 2, -33 },
  { 966, 25, 26, 32, 4, -31 },
  { 1048, 10, 17, 32, 10, -8 },
  { 1070, 17, 3, 32, 8, -19 },
  { 1077, 8, 9, 32, 12, -8 },
  { 1086, 23, 51, 32, 5, -45 },
  { 1233, 23, 41, 32, 5, -40 },
  { 1351, 24, 39, 32, 5, -39 },
  { 1468, 25, 40, 32, 4, -40 },
  { 1593, 23, 40, 32, 4, -39 },
  { 1708, 22, 39, 32, 5, -39 },
  { 1816, 22, 40, 32, 5, -39 },
  { 1926, 24, 40, 32, 4, -39 },
  { 2046, 25, 39, 32, 4, -39 },
  { 2168, 23, 41, 32, 5, -40 },
  { 2286, 24, 40, 32, 4, -40 },
  { 2406, 8, 31, 32, 12, -30 },
  { 2437, 10, 39, 32, 10, -30 },
  { 2486, 23, 28, 32, 5, -32 },
  { 2567, 22, 16, 32, 5, -26 },
  { 2611, 23, 28, 32, 5, -32 },
  { 2692, 19, 39, 32, 8, -39 },
  { 2785, 27, 50, 32, 3, -40 },
  { 2954, 26, 39, 32, 3, -39 },
  { 3081, 22, 39, 32, 6, -39 },
  { 3189, 23, 41, 32, 5, -40 },
  { 3307, 21, 39, 32, 6, -39 },
  { 3410, 22, 39, 32, 6, -39 },
  { 3518, 22, 39, 32, 6, -39 },
  { 3626, 23, 41, 32, 5, -40 },
  { 3744, 21, 39, 32, 6, -39 },
  { 3847, 20, 39, 32, 6, -39 },
  { 3945, 23, 40, 32, 3, -39 },
  { 4060, 24, 39, 32, 6, -39 },
  { 4177, 23, 39, 32, 6, -39 },
  { 4290, 23, 39, 32, 5, -39 },
  { 4403, 21, 39, 32, 6, -39 },
  { 4506, 22, 41, 32, 5, -40 },
  { 4619, 23, 39, 32, 6, -39 },
  { 4732, 23, 50, 32, 5, -40 },
  { 4876, 23, 39, 32, 6, -39 },
  { 4989, 24, 41, 32, 4, -40 },
  { 5112, 26, 39, 32, 3, -39 },
  { 5239, 22, 40, 32, 5, -39 },
  { 5349, 26, 39, 32, 3, -39 },
  { 5476, 29, 39, 32, 2, -39 },
  { 5618, 27, 39, 32, 3, -39 },
  { 5750, 28, 39, 32, 2, -39 },
  { 5887, 23, 39, 32, 5, -39 },
  { 6000, 12, 51, 32, 12, -45 },
  { 6077, 23, 51, 32, 5, -45 },
  { 6224, 13, 51, 32, 8, -45 },
  { 6307, 22, 21, 32, 5, -39 },
  { 6365, 26, 3, 32, 3, 1 },
  { 6375, 10, 7, 32, 10, -42 },
  { 6384, 23, 31, 32, 4, -30 },
  { 6474, 21, 40, 32, 6, -39 },
  { 6579, 22, 31, 32, 5, -30 },
  { 6665, 22, 40, 32, 5, -39 },
  { 6775, 22, 31, 32, 5, -30 },
  { 6861, 25, 39, 32, 4, -39 },
  { 6983, 22, 40, 32, 5, -30 },
  { 7093, 21, 39, 32, 6, -39 },
  { 7196, 24, 42, 32, 5, -42 },
  { 7322, 19, 52, 32, 5, -42 },
  { 7446, 23, 39, 32, 6, -39 },
  { 7559, 27, 39, 32, 2, -39 },
  { 7691, 24, 30, 32, 4, -30 },
  { 7781, 21, 30, 32, 6, -30 },
  { 7860, 22, 30, 32, 5, -30 },
  { 7943, 21, 40, 32, 6, -30 },
  { 8048, 22, 40, 32, 5, -30 },
  { 8158, 21, 30, 32, 7, -30 },
  { 8237, 23, 30, 32, 5, -30 },
  { 8324, 25, 38, 32, 3, -38 },
  { 8443, 22, 31, 32, 5, -30 },
  { 8529, 25, 30, 32, 4, -30 },
  { 8623, 28, 30, 32, 2, -30 },
  { 8728, 25, 30, 32, 4, -30 },
  { 8822, 25, 40, 32, 4, -30 },
  { 8947, 22, 30, 32, 5, -30 },
  { 9030, 22, 51, 32, 5, -45 },
  { 9171, 4, 51, 32, 14, -45 },
  { 9197, 22, 51, 32, 5, -45 },
  { 9338, 24, 10, 32, 4, -24 },
};

const GFXfont JetBrainsMono_ExtraLight54pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight54pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _JETBRAINSMONO_EXTRALIGHT54PT7B_H_
