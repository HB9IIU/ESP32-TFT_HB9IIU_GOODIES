#ifndef _JETBRAINSMONO_EXTRALIGHT31PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight31pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x22, 0x20, 0x00, 0x7F,
  0x70, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0D, 0x86, 0xC3, 0x60,
  0x80, 0x03, 0x06, 0x01, 0x83, 0x00, 0x81, 0x00, 0xC0, 0x80, 0x60, 0xC0,
  0x30, 0x60, 0x18, 0x30, 0xFF, 0xFF, 0x0C, 0x08, 0x06, 0x0C, 0x03, 0x06,
  0x01, 0x83, 0x00, 0x81, 0x80, 0x40, 0x80, 0x60, 0xC1, 0xFF, 0xFC, 0xFF,
  0xFE, 0x08, 0x18, 0x04, 0x08, 0x06, 0x04, 0x03, 0x06, 0x01, 0x83, 0x00,
  0xC1, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x07, 0xC0, 0x7F,
  0xC3, 0x93, 0x9C, 0x46, 0x61, 0x0D, 0x84, 0x36, 0x10, 0x18, 0x40, 0x31,
  0x00, 0xE4, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x04, 0xE0, 0x11, 0xC0,
  0x43, 0x01, 0x0F, 0x84, 0x36, 0x10, 0xD8, 0x43, 0x71, 0x18, 0xFF, 0xC0,
  0xFE, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x3C, 0x01, 0xBF,
  0x00, 0xB0, 0xC0, 0xD8, 0x60, 0xCC, 0x30, 0xC6, 0x18, 0x43, 0x0C, 0x61,
  0x86, 0x60, 0xC7, 0x20, 0x3F, 0x30, 0x04, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x19, 0xF0, 0x19, 0xCC, 0x0C, 0xC3, 0x0C, 0x41, 0x8C, 0x20, 0xC4,
  0x10, 0x66, 0x08, 0x36, 0x06, 0x1A, 0x03, 0xFB, 0x00, 0xF8, 0x0F, 0x80,
  0x3F, 0xC0, 0xE1, 0x81, 0x81, 0x86, 0x03, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xB0, 0x0E, 0x70, 0x78, 0x61,
  0xB0, 0x63, 0x60, 0x6C, 0xC0, 0xF9, 0x80, 0xE3, 0x01, 0xC6, 0x03, 0xCE,
  0x0D, 0xCF, 0xF1, 0x8F, 0xC1, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0x83, 0xC3,
  0x83, 0x83, 0x81, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0,
  0x30, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x04, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0xC0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06,
  0x0E, 0x1E, 0x0E, 0x04, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x61, 0x87, 0xFC, 0x9F, 0x1E, 0xFC, 0x03, 0xC0, 0x01,
  0xC0, 0x03, 0x60, 0x06, 0x70, 0x0E, 0x30, 0x1C, 0x18, 0x18, 0x1C, 0x08,
  0x08, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x39, 0xDC, 0xE7, 0x33, 0x98, 0xC6, 0x00, 0xFF,
  0xFF, 0xF0, 0x27, 0xBF, 0xFF, 0x00, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x1D, 0xC0,
  0x6C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF1, 0xC7,
  0x8E, 0x3C, 0x71, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0xC0, 0x66, 0x07, 0x3F, 0xF0, 0x7F, 0x00, 0x07, 0x00, 0x3C, 0x01,
  0xF0, 0x1C, 0xC0, 0xE3, 0x03, 0x0C, 0x08, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x98, 0x06, 0x60, 0x1D, 0x80, 0x3E,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xF8, 0x0F, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x77, 0xFE, 0x1F, 0x80, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x33, 0x03, 0x60,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x7F, 0xF7, 0xFF, 0xB8, 0x01, 0xC0, 0x0E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC7, 0x86, 0xFF, 0x34, 0x1D, 0xC0, 0x6E,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xF0, 0x0F, 0x80,
  0x66, 0x07, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x6F, 0x03,
  0xFF, 0x1E, 0x0E, 0x70, 0x19, 0x80, 0x36, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x80, 0x36, 0x00, 0xD8, 0x07, 0x30, 0x38, 0xFF, 0xC0, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1B, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6C, 0x03, 0x60, 0x0F, 0x00,
  0xEC, 0x06, 0x60, 0x71, 0xC7, 0x07, 0xE0, 0x1F, 0x03, 0xDC, 0x38, 0x33,
  0x80, 0xD8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7E, 0x03, 0x3F,
  0xF0, 0x7F, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x0D,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xE0, 0x0D, 0x80, 0x36, 0x01, 0xDC, 0x0E,
  0x3F, 0xF8, 0x3E, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF7, 0xFE, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xF0, 0x79, 0xF7, 0xDE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0xE7, 0x1C, 0x71, 0x8E, 0x30, 0xC3, 0x00,
  0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x18,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x60, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x03, 0x00, 0x10, 0x00, 0xF8, 0x3F, 0xC0, 0x78, 0x07,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x38, 0xFC, 0x3E, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1E, 0x07, 0x80,
  0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0x63, 0x00, 0x66, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC1, 0xF7, 0x87, 0xFF, 0x0C, 0x1E, 0x18, 0x3C, 0x20,
  0x78, 0x40, 0xF0, 0x81, 0xE1, 0x03, 0xC2, 0x07, 0x86, 0x0F, 0x0C, 0x1E,
  0x1C, 0xFC, 0x1F, 0x78, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x34, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0x30, 0x06, 0x30, 0x0C, 0x60,
  0x10, 0xC0, 0x61, 0x80, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x0C, 0x1F,
  0xFC, 0x3F, 0xF8, 0xC0, 0x31, 0x80, 0x73, 0x00, 0x66, 0x00, 0xD8, 0x01,
  0xB0, 0x03, 0x80, 0xFE, 0x07, 0xFE, 0x30, 0x39, 0x80, 0x6C, 0x03, 0x60,
  0x0F, 0x00, 0x78, 0x07, 0xC0, 0x36, 0x03, 0xBF, 0xF9, 0xFF, 0x8C, 0x0F,
  0x60, 0x1B, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x07, 0x7F, 0xF3, 0xFF, 0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6C,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0xF0, 0x07,
  0xC0, 0x66, 0x07, 0x1F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xFE, 0x30, 0x79,
  0x80, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xB0, 0x0D, 0x80, 0xEC, 0x0E, 0x7F, 0xE3, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x3F, 0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xFF, 0xEF, 0xFF, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x00, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0, 0x6C, 0x03, 0xE0, 0x0F, 0x00,
  0x78, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x3F, 0xE1, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x66, 0x07, 0x1F,
  0xF0, 0x7F, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x30, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x76, 0x03, 0x1F, 0xF0, 0x7F, 0x00,
  0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xB0, 0x0C, 0xC0, 0x73, 0x01, 0x8C, 0x0E,
  0x30, 0x30, 0xC1, 0xC3, 0x06, 0x0F, 0xF8, 0x3F, 0xC0, 0xC1, 0x83, 0x06,
  0x0C, 0x1C, 0x30, 0x30, 0xC0, 0xE3, 0x01, 0x8C, 0x07, 0x30, 0x0C, 0xC0,
  0x3B, 0x00, 0x6C, 0x01, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x3F, 0x01, 0xE8, 0x1F, 0x60, 0xFB, 0x05,
  0xC8, 0x6F, 0x63, 0x7B, 0x13, 0xC9, 0x9E, 0x6C, 0xF3, 0x47, 0x8E, 0x3C,
  0x71, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x60, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03,
  0xD8, 0x3D, 0x83, 0xD8, 0x3C, 0xC3, 0xCC, 0x3C, 0x43, 0xC6, 0x3C, 0x63,
  0xC3, 0x3C, 0x33, 0xC3, 0x3C, 0x1B, 0xC1, 0xBC, 0x0B, 0xC0, 0xDC, 0x0D,
  0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x0F, 0x81, 0xFF, 0x1C, 0x18, 0xC0, 0x6C,
  0x03, 0x60, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0D,
  0xC0, 0x66, 0x07, 0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x8C, 0x07,
  0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x6C, 0x03, 0xBF, 0xFC, 0xFF, 0xE3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00,
  0x0F, 0x81, 0xFF, 0x1C, 0x19, 0xC0, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xC0, 0x66, 0x07, 0x1F, 0xF0,
  0x7F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0xFF, 0x03, 0xFF, 0x8C, 0x0F, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x6C, 0x01,
  0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x07, 0x3F, 0xF8, 0xFF, 0xC3, 0x06,
  0x0C, 0x18, 0x30, 0x30, 0xC0, 0xC3, 0x01, 0x8C, 0x06, 0x30, 0x0C, 0xC0,
  0x33, 0x00, 0xEC, 0x01, 0xC0, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06,
  0x60, 0x0D, 0x80, 0x36, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0F, 0x80,
  0x36, 0x00, 0xD8, 0x03, 0x70, 0x18, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03,
  0x60, 0x73, 0xFE, 0x1F, 0xC0, 0xC0, 0x07, 0x80, 0x1B, 0x80, 0x33, 0x00,
  0x66, 0x00, 0xCC, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x60,
  0x60, 0xC0, 0xC1, 0x81, 0x86, 0x03, 0x0C, 0x03, 0x18, 0x06, 0x30, 0x0C,
  0xC0, 0x1D, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xC1, 0xC1, 0xE0, 0xE0, 0xB0, 0x70, 0xD8, 0x28, 0x64, 0x14, 0x33,
  0x0A, 0x19, 0x8D, 0x0C, 0xC6, 0x86, 0x63, 0x63, 0x31, 0x31, 0x18, 0x98,
  0x8C, 0x44, 0xC2, 0x22, 0x61, 0xB1, 0x30, 0xD8, 0x98, 0x6C, 0x4C, 0x34,
  0x36, 0x1A, 0x1A, 0x0D, 0x0D, 0x06, 0x83, 0x83, 0xC1, 0xC0, 0xE0, 0xE0,
  0x70, 0x70, 0x60, 0x07, 0x30, 0x06, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x18,
  0x0C, 0x18, 0x0E, 0x30, 0x06, 0x30, 0x07, 0x60, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x30,
  0x0C, 0x18, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0xE0, 0x03,
  0xE0, 0x03, 0x60, 0x03, 0x70, 0x06, 0x30, 0x06, 0x38, 0x0C, 0x18, 0x0C,
  0x1C, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x03, 0x60,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xF7,
  0xFF, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0F, 0xE0, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x3F, 0xE0, 0x06, 0x00, 0x38, 0x03, 0xC0, 0x1B, 0x01, 0x98,
  0x0C, 0x60, 0x63, 0x06, 0x0C, 0x30, 0x63, 0x03, 0x18, 0x0D, 0x80, 0x70,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0F, 0xE0, 0xF7, 0x8C, 0x0E,
  0xE0, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x61, 0xFF, 0x3F, 0xFB, 0x80, 0xD8,
  0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0D, 0x80, 0xEF, 0xBF, 0x1F, 0xD8, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x3F, 0x1B, 0xBC,
  0xE0, 0x77, 0x01, 0xB0, 0x0D, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0xC0, 0x6E, 0x07, 0x6E, 0xF3, 0x3F,
  0x00, 0x1F, 0xC1, 0xFF, 0x18, 0x1D, 0xC0, 0x6C, 0x01, 0xE0, 0x0F, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x3C, 0x01, 0xF0, 0x19,
  0x81, 0xC7, 0xFC, 0x1F, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x1F, 0xB7, 0xDF, 0x60, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0x60,
  0x77, 0xFF, 0x1F, 0xB0, 0x1F, 0xC1, 0xEF, 0x18, 0x1D, 0xC0, 0x6C, 0x03,
  0x60, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xF0, 0x19, 0x81, 0xC7, 0xBC, 0x1F, 0xC0, 0x00, 0x7C, 0x0F, 0xF0,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x1F, 0xB7, 0xDF, 0x60, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x37, 0x0F, 0x3F, 0xB0,
  0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x73, 0xFE, 0x3F, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0xCD, 0xDE,
  0xE0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x03,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x3C, 0x07, 0x80, 0x60, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x03, 0xCF, 0xF1, 0xE0, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x01, 0xF0,
  0x0E, 0xC0, 0x73, 0x01, 0x8C, 0x0C, 0x30, 0x70, 0xC1, 0x83, 0xFC, 0x0F,
  0xF0, 0x30, 0xE0, 0xC1, 0xC3, 0x03, 0x0C, 0x0E, 0x30, 0x1C, 0xC0, 0x33,
  0x00, 0xEC, 0x01, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0xDE, 0x7B, 0x9E, 0x7E, 0x38, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C,
  0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3,
  0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0C, 0xCF, 0xCD, 0xDE, 0xE0,
  0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x1F, 0xC1,
  0xFF, 0x18, 0x1D, 0xC0, 0x6C, 0x03, 0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0x70, 0x19, 0x81, 0xC7, 0xFC,
  0x1F, 0xC0, 0xCF, 0xC6, 0xEF, 0x38, 0x1D, 0xC0, 0x6C, 0x03, 0x60, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0x70,
  0x1B, 0xC1, 0xDB, 0xBC, 0xCF, 0xC6, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x1F, 0xB7, 0xDF, 0x60, 0x7E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x03, 0x60, 0x77, 0xFF, 0x1F, 0xB0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0xDF, 0xCF, 0x9E, 0xE0, 0x6C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0xC3, 0xFF, 0x98, 0x0D, 0x80, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xE0, 0x0F, 0x80, 0xCF, 0xFE, 0x3F, 0xE0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0xFC, 0x07, 0xF0,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x03, 0x60, 0x73, 0xFE,
  0x1F, 0xC0, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0xD8, 0x06, 0x30, 0x18, 0xC0,
  0x63, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x61, 0x80, 0xC6, 0x03, 0x18, 0x0C,
  0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xE0, 0x03, 0x80, 0xC1, 0x83, 0x61, 0xC3,
  0x61, 0xC3, 0x61, 0x43, 0x63, 0x42, 0x63, 0x42, 0x62, 0x46, 0x22, 0x66,
  0x32, 0x66, 0x32, 0x26, 0x36, 0x24, 0x36, 0x24, 0x34, 0x3C, 0x14, 0x3C,
  0x14, 0x3C, 0x1C, 0x1C, 0x1C, 0x18, 0xE0, 0x1C, 0xE0, 0x30, 0xC0, 0xE0,
  0xC1, 0x81, 0xC6, 0x01, 0x98, 0x01, 0xB0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1B, 0x00, 0x63, 0x01, 0x86, 0x07, 0x06, 0x0C, 0x06, 0x30, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0D, 0x80, 0x36, 0x01, 0xCC, 0x06, 0x30, 0x18, 0xE0,
  0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xCE, 0x01, 0xB0, 0x06,
  0xC0, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x78, 0x0F, 0xC0, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x83, 0xF8, 0x1F,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xE0, 0xFF, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x3C, 0x0D, 0xF8, 0x36, 0x30,
  0xF0, 0xE3, 0xC1, 0xFF, 0x01, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraLight31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 4, 23, 19, 7, -23 },
  { 13, 9, 10, 19, 5, -23 },
  { 25, 17, 23, 19, 1, -23 },
  { 74, 14, 31, 19, 2, -27 },
  { 129, 17, 23, 19, 1, -23 },
  { 178, 15, 23, 19, 2, -23 },
  { 222, 2, 10, 19, 8, -23 },
  { 225, 9, 30, 19, 6, -26 },
  { 259, 9, 30, 19, 4, -26 },
  { 293, 16, 16, 19, 1, -19 },
  { 325, 14, 15, 19, 2, -18 },
  { 352, 5, 10, 19, 6, -5 },
  { 359, 10, 2, 19, 4, -11 },
  { 362, 5, 5, 19, 7, -5 },
  { 366, 13, 29, 19, 3, -26 },
  { 414, 13, 23, 19, 3, -23 },
  { 452, 14, 23, 19, 3, -23 },
  { 493, 14, 23, 19, 2, -23 },
  { 534, 12, 23, 19, 3, -23 },
  { 569, 12, 23, 19, 3, -23 },
  { 604, 13, 23, 19, 3, -23 },
  { 642, 14, 23, 19, 2, -23 },
  { 683, 13, 23, 19, 3, -23 },
  { 721, 13, 23, 19, 3, -23 },
  { 759, 14, 23, 19, 2, -23 },
  { 800, 5, 17, 19, 7, -17 },
  { 811, 6, 22, 19, 6, -17 },
  { 828, 13, 16, 19, 3, -18 },
  { 854, 13, 9, 19, 3, -15 },
  { 869, 13, 16, 19, 3, -18 },
  { 895, 10, 23, 19, 5, -23 },
  { 924, 15, 29, 19, 2, -23 },
  { 979, 15, 23, 19, 2, -23 },
  { 1023, 13, 23, 19, 3, -23 },
  { 1061, 13, 23, 19, 3, -23 },
  { 1099, 13, 23, 19, 3, -23 },
  { 1137, 13, 23, 19, 3, -23 },
  { 1175, 13, 23, 19, 3, -23 },
  { 1213, 13, 23, 19, 3, -23 },
  { 1251, 12, 23, 19, 3, -23 },
  { 1286, 11, 23, 19, 4, -23 },
  { 1318, 13, 23, 19, 2, -23 },
  { 1356, 14, 23, 19, 3, -23 },
  { 1397, 12, 23, 19, 4, -23 },
  { 1432, 13, 23, 19, 3, -23 },
  { 1470, 12, 23, 19, 3, -23 },
  { 1505, 13, 23, 19, 3, -23 },
  { 1543, 14, 23, 19, 3, -23 },
  { 1584, 13, 29, 19, 3, -23 },
  { 1632, 14, 23, 19, 3, -23 },
  { 1673, 14, 23, 19, 2, -23 },
  { 1714, 15, 23, 19, 2, -23 },
  { 1758, 12, 23, 19, 3, -23 },
  { 1793, 15, 23, 19, 2, -23 },
  { 1837, 17, 23, 19, 1, -23 },
  { 1886, 16, 23, 19, 1, -23 },
  { 1932, 16, 23, 19, 1, -23 },
  { 1978, 13, 23, 19, 3, -23 },
  { 2016, 7, 29, 19, 7, -26 },
  { 2042, 13, 29, 19, 3, -26 },
  { 2090, 7, 29, 19, 5, -26 },
  { 2116, 13, 12, 19, 3, -23 },
  { 2136, 15, 2, 19, 2, 1 },
  { 2140, 6, 4, 19, 6, -24 },
  { 2143, 13, 17, 19, 2, -17 },
  { 2171, 13, 23, 19, 3, -23 },
  { 2209, 13, 17, 19, 3, -17 },
  { 2237, 12, 23, 19, 3, -23 },
  { 2272, 13, 17, 19, 3, -17 },
  { 2300, 14, 23, 19, 2, -23 },
  { 2341, 12, 23, 19, 3, -17 },
  { 2376, 12, 23, 19, 3, -23 },
  { 2411, 14, 24, 19, 3, -24 },
  { 2453, 11, 30, 19, 3, -24 },
  { 2495, 14, 23, 19, 3, -23 },
  { 2536, 16, 23, 19, 1, -23 },
  { 2582, 14, 17, 19, 2, -17 },
  { 2612, 12, 17, 19, 3, -17 },
  { 2638, 13, 17, 19, 3, -17 },
  { 2666, 13, 23, 19, 3, -17 },
  { 2704, 12, 23, 19, 3, -17 },
  { 2739, 12, 17, 19, 4, -17 },
  { 2765, 13, 17, 19, 3, -17 },
  { 2793, 14, 22, 19, 2, -22 },
  { 2832, 12, 17, 19, 3, -17 },
  { 2858, 14, 17, 19, 2, -17 },
  { 2888, 16, 17, 19, 1, -17 },
  { 2922, 15, 17, 19, 2, -17 },
  { 2954, 14, 23, 19, 2, -17 },
  { 2995, 13, 17, 19, 3, -17 },
  { 3023, 13, 29, 19, 3, -26 },
  { 3071, 2, 29, 19, 8, -26 },
  { 3079, 13, 29, 19, 3, -26 },
  { 3127, 14, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_ExtraLight31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_EXTRALIGHT31PT7B_H_
