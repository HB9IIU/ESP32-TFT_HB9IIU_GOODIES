#ifndef _JETBRAINSMONO_EXTRALIGHT22PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight22pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x00, 0x3F, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0x80, 0x08, 0x41, 0x08, 0x61, 0x0C, 0x67, 0xFE, 0xFF, 0xC4, 0x20, 0x84,
  0x31, 0x84, 0x23, 0xFF, 0x90, 0x82, 0x10, 0xC6, 0x10, 0xC2, 0x10, 0x08,
  0x04, 0x02, 0x07, 0xE6, 0x9E, 0x4F, 0x23, 0x90, 0x48, 0x34, 0x0F, 0x01,
  0xE0, 0x98, 0x44, 0x23, 0x11, 0xC8, 0xB4, 0xCF, 0xC1, 0x00, 0x80, 0x40,
  0x78, 0x1A, 0x21, 0x91, 0x08, 0x88, 0x84, 0x4C, 0x22, 0x41, 0xF4, 0x00,
  0x60, 0x02, 0x00, 0x27, 0x82, 0x44, 0x12, 0x31, 0x11, 0x90, 0x8D, 0x84,
  0x58, 0x1E, 0x1F, 0x06, 0x31, 0x86, 0x30, 0x02, 0x00, 0x60, 0x04, 0x03,
  0xC0, 0x4C, 0x78, 0xCB, 0x0B, 0x61, 0xCC, 0x19, 0x83, 0x99, 0x91, 0xE3,
  0xFE, 0x0E, 0x30, 0xC3, 0x04, 0x08, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x10, 0x20, 0x60, 0x60, 0x60, 0x70, 0x20, 0xC1, 0x83, 0x06, 0x08,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC2, 0x18, 0x47, 0x30, 0x80,
  0x04, 0x00, 0x80, 0x10, 0x62, 0x37, 0x5E, 0x1C, 0x02, 0x80, 0xD8, 0x11,
  0x86, 0x38, 0x82, 0x00, 0x08, 0x02, 0x00, 0x80, 0x20, 0xFF, 0xC2, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x76, 0x64, 0xCC, 0x80, 0xFE, 0xFF, 0x80,
  0x01, 0x80, 0xC0, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08, 0x0C, 0x06, 0x02,
  0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x10, 0x18, 0x00, 0x3E,
  0x31, 0xB0, 0x78, 0x18, 0x0C, 0x06, 0x03, 0x39, 0x8C, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x0D, 0x8C, 0x7C, 0x1C, 0x0D, 0x06, 0x42, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x43,
  0xFF, 0x3E, 0x18, 0xCC, 0x1A, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x03, 0xFF, 0xFF, 0x80, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x78, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x38, 0x1E,
  0x0D, 0x8C, 0x7C, 0x03, 0x03, 0x01, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x43,
  0x61, 0xE0, 0xE0, 0x7F, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x7F, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x63, 0xFD, 0xC3, 0xC1, 0x80, 0x40, 0x20, 0x1C, 0x0E,
  0x0D, 0x8C, 0x7C, 0x06, 0x06, 0x02, 0x03, 0x03, 0x01, 0x01, 0xB8, 0xEE,
  0xC1, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x0D, 0x8C, 0x7C, 0xFF, 0xE0, 0x38,
  0x0A, 0x06, 0x01, 0x00, 0x40, 0x30, 0x08, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x08, 0x06, 0x01, 0x80, 0xC0, 0x3E, 0x31, 0xB0, 0x78, 0x1C, 0x0A, 0x0C,
  0xCC, 0x38, 0x36, 0x30, 0xB0, 0x70, 0x18, 0x0E, 0x05, 0x8E, 0x7E, 0x3E,
  0x31, 0xB0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x83, 0x77, 0x8D, 0x80, 0x80,
  0xC0, 0x40, 0x60, 0x60, 0x60, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x77, 0x70,
  0x00, 0x00, 0x07, 0x66, 0x44, 0xC8, 0x00, 0x80, 0xC1, 0x83, 0x87, 0x06,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x20, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x04, 0x06, 0x0C, 0x18,
  0x38, 0x30, 0x00, 0xFC, 0x0E, 0x03, 0x03, 0x03, 0x03, 0x02, 0x0E, 0x38,
  0x20, 0x20, 0x00, 0x00, 0x00, 0x70, 0x70, 0x1F, 0x86, 0x19, 0x81, 0xA0,
  0x1C, 0x03, 0x86, 0x71, 0xBE, 0x61, 0xCC, 0x39, 0x87, 0x30, 0xE6, 0x1C,
  0xC3, 0x8C, 0xF0, 0xEE, 0x00, 0x40, 0x0C, 0x00, 0xE0, 0x07, 0x80, 0x06,
  0x01, 0xC0, 0x28, 0x05, 0x81, 0xB0, 0x32, 0x04, 0x40, 0x8C, 0x31, 0x84,
  0x10, 0xFE, 0x1F, 0xE6, 0x0C, 0x80, 0x90, 0x16, 0x03, 0xFE, 0x61, 0xB0,
  0x78, 0x1C, 0x0E, 0x0F, 0x05, 0xFC, 0xC3, 0x60, 0xF0, 0x38, 0x1C, 0x0E,
  0x0F, 0x0F, 0xFC, 0x3E, 0x30, 0xB0, 0x78, 0x1C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x0D, 0x8C, 0x7C, 0xFE, 0x63, 0xB0,
  0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E,
  0x0F, 0x1D, 0xF8, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF, 0xB0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x3E, 0x30, 0xB0, 0x78, 0x1C, 0x06, 0x03,
  0x01, 0x80, 0xCF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0D, 0x8C, 0x7C, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x0F, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xC0, 0xD0, 0x26, 0x18, 0xFC, 0xC0, 0xF0, 0x6C, 0x1B, 0x0C, 0xC3, 0x31,
  0x8C, 0x63, 0xF0, 0xC4, 0x31, 0x8C, 0x23, 0x0C, 0xC1, 0x30, 0x6C, 0x0B,
  0x03, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0xFF, 0xC1, 0xE0, 0xE8, 0xF4, 0x5B,
  0x2C, 0xB6, 0x53, 0x39, 0x8C, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xC0, 0xF0, 0x78, 0x3E, 0x1D, 0x0E, 0x87, 0x63, 0x91, 0xC8, 0xE2,
  0x71, 0x38, 0xDC, 0x2E, 0x17, 0x0F, 0x83, 0x3E, 0x31, 0xB0, 0x78, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0D, 0x8C,
  0x7C, 0xFF, 0x30, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x06, 0xFF,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x3E, 0x31, 0xB0,
  0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x0D, 0x8C, 0x7C, 0x02, 0x01, 0x80, 0x40, 0x30, 0xFE, 0x30, 0xEC, 0x0B,
  0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0x0E, 0xFE, 0x31, 0x8C, 0x63, 0x0C, 0xC3,
  0x30, 0x6C, 0x1B, 0x03, 0x3F, 0x30, 0xF0, 0x78, 0x1C, 0x02, 0x01, 0x80,
  0x78, 0x07, 0x00, 0xC0, 0x20, 0x18, 0x0E, 0x05, 0x86, 0x7E, 0xFF, 0xE0,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E, 0x0D,
  0x8C, 0x7C, 0xC0, 0x68, 0x09, 0x81, 0x30, 0x62, 0x0C, 0x41, 0x0C, 0x21,
  0x8C, 0x11, 0x82, 0x20, 0x64, 0x0D, 0x80, 0xA0, 0x14, 0x03, 0x80, 0x70,
  0x86, 0x30, 0xC6, 0x28, 0xE5, 0x1C, 0xA3, 0x94, 0xD2, 0x9A, 0x53, 0x49,
  0x49, 0x29, 0x45, 0x28, 0xA7, 0x14, 0xE2, 0x8C, 0x71, 0x8E, 0xC0, 0x6C,
  0x18, 0x82, 0x18, 0xC1, 0x10, 0x36, 0x03, 0x80, 0x30, 0x0E, 0x01, 0x40,
  0x64, 0x08, 0xC3, 0x08, 0xC1, 0x90, 0x16, 0x03, 0xC0, 0x68, 0x09, 0x83,
  0x10, 0x43, 0x08, 0x22, 0x06, 0x40, 0x58, 0x0E, 0x00, 0xC0, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0xFF, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0xFF,
  0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0xF0, 0xC0, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x01, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30,
  0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43,
  0xF0, 0x0C, 0x0E, 0x05, 0x86, 0x42, 0x23, 0x19, 0x05, 0x83, 0xC0, 0x80,
  0xFF, 0xE0, 0xE2, 0x30, 0x3E, 0x30, 0xB0, 0x60, 0x10, 0x09, 0xFF, 0x03,
  0x01, 0x80, 0xC0, 0xF0, 0xAF, 0x90, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xF7,
  0x0B, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x8D, 0xBC,
  0x3F, 0x30, 0xB0, 0x78, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0xD8,
  0xC7, 0xC0, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xFB, 0x1F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0x8E, 0x7B, 0x3E, 0x30, 0xB0, 0x78,
  0x1C, 0x0F, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0xD8, 0xC7, 0xC0, 0x07, 0xE1,
  0x80, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x3F, 0xB1, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xB1, 0xCF, 0x60, 0x30, 0x18, 0x0C,
  0x0C, 0x7C, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xF7, 0x0B, 0x07, 0x83, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x0C, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xC0, 0x07, 0x07, 0x02, 0x00, 0x00, 0x7E,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x06, 0x0C, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF0, 0x6C, 0x33,
  0x08, 0xC6, 0x3F, 0x0C, 0x43, 0x18, 0xC3, 0x30, 0x4C, 0x1B, 0x03, 0xF8,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x3F, 0xFB, 0xA3, 0x28,
  0x8E, 0x23, 0x88, 0xE2, 0x38, 0x8E, 0x23, 0x88, 0xE2, 0x38, 0x8E, 0x23,
  0xDF, 0x71, 0xB0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x10, 0x3E, 0x31, 0xB0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xD8, 0xC7, 0xC0, 0xDF, 0x70, 0xB0, 0x78, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xF8, 0xDB, 0xCC, 0x06, 0x03, 0x01, 0x80, 0x3F, 0xB1,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xD8, 0xE7, 0xB0,
  0x18, 0x0C, 0x06, 0x03, 0xBE, 0x61, 0xA0, 0x50, 0x38, 0x1C, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x00, 0x7F, 0x30, 0xF0, 0x38, 0x06, 0x03,
  0xF0, 0x1E, 0x03, 0x00, 0xE0, 0x58, 0x67, 0xE0, 0x08, 0x02, 0x00, 0x80,
  0x20, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0xC0, 0x1F, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xD8, 0xC7, 0xC0, 0xC0, 0x6C, 0x09, 0x83, 0x10, 0x43,
  0x08, 0x63, 0x04, 0x40, 0xC8, 0x1B, 0x01, 0x40, 0x38, 0x07, 0x00, 0x84,
  0x38, 0xC7, 0x28, 0xA5, 0x34, 0xA4, 0x94, 0x92, 0x53, 0x4A, 0x71, 0x46,
  0x38, 0xC6, 0x18, 0xC0, 0x60, 0xE4, 0x10, 0xC6, 0x0D, 0x80, 0xA0, 0x0C,
  0x03, 0x80, 0x58, 0x11, 0x06, 0x31, 0x83, 0x60, 0x30, 0xC0, 0x6C, 0x08,
  0x83, 0x10, 0x43, 0x18, 0x23, 0x06, 0x40, 0x58, 0x0A, 0x01, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0xFF, 0x80, 0xC0, 0xC0, 0xC0,
  0x40, 0x60, 0x60, 0x60, 0x20, 0x30, 0x30, 0x1F, 0xF0, 0x07, 0x83, 0x03,
  0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x7C, 0x3E, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x0C, 0x06, 0x01, 0x00, 0xF0, 0xFF, 0xFF, 0xF0, 0xF0,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x07, 0xC3, 0xE3,
  0x01, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1E, 0x00, 0x70, 0xF6,
  0x38, 0xCA, 0x1E,
};

const GFXglyph JetBrainsMono_ExtraLight22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 6, 7, 13, 4, -16 },
  { 13, 11, 16, 13, 1, -16 },
  { 35, 9, 22, 13, 2, -19 },
  { 60, 13, 16, 13, 0, -16 },
  { 86, 11, 16, 13, 1, -16 },
  { 108, 1, 7, 13, 6, -16 },
  { 109, 7, 21, 13, 4, -18 },
  { 128, 6, 21, 13, 3, -18 },
  { 144, 11, 11, 13, 1, -13 },
  { 160, 10, 10, 13, 2, -12 },
  { 173, 4, 7, 13, 4, -3 },
  { 177, 7, 1, 13, 3, -8 },
  { 178, 3, 3, 13, 5, -3 },
  { 180, 9, 20, 13, 2, -18 },
  { 203, 9, 16, 13, 2, -16 },
  { 221, 10, 16, 13, 2, -16 },
  { 241, 10, 16, 13, 2, -16 },
  { 261, 9, 16, 13, 2, -16 },
  { 279, 9, 16, 13, 2, -16 },
  { 297, 9, 16, 13, 2, -16 },
  { 315, 9, 16, 13, 2, -16 },
  { 333, 10, 16, 13, 2, -16 },
  { 353, 9, 16, 13, 2, -16 },
  { 371, 9, 16, 13, 2, -16 },
  { 389, 3, 12, 13, 5, -12 },
  { 394, 4, 16, 13, 4, -12 },
  { 402, 9, 11, 13, 2, -13 },
  { 415, 9, 6, 13, 2, -10 },
  { 422, 9, 11, 13, 2, -13 },
  { 435, 8, 16, 13, 3, -16 },
  { 451, 11, 20, 13, 1, -16 },
  { 479, 11, 16, 13, 1, -16 },
  { 501, 9, 16, 13, 2, -16 },
  { 519, 9, 16, 13, 2, -16 },
  { 537, 9, 16, 13, 2, -16 },
  { 555, 9, 16, 13, 2, -16 },
  { 573, 10, 16, 13, 2, -16 },
  { 593, 9, 16, 13, 2, -16 },
  { 611, 9, 16, 13, 2, -16 },
  { 629, 8, 16, 13, 3, -16 },
  { 645, 10, 16, 13, 1, -16 },
  { 665, 10, 16, 13, 2, -16 },
  { 685, 9, 16, 13, 3, -16 },
  { 703, 9, 16, 13, 2, -16 },
  { 721, 9, 16, 13, 2, -16 },
  { 739, 9, 16, 13, 2, -16 },
  { 757, 10, 16, 13, 2, -16 },
  { 777, 9, 20, 13, 2, -16 },
  { 800, 10, 16, 13, 2, -16 },
  { 820, 9, 16, 13, 2, -16 },
  { 838, 11, 16, 13, 1, -16 },
  { 860, 9, 16, 13, 2, -16 },
  { 878, 11, 16, 13, 1, -16 },
  { 900, 11, 16, 13, 1, -16 },
  { 922, 11, 16, 13, 1, -16 },
  { 944, 11, 16, 13, 1, -16 },
  { 966, 9, 16, 13, 2, -16 },
  { 984, 5, 20, 13, 5, -18 },
  { 997, 9, 20, 13, 2, -18 },
  { 1020, 5, 20, 13, 3, -18 },
  { 1033, 9, 9, 13, 2, -16 },
  { 1044, 11, 1, 13, 1, 1 },
  { 1046, 4, 3, 13, 4, -17 },
  { 1048, 9, 12, 13, 2, -12 },
  { 1062, 9, 16, 13, 2, -16 },
  { 1080, 9, 12, 13, 2, -12 },
  { 1094, 9, 16, 13, 2, -16 },
  { 1112, 9, 12, 13, 2, -12 },
  { 1126, 11, 16, 13, 1, -16 },
  { 1148, 9, 16, 13, 2, -12 },
  { 1166, 9, 16, 13, 2, -16 },
  { 1184, 10, 17, 13, 2, -17 },
  { 1206, 8, 21, 13, 2, -17 },
  { 1227, 10, 16, 13, 2, -16 },
  { 1247, 11, 16, 13, 1, -16 },
  { 1269, 10, 12, 13, 2, -12 },
  { 1284, 9, 12, 13, 2, -12 },
  { 1298, 9, 12, 13, 2, -12 },
  { 1312, 9, 16, 13, 2, -12 },
  { 1330, 9, 16, 13, 2, -12 },
  { 1348, 9, 12, 13, 3, -12 },
  { 1362, 9, 12, 13, 2, -12 },
  { 1376, 10, 16, 13, 1, -16 },
  { 1396, 9, 12, 13, 2, -12 },
  { 1410, 11, 12, 13, 1, -12 },
  { 1427, 11, 12, 13, 1, -12 },
  { 1444, 11, 12, 13, 1, -12 },
  { 1461, 11, 16, 13, 1, -12 },
  { 1483, 9, 12, 13, 2, -12 },
  { 1497, 9, 20, 13, 2, -18 },
  { 1520, 1, 20, 13, 6, -18 },
  { 1523, 9, 20, 13, 2, -18 },
  { 1546, 10, 4, 13, 2, -10 },
};

const GFXfont JetBrainsMono_ExtraLight22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_EXTRALIGHT22PT7B_H_
