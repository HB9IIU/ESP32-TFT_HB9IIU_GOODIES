#ifndef _JETBRAINSMONO_EXTRALIGHT51PT7B_H_
#define _JETBRAINSMONO_EXTRALIGHT51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraLight.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraLight51pt7bBitmaps[] PROGMEM = {
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x7D, 0xFF, 0xFF, 0xF7, 0xC0, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01,
  0xC0, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x38, 0x03, 0x00, 0x06, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0C, 0x00, 0x1C, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x0C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70,
  0x07, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x18, 0x00, 0x30, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x70, 0x00,
  0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x60, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0x77, 0xE0, 0x78,
  0xE3, 0xE1, 0xE1, 0xC3, 0xC3, 0x83, 0x83, 0x8F, 0x07, 0x07, 0x9E, 0x0E,
  0x07, 0x38, 0x1C, 0x0E, 0x78, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0,
  0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0xE7, 0x00, 0x07, 0xEE, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xDF, 0x80, 0x03, 0x8F, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x0F, 0x00,
  0x1C, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x3B, 0x80, 0xE0, 0x7F, 0x01,
  0xC0, 0xEF, 0x03, 0x81, 0xDE, 0x07, 0x03, 0x9E, 0x0E, 0x0F, 0x3E, 0x1C,
  0x3C, 0x3E, 0x38, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x79, 0xFF, 0x80, 0x03, 0x1E, 0x1E, 0x00, 0x38, 0xE0, 0x70, 0x03, 0x86,
  0x01, 0xC0, 0x18, 0x70, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x1C, 0x1C, 0x03,
  0x81, 0xC0, 0xE0, 0x1C, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x07, 0x0E,
  0x00, 0xC0, 0x38, 0x70, 0x07, 0x03, 0x87, 0x00, 0x3C, 0x3C, 0x70, 0x00,
  0xFF, 0xC3, 0x00, 0x03, 0xFC, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x0E, 0x3F, 0xE0, 0x00, 0xE3, 0xFF, 0x80, 0x0E, 0x1C, 0x1E,
  0x00, 0x61, 0xC0, 0x70, 0x07, 0x0E, 0x03, 0x80, 0x70, 0x70, 0x1C, 0x03,
  0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x38, 0x07,
  0x01, 0xC1, 0xC0, 0x38, 0x0E, 0x1C, 0x01, 0xC0, 0x71, 0xC0, 0x0F, 0x07,
  0x8E, 0x00, 0x3E, 0xF8, 0xE0, 0x00, 0xFF, 0x8E, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x07, 0x00, 0x70,
  0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x78, 0x78, 0x07, 0xBC, 0x0F, 0x01, 0xCF,
  0x03, 0xC0, 0xF3, 0xC0, 0x78, 0x38, 0xE0, 0x0F, 0x1E, 0x38, 0x01, 0xE7,
  0x0E, 0x00, 0x7B, 0x83, 0x80, 0x0F, 0xE0, 0xE0, 0x01, 0xF0, 0x38, 0x00,
  0x3C, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xE0, 0xF0, 0x03, 0xFC, 0x1C,
  0x01, 0xE7, 0x07, 0x80, 0xF9, 0xE0, 0xFF, 0xFC, 0x3C, 0x1F, 0xFC, 0x07,
  0x83, 0xFE, 0x00, 0xF0, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x77, 0x70, 0x00, 0x02, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x06, 0x80,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x0F,
  0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x02, 0x00, 0x70, 0x02, 0x70, 0x0E,
  0x03, 0xDF, 0xC1, 0xC1, 0xFB, 0xFE, 0x39, 0xFF, 0x9F, 0xF6, 0x7F, 0x80,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xD8,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1F,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0x40, 0x02, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xF1, 0xFC, 0x3E, 0x01, 0xF0, 0xF0, 0x01, 0xE7, 0x80,
  0x07, 0x9E, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x10, 0x1F, 0xC1, 0xF0, 0x7F, 0x07, 0xC1, 0xFC, 0x1F,
  0x07, 0xF0, 0x7C, 0x1F, 0xC0, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70,
  0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00,
  0x78, 0xF0, 0x03, 0xE3, 0xF0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x1F, 0x3C, 0x01, 0xF0, 0xF0, 0x0F, 0x83,
  0xC0, 0x3C, 0x0F, 0x00, 0xC0, 0x3C, 0x02, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFC, 0x3F, 0x83,
  0xC0, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x01, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0xF1, 0xF0, 0x0F, 0x87, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x71, 0xE0, 0x07, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x78, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0xFF, 0x81, 0xDF, 0xFF, 0x0E, 0xFF, 0xFC, 0x7E, 0x03, 0xE3,
  0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xDE, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xE0, 0x1F, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x0F, 0x7F, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0x07, 0xE1, 0xF8,
  0x03, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0x78, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0x9C, 0x00, 0x0F,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x7C, 0x03, 0xE0, 0x7F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xF1, 0xF8, 0x1E, 0x00, 0xF0, 0xF0, 0x01,
  0xE3, 0x80, 0x03, 0x9E, 0x00, 0x0E, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x03, 0xDE, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xF0, 0x01, 0xE1, 0xE0,
  0x0F, 0x03, 0xC0, 0x78, 0x07, 0xC7, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x07, 0xEF, 0x80, 0x3C, 0x0F, 0x81, 0xE0, 0x0F, 0x0F,
  0x00, 0x1E, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xF7, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x0F,
  0x78, 0x00, 0x3D, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x87, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFC, 0x3F, 0x03, 0xE0, 0x0F, 0x07, 0x80,
  0x0F, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x79,
  0xF0, 0x01, 0xE1, 0xF0, 0x07, 0xC1, 0xFC, 0x7F, 0x81, 0xFF, 0xFE, 0x01,
  0xFF, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x08, 0x7E,
  0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0x7F, 0xFF,
  0xFF, 0x7F, 0x7E, 0x08, 0x02, 0x07, 0xE1, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1,
  0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7F, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xF8, 0x1F, 0x81, 0xF0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0x1F, 0x80, 0x3F,
  0xCF, 0xC0, 0x3F, 0xF7, 0xE0, 0x3E, 0x0F, 0xF0, 0x1C, 0x03, 0xF8, 0x0E,
  0x00, 0xFC, 0x0F, 0x00, 0x7E, 0x07, 0x80, 0x3F, 0x03, 0xC0, 0x1F, 0x81,
  0xE0, 0x0F, 0xC0, 0xF0, 0x07, 0xE0, 0x78, 0x03, 0xF0, 0x3C, 0x01, 0xF8,
  0x1E, 0x00, 0xFC, 0x0F, 0x00, 0x7E, 0x07, 0x80, 0x3F, 0x01, 0xC0, 0x1F,
  0x80, 0xE0, 0x1F, 0xC0, 0x78, 0x1F, 0xE0, 0x1F, 0xBF, 0xF0, 0x0F, 0xFD,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xE3, 0x80, 0x01, 0xE3, 0x80, 0x01,
  0xC3, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x81, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x07,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x0E,
  0x00, 0x78, 0x0E, 0x00, 0x38, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0x70,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03,
  0xCF, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0xC0, 0x03, 0xCF, 0x00,
  0x1E, 0x3C, 0x00, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3C, 0x01, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xBC,
  0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E,
  0xF0, 0x00, 0xF3, 0xC0, 0x1F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0x1F,
  0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0, 0x07, 0x8F, 0x80, 0x78, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x78, 0x00,
  0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0x78, 0x00, 0x3B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x03, 0xE7,
  0x80, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCE, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0x1F,
  0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0, 0x07, 0x8F, 0x80, 0x78, 0x3F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9E,
  0x00, 0x1E, 0x7C, 0x00, 0xF0, 0xF8, 0x07, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0x80, 0xE0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x06, 0xFB, 0x00, 0x3B, 0xEE, 0x00, 0xFF, 0xB8, 0x03,
  0x7E, 0x60, 0x1D, 0xF9, 0xC0, 0x77, 0xE7, 0x01, 0x9F, 0x8C, 0x0E, 0x7E,
  0x38, 0x39, 0xF8, 0xE0, 0xC7, 0xF1, 0x87, 0x1F, 0xC7, 0x1C, 0x7F, 0x1C,
  0x61, 0xFC, 0x3B, 0x87, 0xF0, 0xEE, 0x1F, 0xC3, 0xB0, 0x7F, 0x07, 0xC1,
  0xFC, 0x1F, 0x07, 0xF0, 0x38, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1C, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xEE, 0x00, 0x7E, 0xE0, 0x07, 0xEE, 0x00, 0x7E, 0x70, 0x07, 0xE7, 0x00,
  0x7E, 0x70, 0x07, 0xE3, 0x80, 0x7E, 0x38, 0x07, 0xE1, 0xC0, 0x7E, 0x1C,
  0x07, 0xE1, 0xC0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0x7E, 0x0F, 0x07, 0xE0,
  0x70, 0x7E, 0x07, 0x07, 0xE0, 0x38, 0x7E, 0x03, 0x87, 0xE0, 0x38, 0x7E,
  0x01, 0xC7, 0xE0, 0x1C, 0x7E, 0x00, 0xE7, 0xE0, 0x0E, 0x7E, 0x00, 0xE7,
  0xE0, 0x07, 0x7E, 0x00, 0x77, 0xE0, 0x07, 0x7E, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0x1F, 0x83, 0xC0, 0x1E,
  0x3C, 0x00, 0x79, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xDE, 0x00, 0x0E, 0x70,
  0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0x80, 0x0F, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00,
  0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0xF9, 0xE0, 0x07, 0xE3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7E, 0x1F, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x03, 0xDE,
  0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0E, 0x70, 0x00, 0xF3, 0xC0, 0x0F, 0x8F, 0x00,
  0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0xBC, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xFB, 0xC0,
  0x01, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x01, 0xF3, 0xC0, 0x3F, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0xF0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFE, 0x3F, 0x81, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xEE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0E, 0x78,
  0x00, 0x3C, 0xF8, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0x77, 0x80, 0x0F,
  0x78, 0x01, 0xE3, 0xC0, 0x3E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x02, 0x00, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x1E,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x1E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x78,
  0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x07, 0x80, 0xE0,
  0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0xC1, 0xC0,
  0x03, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0xC0, 0x01, 0xE3, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xF7, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xE0, 0x1E, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0x7C, 0x07, 0xF0, 0x0D, 0x80, 0xEE, 0x01, 0xB0, 0x1D, 0xE0,
  0x36, 0x03, 0x9C, 0x06, 0xC0, 0x73, 0x81, 0xD8, 0x0E, 0x70, 0x3B, 0x81,
  0xCE, 0x07, 0x70, 0x39, 0xC0, 0xCE, 0x07, 0x38, 0x18, 0xC1, 0xC7, 0x03,
  0x18, 0x38, 0xE0, 0x63, 0x07, 0x0E, 0x0C, 0x60, 0xE1, 0xC3, 0x8C, 0x1C,
  0x38, 0x71, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x30,
  0x61, 0x83, 0x86, 0x0C, 0x70, 0x70, 0xC1, 0x8E, 0x0F, 0x38, 0x31, 0xC0,
  0xE7, 0x06, 0x38, 0x1C, 0xC0, 0xE7, 0x03, 0x98, 0x1C, 0xE0, 0x73, 0x03,
  0x9C, 0x0E, 0x60, 0x33, 0x01, 0xCC, 0x06, 0x60, 0x3B, 0x80, 0xDC, 0x07,
  0x70, 0x1B, 0x80, 0x7C, 0x03, 0x70, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x38,
  0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x03, 0xC0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0x87, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x3C, 0x00,
  0x3C, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0F,
  0x00, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x38, 0xF0, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0x78, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0x80,
  0x0F, 0x01, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0x87, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xCF, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xE0,
  0x07, 0x07, 0x00, 0x78, 0x38, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0,
  0x3C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xF3,
  0x80, 0x03, 0xBC, 0x00, 0x1D, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0,
  0x78, 0x1E, 0x00, 0x10, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xDF,
  0xC1, 0xE0, 0x0F, 0x1E, 0x00, 0x3C, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7C, 0x00, 0x3B, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFB, 0xE0, 0x0F, 0xCF, 0xE3,
  0xEE, 0x3F, 0xFE, 0x70, 0xFF, 0xC3, 0x80, 0x60, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x10, 0x07, 0x8F, 0xF8, 0x3D,
  0xFF, 0xE1, 0xEF, 0x1F, 0x8F, 0xC0, 0x1E, 0x7C, 0x00, 0x7B, 0xE0, 0x03,
  0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7,
  0xE0, 0x1F, 0x3D, 0xE7, 0xF1, 0xEF, 0xFF, 0x0F, 0x1F, 0xF0, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83,
  0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x01, 0xDE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xEE, 0x00, 0x0E, 0x78, 0x00, 0xF1, 0xF0, 0x1F, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x40, 0x70, 0x7F, 0xC7, 0x1F, 0xFE, 0x73,
  0xF8, 0xF7, 0x3C, 0x03, 0xF7, 0x80, 0x1F, 0x70, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xF3, 0xC0, 0x3F, 0x3F, 0x9F, 0x71,
  0xFF, 0xE7, 0x07, 0xFC, 0x70, 0x04, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xE0, 0x3E, 0x1F, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0x71, 0xC0,
  0x03, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x78, 0x00,
  0xF1, 0xE0, 0x0F, 0x07, 0xE7, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC7, 0x1F, 0xFE,
  0x73, 0xF8, 0xF7, 0x3C, 0x03, 0xF7, 0x80, 0x1F, 0x70, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x01, 0xF3, 0xE0, 0x77, 0x1F, 0xFF, 0x70, 0xFF, 0xE7, 0x03, 0xF8,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x38, 0x0F, 0x1F, 0xF0, 0xF7, 0xFF, 0x8F, 0x78, 0xFC, 0xFC, 0x03,
  0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x3F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7B, 0xC0,
  0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xE0, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0x80, 0x41, 0xDF, 0xC7, 0xF3,
  0xBF, 0xDF, 0xF7, 0xC7, 0xB1, 0xEF, 0x07, 0x41, 0xDC, 0x07, 0x03, 0xF8,
  0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80,
  0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E,
  0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0,
  0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03,
  0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F,
  0x01, 0xC0, 0x7E, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0F, 0x1F, 0xF0, 0xF7,
  0xFF, 0x8F, 0x79, 0xFC, 0xFC, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x20, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x83, 0xC0, 0x3E, 0x3C, 0x00, 0x71, 0xC0,
  0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3B, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x78, 0x01,
  0xE1, 0xE0, 0x1F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x30, 0x07, 0x8F, 0xF8, 0x3D, 0xFF, 0xE1, 0xEF, 0xBF, 0x8F, 0xC0,
  0x1E, 0x7C, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3B, 0xC0, 0x01,
  0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xE0, 0x1F, 0x3D, 0xE7, 0xF1, 0xE7,
  0xFF, 0x0F, 0x1F, 0xF0, 0x78, 0x08, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC7, 0x1F, 0xFE, 0x73,
  0xF8, 0xF7, 0x3C, 0x03, 0xF7, 0x80, 0x1F, 0x70, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xF3, 0xC0, 0x3F, 0x3F, 0x9F, 0x71,
  0xFF, 0xE7, 0x07, 0xFC, 0x70, 0x04, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x30, 0x07, 0x0F, 0xF8, 0x39, 0xFF, 0xE1, 0xCF,
  0x1F, 0x8E, 0xC0, 0x1E, 0x74, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x0E,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0x39,
  0xC0, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7B, 0xC0, 0x07, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x77, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x1E, 0x3C, 0x03, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0xF0, 0x00,
  0x07, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1E, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x81,
  0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x00, 0xE3,
  0x80, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xE0, 0x0E,
  0x01, 0xDC, 0x07, 0x80, 0x77, 0x01, 0xE0, 0x1D, 0xC0, 0x7C, 0x07, 0x70,
  0x1B, 0x01, 0xDC, 0x06, 0xC0, 0xE7, 0x03, 0xB0, 0x38, 0xE0, 0xEC, 0x0E,
  0x38, 0x33, 0x83, 0x8E, 0x0C, 0xE0, 0xE3, 0x83, 0x18, 0x38, 0xE0, 0xC6,
  0x0C, 0x38, 0x71, 0x87, 0x0E, 0x18, 0x61, 0xC1, 0xC6, 0x1C, 0x70, 0x71,
  0x87, 0x1C, 0x1C, 0x60, 0xC7, 0x07, 0x18, 0x31, 0x81, 0xCE, 0x0C, 0xE0,
  0x73, 0x03, 0x38, 0x0E, 0xC0, 0xEE, 0x03, 0xB0, 0x3B, 0x80, 0xEC, 0x06,
  0xE0, 0x3F, 0x01, 0xB0, 0x0F, 0xC0, 0x6C, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x07, 0x80, 0xF0, 0x07,
  0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0x80, 0x00,
  0xF7, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xE7, 0x80, 0x01,
  0xE3, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0x70, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03,
  0xC1, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xE1, 0xC0, 0x01, 0xE3, 0xC0, 0x00,
  0xE3, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x77, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x0E, 0x7F, 0x80, 0x1D, 0xFF, 0x80,
  0x3F, 0x87, 0x80, 0x7E, 0x07, 0x80, 0xFC, 0x07, 0x83, 0xF8, 0x07, 0x87,
  0x70, 0x07, 0xFE, 0xE0, 0x07, 0xF9, 0xC0, 0x07, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraLight51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 37, 31, 12, -37 },
  { 34, 14, 15, 31, 8, -37 },
  { 61, 27, 37, 31, 2, -37 },
  { 186, 23, 51, 31, 4, -44 },
  { 333, 29, 37, 31, 1, -37 },
  { 468, 26, 39, 31, 3, -38 },
  { 595, 4, 15, 31, 13, -37 },
  { 603, 15, 49, 31, 10, -43 },
  { 695, 15, 49, 31, 6, -43 },
  { 787, 27, 26, 31, 2, -31 },
  { 875, 23, 24, 31, 4, -29 },
  { 944, 10, 16, 31, 9, -8 },
  { 964, 16, 3, 31, 7, -18 },
  { 970, 8, 8, 31, 11, -7 },
  { 978, 22, 48, 31, 4, -42 },
  { 1110, 22, 39, 31, 4, -38 },
  { 1218, 22, 37, 31, 5, -37 },
  { 1320, 23, 38, 31, 4, -38 },
  { 1430, 21, 38, 31, 4, -37 },
  { 1530, 20, 37, 31, 5, -37 },
  { 1623, 21, 38, 31, 5, -37 },
  { 1723, 23, 38, 31, 4, -37 },
  { 1833, 23, 37, 31, 4, -37 },
  { 1940, 22, 39, 31, 4, -38 },
  { 2048, 23, 38, 31, 4, -38 },
  { 2158, 8, 30, 31, 11, -29 },
  { 2188, 10, 37, 31, 9, -29 },
  { 2235, 22, 26, 31, 4, -30 },
  { 2307, 21, 15, 31, 5, -24 },
  { 2347, 22, 26, 31, 4, -30 },
  { 2419, 17, 37, 31, 8, -37 },
  { 2498, 25, 47, 31, 3, -38 },
  { 2645, 24, 37, 31, 3, -37 },
  { 2756, 22, 37, 31, 5, -37 },
  { 2858, 21, 39, 31, 5, -38 },
  { 2961, 21, 37, 31, 5, -37 },
  { 3059, 20, 37, 31, 6, -37 },
  { 3152, 22, 37, 31, 5, -37 },
  { 3254, 21, 39, 31, 5, -38 },
  { 3357, 20, 37, 31, 5, -37 },
  { 3450, 19, 37, 31, 6, -37 },
  { 3538, 22, 38, 31, 3, -37 },
  { 3643, 23, 37, 31, 5, -37 },
  { 3750, 21, 37, 31, 6, -37 },
  { 3848, 22, 37, 31, 4, -37 },
  { 3950, 20, 37, 31, 5, -37 },
  { 4043, 21, 39, 31, 5, -38 },
  { 4146, 23, 37, 31, 5, -37 },
  { 4253, 21, 47, 31, 5, -38 },
  { 4377, 22, 37, 31, 5, -37 },
  { 4479, 23, 39, 31, 4, -38 },
  { 4592, 25, 37, 31, 3, -37 },
  { 4708, 20, 38, 31, 5, -37 },
  { 4803, 24, 37, 31, 3, -37 },
  { 4914, 27, 37, 31, 2, -37 },
  { 5039, 26, 37, 31, 2, -37 },
  { 5160, 26, 37, 31, 2, -37 },
  { 5281, 21, 37, 31, 5, -37 },
  { 5379, 12, 48, 31, 11, -42 },
  { 5451, 22, 48, 31, 4, -42 },
  { 5583, 12, 48, 31, 8, -42 },
  { 5655, 21, 20, 31, 5, -37 },
  { 5708, 25, 3, 31, 3, 1 },
  { 5718, 9, 7, 31, 10, -40 },
  { 5726, 21, 30, 31, 4, -29 },
  { 5805, 21, 38, 31, 5, -37 },
  { 5905, 21, 30, 31, 5, -29 },
  { 5984, 20, 38, 31, 5, -37 },
  { 6079, 21, 30, 31, 5, -29 },
  { 6158, 24, 37, 31, 3, -37 },
  { 6269, 20, 38, 31, 5, -29 },
  { 6364, 20, 37, 31, 5, -37 },
  { 6457, 23, 39, 31, 5, -39 },
  { 6570, 18, 48, 31, 5, -39 },
  { 6678, 23, 37, 31, 5, -37 },
  { 6785, 26, 37, 31, 2, -37 },
  { 6906, 23, 29, 31, 4, -29 },
  { 6990, 20, 29, 31, 5, -29 },
  { 7063, 21, 29, 31, 5, -29 },
  { 7140, 21, 38, 31, 5, -29 },
  { 7240, 20, 38, 31, 5, -29 },
  { 7335, 21, 29, 31, 6, -29 },
  { 7412, 21, 29, 31, 5, -29 },
  { 7489, 23, 36, 31, 3, -36 },
  { 7593, 20, 29, 31, 5, -28 },
  { 7666, 24, 28, 31, 3, -28 },
  { 7750, 26, 28, 31, 2, -28 },
  { 7841, 24, 28, 31, 3, -28 },
  { 7925, 24, 37, 31, 3, -28 },
  { 8036, 21, 28, 31, 5, -28 },
  { 8110, 21, 48, 31, 5, -42 },
  { 8236, 3, 48, 31, 14, -42 },
  { 8254, 21, 48, 31, 5, -42 },
  { 8380, 23, 10, 31, 4, -23 },
};

const GFXfont JetBrainsMono_ExtraLight51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraLight51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraLight51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_EXTRALIGHT51PT7B_H_
