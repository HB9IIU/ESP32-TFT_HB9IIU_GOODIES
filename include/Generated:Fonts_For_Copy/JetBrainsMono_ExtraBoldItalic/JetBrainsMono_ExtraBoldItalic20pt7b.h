#ifndef _JETBRAINSMONO_EXTRABOLDITALIC20PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCF, 0x38, 0xE3, 0x8E, 0x30, 0xC0, 0x00, 0x71, 0xC7,
  0x00, 0x77, 0xE7, 0xE7, 0xE7, 0xE6, 0xE6, 0x06, 0x30, 0x31, 0x81, 0x98,
  0x18, 0xD3, 0xFF, 0x1F, 0xF8, 0x63, 0x03, 0x18, 0x19, 0x81, 0x8C, 0x3F,
  0xF9, 0xFF, 0xC6, 0x30, 0x31, 0x81, 0x98, 0x00, 0x01, 0x00, 0x10, 0x07,
  0x80, 0xFE, 0x1F, 0xF3, 0xB7, 0x3A, 0x03, 0xA0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0x7E, 0x04, 0xE7, 0x4E, 0x7F, 0xC7, 0xFC, 0x3F, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x0E, 0x06, 0x3E, 0x18, 0xCC, 0x61, 0x99, 0x83, 0x36, 0x07,
  0xF8, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0x60, 0x0F, 0xE0, 0x36, 0x60, 0xD9,
  0x83, 0x33, 0x0C, 0x7E, 0x30, 0x78, 0x00, 0x03, 0x80, 0xFC, 0x1F, 0xE1,
  0xCE, 0x18, 0x01, 0xC0, 0x1C, 0x03, 0xE1, 0x7E, 0xE6, 0x7E, 0x67, 0xCE,
  0x38, 0xF3, 0x87, 0xFC, 0x7E, 0xE0, 0x77, 0x7E, 0xEE, 0x01, 0x83, 0x83,
  0xC3, 0xC3, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xE0, 0x7C, 0x1E, 0x07, 0x00, 0x80, 0x10, 0x0E, 0x07, 0x81,
  0xE0, 0x70, 0x38, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70,
  0x38, 0x38, 0xF8, 0x78, 0x38, 0x10, 0x00, 0x06, 0x00, 0xC1, 0x19, 0x7A,
  0xFF, 0xFE, 0x18, 0x07, 0x81, 0xB8, 0xF3, 0x8C, 0x60, 0x0E, 0x03, 0x80,
  0xE3, 0xFF, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x1C, 0x00, 0x1E, 0x78, 0xE1,
  0xC7, 0x1C, 0x00, 0x7F, 0x7F, 0xFE, 0x73, 0xBC, 0xE0, 0x00, 0x38, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x00, 0x0F, 0x03, 0xF8, 0xFF, 0x38, 0x77, 0x0E, 0xE1,
  0x9B, 0x77, 0x7E, 0xED, 0xDC, 0x3B, 0x87, 0x70, 0xCF, 0x79, 0xFE, 0x1F,
  0x80, 0x07, 0x83, 0xE3, 0xF0, 0xFC, 0x67, 0x11, 0xC0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x03, 0xF8, 0xFF,
  0x38, 0xF7, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0xF9, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xF8, 0xFF, 0x01, 0xE0, 0x70,
  0x1C, 0x03, 0xE0, 0xFC, 0x03, 0xC0, 0x38, 0x07, 0x71, 0xCE, 0x79, 0xFE,
  0x1F, 0x80, 0x01, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC7,
  0xE1, 0xF8, 0xEF, 0xFB, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x3F, 0xE7, 0xFC,
  0xFF, 0x18, 0x07, 0x00, 0xE6, 0x1F, 0xE3, 0xFE, 0x01, 0xC0, 0x38, 0x07,
  0x71, 0xCF, 0x79, 0xFE, 0x1F, 0x80, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C,
  0x0E, 0x07, 0xF9, 0xFF, 0xF3, 0xF8, 0x7E, 0x1F, 0x87, 0xF3, 0xBF, 0xC7,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xE3, 0x80, 0xE0, 0x70, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0xFE, 0x1F,
  0xE3, 0x87, 0x38, 0x63, 0x8E, 0x1F, 0xC0, 0xF8, 0x3F, 0xC7, 0x9E, 0x70,
  0xE7, 0x0E, 0x7B, 0xC7, 0xFC, 0x3F, 0x00, 0x0F, 0x03, 0xF8, 0xFF, 0xB8,
  0x77, 0x0E, 0xE1, 0xDC, 0x73, 0xFE, 0x3F, 0x80, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x78, 0x1E, 0x00, 0x38, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x73, 0xC7,
  0x00, 0x1C, 0x3C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF1, 0xC3, 0x8E,
  0x1C, 0x00, 0x00, 0x60, 0x38, 0x3F, 0x1F, 0x87, 0xC0, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x7F, 0xDF, 0xF7, 0xFC, 0x00, 0x00,
  0x1F, 0xEF, 0xFB, 0xFE, 0x60, 0x1E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x70,
  0xFC, 0xFC, 0xFC, 0x38, 0x08, 0x00, 0x3C, 0x3F, 0x9F, 0xE0, 0x70, 0x38,
  0x1C, 0xFC, 0x7E, 0x3C, 0x18, 0x1C, 0x00, 0x07, 0x07, 0x81, 0xC0, 0x03,
  0xC0, 0x7F, 0x07, 0x1C, 0x70, 0x67, 0x03, 0x39, 0xD9, 0x9F, 0xCC, 0xCE,
  0x66, 0x77, 0x73, 0xBB, 0x99, 0xDC, 0xCC, 0xFE, 0x63, 0xB3, 0x00, 0x1C,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0x00, 0x07, 0x80, 0xF0, 0x1F, 0x07, 0xE0,
  0xFC, 0x3B, 0x87, 0x70, 0xEE, 0x39, 0xC7, 0xF9, 0xFF, 0x3F, 0xE7, 0x1D,
  0xC1, 0xB8, 0x38, 0x1F, 0x81, 0xFE, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x8E,
  0x3F, 0xC3, 0xF8, 0x7F, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x73, 0xC7, 0xFC,
  0xFF, 0x00, 0x07, 0x03, 0xF8, 0xFF, 0xB8, 0x77, 0x0E, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0xEF, 0x79, 0xFE, 0x1F, 0x80, 0x1F,
  0x81, 0xFE, 0x3F, 0xE3, 0x8F, 0x38, 0x73, 0x87, 0x38, 0x73, 0x8E, 0x70,
  0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x7F, 0xC7, 0xF8, 0xFF, 0x00, 0x3F, 0xE7,
  0xFC, 0xFF, 0x98, 0x07, 0x00, 0xE0, 0x1F, 0xE3, 0xFC, 0x7F, 0x8E, 0x03,
  0x80, 0x70, 0x0F, 0xF9, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7, 0xFC, 0xFF, 0xB8,
  0x07, 0x00, 0xE0, 0x1F, 0xF3, 0xFE, 0x7F, 0x9C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0x03, 0xF8, 0xFF, 0xB8, 0x77, 0x0E, 0xE0,
  0x1C, 0x07, 0x3E, 0xE7, 0xDC, 0xFB, 0x87, 0x70, 0xEF, 0x79, 0xFE, 0x1F,
  0x80, 0x1C, 0x71, 0xC7, 0x38, 0x73, 0x87, 0x38, 0xE3, 0x8E, 0x3F, 0xE3,
  0xFE, 0x7F, 0xE7, 0x0E, 0x70, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xF1, 0xC0,
  0x3F, 0xE7, 0xFC, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x0F, 0xF9, 0xFF, 0x3F, 0xE0, 0x03, 0xF0, 0x7F,
  0x07, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xCE, 0x1C, 0xF3, 0xC7, 0xF8, 0x3F, 0x00, 0x1C, 0x38, 0xE3, 0x8E,
  0x3C, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0x9C,
  0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x38, 0xE3, 0xC7, 0x80, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0xFF,
  0xFF, 0xFE, 0x3C, 0x79, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0xDB, 0x3E, 0xF9,
  0xD5, 0xCE, 0xEC, 0x76, 0x63, 0x87, 0x18, 0x38, 0xC1, 0xCE, 0x0E, 0x70,
  0x73, 0x83, 0x00, 0x1C, 0x33, 0xC7, 0x3C, 0x73, 0xE7, 0x36, 0x73, 0x66,
  0x36, 0x63, 0x66, 0x77, 0xE7, 0x7E, 0x73, 0xE7, 0x3C, 0x63, 0xC6, 0x3C,
  0xE3, 0xC0, 0x0F, 0x03, 0xF8, 0xFF, 0x38, 0xF7, 0x0E, 0xE3, 0x9C, 0x77,
  0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xCF, 0x79, 0xFE, 0x1F, 0x80, 0x1F,
  0x81, 0xFE, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x38, 0xF3, 0xFE, 0x7F,
  0xC7, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x03,
  0xF8, 0xFF, 0x38, 0xF7, 0x0E, 0xE3, 0x9C, 0x77, 0x0E, 0xE1, 0xDC, 0x3B,
  0x87, 0x71, 0xCF, 0x79, 0xFE, 0x1F, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0x1F, 0x81, 0xFE, 0x3F, 0xF3, 0x8F, 0x38, 0x73, 0x87, 0x38, 0xE3,
  0xFE, 0x7F, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x71, 0xC7, 0x1C, 0xE1, 0xC0,
  0x07, 0x80, 0xFE, 0x1F, 0xF3, 0x87, 0x38, 0x03, 0x80, 0x3F, 0x01, 0xFC,
  0x0F, 0xE0, 0x1E, 0x00, 0xE7, 0x0E, 0x7B, 0xC7, 0xFC, 0x3F, 0x00, 0xFF,
  0xFF, 0xFB, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x38, 0xEE, 0x1D, 0xC3,
  0xB8, 0x77, 0x0E, 0xE3, 0x9C, 0x73, 0x8E, 0xE1, 0xDC, 0x3B, 0x87, 0x71,
  0xCF, 0x79, 0xFE, 0x1F, 0x80, 0xE0, 0xFC, 0x3B, 0x87, 0x70, 0xEE, 0x39,
  0xC7, 0x38, 0xC3, 0x38, 0x67, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x00, 0x67, 0x36, 0x73, 0x66, 0x7E, 0xE6, 0xEE, 0x6E, 0xA6, 0xEA,
  0xED, 0xAC, 0xDA, 0xCD, 0x2C, 0xD3, 0xCF, 0x38, 0xE7, 0x8E, 0x78, 0xE7,
  0x80, 0x38, 0x79, 0xE3, 0x87, 0x38, 0x3B, 0xC0, 0xFC, 0x07, 0xC0, 0x3E,
  0x00, 0xE0, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x77, 0x07, 0x1C, 0x38, 0xE3,
  0x87, 0x80, 0xE0, 0xFC, 0x3B, 0x87, 0x39, 0xC7, 0x38, 0xEE, 0x1D, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x3F,
  0xE7, 0xFC, 0xFF, 0x00, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07,
  0x81, 0xE0, 0x38, 0x0F, 0xF9, 0xFF, 0x3F, 0xE0, 0x1F, 0x8F, 0xC7, 0xE3,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x7E, 0x7F, 0x3F, 0x00, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x1C,
  0x38, 0x70, 0x70, 0xE1, 0xC3, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x38, 0x1F,
  0x8F, 0xC7, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x7E, 0x3F, 0x3F, 0x00, 0x07, 0x03, 0xC0,
  0xF0, 0x7E, 0x1B, 0x8E, 0x67, 0x1F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0xE7,
  0x9E, 0x3F, 0xEF, 0xF9, 0xEF, 0x38, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x1C,
  0xF7, 0x9F, 0xF1, 0xEE, 0x00, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0xBC,
  0x7F, 0xCF, 0x79, 0xC7, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xE7, 0xBC, 0xFF,
  0xBB, 0xE0, 0x1F, 0x8F, 0xF7, 0xBD, 0xC7, 0xE0, 0x38, 0x0E, 0x03, 0x87,
  0xF7, 0xBF, 0xC7, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x73, 0xEC, 0xFF,
  0x9E, 0xF3, 0x8E, 0xE1, 0xDC, 0x3B, 0x87, 0x71, 0xCF, 0x79, 0xFF, 0x1E,
  0xE0, 0x1F, 0x8F, 0xF7, 0x1D, 0x87, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE3,
  0xBF, 0xC7, 0xE0, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x07, 0x00, 0x38, 0x0F,
  0xFC, 0xFF, 0xC7, 0xFE, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0xFC, 0x07, 0xC0, 0x38, 0x00, 0x3F, 0xEF,
  0xF9, 0xEF, 0x38, 0xEE, 0x1D, 0xC3, 0xB8, 0xF7, 0x9C, 0xFF, 0x8F, 0x70,
  0x0E, 0x01, 0xC7, 0xF0, 0xFC, 0x3E, 0x00, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0xBC, 0x7F, 0xCF, 0x79, 0xC7, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xE7,
  0x1C, 0xE3, 0xBC, 0x70, 0x03, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x0F, 0xC3,
  0xF1, 0xF8, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x3C, 0x03, 0x80, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0xFE, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x1F,
  0xE3, 0xF8, 0x7C, 0x00, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x73,
  0x8E, 0x39, 0xE3, 0xBC, 0x3F, 0x87, 0xF0, 0x7F, 0x87, 0x38, 0x73, 0xC7,
  0x1C, 0xF1, 0xE0, 0x7E, 0x1F, 0x87, 0xE2, 0x38, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xC7, 0xF0, 0xFC, 0x36, 0xE7,
  0xFF, 0x77, 0x77, 0x66, 0x76, 0x66, 0x66, 0x66, 0xE6, 0x6E, 0xEE, 0xEE,
  0xCE, 0xEC, 0xC0, 0x3B, 0xC7, 0xFC, 0xF7, 0x9C, 0x77, 0x0E, 0xE1, 0xDC,
  0x3B, 0x8E, 0x71, 0xCE, 0x3B, 0xC7, 0x00, 0x1F, 0x8F, 0xF7, 0xBD, 0xC7,
  0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xF7, 0xBF, 0xC7, 0xE0, 0x3B, 0xC7, 0xFC,
  0xF7, 0x9C, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x8E, 0x7B, 0xCF, 0xF9, 0xBE,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x3E, 0xEF, 0xF9, 0xEF, 0x38, 0xEE,
  0x1D, 0xC3, 0xB8, 0x77, 0x1C, 0xF7, 0x9F, 0xF1, 0xEE, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x77, 0xCF, 0xF9, 0xE7, 0xB8, 0xF7, 0x1E, 0xE0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x1F, 0xC7, 0xFC, 0xE3, 0x9C,
  0x03, 0xF0, 0x7F, 0x80, 0xF8, 0x07, 0x71, 0xCF, 0xF8, 0xFE, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x7F, 0xFF, 0xFD, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1F, 0xC1, 0xF8, 0x3F, 0x00, 0x71, 0xEE, 0x39, 0xC7, 0x38,
  0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x1C, 0xF7, 0x9F, 0xE1, 0xF8, 0x00, 0xF0,
  0xEE, 0x1D, 0xC7, 0x38, 0xE7, 0x38, 0xE7, 0x0D, 0xC1, 0xB8, 0x3E, 0x07,
  0xC0, 0xF0, 0x00, 0xC6, 0x7C, 0xE6, 0xCE, 0x6C, 0xEE, 0xDE, 0xCD, 0xEC,
  0xD7, 0xCD, 0x78, 0xF7, 0x8E, 0x78, 0xE7, 0x00, 0x38, 0xF3, 0xDE, 0x1D,
  0xC1, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xF8, 0x3B, 0x87, 0x1C, 0xE1,
  0xE0, 0x71, 0xDC, 0x77, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B, 0xDE, 0xFF,
  0x9E, 0xE0, 0x38, 0x1E, 0x7F, 0x1F, 0x8F, 0x80, 0x7F, 0xDF, 0xF7, 0xFC,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xBF, 0xEF, 0xF8, 0x00, 0xC0,
  0xF0, 0x7C, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFE, 0x3E, 0x0F, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0x07, 0xC1, 0xE0, 0x1C, 0x71,
  0xC7, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xCE,
  0x00, 0x1C, 0x03, 0xE0, 0x7C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x0F, 0xE0, 0xFC, 0x3F, 0x87, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x7C,
  0x0F, 0x03, 0xC0, 0x00, 0x10, 0x0F, 0x9F, 0xF3, 0xE7, 0xEC, 0x7C, 0x04,
  0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 15, 12, 3, -15 },
  { 13, 8, 6, 12, 3, -15 },
  { 19, 13, 15, 12, 0, -15 },
  { 44, 12, 20, 12, 0, -17 },
  { 74, 15, 15, 12, -1, -15 },
  { 103, 12, 15, 12, 0, -15 },
  { 126, 4, 6, 12, 5, -15 },
  { 129, 9, 20, 12, 3, -17 },
  { 152, 9, 20, 12, 1, -17 },
  { 175, 11, 10, 12, 1, -12 },
  { 189, 10, 9, 12, 1, -11 },
  { 201, 7, 6, 12, 1, -3 },
  { 207, 8, 3, 12, 2, -8 },
  { 210, 5, 4, 12, 3, -4 },
  { 213, 13, 19, 12, 0, -17 },
  { 244, 11, 15, 12, 1, -15 },
  { 265, 10, 15, 12, 1, -15 },
  { 284, 11, 15, 12, 1, -15 },
  { 305, 11, 15, 12, 1, -15 },
  { 326, 10, 15, 12, 1, -15 },
  { 345, 11, 15, 12, 1, -15 },
  { 366, 10, 15, 12, 1, -15 },
  { 385, 10, 15, 12, 2, -15 },
  { 404, 12, 15, 12, 0, -15 },
  { 427, 11, 15, 12, 1, -15 },
  { 448, 6, 11, 12, 3, -11 },
  { 457, 7, 14, 12, 2, -11 },
  { 470, 11, 11, 12, 1, -12 },
  { 486, 10, 8, 12, 1, -11 },
  { 496, 10, 11, 12, 1, -12 },
  { 510, 9, 15, 12, 2, -15 },
  { 527, 13, 19, 12, 0, -15 },
  { 558, 11, 15, 12, 0, -15 },
  { 579, 12, 15, 12, 0, -15 },
  { 602, 11, 15, 12, 1, -15 },
  { 623, 12, 15, 12, 0, -15 },
  { 646, 11, 15, 12, 1, -15 },
  { 667, 11, 15, 12, 1, -15 },
  { 688, 11, 15, 12, 1, -15 },
  { 709, 12, 15, 12, 0, -15 },
  { 732, 11, 15, 12, 1, -15 },
  { 753, 12, 15, 12, 0, -15 },
  { 776, 13, 15, 12, 0, -15 },
  { 801, 9, 15, 12, 1, -15 },
  { 818, 13, 15, 12, 0, -15 },
  { 843, 12, 15, 12, 0, -15 },
  { 866, 11, 15, 12, 1, -15 },
  { 887, 12, 15, 12, 0, -15 },
  { 910, 11, 19, 12, 1, -15 },
  { 937, 12, 15, 12, 0, -15 },
  { 960, 12, 15, 12, 0, -15 },
  { 983, 11, 15, 12, 2, -15 },
  { 1004, 11, 15, 12, 1, -15 },
  { 1025, 11, 15, 12, 2, -15 },
  { 1046, 12, 15, 12, 1, -15 },
  { 1069, 13, 15, 12, 0, -15 },
  { 1094, 11, 15, 12, 2, -15 },
  { 1115, 11, 15, 12, 1, -15 },
  { 1136, 9, 19, 12, 2, -17 },
  { 1158, 7, 19, 12, 3, -17 },
  { 1175, 9, 19, 12, 1, -17 },
  { 1197, 10, 8, 12, 1, -15 },
  { 1207, 10, 3, 12, 0, 0 },
  { 1211, 5, 3, 12, 5, -16 },
  { 1213, 11, 11, 12, 1, -11 },
  { 1229, 11, 15, 12, 0, -15 },
  { 1250, 10, 11, 12, 1, -11 },
  { 1264, 11, 15, 12, 1, -15 },
  { 1285, 10, 11, 12, 1, -11 },
  { 1299, 13, 19, 12, -1, -15 },
  { 1330, 11, 15, 12, 1, -11 },
  { 1351, 11, 15, 12, 0, -15 },
  { 1372, 10, 16, 12, 1, -16 },
  { 1392, 11, 20, 12, 0, -16 },
  { 1420, 12, 15, 12, 0, -15 },
  { 1443, 10, 15, 12, 1, -15 },
  { 1462, 12, 11, 12, 0, -11 },
  { 1479, 11, 11, 12, 0, -11 },
  { 1495, 10, 11, 12, 1, -11 },
  { 1509, 11, 15, 12, 0, -11 },
  { 1530, 11, 15, 12, 1, -11 },
  { 1551, 11, 11, 12, 1, -11 },
  { 1567, 11, 11, 12, 0, -11 },
  { 1583, 11, 14, 12, 1, -14 },
  { 1603, 11, 11, 12, 1, -11 },
  { 1619, 11, 11, 12, 1, -11 },
  { 1635, 12, 11, 12, 1, -11 },
  { 1652, 12, 11, 12, 0, -11 },
  { 1669, 10, 15, 12, 1, -11 },
  { 1688, 10, 11, 12, 1, -11 },
  { 1702, 10, 19, 12, 2, -17 },
  { 1726, 6, 19, 12, 3, -17 },
  { 1741, 11, 19, 12, 0, -17 },
  { 1768, 11, 6, 12, 1, -10 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic20pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic20pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC20PT7B_H_
