#ifndef _JETBRAINSMONO_EXTRABOLDITALIC72PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F,
  0xFE, 0x7F, 0xE0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD,
  0xFF, 0xC0, 0xFF, 0xCF, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x7F, 0xF3, 0xFF,
  0x03, 0xFF, 0xBF, 0xF8, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xEF, 0xFE, 0x07,
  0xFE, 0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFC,
  0xFF, 0xC0, 0x7F, 0xC7, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF,
  0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x08, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFE, 0xF7, 0xFF, 0xE0, 0x3F, 0xFC, 0x78, 0xFF, 0xF0, 0x1F, 0xFC, 0x7C,
  0x3F, 0xF8, 0x1F, 0xFE, 0x3E, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0x0F, 0xFE,
  0x07, 0xFF, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x87, 0x80, 0x00, 0x01, 0xFF,
  0xC3, 0xC0, 0x00, 0x00, 0xFF, 0xE3, 0xE0, 0x00, 0x00, 0x7F, 0xF9, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0x9F, 0xFF, 0x00, 0x00, 0x07, 0x87, 0xFF, 0x80,
  0x00, 0x03, 0xC1, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0x7C, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3C, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0x0F, 0xFF, 0x07, 0xFF, 0xEF, 0x9F, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x8F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xCF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xCF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x9F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xCF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x8F, 0xF0, 0x00, 0x00,
  0x3F, 0xC7, 0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0x87, 0xFF, 0x7F, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE3, 0xFF, 0x9F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF7, 0xFE, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0xF9, 0xFF, 0xCF,
  0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xF3, 0xFF,
  0x9F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x18, 0x00, 0xFF, 0x00,
  0x38, 0x3E, 0x01, 0xFC, 0x01, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xE1, 0xFF,
  0x07, 0xF0, 0x7F, 0xC7, 0xFF, 0x87, 0xC3, 0xFF, 0x8F, 0xFF, 0x8F, 0x9F,
  0xFF, 0xBF, 0xFF, 0x9E, 0x7F, 0xFF, 0x7F, 0xFF, 0xBD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x5F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1,
  0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x07, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x01, 0xFF,
  0x87, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x02, 0x01, 0xFF, 0x87, 0xFE,
  0x3F, 0x87, 0xFF, 0x0F, 0xFC, 0xFF, 0x8F, 0xFC, 0x1F, 0xF9, 0xFF, 0x1F,
  0xF8, 0x7F, 0xF7, 0xFE, 0x3F, 0xF0, 0xFF, 0xCF, 0xFE, 0x7F, 0xE1, 0xFF,
  0x9F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xF3, 0xFF, 0x87, 0xFE, 0x3F, 0xE7,
  0xFE, 0x0F, 0xFC, 0x3F, 0x8F, 0xFC, 0x1F, 0xF8, 0x1C, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xFC,
  0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xE1,
  0xFF, 0xC0, 0x03, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0x01, 0xFF, 0xC0, 0x07,
  0xC0, 0x1F, 0xF8, 0x00, 0x78, 0x03, 0xFF, 0x80, 0x06, 0x00, 0x3F, 0xF8,
  0x00, 0x40, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0x03, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x8F, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0xF0,
  0x07, 0xFF, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0xBF,
  0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0xCF, 0xFE, 0x00,
  0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0xE1,
  0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xDF,
  0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x0F,
  0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xFE, 0x00, 0x7F,
  0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x28, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x70, 0x3F, 0xE0, 0x7F,
  0xC0, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0xF1, 0xFE, 0x07, 0xF8,
  0x07, 0xFF, 0xE7, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0x9F, 0xE0, 0xFF, 0x80,
  0xFF, 0xFF, 0x7F, 0x03, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFF, 0x3F, 0x81, 0xFE, 0x01,
  0xFF, 0xF9, 0xFE, 0x07, 0xF8, 0x03, 0xFF, 0xC7, 0xF8, 0x1F, 0xE0, 0x07,
  0xFE, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0, 0x80, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFC,
  0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFE, 0x00, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xFF,
  0x9F, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFE,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xF8,
  0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0x7F, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xBF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFD, 0xFE,
  0x01, 0xFF, 0x7E, 0x0F, 0xEF, 0xF0, 0x0F, 0xFB, 0xF0, 0x7E, 0xFF, 0x80,
  0x7F, 0x9F, 0x87, 0xF7, 0xFC, 0x03, 0xFC, 0xFC, 0x3F, 0x3F, 0xE0, 0x3F,
  0xE7, 0xE3, 0xF9, 0xFF, 0x01, 0xFF, 0x3F, 0x1F, 0xDF, 0xF8, 0x0F, 0xF9,
  0xFD, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xEF, 0xE7, 0xFC, 0x03, 0xFE, 0x7F,
  0x7E, 0x3F, 0xE0, 0x1F, 0xF1, 0xFF, 0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xFF,
  0x9F, 0xF8, 0x0F, 0xFC, 0x7F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0xC7,
  0xFC, 0x03, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF,
  0x00, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF7, 0xF8, 0x0F, 0xFC,
  0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x3F, 0xE0, 0x0F,
  0xFB, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC7,
  0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x1F, 0xE0,
  0xFF, 0xC0, 0x3F, 0xE3, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0x83, 0xFE,
  0x00, 0xFF, 0x8F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x0F, 0xF8, 0x07,
  0xFE, 0x1F, 0xE3, 0xFF, 0x00, 0xFF, 0xC3, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0,
  0x7F, 0x8F, 0xF8, 0x03, 0xFE, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xE7, 0xFC, 0x03, 0xFF, 0x03, 0xFC, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0x9F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF3, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF,
  0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xA0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x07,
  0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xFB,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xC1, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x07, 0xFC, 0x07, 0xBE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7D, 0xF0, 0x3F,
  0xE0, 0x7F, 0x81, 0xF7, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xDF, 0x07, 0xFC,
  0x07, 0xF8, 0x3F, 0x7C, 0x1F, 0xF0, 0x1F, 0xE0, 0xFD, 0xF0, 0x7F, 0xC0,
  0x7F, 0x83, 0xE7, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0x9F, 0x07, 0xF8, 0x07,
  0xF8, 0x7E, 0x7C, 0x3F, 0xE0, 0x1F, 0xE1, 0xF1, 0xF0, 0xFF, 0x00, 0x7F,
  0x87, 0xC7, 0xC3, 0xFC, 0x03, 0xFE, 0x1F, 0x1F, 0x0F, 0xF0, 0x0F, 0xF8,
  0xFC, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xE3, 0xF1, 0xFE, 0x00, 0xFF, 0x0F,
  0x8F, 0xC7, 0xF8, 0x03, 0xFC, 0x7E, 0x3F, 0x1F, 0xE0, 0x0F, 0xF1, 0xF8,
  0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xC3, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0x0F,
  0x8F, 0xF0, 0x03, 0xFC, 0xFC, 0x3E, 0x3F, 0xC0, 0x0F, 0xF3, 0xF0, 0xF8,
  0xFF, 0x00, 0x3F, 0xCF, 0x83, 0xE7, 0xF8, 0x00, 0xFF, 0x3E, 0x0F, 0x9F,
  0xE0, 0x03, 0xFD, 0xF8, 0x3E, 0x7F, 0x80, 0x0F, 0xF7, 0xC0, 0xF9, 0xFE,
  0x00, 0x3F, 0xDF, 0x03, 0xEF, 0xF0, 0x01, 0xFE, 0xFC, 0x0F, 0xBF, 0xC0,
  0x07, 0xFB, 0xF0, 0x3E, 0xFF, 0x00, 0x1F, 0xEF, 0x80, 0xFB, 0xFC, 0x00,
  0x7F, 0xBE, 0x03, 0xEF, 0xE0, 0x01, 0xFE, 0xF8, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xFD, 0xF0, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x87, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xDF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x01, 0xFF,
  0xCF, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x01, 0xFF, 0xE1, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x1F, 0xF9, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F,
  0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x07, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0x03, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xFF,
  0xC7, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xEF, 0xFE,
  0x01, 0xFF, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFD, 0xFF, 0xC0, 0x0F, 0xFF, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0xF1,
  0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF,
  0xE0, 0x01, 0xFF, 0x8F, 0xFF, 0xF0, 0x07, 0xFF, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x7F, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF,
  0xC1, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF7, 0xFF, 0xFF, 0x80, 0xFF, 0xEF, 0xFF, 0xFF, 0x01, 0xFF,
  0xDF, 0xFF, 0xFC, 0x03, 0xFF, 0x1F, 0xFF, 0xF0, 0x07, 0xFE, 0x1F, 0xFF,
  0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFE, 0x00, 0x3F, 0xFF, 0xFB,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x7F,
  0xF0, 0x00, 0xFF, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0x00,
  0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0x00,
  0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x9F,
  0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x07,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xFE, 0x00,
  0x3F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0xFE,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF, 0xFB, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x87, 0xFF, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF,
  0xC1, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0x80, 0x3F,
  0xFF, 0xF3, 0xFF, 0x00, 0x7F, 0xFF, 0xC7, 0xFE, 0x00, 0x7F, 0xFF, 0x1F,
  0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC3,
  0xFF, 0xE0, 0x01, 0xFF, 0x8F, 0xFF, 0xF0, 0x07, 0xFF, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF7,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F,
  0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x40, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0x80, 0xFE, 0x00, 0x7F,
  0x8F, 0xF8, 0x7F, 0xE0, 0x0F, 0xF3, 0xFF, 0x1F, 0xFE, 0x01, 0xFE, 0xFF,
  0xF3, 0xFF, 0xC0, 0x7F, 0xDF, 0xFE, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xDF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x07, 0xFE, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x81, 0xFC, 0x0F, 0xF8, 0x1F,
  0xF0, 0x7F, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0x07, 0xFE, 0x0F,
  0xF8, 0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFE, 0x07, 0xFC,
  0x0F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x1F,
  0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xFF, 0x80,
  0x7F, 0xF7, 0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0xFF, 0xFF, 0x01, 0xFF, 0xBF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01,
  0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC,
  0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC,
  0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF,
  0xE0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xE0,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0x9F,
  0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFD, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x7F, 0xF7, 0xFF,
  0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0x87, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x07, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xFF, 0xC7, 0xFE, 0x00,
  0x7F, 0xFF, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF,
  0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFD, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0xE1, 0xFF, 0xC0, 0x01,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7E, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0x3F, 0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0xFF, 0xFC, 0x07, 0xFE,
  0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80,
  0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0,
  0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF,
  0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x01, 0xFF,
  0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xEF, 0xF0, 0x07, 0xF8,
  0x07, 0xF9, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE7, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x7F, 0x81,
  0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xFE,
  0x07, 0xFC, 0x3F, 0xC1, 0xF7, 0xC0, 0xFF, 0x07, 0xF8, 0x3E, 0xF8, 0x1F,
  0xE0, 0xFF, 0x07, 0xDF, 0x07, 0xFC, 0x1F, 0xE1, 0xFB, 0xE0, 0xFF, 0x03,
  0xFC, 0x3E, 0x7C, 0x1F, 0xE0, 0x7F, 0x87, 0xCF, 0x87, 0xFC, 0x0F, 0xF0,
  0xF9, 0xF0, 0xFF, 0x01, 0xFE, 0x3E, 0x3E, 0x1F, 0xE0, 0x3F, 0xC7, 0xC7,
  0xC7, 0xFC, 0x07, 0xF8, 0xF8, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0x1F, 0x1F,
  0xE0, 0x1F, 0xE7, 0xC3, 0xE3, 0xFC, 0x07, 0xFC, 0xF8, 0x7C, 0xFF, 0x80,
  0xFF, 0xBF, 0x0F, 0x9F, 0xE0, 0x1F, 0xF7, 0xC1, 0xF3, 0xFC, 0x03, 0xFE,
  0xF8, 0x3E, 0xFF, 0x80, 0x7F, 0xDF, 0x07, 0xDF, 0xE0, 0x0F, 0xFF, 0xE0,
  0xFB, 0xFC, 0x01, 0xFE, 0xF8, 0x1F, 0x7F, 0x80, 0x3F, 0xDF, 0x03, 0xFF,
  0xE0, 0x07, 0xFB, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0x3F, 0xF8, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00,
  0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0xFC,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07,
  0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x7F, 0xE0, 0x3F, 0xFF, 0xF9, 0xFF, 0x80, 0x7F, 0xFF, 0xCF, 0xFE, 0x00,
  0xFF, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0xFE, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x02, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF,
  0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0xFF, 0x80, 0xFF, 0xBF, 0xFF, 0xFF, 0x01,
  0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xFC, 0xFF, 0x87, 0xFF, 0x0F, 0xF9, 0xFE,
  0x07, 0xFF, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x9F, 0xF0, 0x1F, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xFF, 0xFC, 0x7F,
  0x80, 0x1F, 0xFF, 0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 20, 53, 43, 12, -53 },
  { 134, 29, 22, 43, 11, -53 },
  { 214, 45, 53, 43, 0, -53 },
  { 513, 41, 73, 43, 2, -63 },
  { 888, 53, 53, 43, -4, -53 },
  { 1240, 42, 54, 43, 0, -53 },
  { 1524, 13, 22, 43, 19, -53 },
  { 1560, 32, 70, 43, 9, -61 },
  { 1840, 31, 70, 43, 4, -61 },
  { 2112, 39, 38, 43, 3, -44 },
  { 2298, 37, 35, 43, 4, -41 },
  { 2460, 22, 23, 43, 5, -11 },
  { 2524, 27, 10, 43, 9, -29 },
  { 2558, 15, 15, 43, 12, -14 },
  { 2587, 47, 68, 43, -1, -60 },
  { 2987, 39, 54, 43, 3, -53 },
  { 3251, 36, 53, 43, 3, -53 },
  { 3490, 40, 53, 43, 2, -53 },
  { 3755, 40, 54, 43, 2, -53 },
  { 4025, 39, 53, 43, 2, -53 },
  { 4284, 40, 54, 43, 2, -53 },
  { 4554, 38, 54, 43, 2, -53 },
  { 4811, 39, 53, 43, 6, -53 },
  { 5070, 40, 54, 43, 2, -53 },
  { 5340, 38, 53, 43, 5, -53 },
  { 5592, 19, 41, 43, 12, -40 },
  { 5690, 26, 52, 43, 5, -40 },
  { 5859, 37, 40, 43, 5, -44 },
  { 6044, 36, 28, 43, 4, -38 },
  { 6170, 38, 40, 43, 2, -44 },
  { 6360, 33, 53, 43, 8, -53 },
  { 6579, 46, 66, 43, -1, -53 },
  { 6959, 39, 53, 43, -1, -53 },
  { 7218, 41, 53, 43, 2, -53 },
  { 7490, 40, 54, 43, 3, -53 },
  { 7760, 42, 53, 43, 1, -53 },
  { 8039, 40, 53, 43, 3, -53 },
  { 8304, 42, 53, 43, 2, -53 },
  { 8583, 40, 54, 43, 3, -53 },
  { 8853, 42, 53, 43, 2, -53 },
  { 9132, 40, 53, 43, 3, -53 },
  { 9397, 43, 54, 43, 0, -53 },
  { 9688, 44, 53, 43, 2, -53 },
  { 9980, 33, 53, 43, 4, -53 },
  { 10199, 45, 53, 43, 0, -53 },
  { 10498, 43, 53, 43, 1, -53 },
  { 10783, 39, 54, 43, 3, -53 },
  { 11047, 42, 53, 43, 2, -53 },
  { 11326, 39, 66, 43, 3, -53 },
  { 11648, 41, 53, 43, 2, -53 },
  { 11920, 42, 54, 43, 1, -53 },
  { 12204, 40, 53, 43, 6, -53 },
  { 12469, 42, 54, 43, 2, -53 },
  { 12753, 40, 53, 43, 7, -53 },
  { 13018, 46, 53, 43, 2, -53 },
  { 13323, 48, 53, 43, -2, -53 },
  { 13641, 41, 53, 43, 6, -53 },
  { 13913, 40, 53, 43, 2, -53 },
  { 14178, 32, 68, 43, 8, -60 },
  { 14450, 25, 68, 43, 10, -60 },
  { 14663, 32, 68, 43, 5, -60 },
  { 14935, 35, 29, 43, 5, -53 },
  { 15062, 36, 10, 43, -1, 2 },
  { 15107, 17, 11, 43, 17, -57 },
  { 15131, 40, 41, 43, 2, -40 },
  { 15336, 39, 54, 43, 2, -53 },
  { 15600, 38, 41, 43, 3, -40 },
  { 15795, 42, 54, 43, 2, -53 },
  { 16079, 37, 41, 43, 3, -40 },
  { 16269, 49, 66, 43, -4, -53 },
  { 16674, 39, 53, 43, 3, -40 },
  { 16933, 39, 53, 43, 2, -53 },
  { 17192, 37, 57, 43, 2, -57 },
  { 17456, 40, 70, 43, 0, -57 },
  { 17806, 43, 53, 43, 2, -53 },
  { 18091, 34, 53, 43, 5, -53 },
  { 18317, 43, 40, 43, 0, -40 },
  { 18532, 39, 40, 43, 2, -40 },
  { 18727, 37, 41, 43, 3, -40 },
  { 18917, 42, 53, 43, -1, -40 },
  { 19196, 40, 53, 43, 2, -40 },
  { 19461, 40, 40, 43, 3, -40 },
  { 19661, 40, 41, 43, 1, -40 },
  { 19866, 38, 50, 43, 4, -50 },
  { 20104, 39, 41, 43, 3, -40 },
  { 20304, 39, 40, 43, 5, -40 },
  { 20499, 43, 40, 43, 3, -40 },
  { 20714, 44, 40, 43, -1, -40 },
  { 20934, 38, 53, 43, 3, -40 },
  { 21186, 38, 40, 43, 2, -40 },
  { 21376, 38, 68, 43, 6, -60 },
  { 21699, 21, 68, 43, 12, -60 },
  { 21878, 39, 68, 43, 1, -60 },
  { 22210, 39, 19, 43, 3, -35 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic72pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic72pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC72PT7B_H_
