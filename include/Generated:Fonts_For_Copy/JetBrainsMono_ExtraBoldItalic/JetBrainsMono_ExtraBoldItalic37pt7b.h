#ifndef _JETBRAINSMONO_EXTRABOLDITALIC37PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xF0, 0x7E, 0x1F,
  0xC1, 0xF0, 0x00, 0x3E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7C,
  0x3E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8,
  0x7C, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xE0, 0x03, 0xC3,
  0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x07, 0x80, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0x78, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xE6, 0x7E,
  0x3E, 0x73, 0xF1, 0xF3, 0x80, 0x1F, 0x98, 0x00, 0xFE, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0x9F, 0x80, 0x1C, 0xFC, 0x00, 0xE7,
  0xE7, 0xE7, 0x3F, 0x3F, 0x33, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0xE0, 0x7F, 0xC0, 0x78, 0x1F, 0xF8, 0x1E, 0x03, 0x87, 0x07, 0x80, 0xF0,
  0xE0, 0xE0, 0x1E, 0x1C, 0x3C, 0x03, 0xC7, 0x8F, 0x00, 0x78, 0xF3, 0xC0,
  0x0F, 0x1E, 0xF0, 0x01, 0xFF, 0xBC, 0x00, 0x1F, 0xEF, 0x00, 0x01, 0xFB,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xEF, 0xC0, 0x00, 0x7B, 0xFE, 0x00, 0x1E, 0xFF, 0xC0, 0x07, 0x9E,
  0x78, 0x01, 0xE7, 0x87, 0x00, 0x38, 0xF0, 0xE0, 0x0F, 0x1E, 0x3C, 0x03,
  0xC3, 0xC7, 0x80, 0xF0, 0x78, 0xF0, 0x3C, 0x0F, 0xFC, 0x0F, 0x00, 0xFF,
  0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x13, 0xFF, 0x8F, 0x8F, 0xBF,
  0x7E, 0x7E, 0x7D, 0xF1, 0xF1, 0xFF, 0x87, 0xC3, 0xFE, 0x1F, 0x0F, 0xF0,
  0x7C, 0x1F, 0x81, 0xF0, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xEF, 0x81, 0xFE, 0x3F, 0x00, 0x7E, 0xF9, 0xF7, 0xEF,
  0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0x20, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0xFE, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x02, 0x0F, 0x06, 0x78, 0xF1, 0xE7,
  0xE6, 0x7E, 0xFF, 0x6F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x1E, 0x00,
  0x03, 0xF8, 0x00, 0xF3, 0xC0, 0x1F, 0x3E, 0x03, 0xF3, 0xE0, 0x7E, 0x3F,
  0x07, 0xC1, 0xF0, 0x38, 0x1C, 0x00, 0x80, 0x80, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0xFE, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0,
  0xF8, 0x7C, 0x07, 0xE3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F,
  0x80, 0x7C, 0x7C, 0xE3, 0xE3, 0xEF, 0xBF, 0x1F, 0x7D, 0xF8, 0xFB, 0xEF,
  0x8F, 0xCE, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8,
  0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xFE, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBE, 0x07, 0xCF,
  0xC0, 0xF1, 0xF8, 0x18, 0x3F, 0x02, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xC1, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x07, 0xE1, 0xF8, 0x7F,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x3E, 0x1F, 0x83, 0xE3, 0xF0, 0x7E, 0x7F, 0x07,
  0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0xE0, 0x07, 0xDF, 0xE0,
  0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFC, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x7C, 0x3F, 0x07, 0xE1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC4, 0x01, 0xFB, 0xF8,
  0x1F, 0x7F, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF0, 0x7E, 0x7E, 0x03,
  0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0,
  0xFC, 0x7F, 0x1F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFE, 0x7F, 0x0F,
  0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xFC, 0x1F,
  0x07, 0xF3, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xFE, 0x03, 0xFB, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xFC, 0x7F, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xF9, 0xFE, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x7E,
  0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFD, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0x03, 0xF1, 0xFC, 0x7F, 0x3F, 0xC7, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0x3F,
  0xCF, 0xF3, 0xF8, 0x7C, 0x00, 0x00, 0xE0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x81, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x78, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFE, 0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF,
  0x87, 0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x3F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x0F, 0xDF, 0x1E, 0x1F,
  0xFE, 0x1E, 0x1F, 0xFE, 0x1E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x3E, 0x7C,
  0x3E, 0x3E, 0x7C, 0x3E, 0x3C, 0x7C, 0x3C, 0x3C, 0x78, 0x3C, 0x3C, 0x78,
  0x3C, 0x7C, 0x78, 0x3C, 0x7C, 0x78, 0x7C, 0x7C, 0x7C, 0xFC, 0x78, 0x7F,
  0xFC, 0x78, 0x7F, 0x78, 0x78, 0x1E, 0x78, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE4, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F,
  0x8F, 0xC0, 0xF8, 0x3E, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0,
  0x3E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0xFF, 0x00, 0x7E, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0xFF, 0x8F, 0xC0,
  0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x8F,
  0xC1, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x07, 0xC1, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xF1, 0xF1, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x7F, 0x8F, 0xC0, 0xFC,
  0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7E, 0x3F, 0x07, 0xE1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xC1, 0xFC, 0x7C,
  0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C,
  0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0,
  0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0xF8, 0x0F, 0xC7,
  0xC0, 0x7E, 0x3E, 0x0F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x7F, 0x8F, 0xC0, 0xFC,
  0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xCF,
  0xC7, 0xFC, 0x7E, 0x3F, 0xE3, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F,
  0xC7, 0xC0, 0x7E, 0x3F, 0x07, 0xE1, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x7E, 0x1F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x8F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7C, 0x3E, 0x03, 0xE0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xFB, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x1F,
  0x01, 0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x3F,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xF0, 0x3F,
  0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F, 0xF1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xF8, 0xEF, 0x0F, 0x71, 0xDE, 0x1E,
  0xE7, 0xFC, 0x3D, 0xEE, 0xF8, 0x7B, 0xFD, 0xF1, 0xF3, 0xF3, 0xE3, 0xE7,
  0xEF, 0x87, 0xCF, 0xDF, 0x0F, 0x9F, 0x3E, 0x1F, 0x3E, 0x7C, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1F,
  0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x7C, 0x3F, 0x81, 0xE1,
  0xFE, 0x0F, 0x87, 0xF8, 0x3E, 0x1F, 0xE0, 0xF8, 0x7F, 0x83, 0xE1, 0xFE,
  0x0F, 0x87, 0xFC, 0x3C, 0x1E, 0xF1, 0xF0, 0xFB, 0xC7, 0xC3, 0xEF, 0x1F,
  0x0F, 0xBC, 0x7C, 0x3E, 0xF9, 0xF0, 0xF9, 0xE7, 0xC3, 0xC7, 0x9E, 0x1F,
  0x1E, 0xF8, 0x7C, 0x7B, 0xE1, 0xF1, 0xEF, 0x87, 0xC7, 0xFE, 0x1F, 0x0F,
  0xF8, 0x7C, 0x3F, 0xC3, 0xE0, 0xFF, 0x0F, 0x83, 0xFC, 0x3E, 0x0F, 0xF0,
  0xF8, 0x1F, 0xC3, 0xE0, 0x7F, 0x0F, 0x81, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xC0,
  0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F,
  0x8F, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8,
  0x0F, 0xC7, 0xC0, 0x7C, 0x3F, 0x07, 0xE1, 0xFE, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3,
  0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xC0, 0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8,
  0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8,
  0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01,
  0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3F, 0x07, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xC1, 0xFC, 0x7E, 0x07, 0xE3,
  0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x0F,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xE0,
  0x7E, 0x3E, 0x03, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xFE, 0xFF, 0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xE3, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x07, 0xE3, 0xFE, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0xFC, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0xFC, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xF0, 0xF8,
  0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x87, 0xE0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xC1, 0xF8, 0x3F, 0x07,
  0xFB, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7E,
  0xF8, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F,
  0x8F, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7,
  0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7D,
  0xF0, 0x07, 0xDF, 0x00, 0x7D, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x3E,
  0x1F, 0x3C, 0x3E, 0x1E, 0x3C, 0x3E, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x7E,
  0x3C, 0x3C, 0x7E, 0x3C, 0x3C, 0x6E, 0x7C, 0x3C, 0x6E, 0x7C, 0x7C, 0xEC,
  0x78, 0x7C, 0xEC, 0x78, 0x7C, 0xCC, 0xF8, 0x7D, 0xCC, 0xF8, 0x79, 0xCC,
  0xF0, 0x79, 0xDC, 0xF0, 0x79, 0x9C, 0xF0, 0x7B, 0x9D, 0xE0, 0x7B, 0x9D,
  0xE0, 0x7B, 0x9D, 0xE0, 0x7B, 0x1D, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x76, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0xFE, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x83, 0xF0,
  0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x0F,
  0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xFB, 0xE0,
  0x0F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xC3, 0xE0, 0x7E, 0x1F, 0x07, 0xE0,
  0xFC, 0x3E, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xC0,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC1, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3E, 0x78,
  0x1F, 0x3E, 0x1F, 0x1F, 0x1F, 0x8F, 0x8F, 0x87, 0xCF, 0xC1, 0xF7, 0xC0,
  0xFF, 0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF8, 0x00, 0xE0, 0x00,
  0x3F, 0x9F, 0x0F, 0xFD, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0x7F,
  0x3F, 0x07, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFE, 0xF8, 0x1F,
  0xCF, 0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x87, 0x01, 0xF3, 0xFC, 0x1F, 0x7F,
  0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF8, 0x7E, 0x3F, 0x03, 0xF3, 0xF0,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7F, 0xBF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xBF, 0xE0, 0xF9, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF8,
  0x7F, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE7,
  0xE0, 0xFC, 0x7F, 0xBF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0x87, 0xC0, 0x7F, 0x3E,
  0x0F, 0xFD, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0,
  0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0xFC, 0x3F, 0x07,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0x7C, 0x07,
  0xF3, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x7E, 0x0F, 0xC7, 0xFF, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x9F, 0x0F,
  0xFD, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0x7F, 0x3F, 0x07, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xEF, 0xC0, 0xF8, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x87, 0x01, 0xF3, 0xFC,
  0x1F, 0x7F, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF8, 0x7E, 0x3F, 0x07,
  0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x47, 0xE0, 0x7E, 0x1F, 0x03, 0xF8, 0x7C, 0x0F, 0xC1,
  0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x00, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0x30, 0x60,
  0x7B, 0xE7, 0xE1, 0xEF, 0xDF, 0x87, 0xFF, 0xFF, 0x1F, 0x3C, 0xFC, 0xF8,
  0xF1, 0xF3, 0xE3, 0xC7, 0x8F, 0x8F, 0x3E, 0x3E, 0x38, 0xF8, 0xF9, 0xE3,
  0xE3, 0xC7, 0x8F, 0x9F, 0x1E, 0x3E, 0x7C, 0x78, 0xF1, 0xF1, 0xE7, 0xC7,
  0xC7, 0x1F, 0x1F, 0x3C, 0x7C, 0x78, 0xF1, 0xF3, 0xE3, 0xC7, 0xCF, 0x8F,
  0x1E, 0x3E, 0x3C, 0x78, 0xF8, 0xE3, 0xE0, 0x00, 0x07, 0x01, 0xF3, 0xFC,
  0x1F, 0x7F, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF8, 0x7E, 0x3F, 0x07,
  0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8, 0xF8, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xF8, 0x7E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0,
  0x3E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x7E, 0x7C,
  0x07, 0xC7, 0xE0, 0xFC, 0x7F, 0xBF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x7C, 0xFF, 0x03, 0xEF,
  0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE1, 0xF8, 0x7E, 0x07, 0xE3,
  0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0xFC, 0x3F,
  0xDF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xCF, 0xE0,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0x9F,
  0x0F, 0xFD, 0xF1, 0xFF, 0xDF, 0x1F, 0xFF, 0xF3, 0xF8, 0x7F, 0x3F, 0x07,
  0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFE, 0xF8, 0x1F, 0xCF, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0xFD, 0xFF, 0x07, 0xFF,
  0xFC, 0x3E, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0x7E, 0x0F, 0xE3,
  0xE0, 0x3F, 0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF3, 0xF0, 0x3F, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0x81, 0xF1, 0xF0,
  0x1F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0x7C, 0x07, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xFB, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0xF8, 0x03,
  0xFF, 0x80, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x87, 0xC1,
  0xF8, 0x7C, 0x1F, 0x87, 0xC3, 0xF0, 0x7C, 0x3F, 0x07, 0xE3, 0xE0, 0x7E,
  0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x3F, 0xE1, 0xF1, 0xEF, 0x1F,
  0x8F, 0x78, 0xDC, 0xFB, 0xC6, 0xE7, 0x9E, 0x77, 0x3C, 0xF3, 0xBB, 0xE7,
  0x99, 0xDE, 0x3D, 0xCE, 0xF1, 0xEE, 0x77, 0x8F, 0x63, 0xFC, 0x7F, 0x1B,
  0xC3, 0xF8, 0xDE, 0x1F, 0xC6, 0xF0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F,
  0x0F, 0xC1, 0xF0, 0x7C, 0x00, 0x0F, 0xC0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xF0,
  0x07, 0xE3, 0xE0, 0x1F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFC, 0x0F, 0xC7,
  0xF0, 0x1F, 0xC0, 0x1F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xF1, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xEF, 0xC1, 0xFC, 0xF8,
  0x02, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xE1, 0xE7, 0xFF, 0x8F, 0x3C,
  0x7F, 0xF9, 0xE1, 0xFF, 0xDF, 0x0F, 0xFC, 0xF8, 0x3F, 0xC0, 0x00, 0x70,
  0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 11, 27, 22, 6, -27 },
  { 39, 16, 11, 22, 5, -27 },
  { 61, 23, 27, 22, 0, -27 },
  { 139, 21, 37, 22, 1, -32 },
  { 237, 27, 27, 22, -2, -27 },
  { 329, 22, 27, 22, 0, -27 },
  { 404, 7, 11, 22, 10, -27 },
  { 414, 16, 36, 22, 5, -31 },
  { 486, 16, 36, 22, 2, -31 },
  { 558, 20, 20, 22, 2, -23 },
  { 608, 19, 18, 22, 2, -21 },
  { 651, 11, 12, 22, 3, -6 },
  { 668, 13, 5, 22, 5, -15 },
  { 677, 8, 7, 22, 6, -7 },
  { 684, 24, 35, 22, 0, -31 },
  { 789, 21, 27, 22, 1, -27 },
  { 860, 19, 27, 22, 1, -27 },
  { 925, 21, 27, 22, 1, -27 },
  { 996, 21, 27, 22, 1, -27 },
  { 1067, 20, 27, 22, 1, -27 },
  { 1135, 21, 27, 22, 1, -27 },
  { 1206, 20, 27, 22, 1, -27 },
  { 1274, 20, 27, 22, 3, -27 },
  { 1342, 21, 27, 22, 1, -27 },
  { 1413, 19, 27, 22, 3, -27 },
  { 1478, 10, 21, 22, 6, -21 },
  { 1505, 13, 27, 22, 3, -21 },
  { 1549, 20, 21, 22, 2, -23 },
  { 1602, 19, 14, 22, 2, -19 },
  { 1636, 19, 21, 22, 1, -23 },
  { 1686, 17, 27, 22, 4, -27 },
  { 1744, 24, 34, 22, -1, -27 },
  { 1846, 21, 27, 22, -1, -27 },
  { 1917, 21, 27, 22, 1, -27 },
  { 1988, 21, 27, 22, 1, -27 },
  { 2059, 21, 27, 22, 1, -27 },
  { 2130, 21, 27, 22, 1, -27 },
  { 2201, 22, 27, 22, 1, -27 },
  { 2276, 21, 27, 22, 1, -27 },
  { 2347, 21, 27, 22, 1, -27 },
  { 2418, 21, 27, 22, 1, -27 },
  { 2489, 22, 27, 22, 0, -27 },
  { 2564, 23, 27, 22, 1, -27 },
  { 2642, 17, 27, 22, 2, -27 },
  { 2700, 23, 27, 22, 0, -27 },
  { 2778, 22, 27, 22, 1, -27 },
  { 2853, 21, 27, 22, 1, -27 },
  { 2924, 22, 27, 22, 1, -27 },
  { 2999, 21, 34, 22, 1, -27 },
  { 3089, 21, 27, 22, 1, -27 },
  { 3160, 21, 27, 22, 1, -27 },
  { 3231, 20, 27, 22, 3, -27 },
  { 3299, 22, 27, 22, 1, -27 },
  { 3374, 20, 27, 22, 4, -27 },
  { 3442, 24, 27, 22, 1, -27 },
  { 3523, 25, 27, 22, -1, -27 },
  { 3608, 21, 27, 22, 3, -27 },
  { 3679, 21, 27, 22, 1, -27 },
  { 3750, 17, 35, 22, 4, -31 },
  { 3825, 13, 35, 22, 5, -31 },
  { 3882, 17, 35, 22, 2, -31 },
  { 3957, 17, 14, 22, 3, -27 },
  { 3987, 18, 5, 22, 0, 1 },
  { 3999, 9, 5, 22, 9, -29 },
  { 4005, 20, 21, 22, 1, -21 },
  { 4058, 20, 27, 22, 1, -27 },
  { 4126, 20, 21, 22, 1, -21 },
  { 4179, 21, 27, 22, 1, -27 },
  { 4250, 20, 21, 22, 1, -21 },
  { 4303, 25, 34, 22, -2, -27 },
  { 4410, 20, 28, 22, 1, -21 },
  { 4480, 20, 27, 22, 1, -27 },
  { 4548, 19, 29, 22, 1, -29 },
  { 4617, 21, 36, 22, 0, -29 },
  { 4712, 22, 27, 22, 1, -27 },
  { 4787, 17, 27, 22, 3, -27 },
  { 4845, 22, 21, 22, 0, -21 },
  { 4903, 20, 21, 22, 1, -21 },
  { 4956, 20, 21, 22, 1, -21 },
  { 5009, 21, 28, 22, 0, -21 },
  { 5083, 20, 28, 22, 1, -21 },
  { 5153, 21, 21, 22, 1, -21 },
  { 5209, 20, 21, 22, 1, -21 },
  { 5262, 19, 26, 22, 2, -26 },
  { 5324, 20, 20, 22, 1, -20 },
  { 5374, 20, 20, 22, 3, -20 },
  { 5424, 21, 20, 22, 2, -20 },
  { 5477, 23, 20, 22, -1, -20 },
  { 5535, 20, 27, 22, 1, -20 },
  { 5603, 20, 20, 22, 1, -20 },
  { 5653, 20, 35, 22, 3, -31 },
  { 5741, 11, 35, 22, 6, -31 },
  { 5790, 20, 35, 22, 0, -31 },
  { 5878, 21, 10, 22, 1, -18 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC37PT7B_H_
