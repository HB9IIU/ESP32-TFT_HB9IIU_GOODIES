#ifndef _JETBRAINSMONO_EXTRABOLDITALIC32PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0x7C, 0xFB, 0xC7, 0xFE, 0x3F, 0xF1, 0xEF, 0x9F, 0x7C,
  0xFB, 0xC7, 0xDE, 0x3C, 0xF1, 0xE0, 0x00, 0xF0, 0xE0, 0x0E, 0x1E, 0x00,
  0xE1, 0xC0, 0x1E, 0x1C, 0x01, 0xC3, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0,
  0x0F, 0x0E, 0x00, 0xE1, 0xE0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x3C, 0x38, 0x03, 0x87, 0x80, 0x38, 0x70, 0x07, 0x87,
  0x00, 0x70, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF,
  0xCF, 0xD9, 0xF3, 0xE6, 0x7C, 0xF9, 0x80, 0x3E, 0xE0, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x06,
  0x7C, 0x01, 0x9F, 0x00, 0x63, 0xCF, 0x99, 0xF3, 0xF6, 0xFC, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x00, 0x40, 0x01, 0x03, 0xF8, 0x0E, 0x07, 0xF8,
  0x1C, 0x0F, 0x3C, 0x38, 0x0E, 0x3C, 0x78, 0x0E, 0x38, 0xF0, 0x0E, 0x39,
  0xE0, 0x0E, 0x39, 0xC0, 0x0F, 0xFB, 0x80, 0x0F, 0xF7, 0x00, 0x07, 0xEE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x79, 0x80, 0x00, 0xF7,
  0xE0, 0x00, 0xEF, 0xF0, 0x01, 0xDE, 0x70, 0x03, 0x9C, 0x78, 0x07, 0x1C,
  0x70, 0x0E, 0x1C, 0x70, 0x1E, 0x3C, 0x70, 0x3C, 0x1F, 0xF0, 0x78, 0x1F,
  0xE0, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x7C, 0xF8, 0x0F, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x3E, 0x7B,
  0xE7, 0x9F, 0x7D, 0xE3, 0xE7, 0xFC, 0x78, 0xFF, 0x0F, 0x0F, 0xE1, 0xE0,
  0xF8, 0x3C, 0x1F, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFE,
  0x7C, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0xF8, 0x00, 0x04, 0x00, 0xF0,
  0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x0F,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0xFE,
  0x0F, 0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xC0, 0x08, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x20, 0xE0, 0x8E, 0x38, 0xE7,
  0xCE, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x3E, 0x00, 0x1D,
  0xC0, 0x0F, 0x78, 0x07, 0x9F, 0x07, 0xE3, 0xE0, 0xF0, 0xF0, 0x18, 0x30,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C,
  0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0xFF, 0xE0, 0x3C, 0xFD, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3C, 0x07,
  0x8F, 0x01, 0xE3, 0xDE, 0x79, 0xF7, 0xBE, 0x7D, 0xEF, 0x9F, 0x7B, 0xE7,
  0xC8, 0xF1, 0xE0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xCF, 0x81, 0xF1, 0xF0,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1E, 0x7C, 0x18, 0x78,
  0x10, 0xF8, 0x20, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC3, 0xE3, 0xE0, 0x78,
  0xF8, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x4F, 0xC3, 0xC7, 0xC3, 0xE7, 0xC1, 0xF3, 0xC0, 0xF9,
  0xE0, 0x7C, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x0F, 0xFF, 0xC3, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x3E, 0x07, 0xCF,
  0xC3, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xBE, 0x0F, 0xFF, 0x8F, 0xFF,
  0xE7, 0xF3, 0xF3, 0xE0, 0xFF, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0x7C,
  0x0F, 0xBF, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0x80,
  0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7C, 0x0F, 0x9F,
  0x07, 0xC7, 0x81, 0xF2, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x1F, 0x9F, 0x87, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x0F,
  0x87, 0xC7, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x83,
  0xE3, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xF0,
  0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xF0,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xF3, 0xFB, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x07, 0xCF, 0xFF, 0xE7,
  0xFF, 0xE1, 0xFF, 0xF0, 0x7D, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x0F, 0x0F, 0xCF, 0xE7, 0xF1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE1, 0xF9, 0xFC, 0xFC, 0x3E, 0x00, 0x01, 0xE0,
  0x3F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x3F, 0xFF,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0x18, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x7F, 0xC1,
  0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x01, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F, 0x80,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x81, 0xE1, 0xE0, 0x1F, 0x1E, 0x00, 0xF3,
  0xC0, 0x0F, 0x3C, 0x1C, 0xF3, 0xC7, 0xEE, 0x78, 0xFE, 0xE7, 0x8F, 0x1E,
  0x79, 0xE1, 0xE7, 0x9E, 0x1E, 0x79, 0xE1, 0xE7, 0x9E, 0x1E, 0x71, 0xE3,
  0xCF, 0x1E, 0x3C, 0xF1, 0xE3, 0xCF, 0x1F, 0xFC, 0xF1, 0xFF, 0xCF, 0x0F,
  0xBC, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1E,
  0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x1E,
  0x07, 0x87, 0x83, 0xE1, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87,
  0xFF, 0xE3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0xC0,
  0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0xFF, 0x83,
  0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x07, 0xC7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x78, 0x0F, 0x9E, 0x07, 0xCF, 0x83, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x07, 0xCF, 0x81, 0xF1,
  0xF0, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x1F,
  0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1E, 0x0F, 0xCF, 0x81,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xC0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78,
  0x1F, 0x3E, 0x07, 0xCF, 0x8F, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F,
  0xFF, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF1, 0xFE, 0x7C, 0x7F, 0x9F, 0x1F, 0xE7, 0xCF, 0xF9,
  0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0x07, 0xC7, 0xC1,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8,
  0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F,
  0xFF, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07,
  0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE0,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xF0,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x1F,
  0x03, 0xF1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x1E, 0x1F, 0x83,
  0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xC7, 0x80, 0x7C, 0x7C,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x83, 0xC0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0xEF, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x87,
  0xF1, 0xF8, 0x7F, 0x1F, 0xCE, 0xE1, 0xDC, 0xFE, 0x1D, 0xCF, 0xE3, 0xDD,
  0xDE, 0x3D, 0xDD, 0xE3, 0xDF, 0xBE, 0x3D, 0xFB, 0xC3, 0xCF, 0x3C, 0x3C,
  0xF3, 0xC7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0x87,
  0x80, 0x78, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xF0, 0x0F, 0x80, 0x1F, 0x83, 0xE3, 0xF0, 0x78, 0x7E, 0x0F, 0x0F, 0xC1,
  0xE3, 0xFC, 0x3C, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xEE, 0x3C, 0x3D, 0xC7,
  0x87, 0xBC, 0xF1, 0xF7, 0x9E, 0x3E, 0xF3, 0xC7, 0x9E, 0xF8, 0xF1, 0xDE,
  0x1E, 0x3B, 0xC3, 0xC7, 0xF8, 0x78, 0xFF, 0x1F, 0x1F, 0xE3, 0xC1, 0xFC,
  0x78, 0x3F, 0x0F, 0x07, 0xE1, 0xE0, 0xFC, 0x3C, 0x1F, 0x80, 0x00, 0x78,
  0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xC1, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1E, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x03,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xC7, 0xC1, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xC3,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xC0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x1E, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFC,
  0x1F, 0xFE, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0x7C, 0x1E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x81, 0xF0, 0x00,
  0x70, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xCF, 0x81, 0xF3, 0xF0, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C,
  0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0,
  0x3C, 0x3E, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x03,
  0xE1, 0xF0, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xF8,
  0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0x78, 0x1F,
  0x1E, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF8, 0x78, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x07, 0xDF, 0x00, 0xF7,
  0x80, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x38, 0x78, 0xF7, 0x8F, 0x8F, 0x78, 0xF8,
  0xE7, 0x8F, 0x9E, 0x78, 0xF9, 0xE7, 0x9F, 0x1E, 0x79, 0xF1, 0xC7, 0x9B,
  0x3C, 0x79, 0xB3, 0xC7, 0xBB, 0x3C, 0x7B, 0x33, 0x87, 0x33, 0x78, 0x73,
  0x37, 0x87, 0x73, 0x78, 0x76, 0x37, 0x07, 0x63, 0x70, 0x7E, 0x7F, 0x0F,
  0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xF8, 0x7C, 0x00, 0x0F, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xFC, 0x07,
  0xC7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00,
  0x7C, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x03,
  0xE3, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xE7, 0x81, 0xF1, 0xF0,
  0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x03, 0xC7, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8,
  0x07, 0xBC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC1, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xF8,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0xFE,
  0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC1, 0xFF,
  0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xBC, 0x0F, 0x3C, 0x0F, 0x3C, 0x1E,
  0x3C, 0x3E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFC, 0x3E, 0x3E, 0x1F, 0x03, 0xC7, 0x87,
  0xFB, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF3, 0xF9, 0xF0, 0xFD, 0xF0, 0x3E,
  0xF8, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xEF, 0x81,
  0xF7, 0xE1, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0x9F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF1,
  0xE0, 0xFB, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0x8F, 0xCF, 0x83, 0xE7,
  0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3E, 0x0F, 0xBF, 0x0F, 0x9F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xCF,
  0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF3, 0xF1, 0xF9,
  0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x81, 0xF3, 0xE1, 0xF9, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0xF1, 0xE0, 0xFF, 0x78, 0x7F, 0xFE, 0x3F, 0xFF,
  0x8F, 0xCF, 0xE3, 0xE1, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F, 0x07, 0xC7,
  0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0xC3, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x83, 0xF3, 0xE0, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF9, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8,
  0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x9E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0xF1, 0xF9, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC7, 0x87, 0xFB, 0xC7,
  0xFF, 0xE7, 0xFF, 0xF3, 0xF3, 0xF9, 0xF0, 0xFD, 0xF0, 0x3E, 0xF8, 0x1E,
  0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC7, 0xF3, 0xFF,
  0xF1, 0xFF, 0x78, 0x7F, 0x7C, 0x1F, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x83, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF1, 0xE0, 0xFB,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0x8F, 0xCF, 0x83, 0xE7, 0x81, 0xF7,
  0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F,
  0xBE, 0x07, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x0F, 0xCF, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xC7, 0xE0, 0xF8,
  0xF8, 0x1E, 0x3E, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7C, 0xF8, 0x0F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x07, 0xC0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87,
  0xFF, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFF, 0x80, 0x1E, 0xE3, 0x83, 0xBE, 0xF8, 0xFF, 0xFF, 0x9F, 0x7D, 0xF3,
  0xC7, 0x3E, 0x78, 0xE7, 0x8F, 0x3C, 0xF1, 0xE7, 0x9E, 0x7C, 0xE3, 0xCF,
  0x1C, 0x79, 0xE3, 0x8F, 0x3C, 0x73, 0xE7, 0x9E, 0x78, 0xF3, 0xCF, 0x3E,
  0x71, 0xE7, 0x8E, 0x3C, 0xF1, 0xC7, 0x9E, 0x39, 0xF0, 0x3E, 0x3C, 0x1F,
  0x7F, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0, 0x7C, 0xF0, 0x3E,
  0xF8, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81,
  0xF7, 0xC0, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x03, 0xEF, 0x81, 0xF3, 0xE1, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0x1F, 0x1E, 0x07, 0xDF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0x8F, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x9F, 0x87, 0xC7, 0xFF,
  0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0x7E, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xC7, 0x87,
  0xF3, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF3, 0xF9, 0xF0, 0xFD, 0xF0, 0x3E,
  0xF8, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xEF, 0x81,
  0xF7, 0xE1, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xBE, 0x1F, 0x9F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x1E, 0x3E, 0x07, 0xBF, 0xC1, 0xEF, 0xF8, 0xFF, 0xFF, 0x3F, 0x0F, 0xCF,
  0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC7,
  0xFF, 0xF3, 0xE0, 0xF9, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x01, 0xF7, 0xC0, 0xFB, 0xF9,
  0xFD, 0xFF, 0xFC, 0x7F, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0, 0x3E, 0x07, 0xCF, 0x81, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0xF8, 0x07, 0xFE, 0x03, 0xE7, 0x80, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03, 0xEF,
  0x80, 0xFB, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x70, 0xF1, 0xEE, 0x1E, 0x3D, 0xC3, 0xC7,
  0xB8, 0xF8, 0xE7, 0x1F, 0x3C, 0xE3, 0xE7, 0x9C, 0xFC, 0xE3, 0x9B, 0xBC,
  0x73, 0x77, 0x8E, 0xEE, 0xE1, 0xD9, 0xFC, 0x3B, 0x3F, 0x87, 0x67, 0xF0,
  0xFC, 0xDC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x0F, 0x80,
  0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0xFC, 0x03, 0xEF,
  0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xF9, 0xF0, 0x1F,
  0x9F, 0x03, 0xF0, 0xF8, 0x3E, 0x0F, 0x8F, 0xC0, 0x7C, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9E, 0x07, 0xCF, 0x87, 0xE7, 0xEF,
  0xE3, 0xFE, 0xF1, 0xFF, 0xF8, 0x7F, 0x7C, 0x0E, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x83, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0x80, 0xFE, 0x00,
  0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0xFC, 0x07, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x03,
  0x80, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x78, 0x3E, 0x0F, 0x80, 0x07, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0xF7, 0xFE, 0x3D, 0xEF, 0x9E, 0x71,
  0xFF, 0xBC, 0x3F, 0xEF, 0x0F, 0xF0, 0x00, 0xF0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 9, 23, 19, 5, -23 },
  { 27, 13, 9, 19, 5, -23 },
  { 42, 20, 23, 19, 0, -23 },
  { 100, 18, 32, 19, 1, -28 },
  { 172, 24, 24, 19, -2, -24 },
  { 244, 19, 24, 19, 0, -24 },
  { 301, 6, 9, 19, 8, -23 },
  { 308, 14, 31, 19, 4, -27 },
  { 363, 14, 31, 19, 2, -27 },
  { 418, 18, 17, 19, 1, -20 },
  { 457, 16, 15, 19, 2, -18 },
  { 487, 10, 10, 19, 2, -5 },
  { 500, 12, 5, 19, 4, -13 },
  { 508, 7, 6, 19, 5, -6 },
  { 514, 20, 31, 19, 0, -27 },
  { 592, 18, 24, 19, 1, -24 },
  { 646, 16, 23, 19, 1, -23 },
  { 692, 18, 24, 19, 1, -24 },
  { 746, 18, 23, 19, 1, -23 },
  { 798, 17, 23, 19, 1, -23 },
  { 847, 18, 23, 19, 1, -23 },
  { 899, 17, 23, 19, 1, -23 },
  { 948, 18, 23, 19, 2, -23 },
  { 1000, 18, 24, 19, 1, -24 },
  { 1054, 17, 24, 19, 2, -24 },
  { 1105, 9, 18, 19, 5, -18 },
  { 1126, 12, 23, 19, 2, -18 },
  { 1161, 17, 17, 19, 2, -19 },
  { 1198, 16, 13, 19, 2, -17 },
  { 1224, 17, 17, 19, 1, -19 },
  { 1261, 14, 23, 19, 4, -23 },
  { 1302, 20, 30, 19, 0, -24 },
  { 1377, 18, 23, 19, -1, -23 },
  { 1429, 18, 23, 19, 1, -23 },
  { 1481, 18, 24, 19, 1, -24 },
  { 1535, 18, 23, 19, 1, -23 },
  { 1587, 18, 23, 19, 1, -23 },
  { 1639, 19, 23, 19, 1, -23 },
  { 1694, 18, 24, 19, 1, -24 },
  { 1748, 18, 23, 19, 1, -23 },
  { 1800, 18, 23, 19, 1, -23 },
  { 1852, 19, 23, 19, 0, -23 },
  { 1907, 20, 23, 19, 1, -23 },
  { 1965, 15, 23, 19, 2, -23 },
  { 2009, 20, 23, 19, 0, -23 },
  { 2067, 19, 23, 19, 1, -23 },
  { 2122, 18, 24, 19, 1, -24 },
  { 2176, 19, 23, 19, 1, -23 },
  { 2231, 18, 30, 19, 1, -24 },
  { 2299, 18, 23, 19, 1, -23 },
  { 2351, 18, 24, 19, 1, -24 },
  { 2405, 17, 23, 19, 3, -23 },
  { 2454, 19, 23, 19, 1, -23 },
  { 2509, 18, 23, 19, 3, -23 },
  { 2561, 20, 23, 19, 1, -23 },
  { 2619, 21, 23, 19, -1, -23 },
  { 2680, 18, 23, 19, 3, -23 },
  { 2732, 18, 23, 19, 1, -23 },
  { 2784, 15, 31, 19, 3, -27 },
  { 2843, 12, 31, 19, 4, -27 },
  { 2890, 15, 31, 19, 2, -27 },
  { 2949, 16, 12, 19, 2, -23 },
  { 2973, 16, 4, 19, 0, 1 },
  { 2981, 8, 4, 19, 7, -25 },
  { 2985, 17, 18, 19, 1, -18 },
  { 3024, 17, 23, 19, 1, -23 },
  { 3073, 17, 18, 19, 1, -18 },
  { 3112, 18, 23, 19, 1, -23 },
  { 3164, 17, 18, 19, 1, -18 },
  { 3203, 22, 29, 19, -2, -23 },
  { 3283, 17, 24, 19, 1, -18 },
  { 3334, 17, 23, 19, 1, -23 },
  { 3383, 16, 25, 19, 1, -25 },
  { 3433, 18, 31, 19, 0, -25 },
  { 3503, 19, 23, 19, 1, -23 },
  { 3558, 15, 23, 19, 2, -23 },
  { 3602, 19, 18, 19, 0, -18 },
  { 3645, 17, 18, 19, 1, -18 },
  { 3684, 17, 18, 19, 1, -18 },
  { 3723, 18, 24, 19, 0, -18 },
  { 3777, 17, 24, 19, 1, -18 },
  { 3828, 18, 18, 19, 1, -18 },
  { 3869, 17, 18, 19, 1, -18 },
  { 3908, 17, 22, 19, 2, -22 },
  { 3955, 18, 18, 19, 1, -18 },
  { 3996, 18, 18, 19, 2, -18 },
  { 4037, 19, 18, 19, 1, -18 },
  { 4080, 20, 18, 19, -1, -18 },
  { 4125, 17, 24, 19, 1, -18 },
  { 4176, 17, 18, 19, 1, -18 },
  { 4215, 18, 31, 19, 2, -27 },
  { 4285, 10, 31, 19, 5, -27 },
  { 4324, 18, 31, 19, 0, -27 },
  { 4394, 18, 8, 19, 1, -15 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC32PT7B_H_
