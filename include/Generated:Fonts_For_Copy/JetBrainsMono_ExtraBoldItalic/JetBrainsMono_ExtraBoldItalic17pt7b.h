#ifndef _JETBRAINSMONO_EXTRABOLDITALIC17PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0xE7, 0x31, 0x8C, 0x00, 0x39, 0xC0, 0xEF, 0x9B, 0x36,
  0x6D, 0xC0, 0x0C, 0xC1, 0x98, 0xFF, 0xBF, 0xE1, 0x98, 0x26, 0x0C, 0xC7,
  0xFC, 0xFF, 0x8C, 0xC1, 0x98, 0x66, 0x00, 0x02, 0x00, 0x80, 0x60, 0x7E,
  0x3F, 0xCD, 0x73, 0x40, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x26, 0x6B, 0x9F,
  0xC3, 0xE0, 0x20, 0x18, 0x00, 0x08, 0x08, 0xF1, 0x8D, 0x98, 0x6D, 0x83,
  0x78, 0x1E, 0x80, 0x08, 0x00, 0xD0, 0x0F, 0xE0, 0xD3, 0x0C, 0x98, 0xC4,
  0x8C, 0x3C, 0x00, 0x06, 0x07, 0xE1, 0xF8, 0xE6, 0x38, 0x06, 0x07, 0xC1,
  0xB7, 0x6F, 0xB9, 0xCE, 0x73, 0xFC, 0x7F, 0x80, 0x76, 0x66, 0xE0, 0x07,
  0x0E, 0x1C, 0x38, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x60, 0x70,
  0x7C, 0x38, 0x08, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xC3, 0x87, 0x0E, 0x1C,
  0x30, 0xE3, 0x9F, 0x38, 0x60, 0x0C, 0x06, 0x3A, 0x7F, 0xF0, 0x81, 0xE1,
  0xB9, 0xCC, 0x44, 0x00, 0x0C, 0x0E, 0x07, 0x1F, 0xFF, 0xF7, 0xF8, 0x60,
  0x70, 0x39, 0xCC, 0xE6, 0x70, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0xE0,
  0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x0C, 0x1F, 0x9F, 0xEC,
  0x76, 0x3F, 0x1F, 0xFD, 0xF6, 0xC3, 0x61, 0xB1, 0xDF, 0xC7, 0xC0, 0x1E,
  0x7E, 0x6E, 0x4E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x06,
  0x07, 0xE3, 0xFC, 0xC7, 0x41, 0xC0, 0x60, 0x38, 0x1C, 0x1E, 0x0E, 0x07,
  0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xBF, 0xC1, 0xC1, 0x81, 0xE0, 0xF8, 0x1C,
  0x06, 0x07, 0x63, 0xBF, 0x8F, 0x80, 0x07, 0x87, 0x07, 0x07, 0x03, 0x03,
  0x9B, 0x8D, 0x8E, 0xFF, 0x7F, 0x81, 0x80, 0xC0, 0x7F, 0xBF, 0xDC, 0x0C,
  0x06, 0xE3, 0xFA, 0x0C, 0x06, 0x07, 0x63, 0xBF, 0x8F, 0x80, 0x07, 0x87,
  0x03, 0x83, 0x83, 0xA1, 0xFD, 0xCE, 0xC3, 0x61, 0xB1, 0xDF, 0xC7, 0xC0,
  0x7F, 0xDF, 0xE6, 0x3B, 0x8C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x0E,
  0x07, 0x01, 0xC0, 0x06, 0x07, 0xE3, 0xFC, 0xC7, 0x31, 0xCE, 0xE1, 0xF0,
  0xFE, 0x73, 0x98, 0x66, 0x39, 0xFC, 0x3E, 0x00, 0x0C, 0x1F, 0x9F, 0xEC,
  0x3E, 0x1F, 0x1D, 0xFC, 0xFE, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x00, 0x27,
  0x72, 0x00, 0x06, 0xEE, 0x08, 0x71, 0xC2, 0x00, 0x00, 0x0F, 0x38, 0xC7,
  0x18, 0xE0, 0x01, 0x83, 0xCF, 0x9F, 0x0C, 0x07, 0xC0, 0xF8, 0x1E, 0x02,
  0x00, 0x7F, 0xBF, 0x80, 0x00, 0x0F, 0xF7, 0xFB, 0xF8, 0x60, 0x78, 0x3E,
  0x0F, 0x03, 0x1F, 0x7C, 0xF0, 0x80, 0x7E, 0x7E, 0x06, 0x06, 0x1E, 0x7C,
  0x78, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0x03, 0x03, 0xF8, 0xE3, 0x38, 0x76,
  0x0C, 0xCF, 0x9B, 0x33, 0x66, 0xCC, 0xD9, 0x9B, 0x37, 0x67, 0xCC, 0x01,
  0xC0, 0x1F, 0x01, 0xE0, 0x0F, 0x07, 0x83, 0xC3, 0x61, 0xB1, 0xD8, 0xCE,
  0xFF, 0x7F, 0xB1, 0xF8, 0xFC, 0x70, 0x3F, 0x8F, 0xF3, 0x1C, 0xC7, 0x33,
  0x9F, 0x87, 0xF9, 0xC6, 0x61, 0x98, 0xE7, 0xF3, 0xF8, 0x0C, 0x1F, 0x9F,
  0xEC, 0x76, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x61, 0xB9, 0xDF, 0xC7, 0xC0,
  0x3F, 0x8F, 0xF3, 0x1C, 0xC7, 0x31, 0xDC, 0x77, 0x1D, 0xC6, 0x61, 0x99,
  0xE7, 0xF3, 0xF8, 0x7F, 0xBF, 0xDC, 0x0C, 0x06, 0x03, 0xFB, 0xFD, 0xC0,
  0xE0, 0x70, 0x3F, 0xDF, 0xC0, 0x3F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x1F,
  0xE7, 0xF9, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0x0C, 0x1F, 0x9F, 0xEC,
  0x76, 0x07, 0x03, 0xBF, 0xDE, 0xE3, 0x61, 0xB9, 0xDF, 0xC7, 0xC0, 0x38,
  0xCE, 0x73, 0x1C, 0xC7, 0x3F, 0xDF, 0xE7, 0xF9, 0xCE, 0x63, 0x98, 0xE6,
  0x3B, 0x8C, 0x7F, 0xBF, 0xC3, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18,
  0x1C, 0x3F, 0x9F, 0xC0, 0x07, 0xC3, 0xF0, 0x1C, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0xE3, 0xB8, 0xCF, 0xF1, 0xF8, 0x38, 0xE7, 0x38, 0xCE, 0x19,
  0xC3, 0xF0, 0xFC, 0x1F, 0xC3, 0xB8, 0x67, 0x0C, 0x61, 0x8E, 0x71, 0xC0,
  0x30, 0x30, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xFF, 0xFF,
  0x39, 0xE5, 0x39, 0xAF, 0x35, 0xE6, 0xAC, 0xDD, 0x9B, 0x73, 0x0C, 0x61,
  0x9C, 0x33, 0x86, 0x61, 0xC0, 0x38, 0xCF, 0x33, 0xCC, 0xF3, 0x7D, 0xDF,
  0x66, 0x59, 0x9E, 0x67, 0x99, 0xE6, 0x7B, 0x9E, 0x0C, 0x1F, 0x9F, 0xEC,
  0x76, 0x3F, 0x1F, 0x8D, 0xC6, 0xE3, 0x63, 0xB9, 0xDF, 0xC7, 0xC0, 0x3F,
  0x8F, 0xF3, 0x0C, 0xC3, 0x31, 0xDF, 0xE7, 0xF1, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x80, 0x0C, 0x1F, 0x9F, 0xEC, 0x76, 0x3F, 0x1F, 0x8D, 0xC6, 0xE3,
  0x63, 0xB9, 0xDF, 0xC7, 0xC0, 0x60, 0x30, 0x1C, 0x3F, 0x8F, 0xF3, 0x1C,
  0xC7, 0x31, 0xDF, 0xE7, 0xF1, 0xD8, 0x67, 0x19, 0xC6, 0x33, 0x8E, 0x06,
  0x07, 0xE3, 0xFC, 0xC7, 0x30, 0x0E, 0x03, 0xF0, 0x3E, 0x03, 0x80, 0x66,
  0x39, 0xFC, 0x3E, 0x00, 0xFF, 0xFF, 0x86, 0x07, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x1C, 0x0E, 0x00, 0x71, 0xB0, 0xD8, 0xEC, 0x7E, 0x3F,
  0x1B, 0x8D, 0xC6, 0xC7, 0x73, 0xBF, 0x8F, 0x80, 0xC3, 0xE1, 0xB1, 0xD8,
  0xCE, 0x67, 0x73, 0xB1, 0xF8, 0xF8, 0x3C, 0x1E, 0x0E, 0x00, 0xCC, 0xF3,
  0x3C, 0xDB, 0x76, 0xD5, 0xB5, 0x6F, 0x53, 0x9C, 0xE7, 0x39, 0xCE, 0xE3,
  0x38, 0x39, 0xE7, 0x38, 0x6E, 0x0F, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0,
  0x3F, 0x0E, 0x61, 0x8E, 0x71, 0xC0, 0xE1, 0xDC, 0xE7, 0x30, 0xDC, 0x36,
  0x0F, 0x83, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x7F, 0xBF, 0xC1,
  0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0xBF, 0x9F, 0xC0, 0x3F,
  0x3E, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0,
  0xF8, 0xF8, 0xF8, 0xE1, 0x86, 0x1C, 0x70, 0xC3, 0x0E, 0x38, 0xE1, 0x86,
  0x1C, 0x71, 0xC3, 0x1F, 0x3F, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C,
  0x0C, 0x0C, 0x1C, 0x1C, 0xFC, 0xF8, 0xF8, 0x0E, 0x1E, 0x3E, 0x37, 0x73,
  0xE3, 0xFF, 0xFF, 0xFF, 0xE7, 0x10, 0x3F, 0xDF, 0xFC, 0x6E, 0x37, 0x3B,
  0x1D, 0xCE, 0xFF, 0x3B, 0x00, 0x38, 0x0E, 0x03, 0x20, 0xDE, 0x3F, 0x9C,
  0x67, 0x19, 0xC6, 0x63, 0x9C, 0xE7, 0xF3, 0xB8, 0x08, 0x1F, 0x9F, 0xDC,
  0x7E, 0x07, 0x03, 0x01, 0xCE, 0xFE, 0x3E, 0x00, 0x01, 0x81, 0xC4, 0xEF,
  0xF7, 0xFF, 0x1B, 0x8D, 0xCE, 0xC7, 0x73, 0xBF, 0xCE, 0xC0, 0x08, 0x1F,
  0x9D, 0xDC, 0x6F, 0xF7, 0xFB, 0x01, 0x8E, 0xFE, 0x3E, 0x00, 0x03, 0xF0,
  0x7E, 0x07, 0x00, 0x60, 0x3F, 0xE3, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x0F, 0x80, 0xF0, 0x00, 0x10, 0x3F, 0xDF,
  0xFC, 0x6E, 0x37, 0x3B, 0x9D, 0xFE, 0xFF, 0x03, 0x01, 0x9F, 0xCF, 0x80,
  0x38, 0x0E, 0x03, 0x20, 0xDE, 0x3F, 0x9C, 0x67, 0x19, 0xC6, 0x63, 0x98,
  0xE6, 0x3B, 0x8C, 0x07, 0x03, 0x80, 0x00, 0x23, 0xE1, 0xF0, 0x18, 0x0C,
  0x0E, 0x07, 0x03, 0x0F, 0xFF, 0xF8, 0x03, 0x80, 0xE0, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x8F,
  0xE3, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x98, 0xE3, 0x38, 0xE6, 0x1F, 0xC3,
  0xF0, 0x77, 0x0C, 0xE1, 0x8C, 0x71, 0xC0, 0x7C, 0xFC, 0x1C, 0x18, 0x18,
  0x18, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0x04, 0x9B, 0x77, 0x6D, 0x93,
  0x6D, 0xDB, 0x66, 0xDB, 0xB6, 0xC9, 0xB6, 0x60, 0x02, 0x0D, 0xE3, 0xF9,
  0xC6, 0x71, 0x9C, 0x66, 0x39, 0x8E, 0x63, 0xB8, 0xC0, 0x08, 0x1F, 0x9F,
  0xDC, 0x6E, 0x37, 0x1B, 0x1D, 0xCE, 0xFE, 0x3E, 0x00, 0x02, 0x0D, 0xE3,
  0xF9, 0xC6, 0x71, 0x9C, 0x66, 0x39, 0xCE, 0x7F, 0x3B, 0x8E, 0x03, 0x80,
  0xE0, 0x00, 0x10, 0x3F, 0xDF, 0xFC, 0x6E, 0x37, 0x3B, 0x1D, 0xCE, 0xFF,
  0x3B, 0x01, 0x80, 0xC0, 0xE0, 0x12, 0x37, 0xDF, 0xEC, 0x76, 0x3F, 0x03,
  0x81, 0xC0, 0xC0, 0x60, 0x00, 0x04, 0x0F, 0xE3, 0xBD, 0xC0, 0x7E, 0x0F,
  0xE0, 0x3B, 0x8E, 0x7F, 0x9F, 0xC0, 0x1C, 0x0E, 0x06, 0x1F, 0xFF, 0xF9,
  0xC0, 0xE0, 0x70, 0x30, 0x18, 0x8F, 0x83, 0xC0, 0x63, 0xB1, 0xF8, 0xDC,
  0x6E, 0x36, 0x3B, 0x9D, 0xFC, 0x7C, 0x00, 0xE3, 0xF1, 0xD8, 0xCC, 0xE6,
  0x63, 0xF1, 0xF0, 0x78, 0x38, 0x00, 0xCC, 0xF7, 0x6D, 0xDB, 0x76, 0xFF,
  0x3B, 0xCE, 0xF3, 0xB8, 0xCE, 0x00, 0x79, 0xCE, 0xE1, 0xF0, 0x78, 0x1E,
  0x07, 0x83, 0xF1, 0xCC, 0xE3, 0x80, 0x63, 0xF1, 0xB8, 0xDC, 0x6C, 0x77,
  0x3B, 0xFD, 0xEC, 0x06, 0x07, 0x3F, 0x9F, 0x00, 0x3F, 0xCF, 0xE0, 0x78,
  0x38, 0x1C, 0x0E, 0x07, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0x83, 0xC3, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0xF8, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xF0,
  0x78, 0x1C, 0x39, 0xCC, 0x63, 0x39, 0xCE, 0x73, 0x19, 0xCE, 0x73, 0x98,
  0x1C, 0x1F, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x38, 0x1F, 0x0F, 0x8E, 0x06,
  0x03, 0x01, 0x83, 0xC3, 0xE1, 0xC0, 0x79, 0xFC, 0xF7, 0xF9, 0xE0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 12, 10, 3, -12 },
  { 9, 7, 5, 10, 3, -12 },
  { 14, 11, 12, 10, 0, -12 },
  { 31, 10, 17, 10, 0, -15 },
  { 53, 13, 13, 10, -1, -13 },
  { 75, 10, 13, 10, 0, -13 },
  { 92, 4, 5, 10, 4, -12 },
  { 95, 8, 16, 10, 2, -14 },
  { 111, 7, 16, 10, 1, -14 },
  { 125, 9, 9, 10, 1, -10 },
  { 136, 9, 8, 10, 1, -10 },
  { 145, 5, 6, 10, 1, -3 },
  { 149, 6, 3, 10, 2, -7 },
  { 152, 3, 3, 10, 3, -3 },
  { 154, 11, 16, 10, 0, -14 },
  { 176, 9, 13, 10, 1, -13 },
  { 191, 8, 12, 10, 1, -12 },
  { 203, 10, 13, 10, 0, -13 },
  { 220, 9, 12, 10, 1, -12 },
  { 234, 9, 12, 10, 1, -12 },
  { 248, 9, 12, 10, 1, -12 },
  { 262, 9, 12, 10, 0, -12 },
  { 276, 10, 12, 10, 1, -12 },
  { 291, 10, 13, 10, 0, -13 },
  { 308, 9, 13, 10, 1, -13 },
  { 323, 4, 10, 10, 3, -10 },
  { 328, 6, 13, 10, 1, -10 },
  { 338, 9, 9, 10, 1, -10 },
  { 349, 9, 7, 10, 1, -9 },
  { 357, 8, 9, 10, 1, -10 },
  { 366, 8, 12, 10, 2, -12 },
  { 378, 11, 16, 10, 0, -13 },
  { 400, 9, 12, 10, 0, -12 },
  { 414, 10, 12, 10, 0, -12 },
  { 429, 9, 13, 10, 1, -13 },
  { 444, 10, 12, 10, 0, -12 },
  { 459, 9, 12, 10, 1, -12 },
  { 473, 10, 12, 10, 0, -12 },
  { 488, 9, 13, 10, 1, -13 },
  { 503, 10, 12, 10, 0, -12 },
  { 518, 9, 12, 10, 1, -12 },
  { 532, 10, 12, 10, 0, -12 },
  { 547, 11, 12, 10, 0, -12 },
  { 564, 8, 12, 10, 1, -12 },
  { 576, 11, 12, 10, 0, -12 },
  { 593, 10, 12, 10, 0, -12 },
  { 608, 9, 13, 10, 1, -13 },
  { 623, 10, 12, 10, 0, -12 },
  { 638, 9, 16, 10, 1, -13 },
  { 656, 10, 12, 10, 0, -12 },
  { 671, 10, 13, 10, 0, -13 },
  { 688, 9, 12, 10, 2, -12 },
  { 702, 9, 12, 10, 1, -12 },
  { 716, 9, 12, 10, 2, -12 },
  { 730, 10, 12, 10, 1, -12 },
  { 745, 11, 12, 10, 0, -12 },
  { 762, 10, 12, 10, 1, -12 },
  { 777, 9, 12, 10, 1, -12 },
  { 791, 8, 16, 10, 2, -14 },
  { 807, 6, 16, 10, 2, -14 },
  { 819, 8, 16, 10, 1, -14 },
  { 835, 8, 6, 10, 1, -12 },
  { 841, 8, 3, 10, 0, 0 },
  { 844, 4, 2, 10, 4, -13 },
  { 845, 9, 10, 10, 1, -10 },
  { 857, 10, 12, 10, 0, -12 },
  { 872, 9, 10, 10, 1, -10 },
  { 884, 9, 12, 10, 1, -12 },
  { 898, 9, 10, 10, 1, -10 },
  { 910, 12, 15, 10, -1, -12 },
  { 933, 9, 13, 10, 1, -10 },
  { 948, 10, 12, 10, 0, -12 },
  { 963, 9, 13, 10, 0, -13 },
  { 978, 10, 16, 10, 0, -13 },
  { 998, 11, 12, 10, 0, -12 },
  { 1015, 8, 12, 10, 1, -12 },
  { 1027, 10, 10, 10, 0, -10 },
  { 1040, 10, 10, 10, 0, -10 },
  { 1053, 9, 10, 10, 1, -10 },
  { 1065, 10, 13, 10, 0, -10 },
  { 1082, 9, 13, 10, 1, -10 },
  { 1097, 9, 10, 10, 1, -10 },
  { 1109, 10, 10, 10, 0, -10 },
  { 1122, 9, 12, 10, 1, -12 },
  { 1136, 9, 9, 10, 1, -9 },
  { 1147, 9, 9, 10, 1, -9 },
  { 1158, 10, 9, 10, 1, -9 },
  { 1170, 10, 9, 10, 0, -9 },
  { 1182, 9, 12, 10, 1, -9 },
  { 1196, 10, 9, 10, 0, -9 },
  { 1208, 9, 16, 10, 1, -14 },
  { 1226, 5, 16, 10, 3, -14 },
  { 1236, 9, 16, 10, 0, -14 },
  { 1254, 9, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC17PT7B_H_
