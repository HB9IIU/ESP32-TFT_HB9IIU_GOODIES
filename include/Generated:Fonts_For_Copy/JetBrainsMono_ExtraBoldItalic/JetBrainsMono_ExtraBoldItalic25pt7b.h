#ifndef _JETBRAINSMONO_EXTRABOLDITALIC25PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x3C, 0x70, 0xE1, 0xC0,
  0x00, 0x00, 0x3C, 0xF8, 0xE0, 0xF3, 0xFC, 0xFF, 0x3F, 0xCE, 0xE3, 0xB8,
  0xEE, 0x78, 0x03, 0x8E, 0x03, 0x8C, 0x03, 0x1C, 0x07, 0x1C, 0x3F, 0xFF,
  0x3F, 0xFE, 0x3F, 0xFE, 0x0E, 0x38, 0x0C, 0x30, 0x1C, 0x70, 0x1C, 0x70,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x30, 0xC0, 0x71, 0xC0, 0x71, 0xC0,
  0x63, 0x80, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x60, 0x0F, 0xF0, 0x7F,
  0xE3, 0xFF, 0x8F, 0x4F, 0x79, 0x3D, 0xEC, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0x00, 0xBE, 0x06, 0x7B, 0xD9, 0xCF, 0x6F, 0x3F,
  0xF8, 0x7F, 0xE0, 0xFE, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x0F, 0x81, 0xC7, 0xF0, 0xE1, 0x8C, 0x70, 0xE7, 0x38, 0x39, 0xDC, 0x0E,
  0x7E, 0x03, 0xFB, 0x00, 0x7D, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3B,
  0xE0, 0x1D, 0xF8, 0x0E, 0xE6, 0x07, 0x31, 0x81, 0x8C, 0x60, 0xC3, 0x38,
  0x70, 0xFC, 0x38, 0x1E, 0x00, 0x00, 0x40, 0x07, 0xE0, 0x1F, 0xE0, 0x7F,
  0xE0, 0xE3, 0xC3, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x01,
  0xFE, 0x7B, 0xDD, 0xE7, 0x3F, 0x8E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0x7F,
  0xF0, 0xFF, 0xF0, 0xFC, 0xE0, 0xFF, 0xFF, 0xEE, 0xE0, 0x00, 0x60, 0x3C,
  0x0F, 0x83, 0xF0, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3E,
  0x03, 0xF0, 0x3E, 0x03, 0xC0, 0x18, 0x0C, 0x01, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x87, 0xE0, 0xF8,
  0x1C, 0x06, 0x00, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x18, 0xC6, 0x7B, 0x7B,
  0xFF, 0xF3, 0xFE, 0x01, 0xC0, 0x1D, 0xC0, 0xF7, 0x07, 0x9E, 0x1C, 0x38,
  0x10, 0x80, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x07, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x3E,
  0x3C, 0x3C, 0x78, 0x70, 0xF0, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x33,
  0xFF, 0xF7, 0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3C, 0x3C,
  0xE0, 0xF7, 0x83, 0x9E, 0x0E, 0x7B, 0x39, 0xDF, 0xE7, 0x77, 0x9C, 0x9E,
  0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8,
  0x00, 0x03, 0xE0, 0xFE, 0x1F, 0xE3, 0xDE, 0x39, 0xC2, 0x3C, 0x43, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3C,
  0x79, 0xE0, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0xFF, 0xF3, 0xFF, 0xCF,
  0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x73, 0xC3, 0xCF, 0x0F, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xCF, 0x7C,
  0x7B, 0xC3, 0xBC, 0x3D, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xC0, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x8F, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0xBE, 0x0F, 0xFC, 0x7F, 0xF1, 0xE3, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x73, 0xC3, 0xCF, 0x1F, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xFC, 0x7F, 0xF3, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3B, 0xC3,
  0xDF, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0xBC,
  0x1E, 0xF0, 0xF3, 0xC3, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x00, 0x00, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3C, 0x7C, 0xE0,
  0xE3, 0x87, 0x8F, 0x1E, 0x3F, 0xF0, 0x3F, 0x03, 0xFE, 0x1F, 0x3C, 0xF0,
  0xF3, 0xC1, 0xCF, 0x0F, 0x3C, 0x3C, 0xFF, 0xE1, 0xFF, 0x83, 0xF8, 0x00,
  0x01, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x87, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0xF7, 0xFF, 0x9F, 0xB8, 0x7B, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x7C, 0xF9, 0xE1, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE7, 0xCF, 0x8E, 0x00, 0x07, 0x07, 0xC3, 0xE1,
  0xE0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC3, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0x70, 0x70, 0x00, 0x00, 0x18, 0x07, 0x80, 0xFC, 0x1F, 0xE7,
  0xF8, 0x7F, 0x03, 0xC0, 0x1F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xC0, 0x0E, 0x00, 0x10, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x7F, 0xF7, 0xFF, 0x00, 0x30, 0x01, 0xE0,
  0x0F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x01, 0xE0, 0x3E, 0x07, 0xF1,
  0xFE, 0x3F, 0xC1, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x7F, 0x8F, 0xF9, 0xFF,
  0x81, 0xF0, 0x1E, 0x03, 0xC0, 0xF1, 0xFE, 0x3F, 0x87, 0xE0, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x1E, 0x00, 0x00, 0x40, 0x07,
  0xF8, 0x0F, 0xFE, 0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x71,
  0xFE, 0x73, 0xFE, 0x73, 0x8E, 0x73, 0x8E, 0x73, 0x8E, 0x77, 0x1C, 0xE7,
  0x1C, 0xE7, 0x1C, 0xE7, 0xFC, 0xE3, 0xDC, 0xE1, 0x80, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xE0, 0x77, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x1E, 0x70, 0xF3, 0xC7,
  0x1E, 0x7F, 0xF3, 0xFF, 0xBF, 0xFD, 0xE1, 0xEE, 0x0F, 0xF0, 0x7F, 0x81,
  0xC0, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCE, 0x0F, 0x38, 0x3C, 0xE0, 0xE7,
  0x87, 0x9F, 0xFC, 0x7F, 0x81, 0xFF, 0xC7, 0x0F, 0x9C, 0x1E, 0xF0, 0x7B,
  0xC1, 0xEF, 0x0F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0x00, 0x80, 0x1F,
  0xC1, 0xFF, 0x8F, 0xFE, 0x3C, 0x3C, 0xE0, 0xF7, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0x3C,
  0x3C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xF0, 0xF1, 0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C,
  0x78, 0x78, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x0F, 0x1F, 0xFE, 0x3F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xCF, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF,
  0x80, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x1F,
  0xC1, 0xFF, 0x8F, 0xFE, 0x3C, 0x3C, 0xE0, 0xF7, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE7, 0xE7, 0xBF, 0x9C, 0xFE, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F, 0x3C,
  0x3C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x38, 0x38, 0xE1, 0xE7, 0x87, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF,
  0xE7, 0x07, 0x1C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xE3, 0x87, 0x80, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0x80, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x01,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xCF, 0x07, 0x9E,
  0x0F, 0x3E, 0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x3C, 0x3E, 0x78,
  0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0x8F, 0x0F, 0x1E, 0x1E, 0x78, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xCF, 0x03, 0x8E, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x78, 0x78, 0x78, 0xF0, 0xF1, 0xC1, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x7F, 0xF7, 0xFF, 0x7F, 0xFF, 0xFE, 0x1E, 0x1F,
  0x1E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3F, 0x7E, 0x3B, 0x6E, 0x3B, 0xFE,
  0x3B, 0xDE, 0x7B, 0xDC, 0x7B, 0xDC, 0x78, 0x1C, 0x70, 0x3C, 0x70, 0x3C,
  0x70, 0x3C, 0xF0, 0x38, 0xF0, 0x38, 0xF0, 0x38, 0xE0, 0x78, 0x1F, 0x0E,
  0x3E, 0x1C, 0x7C, 0x38, 0xF8, 0xF1, 0xF1, 0xE7, 0x73, 0x8E, 0xE7, 0x1D,
  0xCE, 0x3B, 0x9C, 0x73, 0x38, 0xE7, 0xF3, 0xCF, 0xC7, 0x9F, 0x8E, 0x3F,
  0x1C, 0x7E, 0x38, 0x7C, 0x70, 0xF9, 0xE1, 0xE0, 0x00, 0x80, 0x3F, 0xC1,
  0xFF, 0x8F, 0xFE, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0x9E, 0x1E, 0x78, 0x79,
  0xE1, 0xE7, 0x87, 0x9C, 0x1E, 0xF0, 0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x7C,
  0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF,
  0x0F, 0x38, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x1F, 0x7F, 0xF9, 0xFF, 0xC7,
  0xFE, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0x00, 0x80, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x3C, 0x7C, 0xE0,
  0xF7, 0x83, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9C, 0x1E, 0xF0,
  0x73, 0xC1, 0xCF, 0x0F, 0x3C, 0x7C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x00,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x3F, 0xF0, 0xFF, 0xE3,
  0xFF, 0xCF, 0x1F, 0x38, 0x3D, 0xE0, 0xF7, 0x83, 0x9E, 0x3E, 0x7F, 0xF1,
  0xFF, 0x87, 0xFC, 0x1C, 0xF0, 0xF1, 0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF0, 0xF3, 0x83, 0xC0, 0x00, 0x40, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1,
  0xE1, 0xE7, 0x83, 0xCF, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x00,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0F, 0x38, 0x3D, 0xE0, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x07, 0xBC, 0x1C, 0xF0, 0x73, 0xC3,
  0xCF, 0x1F, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0xF0, 0x3D, 0xC0, 0xE7,
  0x07, 0x9C, 0x1E, 0x78, 0x71, 0xE3, 0xC7, 0x8E, 0x1E, 0x78, 0x79, 0xE1,
  0xE7, 0x07, 0xBC, 0x1E, 0xE0, 0x3B, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x00, 0x71, 0xCF, 0x73, 0xCE, 0x73, 0xCE, 0x73, 0xCE,
  0x72, 0xDC, 0x76, 0x9C, 0x76, 0x9C, 0x67, 0x9C, 0xED, 0xB8, 0xED, 0xB8,
  0xED, 0xB8, 0xED, 0xB8, 0xF9, 0xB0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xE0,
  0xF1, 0xE0, 0xF1, 0xE0, 0x0F, 0x0F, 0x87, 0x87, 0x81, 0xC7, 0x80, 0xF7,
  0x80, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0x00, 0xF3, 0xC0, 0x79, 0xE0,
  0x78, 0x70, 0x7C, 0x3C, 0x7C, 0x1E, 0x00, 0xF0, 0x3D, 0xC1, 0xE7, 0x87,
  0x9E, 0x3C, 0x38, 0xF0, 0xE7, 0x83, 0xDC, 0x0F, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x00, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x78, 0x0F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF0, 0xF0, 0x38, 0x1E, 0x0F,
  0x07, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0xF0,
  0x78, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x8F, 0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0x07, 0x80, 0xFC, 0x0F,
  0xC1, 0xFC, 0x1D, 0xC3, 0xDE, 0x38, 0xE7, 0x0E, 0xF0, 0xEE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF1, 0xC7, 0x8F, 0x0F, 0x38, 0xFD, 0xCF, 0xFE,
  0xF9, 0xF7, 0x87, 0xBC, 0x3D, 0xC1, 0xDE, 0x0E, 0xF0, 0xF7, 0x87, 0xBC,
  0x7D, 0xFF, 0xE7, 0xEE, 0x3E, 0x70, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x9E, 0x1D, 0xF9, 0xFF, 0xEF, 0x9F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E,
  0xE0, 0xEF, 0x07, 0x78, 0x7B, 0xE7, 0xDF, 0xFC, 0xEF, 0xE7, 0x3C, 0x00,
  0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0xF9, 0xF7, 0x87, 0xBC, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x87, 0xBC, 0x3D, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x0F, 0x38, 0x7E, 0xE3, 0xFF, 0x9F,
  0x3E, 0x78, 0x79, 0xE1, 0xE7, 0x07, 0x3C, 0x1C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x1F, 0x3F, 0xFC, 0x7E, 0xE1, 0xF3, 0x80, 0x07, 0xC0, 0xFF, 0x8F, 0xFC,
  0xF0, 0xF7, 0x87, 0xB8, 0x3D, 0xFF, 0xFF, 0xFE, 0xF0, 0x07, 0x80, 0x3C,
  0x3D, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x08, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x0F, 0x38, 0xFD, 0xCF, 0xFE,
  0xF9, 0xF7, 0x87, 0xBC, 0x3D, 0xC1, 0xDE, 0x0E, 0xF0, 0xF7, 0xCF, 0xBF,
  0xFC, 0xFF, 0xE3, 0xEE, 0x00, 0x70, 0x07, 0x8F, 0xFC, 0x7F, 0xC3, 0xFC,
  0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x9E, 0x1D, 0xF9,
  0xFF, 0xEF, 0x9F, 0x78, 0x7B, 0xC3, 0xDE, 0x1C, 0xE0, 0xEF, 0x0F, 0x78,
  0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x07, 0x00, 0x00, 0xC0, 0x1E, 0x03,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xF8, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x3C, 0xE1, 0xF7, 0x87, 0x9E, 0x3C,
  0x79, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xC7, 0x0F, 0x1E,
  0x3C, 0x78, 0xF0, 0xF3, 0x83, 0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3E, 0x11, 0xFE, 0x1F, 0xE0, 0xFE, 0x3B, 0x9C, 0x7F,
  0x78, 0xFF, 0xF9, 0xCC, 0xF7, 0x99, 0xCF, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE6, 0x7B, 0xCC, 0xE7, 0x99, 0xCE, 0x73, 0x9C, 0xE7, 0x00,
  0x39, 0xE1, 0xDF, 0x9F, 0xFE, 0xF9, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xCE,
  0x0E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x70, 0x70, 0x07,
  0xC0, 0xFF, 0x8F, 0xFC, 0xF9, 0xF7, 0x87, 0xBC, 0x3D, 0xC1, 0xFE, 0x0E,
  0xF0, 0x77, 0x87, 0xBC, 0x7D, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0x1C, 0xF0,
  0x77, 0xE3, 0xFF, 0xCF, 0x9F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCE, 0x0E,
  0x78, 0x39, 0xE1, 0xE7, 0xCF, 0x9F, 0xFC, 0x77, 0xF1, 0xCF, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x38, 0xFD, 0xCF,
  0xFE, 0xF9, 0xF7, 0x87, 0xBC, 0x3D, 0xC1, 0xDE, 0x0E, 0xF0, 0xF7, 0x87,
  0xBC, 0x7D, 0xFF, 0xE7, 0xEE, 0x3E, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x3D, 0xF0, 0xEF, 0xE3, 0xFF, 0x8F, 0x1F, 0x78, 0x7D,
  0xE1, 0xE7, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xE1, 0xFF, 0xCF, 0x0F, 0x3C,
  0x00, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0xE7, 0x87, 0x9F,
  0xFE, 0x7F, 0xF0, 0xFF, 0x80, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x07,
  0xFF, 0xBF, 0xFD, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x43, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x38,
  0x3B, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xC1, 0xEE, 0x0E,
  0xF0, 0xF7, 0x87, 0xBE, 0x7C, 0xFF, 0xC7, 0xFC, 0x1F, 0xC0, 0xF0, 0x7F,
  0x83, 0xFC, 0x3D, 0xE1, 0xEF, 0x0E, 0x38, 0xF1, 0xC7, 0x0F, 0x78, 0x7B,
  0x83, 0xFC, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xE3, 0x8F, 0xC7,
  0x1B, 0x8E, 0x77, 0x3C, 0xEE, 0x79, 0xDC, 0xB7, 0x3B, 0x6E, 0x76, 0xDC,
  0xED, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E, 0x1E, 0x3C, 0x00,
  0x3C, 0x1E, 0x3C, 0x78, 0x79, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFB, 0x81, 0xE7, 0x87, 0x87,
  0x1E, 0x0F, 0x00, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xB8,
  0x39, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0xCF, 0xBF, 0xFC, 0xFD, 0xE3, 0xCE,
  0x00, 0x70, 0x07, 0x8F, 0xFC, 0x7F, 0xC3, 0xFC, 0x1E, 0x00, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x01, 0xFF, 0xEF, 0xFE, 0x7F, 0xF0, 0x00, 0x78, 0x07,
  0xC0, 0x7E, 0x07, 0xF0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x80, 0x3C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x78,
  0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0,
  0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F,
  0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x01, 0xFC, 0x77, 0xF3, 0xB9,
  0xFE, 0xE3, 0xFB, 0x8F, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 7, 18, 15, 4, -18 },
  { 17, 10, 7, 15, 4, -18 },
  { 26, 16, 18, 15, 0, -18 },
  { 62, 14, 26, 15, 1, -22 },
  { 108, 18, 18, 15, -1, -18 },
  { 149, 15, 19, 15, 0, -19 },
  { 185, 4, 7, 15, 7, -18 },
  { 189, 11, 24, 15, 3, -21 },
  { 222, 11, 24, 15, 1, -21 },
  { 255, 14, 13, 15, 1, -15 },
  { 278, 13, 12, 15, 1, -14 },
  { 298, 8, 8, 15, 2, -4 },
  { 306, 9, 4, 15, 3, -10 },
  { 311, 5, 5, 15, 4, -5 },
  { 315, 16, 24, 15, 0, -21 },
  { 363, 14, 19, 15, 1, -19 },
  { 397, 12, 18, 15, 1, -18 },
  { 424, 14, 19, 15, 1, -19 },
  { 458, 14, 18, 15, 1, -18 },
  { 490, 13, 18, 15, 1, -18 },
  { 520, 14, 18, 15, 1, -18 },
  { 552, 13, 18, 15, 1, -18 },
  { 582, 14, 18, 15, 2, -18 },
  { 614, 14, 19, 15, 1, -19 },
  { 648, 13, 19, 15, 2, -19 },
  { 679, 7, 14, 15, 4, -14 },
  { 692, 9, 18, 15, 2, -14 },
  { 713, 13, 14, 15, 2, -15 },
  { 736, 13, 10, 15, 1, -13 },
  { 753, 13, 14, 15, 1, -15 },
  { 776, 11, 18, 15, 3, -18 },
  { 801, 16, 23, 15, 0, -19 },
  { 847, 13, 18, 15, 0, -18 },
  { 877, 14, 18, 15, 1, -18 },
  { 909, 14, 19, 15, 1, -19 },
  { 943, 15, 18, 15, 0, -18 },
  { 977, 14, 18, 15, 1, -18 },
  { 1009, 14, 18, 15, 1, -18 },
  { 1041, 14, 19, 15, 1, -19 },
  { 1075, 14, 18, 15, 1, -18 },
  { 1107, 14, 18, 15, 1, -18 },
  { 1139, 15, 18, 15, 0, -18 },
  { 1173, 15, 18, 15, 1, -18 },
  { 1207, 12, 18, 15, 1, -18 },
  { 1234, 16, 18, 15, 0, -18 },
  { 1270, 15, 18, 15, 0, -18 },
  { 1304, 14, 19, 15, 1, -19 },
  { 1338, 14, 18, 15, 1, -18 },
  { 1370, 14, 24, 15, 1, -19 },
  { 1412, 14, 18, 15, 1, -18 },
  { 1444, 15, 19, 15, 0, -19 },
  { 1480, 14, 18, 15, 2, -18 },
  { 1512, 14, 18, 15, 1, -18 },
  { 1544, 14, 18, 15, 2, -18 },
  { 1576, 16, 18, 15, 1, -18 },
  { 1612, 17, 18, 15, -1, -18 },
  { 1651, 14, 18, 15, 2, -18 },
  { 1683, 14, 18, 15, 1, -18 },
  { 1715, 11, 24, 15, 3, -21 },
  { 1748, 9, 24, 15, 3, -21 },
  { 1775, 11, 24, 15, 2, -21 },
  { 1808, 12, 10, 15, 2, -18 },
  { 1823, 12, 3, 15, 0, 1 },
  { 1828, 6, 4, 15, 6, -20 },
  { 1831, 13, 14, 15, 1, -14 },
  { 1854, 13, 18, 15, 1, -18 },
  { 1884, 13, 14, 15, 1, -14 },
  { 1907, 14, 18, 15, 1, -18 },
  { 1939, 13, 14, 15, 1, -14 },
  { 1962, 17, 23, 15, -2, -18 },
  { 2011, 13, 19, 15, 1, -14 },
  { 2042, 13, 18, 15, 1, -18 },
  { 2072, 12, 20, 15, 1, -20 },
  { 2102, 14, 25, 15, 0, -20 },
  { 2146, 14, 18, 15, 1, -18 },
  { 2178, 12, 18, 15, 2, -18 },
  { 2205, 15, 14, 15, 0, -14 },
  { 2232, 13, 14, 15, 1, -14 },
  { 2255, 13, 14, 15, 1, -14 },
  { 2278, 14, 19, 15, 0, -14 },
  { 2312, 13, 19, 15, 1, -14 },
  { 2343, 14, 14, 15, 1, -14 },
  { 2368, 14, 14, 15, 0, -14 },
  { 2393, 13, 18, 15, 1, -18 },
  { 2423, 13, 14, 15, 1, -14 },
  { 2446, 13, 14, 15, 2, -14 },
  { 2469, 15, 14, 15, 1, -14 },
  { 2496, 15, 14, 15, 0, -14 },
  { 2523, 13, 19, 15, 1, -14 },
  { 2554, 13, 14, 15, 1, -14 },
  { 2577, 13, 24, 15, 2, -21 },
  { 2616, 8, 24, 15, 4, -21 },
  { 2640, 14, 24, 15, 0, -21 },
  { 2682, 14, 6, 15, 1, -12 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic25pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic25pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC25PT7B_H_
