#ifndef _JETBRAINSMONO_EXTRABOLDITALIC34PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x03,
  0x83, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF,
  0x1F, 0xFC, 0xFB, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF8, 0xFB, 0xC3, 0xC0,
  0x00, 0x78, 0x70, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x0E,
  0x1E, 0x00, 0xF0, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0x1E, 0x1C, 0x00, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x70, 0x03, 0x87,
  0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x38, 0x38, 0x03, 0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0xE0, 0xE0,
  0x0F, 0x0F, 0x00, 0x78, 0x70, 0x00, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xF7, 0xFC, 0x7C, 0xDF, 0x9F, 0xB9, 0xF3, 0xE6,
  0x00, 0x7E, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x0D, 0xF8, 0x01, 0x9F, 0x80, 0x33,
  0xE7, 0xCE, 0x7C, 0xF9, 0xCF, 0x9F, 0xB3, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x07, 0x81, 0xFE, 0x03,
  0x81, 0xFF, 0x03, 0x81, 0xE3, 0x83, 0x80, 0xE1, 0xC3, 0xC0, 0x70, 0xE3,
  0xC0, 0x38, 0x73, 0xC0, 0x1C, 0x7B, 0xC0, 0x0F, 0x7B, 0xC0, 0x07, 0xFD,
  0xC0, 0x01, 0xF9, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xEF, 0xC0, 0x01, 0xEF, 0xF0, 0x01, 0xEF, 0xFC, 0x00,
  0xE7, 0x1E, 0x00, 0xE7, 0x8F, 0x00, 0xE3, 0xC7, 0x00, 0xF1, 0xC3, 0x80,
  0xF0, 0xF1, 0xC0, 0xF0, 0x7F, 0xE0, 0xF0, 0x1F, 0xE0, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xC7, 0xE0, 0x78, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x1F,
  0x7C, 0xFB, 0xE7, 0xCF, 0xFC, 0x7C, 0x7F, 0xC7, 0xC7, 0xF8, 0x78, 0x3F,
  0x07, 0x83, 0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0x78, 0x1F, 0xC7, 0xC0, 0x7D, 0xF7, 0xDF, 0xFB, 0xEF, 0xBE, 0xFB, 0xC0,
  0x00, 0x01, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x04, 0x00, 0x0E, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x02, 0x0F, 0x04, 0x70, 0xE3, 0x9F, 0x99,
  0xFB, 0xFB, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x07, 0x80, 0x01, 0xDC,
  0x00, 0x7B, 0xC0, 0x3E, 0x78, 0x0F, 0x8F, 0x83, 0xF1, 0xF8, 0x3C, 0x1C,
  0x01, 0x03, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0,
  0x7C, 0x1F, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00,
  0x10, 0xFB, 0xFF, 0xFF, 0xDF, 0xBE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0xFE, 0x3E,
  0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xFB,
  0x9F, 0x1E, 0xFB, 0xE3, 0xDF, 0x7C, 0xFB, 0xEF, 0x9F, 0x39, 0xF3, 0xE0,
  0x3C, 0x7C, 0x0F, 0x8F, 0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x07, 0xC7, 0xE3,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0xFD, 0xF0,
  0x79, 0xF8, 0x38, 0xF8, 0x10, 0x7C, 0x10, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xE1, 0xFD, 0xFC, 0x3E, 0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF3,
  0xE0, 0x3E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x3F, 0x3F, 0x0F, 0x9F, 0x83,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF3,
  0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xCF, 0xC0, 0xFB, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x7E,
  0x0F, 0xC7, 0xE3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xFB, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0xE0, 0xFD,
  0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xFC,
  0x1F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x03,
  0xEF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0x7E, 0x3E, 0x0F, 0xC7, 0xC0,
  0xF9, 0xF0, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xEF, 0xC3, 0xF0, 0xFC, 0x7C, 0x0F,
  0x9F, 0x81, 0xF3, 0xE0, 0x3E, 0x7E, 0x07, 0xCF, 0xC3, 0xF9, 0xFF, 0xFE,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F, 0xDF, 0x81, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF9, 0xFD, 0xFE, 0x7F,
  0xFF, 0x8F, 0xFF, 0xC1, 0xFB, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF0, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC1, 0xF1, 0xFC, 0xFE,
  0x7E, 0x3E, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78, 0x00, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0x80, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xF0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x60, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF,
  0xFF, 0xE0, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x01,
  0xE0, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0xF0, 0xFF, 0xF1, 0xFF, 0xE7, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xC0, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFE, 0xFE, 0x07, 0xC0, 0x7C, 0x3E, 0x01,
  0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x0F, 0x3C, 0x78, 0x7E, 0xF1,
  0xE3, 0xFB, 0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC7,
  0x87, 0x8F, 0x3E, 0x1E, 0x3C, 0xF0, 0xF8, 0xF3, 0xC3, 0xC7, 0x8F, 0x0F,
  0x1E, 0x3C, 0x3C, 0x78, 0xFF, 0xF1, 0xE1, 0xFB, 0xC7, 0x83, 0xCF, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0xC0, 0x3C, 0xF8, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0x81, 0xF3, 0xE0, 0x3E,
  0x7C, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF0, 0xFE, 0x3E, 0x0F,
  0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0x07, 0xE3, 0xE0, 0x7E,
  0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xCF, 0x83, 0xF9,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFC, 0x7E, 0x3E, 0x07,
  0xCF, 0xC0, 0xF9, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xE3, 0xF0,
  0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3E, 0x0F,
  0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x1F,
  0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x87,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xF1, 0xFC,
  0x7E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x3F, 0xE3, 0xE7, 0xFC, 0xF8, 0xFF, 0x9F, 0x1F,
  0xF3, 0xE3, 0xFE, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xE3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0,
  0x00, 0x0F, 0x83, 0xF1, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xE1, 0xF0, 0x7C, 0x3E, 0x07, 0xC3,
  0xE0, 0x7C, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F,
  0x87, 0xC1, 0xF8, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xF1, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0xFE, 0x3F, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0xFC, 0x1F,
  0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7C,
  0x7E, 0x07, 0xE3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0xF8, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE3, 0xBC, 0x7F, 0x1F, 0xC3, 0xF9, 0xDE,
  0x1E, 0xEE, 0xF1, 0xF7, 0xF7, 0x8F, 0xBF, 0x7C, 0x7D, 0xFB, 0xE3, 0xCF,
  0x9E, 0x1E, 0x7C, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x1F, 0x81, 0xF1,
  0xFC, 0x1F, 0x1F, 0xC1, 0xE1, 0xFC, 0x1E, 0x1F, 0xC1, 0xE1, 0xFC, 0x3E,
  0x3F, 0xE3, 0xE3, 0xDE, 0x3E, 0x3D, 0xE3, 0xE3, 0xDE, 0x3C, 0x3D, 0xE3,
  0xC3, 0xCE, 0x3C, 0x3C, 0xF7, 0xC7, 0xCF, 0x7C, 0x7C, 0xF7, 0xC7, 0xCF,
  0x78, 0x78, 0xF7, 0x87, 0x87, 0x78, 0x78, 0x7F, 0x8F, 0x87, 0xF8, 0xF8,
  0x7F, 0x8F, 0x87, 0xF0, 0xF0, 0x3F, 0x0F, 0x03, 0xF0, 0xF0, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xFC, 0xFE,
  0x3E, 0x0F, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03, 0xF3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x0F, 0xC7,
  0xE3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE1, 0xF0, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3E, 0x07, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFC, 0xFE, 0x3E, 0x0F, 0xCF, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x03, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x0F, 0xC7, 0xE3, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3E, 0x0F, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0xFC, 0xF8, 0x3F, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81,
  0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7E, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0x07, 0xFF, 0xF1, 0xF8, 0xFE, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF3,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0xC1, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x81,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x81, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E,
  0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07,
  0xE3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C,
  0x0F, 0x87, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x03,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0xF9, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x0F, 0x3E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x07, 0xBE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x3C, 0x7C, 0xF1, 0xF1, 0xE3, 0xC7,
  0xC7, 0x8F, 0x1E, 0x1E, 0x7C, 0xF8, 0xF1, 0xE3, 0xE3, 0xC7, 0x8D, 0x8F,
  0x1E, 0x36, 0x3C, 0x79, 0xD9, 0xE1, 0xE7, 0x67, 0x87, 0x99, 0x9E, 0x1E,
  0x66, 0x78, 0x7B, 0xBB, 0xC1, 0xEE, 0xEF, 0x07, 0xB3, 0xBC, 0x1F, 0xCE,
  0xF0, 0x7F, 0x3B, 0x81, 0xDC, 0xFE, 0x07, 0x63, 0xF8, 0x3F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0x80, 0xFC,
  0x3E, 0x00, 0x07, 0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xE0, 0x1F,
  0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x01,
  0xF8, 0xFC, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xF0, 0xFC,
  0x03, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0xFD, 0xF0, 0x1F, 0x3E, 0x07, 0xC7,
  0xC1, 0xF8, 0xFC, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x7C, 0x03,
  0xCF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE1,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0x07, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xF0, 0x3E, 0x78, 0x1E, 0x3C, 0x1F,
  0x1E, 0x0F, 0x0F, 0x8F, 0x87, 0xCF, 0x81, 0xEF, 0xC0, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0xF8, 0x7C, 0x7E,
  0x3E, 0x1F, 0x03, 0xE3, 0xE1, 0xFE, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xF9, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x3F, 0x3F,
  0x8F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFB, 0xE0, 0x7E, 0x7C, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF3, 0xE0, 0x7D, 0xFE, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xF9,
  0xFC, 0xFC, 0x3F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xE0, 0xFD, 0xF0, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x7E, 0xFE, 0x3F, 0x3F,
  0xFF, 0xCF, 0xFF, 0xE3, 0xEF, 0xF0, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0x9F, 0xCF, 0x81, 0xF3, 0xE0,
  0x7D, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xE3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE3, 0xE0, 0xFF, 0x7C,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0x9F, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F,
  0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x0F, 0x8F, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFD, 0xF0, 0x1F, 0x9F, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F, 0xCF, 0x81, 0xF3, 0xC0, 0x7D, 0xF0,
  0x1F, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9, 0xF0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x27, 0xC1, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xE7, 0xE1, 0xFE,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xF9, 0xFC, 0x7C, 0x1F, 0x8F, 0x83,
  0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07,
  0xC7, 0xC1, 0xF8, 0xFE, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xDF,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF3, 0xE0,
  0x7D, 0xFE, 0x3E, 0xFF, 0x8F, 0xFF, 0xF3, 0xF9, 0xFC, 0xF8, 0x3F, 0x3E,
  0x07, 0xCF, 0x83, 0xF7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x7E, 0xFC, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x03, 0xF1, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x3E,
  0x1F, 0x83, 0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xE0,
  0x7C, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x1F,
  0x80, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x1E, 0xF1, 0xE1, 0xFF, 0xBE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3E, 0x79,
  0xF3, 0xC7, 0x9F, 0x3C, 0x71, 0xF3, 0xC7, 0x1E, 0x3C, 0x71, 0xE7, 0xCF,
  0x1E, 0x7C, 0xF3, 0xE7, 0xCF, 0x3E, 0x78, 0xF3, 0xE7, 0x8E, 0x3C, 0x78,
  0xE3, 0xCF, 0x8E, 0x3C, 0xF9, 0xE3, 0xCF, 0x9E, 0x7C, 0xF1, 0xE7, 0xC0,
  0x1F, 0x3E, 0x0F, 0x9F, 0xE3, 0xEF, 0xF8, 0xFF, 0xFF, 0x3F, 0x9F, 0xCF,
  0x83, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC0,
  0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x07, 0xEF, 0xC1, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x9F, 0xCF, 0x83, 0xF3, 0xE0, 0x7D, 0xF0,
  0x1F, 0x7C, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F,
  0x9F, 0x07, 0xE7, 0xE3, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0x9F, 0x03, 0xE7, 0xF8, 0x7D, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFC, 0xFE, 0x3F, 0x0F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x3F, 0x07, 0xE7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x9F,
  0xC7, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xBF, 0xC1, 0xF3, 0xF0, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE3, 0xE1, 0xFE, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xF9, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x3F, 0x1F,
  0x8F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFB, 0xE0, 0x7E, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x1F, 0x1F, 0x03, 0xEF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xF8, 0xFE, 0x7E, 0x0F, 0xCF, 0x81, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xE7,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3E, 0x07, 0xCF,
  0x80, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0x80, 0xFB, 0xFF, 0xFC,
  0xFF, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF0, 0x1F, 0x03, 0xE7, 0xE0, 0xFC, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x7E, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0x8F,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFC,
  0x03, 0xEF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x3E, 0x1F, 0x07, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0xE1, 0xFF,
  0x1E, 0x1E, 0xF1, 0xE1, 0xEF, 0x1E, 0x1E, 0xF1, 0xE3, 0xCF, 0x3E, 0x3C,
  0xF3, 0x63, 0xCF, 0x36, 0x78, 0xF7, 0x67, 0x8F, 0x66, 0x78, 0xF6, 0x67,
  0x0F, 0xE6, 0xF0, 0xFE, 0x6F, 0x0E, 0xC6, 0xF0, 0xEC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x00, 0x0F, 0x80, 0xFC,
  0x3F, 0x07, 0xE0, 0x7C, 0x3F, 0x01, 0xF9, 0xF8, 0x03, 0xEF, 0xC0, 0x0F,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00,
  0xFD, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0xC0, 0xF8, 0x1F, 0x0F, 0xE0,
  0x7E, 0x00, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x83, 0xF7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x7E, 0x7C, 0x3F, 0x9F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0x7C, 0x3F, 0x9F, 0x01, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFC, 0xFF,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x3D, 0xFF, 0x87, 0xBF, 0xF9, 0xF7,
  0x9F, 0xFC, 0xF1, 0xFF, 0xBC, 0x1F, 0xE0, 0x01, 0xF8,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 9, 25, 20, 6, -25 },
  { 30, 14, 10, 20, 5, -25 },
  { 48, 21, 25, 20, 0, -25 },
  { 114, 19, 35, 20, 1, -30 },
  { 198, 25, 25, 20, -2, -25 },
  { 277, 20, 25, 20, 0, -25 },
  { 340, 6, 10, 20, 9, -25 },
  { 348, 16, 33, 20, 4, -29 },
  { 414, 15, 33, 20, 2, -29 },
  { 476, 19, 18, 20, 1, -21 },
  { 519, 17, 16, 20, 2, -19 },
  { 553, 11, 10, 20, 2, -5 },
  { 567, 13, 5, 20, 4, -14 },
  { 576, 7, 7, 20, 6, -7 },
  { 583, 22, 32, 20, 0, -28 },
  { 671, 19, 25, 20, 1, -25 },
  { 731, 17, 25, 20, 1, -25 },
  { 785, 19, 25, 20, 1, -25 },
  { 845, 19, 25, 20, 1, -25 },
  { 905, 18, 25, 20, 1, -25 },
  { 962, 19, 25, 20, 1, -25 },
  { 1022, 18, 25, 20, 1, -25 },
  { 1079, 18, 25, 20, 3, -25 },
  { 1136, 19, 25, 20, 1, -25 },
  { 1196, 18, 25, 20, 2, -25 },
  { 1253, 9, 19, 20, 6, -19 },
  { 1275, 12, 24, 20, 3, -19 },
  { 1311, 18, 19, 20, 2, -21 },
  { 1354, 17, 13, 20, 2, -18 },
  { 1382, 18, 19, 20, 1, -21 },
  { 1425, 15, 25, 20, 4, -25 },
  { 1472, 22, 31, 20, -1, -25 },
  { 1558, 19, 25, 20, -1, -25 },
  { 1618, 19, 25, 20, 1, -25 },
  { 1678, 19, 25, 20, 1, -25 },
  { 1738, 19, 25, 20, 1, -25 },
  { 1798, 19, 25, 20, 1, -25 },
  { 1858, 20, 25, 20, 1, -25 },
  { 1921, 19, 25, 20, 1, -25 },
  { 1981, 20, 25, 20, 1, -25 },
  { 2044, 19, 25, 20, 1, -25 },
  { 2104, 20, 25, 20, 0, -25 },
  { 2167, 21, 25, 20, 1, -25 },
  { 2233, 16, 25, 20, 2, -25 },
  { 2283, 21, 25, 20, 0, -25 },
  { 2349, 20, 25, 20, 1, -25 },
  { 2412, 19, 25, 20, 1, -25 },
  { 2472, 20, 25, 20, 1, -25 },
  { 2535, 19, 31, 20, 1, -25 },
  { 2609, 19, 25, 20, 1, -25 },
  { 2669, 19, 25, 20, 1, -25 },
  { 2729, 18, 25, 20, 3, -25 },
  { 2786, 20, 25, 20, 1, -25 },
  { 2849, 19, 25, 20, 3, -25 },
  { 2909, 22, 25, 20, 1, -25 },
  { 2978, 23, 25, 20, -1, -25 },
  { 3050, 19, 25, 20, 3, -25 },
  { 3110, 19, 25, 20, 1, -25 },
  { 3170, 15, 32, 20, 4, -28 },
  { 3230, 12, 32, 20, 5, -28 },
  { 3278, 16, 32, 20, 2, -28 },
  { 3342, 17, 13, 20, 2, -25 },
  { 3370, 17, 5, 20, 0, 1 },
  { 3381, 8, 5, 20, 8, -27 },
  { 3386, 19, 19, 20, 1, -19 },
  { 3432, 18, 25, 20, 1, -25 },
  { 3489, 18, 19, 20, 1, -19 },
  { 3532, 20, 25, 20, 1, -25 },
  { 3595, 18, 19, 20, 1, -19 },
  { 3638, 23, 31, 20, -2, -25 },
  { 3728, 19, 25, 20, 1, -19 },
  { 3788, 18, 25, 20, 1, -25 },
  { 3845, 17, 27, 20, 1, -27 },
  { 3903, 19, 33, 20, 0, -27 },
  { 3982, 20, 25, 20, 1, -25 },
  { 4045, 15, 25, 20, 3, -25 },
  { 4092, 20, 19, 20, 0, -19 },
  { 4140, 18, 19, 20, 1, -19 },
  { 4183, 18, 19, 20, 1, -19 },
  { 4226, 19, 25, 20, 0, -19 },
  { 4286, 19, 25, 20, 1, -19 },
  { 4346, 19, 19, 20, 1, -19 },
  { 4392, 18, 19, 20, 1, -19 },
  { 4435, 18, 24, 20, 2, -24 },
  { 4489, 19, 19, 20, 1, -19 },
  { 4535, 19, 19, 20, 2, -19 },
  { 4581, 20, 19, 20, 2, -19 },
  { 4629, 22, 19, 20, -1, -19 },
  { 4682, 18, 25, 20, 1, -19 },
  { 4739, 18, 19, 20, 1, -19 },
  { 4782, 18, 32, 20, 3, -28 },
  { 4854, 10, 32, 20, 6, -28 },
  { 4894, 19, 32, 20, 0, -28 },
  { 4970, 19, 8, 20, 1, -16 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC34PT7B_H_
