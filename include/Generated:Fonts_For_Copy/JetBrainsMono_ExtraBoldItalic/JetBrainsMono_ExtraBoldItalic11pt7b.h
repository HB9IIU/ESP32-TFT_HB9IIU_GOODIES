#ifndef _JETBRAINSMONO_EXTRABOLDITALIC11PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xA4, 0x06, 0xFB, 0xB0, 0x16, 0x69, 0xF9, 0x46, 0x9F, 0x94,
  0x68, 0x08, 0x10, 0xF3, 0xA7, 0x0F, 0x0F, 0x0E, 0xDC, 0xF0, 0x81, 0x00,
  0x39, 0x95, 0x0B, 0x07, 0x01, 0xE0, 0xD0, 0xA9, 0x9C, 0x3C, 0xB2, 0x18,
  0x77, 0x7D, 0x9F, 0xF8, 0x19, 0xC8, 0xC6, 0x21, 0x08, 0x61, 0x80, 0x67,
  0x31, 0x33, 0x32, 0xEC, 0x18, 0x4F, 0xC4, 0x79, 0x20, 0x31, 0x3E, 0xC6,
  0x00, 0x6F, 0x40, 0xF0, 0xF0, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30,
  0x61, 0x80, 0x3D, 0x96, 0x55, 0x5D, 0x3C, 0xDE, 0x19, 0xE5, 0x86, 0x18,
  0x41, 0x3F, 0x3D, 0xB0, 0x43, 0x18, 0xC6, 0x3F, 0x3C, 0x31, 0x8F, 0x0C,
  0x3C, 0xDE, 0x0C, 0x63, 0x1B, 0x4D, 0xFF, 0xC2, 0x3D, 0x86, 0x1F, 0x0C,
  0x3C, 0xDE, 0x1C, 0x43, 0x1E, 0x6F, 0x3C, 0xDE, 0xFF, 0xFD, 0x84, 0x31,
  0x86, 0x30, 0x3D, 0x96, 0x4E, 0x7D, 0x3C, 0xDE, 0x7B, 0x28, 0xF6, 0xF8,
  0xC6, 0x30, 0x68, 0x0D, 0x80, 0x32, 0x00, 0x66, 0xC8, 0x08, 0xFD, 0x0F,
  0x1C, 0xFF, 0xC1, 0xFF, 0x00, 0x41, 0xC1, 0xC3, 0x3B, 0x80, 0x73, 0xC6,
  0xF6, 0x20, 0x18, 0x3C, 0xCD, 0x1A, 0xFF, 0x5E, 0xAF, 0x40, 0xC0, 0xE0,
  0x18, 0xE3, 0x8A, 0x6D, 0xFC, 0xF3, 0x7C, 0xC9, 0x93, 0xC7, 0xC9, 0xB3,
  0x7C, 0x3C, 0xC9, 0x83, 0x04, 0x08, 0x33, 0x3C, 0x7C, 0xF9, 0x93, 0x24,
  0xC9, 0xBF, 0x7C, 0x3E, 0xC1, 0x83, 0xE7, 0xC8, 0x11, 0x7C, 0x7E, 0xF9,
  0x83, 0xE7, 0xC8, 0x10, 0x60, 0x3C, 0xC9, 0x83, 0x05, 0xC9, 0xB3, 0x3C,
  0x66, 0xC9, 0x93, 0xE7, 0xC9, 0xB3, 0x64, 0x3E, 0xB0, 0x60, 0x81, 0x06,
  0x0C, 0x7C, 0x1E, 0x38, 0x30, 0x60, 0xC1, 0xB6, 0x3C, 0x66, 0xD9, 0xB3,
  0xC7, 0x8B, 0x32, 0x66, 0x42, 0x31, 0x8C, 0x63, 0xFF, 0x66, 0xDD, 0xBA,
  0xE5, 0x58, 0xB3, 0x66, 0x66, 0xE9, 0x52, 0xA5, 0x4A, 0xB7, 0x6E, 0x3D,
  0x96, 0x59, 0x4D, 0x3C, 0xDE, 0x7C, 0xDD, 0x9B, 0x67, 0x88, 0x30, 0x60,
  0x3D, 0x96, 0x59, 0x4D, 0x3C, 0xDE, 0x18, 0x60, 0x7C, 0xDD, 0x93, 0x67,
  0x8B, 0x32, 0x66, 0x3C, 0xC9, 0x83, 0xC3, 0xC1, 0xB3, 0x3C, 0xFF, 0xF3,
  0x08, 0x21, 0x86, 0x18, 0x66, 0xC9, 0x93, 0x24, 0xC9, 0x93, 0x3C, 0xCF,
  0x2D, 0xB6, 0xD1, 0xC6, 0x18, 0x5A, 0xB5, 0x7B, 0x66, 0xCD, 0xB3, 0x6C,
  0x66, 0x58, 0xE1, 0xC3, 0x8F, 0x1A, 0x66, 0xCF, 0x25, 0x94, 0x61, 0x86,
  0x18, 0x3D, 0xF0, 0x86, 0x31, 0x87, 0xFE, 0x39, 0x18, 0xC6, 0x31, 0x08,
  0xC7, 0x80, 0xC6, 0x66, 0x62, 0x33, 0x31, 0x78, 0x84, 0x63, 0x18, 0xC4,
  0x27, 0x00, 0x33, 0x97, 0xB0, 0xFF, 0xC0, 0xB0, 0x35, 0xB4, 0xD3, 0xCD,
  0xE0, 0x61, 0x87, 0xDB, 0x4D, 0x3C, 0xFE, 0x3D, 0xB4, 0x10, 0xCD, 0xE0,
  0x06, 0x08, 0xD3, 0x64, 0xC9, 0xB3, 0x3C, 0x3D, 0xB7, 0xD0, 0xCD, 0xE0,
  0x0F, 0x0C, 0x08, 0x3E, 0x18, 0x18, 0x18, 0x10, 0x30, 0xE0, 0x35, 0xB4,
  0xD3, 0x7D, 0xA1, 0x9C, 0x61, 0x87, 0xDB, 0x4D, 0x3C, 0xF2, 0x08, 0x60,
  0x1E, 0x18, 0x41, 0x1F, 0xFC, 0x04, 0x30, 0x0F, 0x48, 0x21, 0x86, 0x1B,
  0xEF, 0x00, 0x60, 0xC1, 0x9B, 0x67, 0x8F, 0x16, 0x66, 0xF1, 0x08, 0xC6,
  0x31, 0x8F, 0x7C, 0xA9, 0x56, 0xAF, 0xD5, 0x80, 0x7D, 0xB4, 0xD3, 0xCF,
  0x20, 0x3D, 0xB4, 0xD3, 0xCD, 0xE0, 0x7D, 0xB4, 0xD3, 0xCF, 0xEC, 0x30,
  0x35, 0xB4, 0xD3, 0xCD, 0xE0, 0x86, 0x7C, 0xD9, 0x92, 0x04, 0x18, 0x00,
  0x3D, 0x97, 0x87, 0xCD, 0xE0, 0x21, 0x3E, 0xC6, 0x31, 0xAE, 0x65, 0xB4,
  0xD3, 0x4D, 0xE0, 0xCF, 0x6D, 0xBC, 0x71, 0x80, 0x52, 0xA9, 0xD3, 0xA7,
  0xDB, 0x00, 0x6E, 0x50, 0xE1, 0xC7, 0x99, 0x80, 0x65, 0xB4, 0xD3, 0x7C,
  0xA1, 0x9C, 0x7C, 0x31, 0x8C, 0x67, 0xE0, 0x1C, 0x43, 0x0C, 0xF3, 0x83,
  0x08, 0x60, 0xC0, 0x6D, 0xB4, 0xB6, 0xD8, 0x30, 0x41, 0x0C, 0x3C, 0xF3,
  0x08, 0x23, 0x80, 0x77, 0x70, 0x80,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 4, 3, 7, 2, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 7, 12, 7, 0, -10 },
  { 24, 9, 8, 7, -1, -8 },
  { 33, 6, 8, 7, 0, -8 },
  { 39, 2, 3, 7, 3, -8 },
  { 40, 5, 10, 7, 1, -9 },
  { 47, 4, 10, 7, 1, -9 },
  { 52, 6, 6, 7, 0, -7 },
  { 57, 5, 5, 7, 1, -6 },
  { 61, 3, 4, 7, 1, -2 },
  { 63, 4, 1, 7, 1, -4 },
  { 64, 2, 2, 7, 2, -2 },
  { 65, 7, 10, 7, 0, -9 },
  { 74, 6, 8, 7, 0, -8 },
  { 80, 6, 8, 7, 0, -8 },
  { 86, 6, 8, 7, 0, -8 },
  { 92, 6, 8, 7, 0, -8 },
  { 98, 6, 8, 7, 0, -8 },
  { 104, 6, 8, 7, 0, -8 },
  { 110, 6, 8, 7, 0, -8 },
  { 116, 6, 8, 7, 1, -8 },
  { 122, 6, 8, 7, 0, -8 },
  { 128, 6, 8, 7, 1, -8 },
  { 134, 3, 6, 7, 2, -6 },
  { 137, 4, 8, 7, 1, -6 },
  { 141, 5, 6, 7, 1, -7 },
  { 145, 5, 5, 7, 1, -6 },
  { 149, 6, 6, 7, 0, -7 },
  { 154, 5, 8, 7, 1, -8 },
  { 159, 7, 10, 7, 0, -8 },
  { 168, 6, 8, 7, 0, -8 },
  { 174, 7, 8, 7, 0, -8 },
  { 181, 7, 8, 7, 0, -8 },
  { 188, 7, 8, 7, 0, -8 },
  { 195, 7, 8, 7, 0, -8 },
  { 202, 7, 8, 7, 0, -8 },
  { 209, 7, 8, 7, 0, -8 },
  { 216, 7, 8, 7, 0, -8 },
  { 223, 7, 8, 7, 0, -8 },
  { 230, 7, 8, 7, 0, -8 },
  { 237, 7, 8, 7, 0, -8 },
  { 244, 5, 8, 7, 1, -8 },
  { 249, 7, 8, 7, 0, -8 },
  { 256, 7, 8, 7, 0, -8 },
  { 263, 6, 8, 7, 0, -8 },
  { 269, 7, 8, 7, 0, -8 },
  { 276, 6, 10, 7, 0, -8 },
  { 284, 7, 8, 7, 0, -8 },
  { 291, 7, 8, 7, 0, -8 },
  { 298, 6, 8, 7, 1, -8 },
  { 304, 7, 8, 7, 0, -8 },
  { 311, 6, 8, 7, 1, -8 },
  { 317, 7, 8, 7, 0, -8 },
  { 324, 7, 8, 7, 0, -8 },
  { 331, 6, 8, 7, 1, -8 },
  { 337, 6, 8, 7, 0, -8 },
  { 343, 5, 10, 7, 1, -9 },
  { 350, 4, 10, 7, 1, -9 },
  { 355, 5, 10, 7, 1, -9 },
  { 362, 5, 4, 7, 1, -8 },
  { 365, 5, 2, 7, 0, 0 },
  { 367, 2, 2, 7, 3, -9 },
  { 368, 6, 6, 7, 0, -6 },
  { 373, 6, 8, 7, 0, -8 },
  { 379, 6, 6, 7, 0, -6 },
  { 384, 7, 8, 7, 0, -8 },
  { 391, 6, 6, 7, 0, -6 },
  { 396, 8, 10, 7, -1, -8 },
  { 406, 6, 8, 7, 0, -6 },
  { 412, 6, 8, 7, 0, -8 },
  { 418, 6, 9, 7, 0, -9 },
  { 425, 6, 11, 7, 0, -9 },
  { 434, 7, 8, 7, 0, -8 },
  { 441, 5, 8, 7, 1, -8 },
  { 446, 7, 6, 7, 0, -6 },
  { 452, 6, 6, 7, 0, -6 },
  { 457, 6, 6, 7, 0, -6 },
  { 462, 6, 8, 7, 0, -6 },
  { 468, 6, 8, 7, 0, -6 },
  { 474, 7, 6, 7, 0, -6 },
  { 480, 6, 6, 7, 0, -6 },
  { 485, 5, 8, 7, 1, -8 },
  { 490, 6, 6, 7, 0, -6 },
  { 495, 6, 6, 7, 1, -6 },
  { 500, 7, 6, 7, 0, -6 },
  { 506, 7, 6, 7, 0, -6 },
  { 512, 6, 8, 7, 0, -6 },
  { 518, 6, 6, 7, 0, -6 },
  { 523, 6, 10, 7, 1, -9 },
  { 531, 3, 10, 7, 2, -9 },
  { 535, 6, 10, 7, 0, -9 },
  { 543, 6, 3, 7, 0, -5 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC11PT7B_H_
