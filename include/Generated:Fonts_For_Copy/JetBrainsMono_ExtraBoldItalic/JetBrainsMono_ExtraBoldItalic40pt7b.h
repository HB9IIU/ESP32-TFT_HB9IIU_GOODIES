#ifndef _JETBRAINSMONO_EXTRABOLDITALIC40PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F,
  0xC3, 0xF8, 0x7F, 0x07, 0xC0, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7E,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xF8,
  0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x80,
  0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0,
  0x03, 0xE0, 0xF0, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xC0, 0x3C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1,
  0xE0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC0, 0x78, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7E, 0xE7, 0xE1, 0xF9,
  0xCF, 0xC3, 0xF3, 0x9F, 0x87, 0xE7, 0x00, 0x0F, 0xCC, 0x00, 0x1F, 0xD8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x73, 0xF8,
  0x00, 0xE3, 0xF0, 0x01, 0xC7, 0xE7, 0xE3, 0x8F, 0xCF, 0xE6, 0x3F, 0x1F,
  0xCC, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x78, 0x1F, 0xF8, 0x07, 0x81, 0xFF, 0xC0, 0x78, 0x0F, 0x1E, 0x07,
  0x80, 0x78, 0x78, 0x78, 0x07, 0x87, 0x87, 0xC0, 0x3C, 0x3C, 0x7C, 0x01,
  0xE1, 0xE3, 0xC0, 0x0F, 0x0F, 0x3C, 0x00, 0x7C, 0xF3, 0xC0, 0x03, 0xFF,
  0xBC, 0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x7E, 0x00,
  0x01, 0xEF, 0xF8, 0x00, 0x1E, 0xFF, 0xE0, 0x01, 0xE7, 0x8F, 0x00, 0x1E,
  0x78, 0x78, 0x01, 0xE3, 0xC3, 0xC0, 0x1F, 0x1E, 0x1E, 0x01, 0xF0, 0xF0,
  0xF0, 0x0F, 0x07, 0x87, 0x80, 0xF0, 0x3C, 0x78, 0x0F, 0x01, 0xFF, 0xC0,
  0xF0, 0x07, 0xFC, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F,
  0x3F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x7E, 0x7E, 0xFC, 0xF9,
  0xF9, 0xFB, 0xF3, 0xF1, 0xFF, 0xC7, 0xE3, 0xFF, 0x0F, 0xC3, 0xFE, 0x1F,
  0x03, 0xF8, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x83, 0xFE, 0x3F, 0x00, 0x7E,
  0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7C, 0xF9, 0xF3, 0xE7, 0x80, 0x00, 0x00,
  0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x20, 0x7C, 0x08, 0xE1, 0xE0, 0xE7, 0xC7,
  0x8F, 0x9F, 0xDC, 0xFE, 0xFF, 0xB7, 0xFB, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC,
  0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0xF9, 0xF0, 0x07,
  0xC7, 0xC0, 0x3F, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xE0, 0xF0, 0x07, 0x03,
  0x80, 0x08, 0x04, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80,
  0x0E, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xF8, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x8F,
  0x80, 0x7E, 0x7E, 0x21, 0xF9, 0xFB, 0xE7, 0xC7, 0xEF, 0x9F, 0x1F, 0xBE,
  0x7C, 0x7C, 0xFB, 0xF1, 0xF1, 0xCF, 0xCF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0xFE,
  0x0F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xDF, 0x80, 0xF1, 0xF8,
  0x0E, 0x1F, 0x81, 0x81, 0xF8, 0x10, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF3, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x1F, 0x81, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE1, 0xF8,
  0x7F, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8,
  0x0F, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF9, 0xFC, 0x07, 0xEF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x8F, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x1F,
  0xC1, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xDF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0x03,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xCF, 0xC0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xF8,
  0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xEF, 0xF0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87,
  0xF0, 0xFE, 0x0F, 0xE7, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xBF, 0x83, 0xF8, 0x7F, 0x1F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xCF, 0xC0, 0x3F, 0x3F, 0x80, 0xFC, 0xFE,
  0x07, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x1F, 0xF7, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xEF,
  0xC0, 0x3F, 0x7F, 0x07, 0xFB, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x01, 0xC7, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xC1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0x81, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3F, 0x0F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF0, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F,
  0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0x08, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x3C, 0x7C, 0x7C, 0x1F,
  0xDE, 0x1F, 0x0F, 0xF7, 0x87, 0xC7, 0xFF, 0xE1, 0xF1, 0xF1, 0xF8, 0x78,
  0xF8, 0x3E, 0x3E, 0x3E, 0x0F, 0x8F, 0x8F, 0x83, 0xC3, 0xE3, 0xE1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x3E, 0x3C, 0x1F, 0x0F, 0x1F, 0x07, 0xC7, 0xC7, 0xC1,
  0xF1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7F, 0xFE, 0x1F, 0x0F, 0xF7, 0x87, 0xC3,
  0xF9, 0xE1, 0xF0, 0x3C, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0,
  0x03, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x0F,
  0xC7, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x83,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1,
  0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF0, 0x1F,
  0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0x7E, 0x07, 0xE0, 0xF8, 0x7F, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80,
  0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF8, 0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF0, 0x7F, 0x87,
  0xE0, 0x3F, 0x8F, 0xC0, 0x7F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x41, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE3, 0xFF, 0x9F,
  0x8F, 0xFC, 0x7E, 0x3F, 0xF1, 0xF8, 0xFF, 0xCF, 0xC3, 0xFF, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x03, 0xF0, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFE,
  0x03, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x87,
  0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0x78, 0x7D, 0xC7, 0xFC, 0x3E, 0xE3,
  0xFE, 0x1F, 0x73, 0xDF, 0x0F, 0xB9, 0xEF, 0x87, 0xDE, 0xEF, 0xC3, 0xEF,
  0xF7, 0xC1, 0xF7, 0xF3, 0xE1, 0xFB, 0xF9, 0xF0, 0xFD, 0xFC, 0xF8, 0x7C,
  0x7C, 0xFC, 0x3E, 0x3E, 0x7E, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x0F,
  0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0,
  0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x3E, 0x1F, 0xE0,
  0x7C, 0x3F, 0xC0, 0xF8, 0x7F, 0x81, 0xF0, 0xFF, 0x07, 0xE3, 0xFE, 0x0F,
  0xC7, 0xFC, 0x1F, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8,
  0x7D, 0xE3, 0xF1, 0xFB, 0xC7, 0xE3, 0xE7, 0x8F, 0x87, 0xCF, 0x9F, 0x0F,
  0x9F, 0x3E, 0x1F, 0x1E, 0x7C, 0x3E, 0x3C, 0xF8, 0xFC, 0x79, 0xF1, 0xF8,
  0xFB, 0xE3, 0xE1, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x83, 0xFE, 0x1F, 0x07,
  0xFC, 0x7E, 0x0F, 0xF8, 0xFC, 0x1F, 0xF1, 0xF0, 0x3F, 0xC3, 0xE0, 0x7F,
  0x87, 0xC0, 0x7F, 0x0F, 0x80, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xFF,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03,
  0xF8, 0xFE, 0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xC1, 0xFE,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x03, 0xF8, 0xFE, 0x0F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0xC7, 0xE0, 0x3F, 0x8F,
  0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x0F, 0xE3, 0xF0, 0x3F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7F, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x7F, 0x01, 0xF8,
  0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0xFC, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8,
  0x7C, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x7E, 0x01, 0xF9, 0xF8,
  0x03, 0xE7, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x1F, 0x0F, 0x9F, 0x0F,
  0x87, 0xCF, 0x87, 0xC3, 0xE7, 0xC7, 0xE1, 0xF3, 0xE3, 0xF1, 0xF1, 0xF1,
  0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x78, 0xEE, 0x3C, 0x3C, 0x77, 0x1E, 0x1E,
  0x3B, 0x9F, 0x0F, 0x1D, 0xCF, 0x8F, 0x9C, 0xE7, 0x87, 0xCE, 0x73, 0xC3,
  0xE7, 0x33, 0xE1, 0xF3, 0xB9, 0xF0, 0xFB, 0x9C, 0xF0, 0x7D, 0xCE, 0x78,
  0x3E, 0xE7, 0x7C, 0x1F, 0xE3, 0xBE, 0x0F, 0x71, 0xDE, 0x07, 0xB8, 0xEF,
  0x03, 0xDC, 0x77, 0x81, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0xFE,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F,
  0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x7E,
  0x0F, 0xE0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0xFC, 0x01, 0xF9, 0xF8, 0x07,
  0xF1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0x7E, 0x00,
  0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3F,
  0x1F, 0x83, 0xE7, 0xE0, 0x7C, 0xFC, 0x0F, 0xBF, 0x01, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFE, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0xFC, 0x1F,
  0xFB, 0xF0, 0xFF, 0xEF, 0xC3, 0xFF, 0xBF, 0x1F, 0xFF, 0xF8, 0x7E, 0x0F,
  0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x81, 0xFC, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xF7, 0xE0, 0x7F, 0x9F, 0x80, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE7, 0xF8, 0x1F, 0xBF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x07, 0xE3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x9F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F,
  0x1F, 0xC1, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xDF, 0xFC, 0x3F,
  0x7F, 0xE0, 0xFC, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFE,
  0x0F, 0xE7, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0xFE, 0x7E, 0x07, 0xFE, 0xFC, 0x1F, 0xFD, 0xF8, 0x3F, 0xFB, 0xF0, 0xFF,
  0xFF, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x87, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xBF, 0x01,
  0xFE, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x3F, 0x87, 0xF3, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x03, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xEF, 0xE1, 0xFC,
  0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF9, 0xF8, 0x7F, 0xEF, 0xC7, 0xFF, 0x7E, 0x3F, 0xFB, 0xF3, 0xFF,
  0xFF, 0x1F, 0x83, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03,
  0xF3, 0xF8, 0x3F, 0x9F, 0xF7, 0xFC, 0xFF, 0xF7, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFB, 0xF0, 0x7F, 0x9F, 0x80, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF,
  0xF8, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE3, 0xF8, 0x1F, 0xBF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x3F, 0xC3, 0xF8, 0xFE, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x02,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x7F, 0x1F, 0x80, 0xFE, 0x1F, 0x81, 0xFC, 0x1F, 0x83, 0xF8, 0x1F, 0x83,
  0xF8, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xF0, 0xFC, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xFC, 0x1F, 0x3C, 0x7C, 0x1F, 0x7E, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0x1E, 0x3E, 0x1F, 0x1E, 0x3E, 0x3F, 0x1E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3C, 0x3E, 0x3E, 0x3C, 0x7E, 0x3E, 0x3C, 0x7C, 0x3E, 0x3C,
  0x7C, 0x7E, 0x3C, 0x7C, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78,
  0xFC, 0x7C, 0x78, 0xF8, 0x7C, 0x78, 0xF8, 0xFC, 0x78, 0xF8, 0xF8, 0x78,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0xFF,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x0F, 0xE3,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0,
  0x3F, 0x8F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xF0, 0x7F, 0x7E,
  0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE,
  0xFE, 0x1F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xCF, 0xF0, 0x1F, 0xBF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81,
  0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xF7, 0xFF,
  0x07, 0xEF, 0xFC, 0x0F, 0xCF, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x1F, 0xFB, 0xF0, 0xFF, 0xEF, 0xC3,
  0xFF, 0xBF, 0x1F, 0xFF, 0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x7F,
  0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xF7,
  0xE0, 0x7F, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F,
  0x9F, 0xE0, 0x7C, 0xFF, 0xC1, 0xF7, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFE, 0x0F, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF9,
  0xFC, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7C, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xFC,
  0x3F, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xFD, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFE, 0x1F, 0xC7,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC,
  0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3F, 0x3F,
  0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x00, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1, 0xF0, 0xFF, 0xC7,
  0xE1, 0xEF, 0x8F, 0xC7, 0xDF, 0x1F, 0x8F, 0xBE, 0x37, 0x1E, 0x7C, 0xEE,
  0x7C, 0xF9, 0xDC, 0xF9, 0xF3, 0x39, 0xE3, 0xEE, 0x73, 0xC7, 0xDC, 0xEF,
  0x8F, 0xB9, 0xDF, 0x1F, 0xE3, 0xBC, 0x3D, 0xC7, 0xF8, 0x7B, 0x8F, 0xF0,
  0xF6, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x3F,
  0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xDF,
  0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07,
  0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x1F, 0x87,
  0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xF0, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0x7E, 0x07, 0xF1, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0xF3, 0xFF, 0x87,
  0xCF, 0xFF, 0x1F, 0x7E, 0xFC, 0x7D, 0xF1, 0xFF, 0xF7, 0xC7, 0xFF, 0x9E,
  0x0F, 0xFE, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 11, 29, 24, 7, -29 },
  { 41, 16, 12, 24, 6, -29 },
  { 65, 25, 29, 24, 0, -29 },
  { 156, 23, 41, 24, 1, -35 },
  { 274, 29, 29, 24, -2, -29 },
  { 380, 23, 30, 24, 0, -30 },
  { 467, 7, 12, 24, 11, -29 },
  { 478, 18, 39, 24, 5, -34 },
  { 566, 18, 39, 24, 2, -34 },
  { 654, 22, 21, 24, 2, -24 },
  { 712, 21, 19, 24, 2, -23 },
  { 762, 12, 12, 24, 3, -6 },
  { 780, 15, 6, 24, 5, -16 },
  { 792, 9, 8, 24, 6, -8 },
  { 801, 25, 37, 24, 0, -33 },
  { 917, 22, 30, 24, 2, -30 },
  { 1000, 20, 29, 24, 1, -29 },
  { 1073, 22, 30, 24, 1, -30 },
  { 1156, 22, 29, 24, 1, -29 },
  { 1236, 22, 29, 24, 1, -29 },
  { 1316, 22, 29, 24, 1, -29 },
  { 1396, 21, 29, 24, 1, -29 },
  { 1473, 22, 29, 24, 3, -29 },
  { 1553, 22, 30, 24, 1, -30 },
  { 1636, 21, 30, 24, 3, -30 },
  { 1715, 11, 22, 24, 6, -22 },
  { 1746, 14, 28, 24, 3, -22 },
  { 1795, 20, 22, 24, 3, -24 },
  { 1850, 20, 16, 24, 2, -21 },
  { 1890, 21, 22, 24, 1, -24 },
  { 1948, 18, 29, 24, 5, -29 },
  { 2014, 26, 37, 24, -1, -30 },
  { 2135, 22, 29, 24, -1, -29 },
  { 2215, 23, 29, 24, 1, -29 },
  { 2299, 22, 30, 24, 2, -30 },
  { 2382, 23, 29, 24, 1, -29 },
  { 2466, 23, 29, 24, 1, -29 },
  { 2550, 23, 29, 24, 1, -29 },
  { 2634, 22, 30, 24, 2, -30 },
  { 2717, 23, 29, 24, 1, -29 },
  { 2801, 23, 29, 24, 1, -29 },
  { 2885, 24, 29, 24, 0, -29 },
  { 2972, 25, 29, 24, 1, -29 },
  { 3063, 19, 29, 24, 2, -29 },
  { 3132, 25, 29, 24, 0, -29 },
  { 3223, 23, 29, 24, 1, -29 },
  { 3307, 22, 30, 24, 2, -30 },
  { 3390, 24, 29, 24, 1, -29 },
  { 3477, 22, 37, 24, 2, -30 },
  { 3579, 23, 29, 24, 1, -29 },
  { 3663, 23, 30, 24, 1, -30 },
  { 3750, 21, 29, 24, 4, -29 },
  { 3827, 23, 29, 24, 1, -29 },
  { 3911, 22, 29, 24, 4, -29 },
  { 3991, 25, 29, 24, 1, -29 },
  { 4082, 27, 29, 24, -1, -29 },
  { 4180, 23, 29, 24, 3, -29 },
  { 4264, 22, 29, 24, 1, -29 },
  { 4344, 18, 37, 24, 4, -33 },
  { 4428, 15, 37, 24, 5, -33 },
  { 4498, 18, 37, 24, 3, -33 },
  { 4582, 19, 15, 24, 3, -29 },
  { 4618, 20, 6, 24, 0, 1 },
  { 4633, 10, 5, 24, 9, -31 },
  { 4640, 22, 22, 24, 1, -22 },
  { 4701, 22, 29, 24, 1, -29 },
  { 4781, 21, 22, 24, 2, -22 },
  { 4839, 23, 29, 24, 1, -29 },
  { 4923, 20, 22, 24, 2, -22 },
  { 4978, 27, 36, 24, -2, -29 },
  { 5100, 21, 29, 24, 2, -22 },
  { 5177, 22, 29, 24, 1, -29 },
  { 5257, 21, 32, 24, 1, -32 },
  { 5341, 22, 39, 24, 0, -32 },
  { 5449, 24, 29, 24, 1, -29 },
  { 5536, 19, 29, 24, 3, -29 },
  { 5605, 24, 22, 24, 0, -22 },
  { 5671, 22, 22, 24, 1, -22 },
  { 5732, 20, 22, 24, 2, -22 },
  { 5787, 23, 29, 24, 0, -22 },
  { 5871, 22, 29, 24, 1, -22 },
  { 5951, 22, 22, 24, 2, -22 },
  { 6012, 22, 22, 24, 1, -22 },
  { 6073, 21, 28, 24, 2, -28 },
  { 6147, 21, 22, 24, 2, -22 },
  { 6205, 22, 22, 24, 3, -22 },
  { 6266, 23, 22, 24, 2, -22 },
  { 6330, 25, 22, 24, -1, -22 },
  { 6399, 22, 29, 24, 1, -22 },
  { 6479, 21, 22, 24, 1, -22 },
  { 6537, 21, 37, 24, 3, -33 },
  { 6635, 11, 37, 24, 7, -33 },
  { 6686, 21, 37, 24, 1, -33 },
  { 6784, 22, 10, 24, 1, -19 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC40PT7B_H_
