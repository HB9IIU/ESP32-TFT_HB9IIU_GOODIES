#ifndef _JETBRAINSMONO_EXTRABOLDITALIC39PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3E, 0xFC, 0x7E,
  0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x3E, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x01, 0xE0, 0xF0, 0x03,
  0xE1, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0x83, 0xC0, 0x07, 0x83, 0xC0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3E,
  0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xE7, 0x3F, 0x1F,
  0x9C, 0xFC, 0x7E, 0x60, 0x01, 0xF9, 0x80, 0x07, 0xEE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1D, 0xFC, 0x00, 0x73, 0xF0, 0x01,
  0x8F, 0xCF, 0xC6, 0x3F, 0x3F, 0x18, 0xFC, 0xFE, 0xE7, 0xE3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x08, 0x0F, 0xF0, 0x07, 0x80, 0xFF, 0xC0,
  0x78, 0x0F, 0xFE, 0x07, 0x80, 0x78, 0xF0, 0x78, 0x07, 0x87, 0x87, 0x80,
  0x3C, 0x3C, 0x7C, 0x01, 0xE1, 0xE3, 0xC0, 0x0F, 0x0F, 0x3C, 0x00, 0x78,
  0xF3, 0xC0, 0x03, 0xFF, 0xBC, 0x00, 0x0F, 0xFB, 0xC0, 0x00, 0x3F, 0xBC,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x01, 0xEF, 0xF0, 0x00, 0x1E, 0xFF, 0xC0, 0x01,
  0xEF, 0x9E, 0x00, 0x1E, 0x78, 0x78, 0x01, 0xE3, 0xC3, 0x80, 0x1F, 0x1E,
  0x3C, 0x00, 0xF1, 0xE1, 0xE0, 0x0F, 0x0F, 0x0F, 0x00, 0xF0, 0x7C, 0xF8,
  0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0x3F, 0xFC,
  0xFC, 0xFC, 0xFD, 0xF1, 0xF8, 0xFF, 0xE3, 0xF1, 0xFF, 0x87, 0xC1, 0xFE,
  0x0F, 0x83, 0xFC, 0x1F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7F, 0x3F, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0x80,
  0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0x9F, 0x7E, 0xFD, 0xF3, 0xE0, 0x00, 0x00,
  0x80, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x02, 0x00, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x18, 0x3C, 0x19, 0xF1, 0xE3, 0xCF, 0xCE,
  0x7E, 0xFF, 0x77, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x01, 0xE0, 0x00,
  0x1F, 0x80, 0x03, 0xDE, 0x00, 0x3E, 0xF8, 0x03, 0xE7, 0xE0, 0x3F, 0x1F,
  0x03, 0xF0, 0xFC, 0x0F, 0x07, 0xC0, 0x38, 0x1C, 0x00, 0x80, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0x3F, 0x9F, 0xEF, 0xE7, 0xF3, 0xF9, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE3, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x3E, 0x01, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xEF,
  0x3F, 0x3F, 0x7D, 0xF9, 0xF7, 0xEF, 0xCF, 0x9F, 0x7C, 0x7C, 0xF3, 0xE7,
  0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x80, 0xFD, 0xF8, 0x0F,
  0x9F, 0x80, 0xE1, 0xF8, 0x1C, 0x1F, 0x81, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xE1, 0xFC,
  0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x08, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x03, 0xF3,
  0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0xEF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x3C,
  0x01, 0xFB, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xBF, 0x81, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xF0, 0xFE, 0x7E, 0x03, 0xF3, 0xF0,
  0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0x7E, 0x01, 0xF9,
  0xF8, 0x1F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x3E, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0x80,
  0xFC, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x87, 0xF1, 0xFC,
  0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0x83, 0xF1, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFE, 0x1F, 0x83, 0xF0, 0x3F, 0x1F, 0x80,
  0xFC, 0x7C, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x81, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE7, 0xF8, 0x7F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xEF, 0xFB,
  0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0xF9, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0x83,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x00, 0x00, 0xF0,
  0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x10, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x10, 0x00, 0x00, 0xC0,
  0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC1,
  0xFB, 0xE3, 0xE1, 0xFD, 0xF1, 0xF1, 0xFF, 0x78, 0xF0, 0xF8, 0xF8, 0x78,
  0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x1E, 0x0F, 0x8F,
  0x8F, 0x07, 0xC7, 0x8F, 0x83, 0xC3, 0xC7, 0xC1, 0xE3, 0xE3, 0xE1, 0xF1,
  0xF1, 0xF0, 0xF8, 0xF8, 0xFD, 0xFC, 0x7C, 0x7F, 0xDE, 0x3E, 0x1F, 0xDE,
  0x1E, 0x03, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0,
  0x1F, 0x9F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0xC7, 0xC0, 0x3E,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xF0, 0x0F, 0x8F,
  0xC0, 0x3E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0x83, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x80, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3E, 0x03, 0xF0,
  0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF8,
  0x0F, 0xC7, 0xC0, 0x7F, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0xFE, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0x81, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC,
  0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3E, 0x01, 0xF9, 0xF8, 0x07,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7,
  0xC3, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE1, 0xFC, 0xFE, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0xF9, 0xF8, 0xFF, 0xCF, 0xC7, 0xFE,
  0x7C, 0x3F, 0xF7, 0xE3, 0xFF, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0x81, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x7E, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xF8,
  0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0x03, 0xF0,
  0x7C, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x0F, 0x81,
  0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x87, 0xF0, 0x1F, 0x87, 0xE0, 0x1F, 0x8F,
  0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0x78, 0x3E,
  0xE7, 0xBC, 0x1F, 0x73, 0xBE, 0x0F, 0xBB, 0xDF, 0x07, 0xDD, 0xEF, 0x83,
  0xEE, 0xE7, 0xC3, 0xE7, 0xF7, 0xE1, 0xF3, 0xF3, 0xE0, 0xF9, 0xF9, 0xF0,
  0x7C, 0xFC, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03,
  0xE0, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x3E, 0x1F, 0xC0, 0xFC, 0x3F,
  0x81, 0xF0, 0xFF, 0x83, 0xE1, 0xFF, 0x07, 0xC3, 0xFE, 0x0F, 0x87, 0xFC,
  0x1F, 0x0F, 0xF8, 0x7E, 0x1F, 0xF0, 0xF8, 0x3D, 0xF1, 0xF0, 0xFB, 0xE3,
  0xE1, 0xF3, 0xC7, 0xC3, 0xE7, 0x8F, 0x87, 0xCF, 0x1F, 0x0F, 0x9F, 0x7E,
  0x1F, 0x3E, 0xF8, 0x7E, 0x3D, 0xF0, 0xF8, 0x7B, 0xE1, 0xF0, 0xF7, 0xC3,
  0xE1, 0xEF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFC, 0x3F, 0x07, 0xF8, 0x7E,
  0x0F, 0xF0, 0xF8, 0x1F, 0xE1, 0xF0, 0x3F, 0xC3, 0xE0, 0x7F, 0x87, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xE3, 0xFC, 0xFE, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7C, 0x07, 0xE7, 0xE0,
  0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xE3,
  0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF0, 0x1F,
  0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xF8,
  0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0xFE, 0x0F, 0xE7, 0xE0,
  0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7C, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x03, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x8F,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x81, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3E,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x1F, 0x83, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xBF,
  0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F,
  0x1F, 0x81, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7C, 0x1F, 0x07, 0xE0, 0xF8,
  0x3E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0xBF, 0x00, 0x7D, 0xF0, 0x03, 0xEF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x1F, 0x0F, 0x9F,
  0x0F, 0x87, 0x8F, 0x8F, 0xC7, 0xC7, 0xC7, 0xE3, 0xE3, 0xC3, 0xF1, 0xF1,
  0xE1, 0xB0, 0xF0, 0xF1, 0xD8, 0xF8, 0x78, 0xFC, 0x7C, 0x3C, 0x7E, 0x3E,
  0x1E, 0x77, 0x1E, 0x1F, 0x3B, 0x9F, 0x0F, 0x9D, 0xCF, 0x87, 0xCE, 0xE7,
  0x83, 0xEE, 0x73, 0xC1, 0xF7, 0x39, 0xE0, 0xFB, 0x9D, 0xF0, 0x79, 0xCE,
  0xF0, 0x3D, 0xC7, 0x78, 0x1E, 0xE3, 0xBC, 0x0F, 0x71, 0xFE, 0x07, 0xB0,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E,
  0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00,
  0x3E, 0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x02, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x3E, 0x3E,
  0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3F, 0x7E, 0x07, 0xFF,
  0x01, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0,
  0x00, 0xF0, 0x04, 0x0F, 0xF3, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1,
  0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFD, 0xF8, 0x3F, 0xF7, 0xC0, 0x7F, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x1E, 0x03, 0xF3, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFB, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x8F, 0xF3, 0xF8, 0x3F, 0x9F,
  0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x03, 0xF1, 0xFC,
  0x3F, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0x7F, 0xC1,
  0xF9, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xF8, 0xFF, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x3C, 0x3F, 0x01, 0xFE, 0x7C, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFE, 0x3F, 0xC3, 0xF8, 0x3F, 0x87,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xEF,
  0xC0, 0xFF, 0xDF, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xF8,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0x7E, 0x7E, 0x03,
  0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x0F, 0xCF, 0xE1, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x08, 0x3F,
  0xCF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xC7, 0xF9,
  0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x01,
  0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0xC7, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFB, 0xF0, 0x7F, 0x9F,
  0x80, 0xF0, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x3E, 0x03, 0xF3, 0xFC, 0x1F, 0xBF,
  0xF0, 0xFB, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0x8F, 0xE3, 0xF8, 0x3F, 0x9F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x8F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF1,
  0xF8, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x07, 0xF0, 0x7E,
  0x0F, 0xC0, 0xF8, 0x3F, 0x83, 0xF0, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC7,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xF0,
  0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87,
  0xE0, 0x3F, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x38, 0x78, 0x3E, 0xF9, 0xF8,
  0x7F, 0xFF, 0xF8, 0xF7, 0xFF, 0xF1, 0xF3, 0xE7, 0xE3, 0xE3, 0xC7, 0xCF,
  0x8F, 0x1F, 0x9F, 0x1E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8,
  0xF1, 0xF1, 0xF1, 0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F, 0x1F, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF1, 0xF3, 0xF1, 0xE3,
  0xE7, 0xC7, 0x8F, 0x8F, 0x8F, 0x1F, 0x1F, 0x1E, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0xFC, 0xFF, 0x07, 0xEF, 0xFC, 0x3E, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0xE3, 0xF8, 0xFE, 0x0F, 0xE7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8,
  0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xF8, 0xFE, 0x7F,
  0x07, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xE7, 0xC0, 0x7E, 0xFC, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0xFC,
  0xFC, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x3F, 0x3F, 0xC0, 0xFF, 0xFF, 0x83,
  0xEF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFC, 0x3F,
  0x87, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7E, 0xFF,
  0x81, 0xF9, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x04, 0x0F, 0xF3, 0xE0, 0x7F, 0xEF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0x7F, 0x1F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8,
  0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0xFD, 0xF8, 0x3F, 0xE7, 0xC0, 0x7F, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x7F,
  0xC0, 0xFB, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x0F, 0xF1,
  0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0x80, 0xFC,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0xFC, 0x03, 0xF7, 0xF0, 0x7F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x05, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x20, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0xC3,
  0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8,
  0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03, 0xE7,
  0xE0, 0x1F, 0xBE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xF8,
  0x78, 0x3F, 0xF0, 0xF0, 0x7B, 0xE3, 0xE1, 0xF7, 0xC7, 0xC3, 0xCF, 0x8D,
  0x87, 0x9F, 0x3B, 0x1F, 0x3E, 0x76, 0x3E, 0x7C, 0xEC, 0x78, 0xF1, 0x99,
  0xF1, 0xE7, 0x73, 0xE3, 0xCE, 0xE7, 0x87, 0x99, 0xCF, 0x0F, 0x73, 0xBE,
  0x1E, 0xE7, 0x78, 0x3D, 0xCE, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F, 0xC1,
  0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x83, 0xF0, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07,
  0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC7, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xF7, 0xE1, 0xFF, 0xBE, 0x07, 0xF1, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0xC1, 0xF3, 0xFF, 0x07, 0xCF, 0xFE, 0x1F, 0x7F, 0xFC, 0x79, 0xF3, 0xF3,
  0xE7, 0x87, 0xFF, 0x9E, 0x0F, 0xFC, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 11, 28, 23, 7, -28 },
  { 40, 16, 11, 23, 6, -28 },
  { 62, 24, 28, 23, 0, -28 },
  { 146, 22, 39, 23, 1, -34 },
  { 254, 29, 29, 23, -2, -29 },
  { 360, 23, 29, 23, 0, -29 },
  { 444, 7, 11, 23, 10, -28 },
  { 454, 17, 38, 23, 5, -33 },
  { 535, 17, 38, 23, 2, -33 },
  { 616, 21, 21, 23, 2, -24 },
  { 672, 20, 18, 23, 2, -22 },
  { 717, 12, 12, 23, 3, -6 },
  { 735, 14, 6, 23, 5, -16 },
  { 746, 9, 7, 23, 6, -7 },
  { 754, 25, 36, 23, 0, -32 },
  { 867, 21, 29, 23, 2, -29 },
  { 944, 20, 28, 23, 1, -28 },
  { 1014, 22, 29, 23, 1, -29 },
  { 1094, 22, 28, 23, 1, -28 },
  { 1171, 21, 28, 23, 1, -28 },
  { 1245, 22, 28, 23, 1, -28 },
  { 1322, 21, 28, 23, 1, -28 },
  { 1396, 21, 28, 23, 3, -28 },
  { 1470, 22, 29, 23, 1, -29 },
  { 1550, 20, 29, 23, 3, -29 },
  { 1623, 11, 22, 23, 6, -22 },
  { 1654, 14, 28, 23, 3, -22 },
  { 1703, 20, 22, 23, 3, -24 },
  { 1758, 20, 15, 23, 2, -20 },
  { 1796, 20, 22, 23, 1, -24 },
  { 1851, 17, 28, 23, 5, -28 },
  { 1911, 25, 36, 23, -1, -29 },
  { 2024, 22, 28, 23, -1, -28 },
  { 2101, 22, 28, 23, 1, -28 },
  { 2178, 21, 29, 23, 2, -29 },
  { 2255, 22, 28, 23, 1, -28 },
  { 2332, 22, 28, 23, 1, -28 },
  { 2409, 23, 28, 23, 1, -28 },
  { 2490, 21, 29, 23, 2, -29 },
  { 2567, 23, 28, 23, 1, -28 },
  { 2648, 22, 28, 23, 1, -28 },
  { 2725, 23, 28, 23, 0, -28 },
  { 2806, 24, 28, 23, 1, -28 },
  { 2890, 18, 28, 23, 2, -28 },
  { 2953, 25, 28, 23, 0, -28 },
  { 3041, 23, 28, 23, 1, -28 },
  { 3122, 21, 29, 23, 2, -29 },
  { 3199, 23, 28, 23, 1, -28 },
  { 3280, 21, 36, 23, 2, -29 },
  { 3375, 22, 28, 23, 1, -28 },
  { 3452, 22, 29, 23, 1, -29 },
  { 3532, 22, 28, 23, 3, -28 },
  { 3609, 23, 28, 23, 1, -28 },
  { 3690, 21, 28, 23, 4, -28 },
  { 3764, 25, 28, 23, 1, -28 },
  { 3852, 26, 28, 23, -1, -28 },
  { 3943, 23, 28, 23, 3, -28 },
  { 4024, 22, 28, 23, 1, -28 },
  { 4101, 18, 36, 23, 4, -32 },
  { 4182, 14, 36, 23, 5, -32 },
  { 4245, 18, 36, 23, 2, -32 },
  { 4326, 18, 15, 23, 3, -28 },
  { 4360, 19, 5, 23, 0, 1 },
  { 4372, 10, 6, 23, 9, -31 },
  { 4380, 22, 22, 23, 1, -22 },
  { 4441, 21, 28, 23, 1, -28 },
  { 4515, 20, 22, 23, 2, -22 },
  { 4570, 23, 28, 23, 1, -28 },
  { 4651, 20, 22, 23, 2, -22 },
  { 4706, 26, 35, 23, -2, -28 },
  { 4820, 21, 29, 23, 2, -22 },
  { 4897, 21, 28, 23, 1, -28 },
  { 4971, 20, 31, 23, 1, -31 },
  { 5049, 22, 38, 23, 0, -31 },
  { 5154, 23, 28, 23, 1, -28 },
  { 5235, 18, 28, 23, 3, -28 },
  { 5298, 23, 22, 23, 0, -22 },
  { 5362, 21, 22, 23, 1, -22 },
  { 5420, 20, 22, 23, 2, -22 },
  { 5475, 22, 29, 23, 0, -22 },
  { 5555, 22, 29, 23, 1, -22 },
  { 5635, 22, 22, 23, 1, -22 },
  { 5696, 21, 22, 23, 1, -22 },
  { 5754, 21, 27, 23, 2, -27 },
  { 5825, 22, 21, 23, 1, -21 },
  { 5883, 21, 21, 23, 3, -21 },
  { 5939, 23, 21, 23, 2, -21 },
  { 6000, 25, 21, 23, -1, -21 },
  { 6066, 21, 28, 23, 1, -21 },
  { 6140, 21, 21, 23, 1, -21 },
  { 6196, 21, 36, 23, 3, -32 },
  { 6291, 12, 36, 23, 6, -32 },
  { 6345, 21, 36, 23, 0, -32 },
  { 6440, 22, 10, 23, 1, -19 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC39PT7B_H_
