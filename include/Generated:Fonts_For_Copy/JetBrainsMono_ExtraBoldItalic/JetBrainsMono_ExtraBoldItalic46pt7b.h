#ifndef _JETBRAINSMONO_EXTRABOLDITALIC46PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x3F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x0F, 0xEF,
  0xE1, 0xFD, 0xFC, 0x3F, 0xBF, 0x87, 0xE7, 0xF1, 0xFC, 0xFC, 0x3F, 0xBF,
  0x87, 0xF7, 0xF0, 0xFE, 0xFE, 0x1F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x0F, 0xF7, 0x3F, 0xC3, 0xF9, 0xC7, 0xF0, 0xFE, 0x71, 0xFC,
  0x7F, 0x1C, 0x00, 0x1F, 0xC7, 0x00, 0x07, 0xF9, 0xC0, 0x01, 0xFE, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x73, 0xFC, 0x00, 0x1C, 0x7F, 0x00, 0x07, 0x1F,
  0xC0, 0x11, 0xC7, 0xF3, 0xF8, 0xE1, 0xFC, 0xFF, 0x38, 0xFE, 0x1F, 0xCE,
  0x7F, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xF8,
  0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x3E,
  0x1F, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x00, 0xF0, 0x7C, 0x3E, 0x00,
  0x1E, 0x0F, 0x07, 0x80, 0x07, 0xC1, 0xE1, 0xF0, 0x00, 0xF8, 0x3C, 0x7C,
  0x00, 0x1F, 0x0F, 0x9F, 0x00, 0x03, 0xF3, 0xF7, 0xC0, 0x00, 0x3F, 0xFD,
  0xF0, 0x00, 0x07, 0xFF, 0x7C, 0x00, 0x00, 0x7F, 0xDF, 0x00, 0x00, 0x00,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x00, 0xFB, 0xFF,
  0x00, 0x00, 0x3E, 0xFF, 0xF0, 0x00, 0x0F, 0x9F, 0xFE, 0x00, 0x03, 0xE7,
  0xC3, 0xE0, 0x00, 0x7C, 0xF0, 0x7C, 0x00, 0x1F, 0x1E, 0x0F, 0x00, 0x07,
  0xC7, 0xC1, 0xE0, 0x01, 0xF0, 0xF8, 0x3C, 0x00, 0x7C, 0x1F, 0x0F, 0x80,
  0x1F, 0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x7F, 0xFC, 0x01, 0xF0, 0x07, 0xFF,
  0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0xFC, 0xFF,
  0xFC, 0x3F, 0x1F, 0xDF, 0xCF, 0xE3, 0xF1, 0xF9, 0xF8, 0xFE, 0x3F, 0xFE,
  0x1F, 0xC3, 0xFF, 0xC3, 0xF8, 0x7F, 0xF0, 0x7F, 0x07, 0xFC, 0x0F, 0xC0,
  0xFF, 0x81, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x7F, 0x01, 0xFF, 0x87, 0xF0, 0x3F, 0x9F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x8F, 0xC7, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x08, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x01, 0x00,
  0xF8, 0x08, 0xE0, 0x7C, 0x1C, 0x7C, 0x3C, 0x3E, 0x7F, 0x9E, 0x7F, 0x3F,
  0xEE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xDF, 0x00, 0x07, 0xEF, 0xC0,
  0x07, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0x81, 0xF8, 0x1F, 0x80, 0x78, 0x0F, 0x00, 0x08, 0x02, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0xC0, 0x7E, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x0F, 0x0F, 0xE3, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0x80,
  0x7F, 0x1F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0xF1, 0xFC, 0x7E,
  0xFC, 0xFE, 0x7F, 0x7F, 0x7F, 0x3F, 0xBF, 0xBF, 0x1F, 0xDF, 0x9F, 0x8F,
  0xC7, 0xCF, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F,
  0x1F, 0xE0, 0x7F, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xCF,
  0xE0, 0x3E, 0x1F, 0xC0, 0x78, 0x3F, 0x80, 0xC0, 0x7F, 0x01, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8,
  0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F,
  0xC7, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0xFC,
  0xFF, 0xC0, 0x7E, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFB, 0xFF, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x7F, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC6,
  0x00, 0x3F, 0xDF, 0xE0, 0x1F, 0xDF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8,
  0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0x3F,
  0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F, 0xC7, 0xFC, 0x7F, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0xE7,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF3, 0xF8,
  0x07, 0xF9, 0xFC, 0x07, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0,
  0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x7F, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x81, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x10, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x90, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83,
  0xE0, 0x1C, 0x3E, 0x0F, 0x81, 0xFC, 0xF8, 0x7E, 0x0F, 0xFB, 0xE1, 0xF8,
  0x7F, 0xEF, 0x87, 0xE3, 0xF8, 0xFE, 0x1F, 0x0F, 0xC3, 0xF0, 0x7C, 0x3E,
  0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x1F, 0x83,
  0xF0, 0xFC, 0x7E, 0x0F, 0xC3, 0xE1, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0xF8,
  0x3E, 0x1F, 0x03, 0xE1, 0xF8, 0xFC, 0x1F, 0x87, 0xE1, 0xF0, 0x7E, 0x1F,
  0x87, 0xF7, 0xF8, 0x7E, 0x1F, 0xFB, 0xE1, 0xF0, 0x7F, 0xCF, 0x07, 0xC0,
  0xFE, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7,
  0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF3,
  0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xF8, 0x1F, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F,
  0xC1, 0xFF, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE,
  0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x87, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xFF, 0x3F,
  0x87, 0xFF, 0x9F, 0xC3, 0xFF, 0xCF, 0xE1, 0xFF, 0xC7, 0xF1, 0xFF, 0xE3,
  0xF8, 0x07, 0xF1, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80,
  0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE,
  0x00, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x81,
  0xFF, 0x07, 0xDE, 0x0F, 0xF8, 0x3E, 0xF0, 0xF7, 0xC1, 0xF7, 0x87, 0xFE,
  0x0F, 0xBC, 0x7F, 0xF0, 0x7D, 0xE3, 0xDF, 0x83, 0xEF, 0x1E, 0xF8, 0x3F,
  0x79, 0xEF, 0xC1, 0xFB, 0xCF, 0x7E, 0x0F, 0xDF, 0xFB, 0xF0, 0x7E, 0x7F,
  0x9F, 0x83, 0xF3, 0xFC, 0xFC, 0x1F, 0x9F, 0xCF, 0xC0, 0xFC, 0xFE, 0x7E,
  0x0F, 0xC7, 0xE3, 0xF0, 0x7E, 0x3F, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xE0, 0xFF, 0x00, 0xFC, 0x1F, 0xE0, 0x1F, 0x83, 0xFE, 0x03,
  0xF0, 0xFF, 0xC0, 0xFE, 0x1F, 0xF8, 0x1F, 0x83, 0xFF, 0x03, 0xF0, 0x7F,
  0xE0, 0x7E, 0x0F, 0xFC, 0x0F, 0xC1, 0xF7, 0xC1, 0xF8, 0x7E, 0xF8, 0x7F,
  0x0F, 0xDF, 0x0F, 0xC1, 0xFB, 0xE1, 0xF8, 0x3F, 0x7C, 0x3F, 0x07, 0xEF,
  0xC7, 0xE0, 0xFC, 0xF8, 0xFC, 0x1F, 0x9F, 0x1F, 0x87, 0xE3, 0xE7, 0xE0,
  0xFC, 0x7C, 0xFC, 0x1F, 0x8F, 0x9F, 0x83, 0xF1, 0xFB, 0xF0, 0x7E, 0x1F,
  0x7E, 0x0F, 0xC3, 0xEF, 0xC3, 0xF8, 0x7D, 0xF0, 0x7E, 0x0F, 0xBE, 0x0F,
  0xC1, 0xFF, 0xC1, 0xF8, 0x1F, 0xF8, 0x3F, 0x03, 0xFF, 0x07, 0xE0, 0x7F,
  0xE1, 0xFC, 0x0F, 0xFC, 0x3F, 0x01, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0xFC,
  0x03, 0xFC, 0x1F, 0x80, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC,
  0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xE0, 0x7F, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF1, 0xFC, 0x01,
  0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0,
  0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0x03, 0xF9,
  0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x1F, 0xE0, 0x7F, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0xF0,
  0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07,
  0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xF0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x01, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x0F, 0xE3, 0xFC,
  0x07, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F,
  0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3E, 0x0F, 0xC1, 0xF3, 0xE0, 0xFC, 0x3F, 0x3E, 0x0F,
  0xC3, 0xF3, 0xE0, 0xFC, 0x3F, 0x7E, 0x1F, 0xC3, 0xE7, 0xE1, 0xFC, 0x3E,
  0x7E, 0x1F, 0x87, 0xE7, 0xE3, 0xF8, 0x7E, 0x7E, 0x3F, 0x87, 0xC7, 0xE3,
  0xB8, 0x7C, 0x7C, 0x3B, 0x8F, 0xC7, 0xC7, 0xB8, 0xFC, 0x7C, 0x7B, 0x8F,
  0x87, 0xC7, 0x38, 0xF8, 0x7C, 0x73, 0x8F, 0x87, 0xCF, 0x39, 0xF8, 0x7C,
  0xE3, 0x9F, 0x07, 0xCE, 0x79, 0xF0, 0x7D, 0xE7, 0x9F, 0x0F, 0xDE, 0x7B,
  0xF0, 0xFD, 0xC7, 0xBE, 0x0F, 0xDC, 0x7B, 0xE0, 0xFB, 0xC7, 0xBE, 0x0F,
  0xBC, 0x7F, 0xE0, 0xFB, 0x87, 0x7C, 0x0F, 0xB8, 0x77, 0xC0, 0xFF, 0x87,
  0x7C, 0x0F, 0xF8, 0x77, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x7F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x3F, 0x80,
  0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x0F,
  0xE0, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xF7, 0xF0, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xBE, 0x00,
  0x7E, 0xF8, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7E, 0x3F, 0x03, 0xF8,
  0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7F,
  0x7F, 0x00, 0xFF, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0,
  0x00, 0x3C, 0x00, 0x40, 0x3F, 0xC7, 0xE0, 0x3F, 0xFB, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x1F, 0xF8, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xBF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xF0, 0x1F, 0xF9, 0xFC, 0x03, 0xFC, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0xF0, 0x07, 0xF3, 0xFE, 0x03, 0xFB, 0xFF, 0x81,
  0xFB, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC3, 0xFC,
  0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0x8F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xE0,
  0x3F, 0x8F, 0xF0, 0x3F, 0xC7, 0xFF, 0xFF, 0xC3, 0xF7, 0xFF, 0xE1, 0xFB,
  0xFF, 0xE1, 0xFD, 0xFF, 0xE0, 0xFE, 0x7F, 0xE0, 0x7F, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF, 0x3F, 0x80, 0xFF,
  0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFF, 0x03, 0xFC,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x78, 0x3F, 0x80,
  0x7F, 0x8F, 0xC0, 0x7F, 0xF7, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC3, 0xFE, 0x3F, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xFC, 0x1F,
  0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xEF, 0xE0, 0x3F, 0xF3, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E,
  0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0xFF, 0x03, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x80, 0xFF, 0x1F, 0x81, 0xFF, 0xDF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xFC, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xF3, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xDF, 0x83, 0xFF, 0xEF, 0xC0, 0xFF, 0xEF, 0xE0, 0x3F, 0xE7,
  0xF0, 0x03, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0xF0, 0x07, 0xF3, 0xFE, 0x03, 0xFB, 0xFF, 0x81, 0xFB, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC,
  0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xC0,
  0xFC, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F,
  0xF0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0,
  0x1F, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x06, 0x07, 0x01, 0xF3, 0xF3, 0xF8, 0x3E, 0xFE, 0xFF, 0x0F, 0xFF,
  0xDF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF8,
  0xFC, 0x7C, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE1, 0xF1, 0xF8, 0xFC, 0x3E,
  0x3F, 0x1F, 0x87, 0x87, 0xE3, 0xF0, 0xF0, 0xFC, 0x7E, 0x3E, 0x1F, 0x8F,
  0xC7, 0xC3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x1F, 0x1F, 0x8F, 0xC3, 0xE3,
  0xF1, 0xF8, 0x78, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xE3, 0xE1, 0xF8, 0xFC,
  0x7C, 0x7E, 0x3F, 0x0F, 0x8F, 0xC7, 0xE1, 0xF1, 0xF8, 0xFC, 0x3C, 0x3F,
  0x1F, 0x8F, 0x87, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xF3, 0xFE, 0x03, 0xF3,
  0xFF, 0x81, 0xFB, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xC7, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0xFE, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F,
  0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE1, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0xFE,
  0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFF,
  0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xFC, 0xFF, 0x80, 0x7E, 0x7F, 0xF0, 0x1F, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0,
  0x3F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x03,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0x83, 0xF7, 0xFF, 0xC1, 0xFD,
  0xFF, 0xE0, 0x7F, 0x3F, 0xF0, 0x1F, 0xC7, 0xF0, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x80, 0xFF, 0x1F, 0x81, 0xFF, 0xCF, 0xC1, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x8F, 0xFC, 0x7F, 0x01, 0xFC,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xE0,
  0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xEF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xF7, 0xF0, 0x3F, 0xF3, 0xF8, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xE3, 0xFE, 0x07, 0xF7, 0xFF, 0x83, 0xFB, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0x80, 0xFF, 0x1F,
  0xC0, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F, 0xE3,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF0,
  0x1F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80,
  0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xE1, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x01, 0xFE, 0x3F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x1F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x7E,
  0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x7E, 0x7F, 0x00,
  0x3F, 0x3F, 0x80, 0x1F, 0xDF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x07, 0xFF,
  0x83, 0xE0, 0xFF, 0xF0, 0xFC, 0x1F, 0x7E, 0x1F, 0x83, 0xEF, 0xC3, 0xF0,
  0xFD, 0xF8, 0x7E, 0x1F, 0x3F, 0x1D, 0xC3, 0xE7, 0xE3, 0xB8, 0xFC, 0xFC,
  0x77, 0x1F, 0x1F, 0x9E, 0xE3, 0xE3, 0xF3, 0x9C, 0x7C, 0x7E, 0x73, 0x9F,
  0x8F, 0xDE, 0x73, 0xE1, 0xFB, 0x8E, 0x7C, 0x3F, 0x71, 0xDF, 0x87, 0xDE,
  0x3B, 0xE0, 0xFB, 0xC7, 0x7C, 0x1F, 0x70, 0xEF, 0x83, 0xEE, 0x1F, 0xE0,
  0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0xC1,
  0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x7F, 0x80,
  0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xEF, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFD,
  0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFB, 0xF8, 0x3F, 0xF3, 0xF8, 0x0F, 0xC3,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x04, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x0F,
  0xCF, 0xFF, 0x07, 0xEF, 0xFF, 0x83, 0xF7, 0xFF, 0xE1, 0xFF, 0xF7, 0xF8,
  0xFB, 0xF1, 0xFF, 0xFD, 0xF8, 0x7F, 0xFE, 0xF8, 0x1F, 0xFE, 0x7C, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x70, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 13, 34, 28, 8, -34 },
  { 57, 19, 14, 28, 7, -34 },
  { 91, 29, 34, 28, 0, -34 },
  { 215, 26, 46, 28, 1, -40 },
  { 365, 35, 34, 28, -3, -34 },
  { 514, 27, 34, 28, 0, -34 },
  { 629, 9, 14, 28, 12, -34 },
  { 645, 20, 45, 28, 6, -39 },
  { 758, 20, 45, 28, 2, -39 },
  { 871, 25, 24, 28, 2, -28 },
  { 946, 24, 22, 28, 2, -26 },
  { 1012, 14, 14, 28, 3, -7 },
  { 1037, 17, 6, 28, 6, -18 },
  { 1050, 10, 9, 28, 7, -9 },
  { 1062, 30, 43, 28, -1, -38 },
  { 1224, 25, 34, 28, 2, -34 },
  { 1331, 23, 34, 28, 2, -34 },
  { 1429, 26, 34, 28, 1, -34 },
  { 1540, 26, 34, 28, 1, -34 },
  { 1651, 25, 34, 28, 1, -34 },
  { 1758, 25, 34, 28, 2, -34 },
  { 1865, 25, 34, 28, 1, -34 },
  { 1972, 25, 34, 28, 4, -34 },
  { 2079, 26, 34, 28, 1, -34 },
  { 2190, 25, 34, 28, 3, -34 },
  { 2297, 13, 26, 28, 7, -26 },
  { 2340, 17, 33, 28, 3, -26 },
  { 2411, 24, 26, 28, 3, -28 },
  { 2489, 23, 18, 28, 3, -24 },
  { 2541, 23, 26, 28, 2, -28 },
  { 2616, 21, 34, 28, 5, -34 },
  { 2706, 30, 42, 28, -1, -34 },
  { 2864, 25, 34, 28, -1, -34 },
  { 2971, 27, 34, 28, 1, -34 },
  { 3086, 25, 34, 28, 2, -34 },
  { 3193, 27, 34, 28, 1, -34 },
  { 3308, 26, 34, 28, 2, -34 },
  { 3419, 27, 34, 28, 1, -34 },
  { 3534, 25, 34, 28, 2, -34 },
  { 3641, 27, 34, 28, 1, -34 },
  { 3756, 25, 34, 28, 2, -34 },
  { 3863, 27, 35, 28, 0, -34 },
  { 3982, 28, 34, 28, 1, -34 },
  { 4101, 22, 34, 28, 2, -34 },
  { 4195, 29, 34, 28, 0, -34 },
  { 4319, 27, 34, 28, 1, -34 },
  { 4434, 25, 34, 28, 2, -34 },
  { 4541, 27, 34, 28, 1, -34 },
  { 4656, 25, 42, 28, 2, -34 },
  { 4788, 27, 34, 28, 1, -34 },
  { 4903, 26, 34, 28, 1, -34 },
  { 5014, 25, 34, 28, 4, -34 },
  { 5121, 26, 34, 28, 2, -34 },
  { 5232, 26, 34, 28, 4, -34 },
  { 5343, 28, 34, 28, 2, -34 },
  { 5462, 30, 34, 28, -1, -34 },
  { 5590, 26, 34, 28, 4, -34 },
  { 5701, 26, 34, 28, 1, -34 },
  { 5812, 21, 43, 28, 5, -38 },
  { 5925, 16, 43, 28, 6, -38 },
  { 6011, 21, 43, 28, 3, -38 },
  { 6124, 22, 18, 28, 3, -34 },
  { 6174, 23, 7, 28, 0, 1 },
  { 6195, 11, 6, 28, 11, -36 },
  { 6204, 26, 26, 28, 1, -26 },
  { 6289, 25, 34, 28, 1, -34 },
  { 6396, 24, 26, 28, 2, -26 },
  { 6474, 26, 34, 28, 2, -34 },
  { 6585, 24, 26, 28, 2, -26 },
  { 6663, 31, 42, 28, -3, -34 },
  { 6826, 25, 34, 28, 2, -26 },
  { 6933, 25, 34, 28, 1, -34 },
  { 7040, 24, 36, 28, 1, -36 },
  { 7148, 26, 44, 28, 0, -36 },
  { 7291, 27, 34, 28, 1, -34 },
  { 7406, 22, 34, 28, 3, -34 },
  { 7500, 27, 26, 28, 0, -26 },
  { 7588, 25, 26, 28, 1, -26 },
  { 7670, 24, 26, 28, 2, -26 },
  { 7748, 26, 34, 28, 0, -26 },
  { 7859, 25, 34, 28, 2, -26 },
  { 7966, 25, 26, 28, 2, -26 },
  { 8048, 25, 26, 28, 1, -26 },
  { 8130, 24, 32, 28, 3, -32 },
  { 8226, 25, 25, 28, 2, -25 },
  { 8305, 25, 25, 28, 3, -25 },
  { 8384, 27, 25, 28, 2, -25 },
  { 8469, 29, 25, 28, -1, -25 },
  { 8560, 24, 33, 28, 2, -25 },
  { 8659, 25, 25, 28, 1, -25 },
  { 8738, 24, 43, 28, 4, -38 },
  { 8867, 13, 43, 28, 8, -38 },
  { 8937, 24, 43, 28, 1, -38 },
  { 9066, 25, 12, 28, 2, -22 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC46PT7B_H_
