#ifndef _JETBRAINSMONO_EXTRABOLDITALIC15PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x66, 0x66, 0x40, 0x0C, 0xC0, 0x6F, 0xBE, 0xF3, 0xCC, 0x0D,
  0x84, 0xC6, 0x4F, 0xF1, 0x31, 0x90, 0x99, 0xFE, 0x64, 0x26, 0x33, 0x00,
  0x04, 0x02, 0x07, 0xC7, 0xF3, 0x7B, 0xC0, 0xF0, 0x7E, 0x0F, 0x05, 0xBA,
  0xCF, 0xC7, 0xC0, 0x80, 0x40, 0x1C, 0x66, 0x98, 0x92, 0x12, 0x83, 0xA0,
  0x0C, 0x03, 0xE0, 0xF6, 0x36, 0xCC, 0xD3, 0x1E, 0x00, 0x1E, 0x1F, 0x8C,
  0xC6, 0x03, 0x83, 0xC5, 0xFD, 0xDE, 0xC6, 0x7F, 0x1E, 0xC0, 0xFB, 0x6C,
  0x02, 0x18, 0x71, 0x87, 0x0C, 0x18, 0x30, 0xE1, 0x83, 0x87, 0x07, 0x07,
  0x04, 0x00, 0x20, 0xC3, 0x87, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0x8E, 0xF3,
  0x88, 0x00, 0x18, 0x18, 0xDF, 0xFF, 0x38, 0x6C, 0xEC, 0x48, 0x18, 0x30,
  0x67, 0xFF, 0xE7, 0x0C, 0x18, 0x3B, 0x99, 0xC0, 0xFF, 0xC0, 0x67, 0x60,
  0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x3E, 0x7F, 0x63, 0xE3, 0xD6, 0xDE,
  0xD6, 0xC6, 0xC6, 0xFC, 0x78, 0x1C, 0x79, 0xB2, 0xE1, 0xC3, 0x06, 0x0C,
  0x19, 0xFF, 0xF8, 0x1F, 0x1F, 0x8C, 0xE8, 0x70, 0x30, 0x30, 0x38, 0x70,
  0x70, 0x3F, 0xBF, 0xC0, 0x3F, 0x9F, 0xC1, 0xC1, 0x80, 0xE0, 0xF8, 0x0C,
  0x06, 0x63, 0x3F, 0x1F, 0x00, 0x03, 0x83, 0x03, 0x03, 0x83, 0x83, 0x99,
  0x8C, 0xFE, 0xFF, 0x03, 0x01, 0x80, 0x7F, 0x7F, 0x60, 0x60, 0x7E, 0xFE,
  0x06, 0x06, 0xCE, 0xFC, 0x78, 0x07, 0x0E, 0x1C, 0x18, 0x36, 0x7F, 0x63,
  0x63, 0x63, 0x7E, 0x3C, 0x7F, 0x7F, 0xE7, 0xC6, 0x0E, 0x0C, 0x18, 0x38,
  0x30, 0x70, 0xE0, 0x1F, 0x1F, 0xCC, 0xE6, 0x63, 0xF0, 0xF1, 0xDC, 0xC6,
  0x63, 0x3F, 0x1F, 0x00, 0x3E, 0x7F, 0xE3, 0xC3, 0xE7, 0xFE, 0x7E, 0x1C,
  0x18, 0x30, 0x70, 0x33, 0x80, 0x00, 0x11, 0xCC, 0x18, 0xE0, 0x00, 0x00,
  0x23, 0x1C, 0x63, 0x80, 0x03, 0x0E, 0x3C, 0xF0, 0xE0, 0x78, 0x1E, 0x06,
  0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x40, 0xE0, 0xF0, 0x70, 0xEF, 0xBC,
  0x40, 0x79, 0xF8, 0x30, 0x67, 0xCF, 0x18, 0x20, 0x01, 0xC3, 0x00, 0x1F,
  0x1D, 0xD8, 0x6C, 0x36, 0xEA, 0x4F, 0x67, 0xB3, 0xD9, 0x6F, 0xB0, 0x18,
  0x07, 0x81, 0xC0, 0x0E, 0x0E, 0x1E, 0x1E, 0x36, 0x36, 0x37, 0x7F, 0x7F,
  0xE3, 0xC3, 0x3F, 0x1F, 0xCC, 0xE6, 0x77, 0xF3, 0xF1, 0x8C, 0xC6, 0x63,
  0x3F, 0xBF, 0x00, 0x3E, 0x7F, 0x63, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC6,
  0xFC, 0x78, 0x3F, 0x1F, 0xCC, 0xEE, 0x37, 0x3B, 0x19, 0x8C, 0xC6, 0x67,
  0x3F, 0x3F, 0x00, 0x7F, 0x7F, 0x60, 0x60, 0x7E, 0xFE, 0xC0, 0xC0, 0xC0,
  0xFE, 0xFC, 0x3F, 0x9F, 0xCC, 0x06, 0x07, 0x03, 0xF9, 0xFC, 0xC0, 0x60,
  0x30, 0x38, 0x00, 0x3E, 0x7F, 0x63, 0xE0, 0xE0, 0xCF, 0xDE, 0xC6, 0xC6,
  0xFC, 0x78, 0x31, 0x98, 0xCC, 0xE6, 0x77, 0xF3, 0xF9, 0x8C, 0xC6, 0x67,
  0x33, 0xB9, 0x80, 0x7F, 0x7F, 0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30,
  0xFC, 0xFC, 0x0F, 0x87, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0xC6,
  0x7F, 0x1F, 0x00, 0x31, 0xCC, 0xE3, 0x30, 0xDC, 0x7E, 0x1F, 0x06, 0xE1,
  0x98, 0x66, 0x19, 0xCE, 0x70, 0x70, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x70,
  0xC1, 0xFF, 0xF8, 0x31, 0xB9, 0xDE, 0xEF, 0xF7, 0xDB, 0x6D, 0x8C, 0xC6,
  0xC3, 0x61, 0xB0, 0xC0, 0x39, 0x9C, 0xCE, 0x6D, 0x36, 0xB3, 0x79, 0xBC,
  0xDE, 0x6F, 0x63, 0xB1, 0xC0, 0x3E, 0x7F, 0x67, 0xE7, 0xE6, 0xC6, 0xC6,
  0xC6, 0xCE, 0xFC, 0x78, 0x3F, 0x1F, 0xCC, 0x66, 0x37, 0x3B, 0xF9, 0xF8,
  0xC0, 0x60, 0x30, 0x38, 0x00, 0x3E, 0x7F, 0x67, 0xE7, 0xE6, 0xC6, 0xC6,
  0xC6, 0xCE, 0xFC, 0x78, 0x18, 0x1C, 0x0C, 0x3F, 0x1F, 0xCC, 0xE6, 0x37,
  0x3B, 0xF9, 0xF0, 0xDC, 0x66, 0x33, 0x39, 0xC0, 0x1F, 0x1F, 0xCC, 0xEE,
  0x03, 0x81, 0xF0, 0x3C, 0x06, 0xE3, 0x3F, 0x1F, 0x00, 0x7F, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x63, 0x63, 0x63, 0xE7,
  0xE6, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0xE3, 0xB1, 0x99, 0xCC, 0xC6,
  0x63, 0x71, 0xB0, 0xD8, 0x78, 0x3C, 0x1C, 0x00, 0xC9, 0xEC, 0xF6, 0x5B,
  0x6F, 0xB7, 0x5A, 0xA9, 0x5C, 0xEE, 0x66, 0x33, 0x00, 0x31, 0xCC, 0xE3,
  0xB0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xD8, 0x76, 0x19, 0x8C, 0x70, 0xE3,
  0xB1, 0x99, 0x8C, 0xC3, 0xC1, 0xE0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x00,
  0x3F, 0x9F, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x3F, 0xBF,
  0x80, 0x3C, 0xF7, 0x18, 0x61, 0x86, 0x18, 0xE3, 0x8C, 0x32, 0xF3, 0xC0,
  0xE7, 0x18, 0xC6, 0x38, 0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x3E, 0x78, 0x30,
  0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xCF, 0x9F, 0x00, 0x1C, 0x38,
  0xF3, 0xB6, 0x78, 0xC0, 0xFF, 0xFC, 0xE7, 0x3F, 0xBF, 0x98, 0xCC, 0x66,
  0x33, 0x39, 0xFC, 0xFC, 0x30, 0x30, 0x30, 0x3F, 0x7F, 0x63, 0x63, 0x63,
  0x67, 0x7E, 0xFE, 0x7E, 0x7E, 0xC6, 0xC0, 0xC0, 0xC6, 0xFC, 0x78, 0x01,
  0x80, 0xC0, 0xE7, 0xF7, 0xF3, 0x19, 0x8C, 0xC6, 0x67, 0x3F, 0x9F, 0x80,
  0x7E, 0xCF, 0x1F, 0xFC, 0x18, 0x7F, 0x3C, 0x03, 0xC1, 0xF0, 0x60, 0x38,
  0x3F, 0xCF, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0xF8, 0x38,
  0x00, 0x7F, 0xFE, 0xC6, 0xC6, 0xC6, 0xEE, 0xFE, 0x2C, 0x0C, 0xFC, 0xF0,
  0x30, 0x30, 0x30, 0x3F, 0x7F, 0x63, 0x63, 0x63, 0x63, 0x67, 0xE6, 0x06,
  0x0E, 0x00, 0x00, 0x3E, 0x3C, 0x0C, 0x0C, 0x0C, 0x0C, 0x7F, 0xFF, 0x03,
  0x03, 0x00, 0x00, 0x3F, 0x3E, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x1C,
  0xFC, 0xF0, 0x30, 0x18, 0x0C, 0x06, 0x77, 0x73, 0x31, 0xF8, 0xFC, 0x66,
  0x33, 0x39, 0xC0, 0xF9, 0xF0, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x7C,
  0x78, 0x7F, 0xB6, 0xDA, 0x6D, 0x24, 0xB6, 0xDB, 0x6D, 0xB6, 0x3F, 0x7F,
  0x63, 0x63, 0x63, 0x63, 0x67, 0xE6, 0x7E, 0xFF, 0x1E, 0x3C, 0x79, 0xFF,
  0x3C, 0x3F, 0x7F, 0x63, 0x63, 0x63, 0x67, 0x7E, 0xFE, 0xC0, 0xC0, 0xC0,
  0x3F, 0xBF, 0x98, 0xCC, 0x66, 0x33, 0x39, 0xFC, 0xFC, 0x06, 0x03, 0x01,
  0x80, 0x7E, 0x7F, 0xE7, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x39, 0x98,
  0x0F, 0xC0, 0xF0, 0x1B, 0xFC, 0xFC, 0x18, 0x18, 0x38, 0xFF, 0xFE, 0x30,
  0x30, 0x30, 0x70, 0x7E, 0x3C, 0xE7, 0xE6, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC,
  0x78, 0xC3, 0xE6, 0x66, 0x6C, 0x6C, 0x78, 0x78, 0x78, 0xD9, 0xED, 0xAE,
  0xD5, 0x4A, 0xE5, 0x73, 0x31, 0x98, 0x73, 0x9B, 0x87, 0x83, 0x81, 0xC1,
  0xF1, 0x99, 0xCE, 0xE7, 0xC6, 0xC6, 0xC6, 0xC6, 0xFE, 0xFE, 0x0C, 0x0C,
  0xFC, 0xF0, 0x3F, 0x3F, 0x06, 0x1C, 0x38, 0x70, 0x7F, 0xFE, 0x07, 0x0F,
  0x0C, 0x0C, 0x0C, 0x1C, 0xF0, 0xF8, 0x18, 0x18, 0x18, 0x38, 0x1C, 0x0C,
  0x19, 0xCC, 0x63, 0x18, 0xCE, 0x73, 0x18, 0xC6, 0x70, 0x3C, 0x3C, 0x0C,
  0x1C, 0x18, 0x1C, 0x0F, 0x1F, 0x18, 0x18, 0x38, 0x38, 0xF0, 0xE0, 0xF3,
  0xFB, 0x9E, 0x0C,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 11, 9, 3, -11 },
  { 7, 6, 5, 9, 2, -11 },
  { 11, 9, 11, 9, 0, -11 },
  { 24, 9, 15, 9, 0, -13 },
  { 41, 11, 11, 9, -1, -11 },
  { 57, 9, 11, 9, 0, -11 },
  { 70, 3, 5, 9, 4, -11 },
  { 72, 7, 15, 9, 2, -13 },
  { 86, 6, 15, 9, 1, -13 },
  { 98, 8, 8, 9, 1, -9 },
  { 106, 7, 8, 9, 1, -9 },
  { 113, 5, 4, 9, 1, -2 },
  { 116, 5, 2, 9, 2, -6 },
  { 118, 4, 3, 9, 2, -3 },
  { 120, 10, 14, 9, 0, -12 },
  { 138, 8, 11, 9, 1, -11 },
  { 149, 7, 11, 9, 1, -11 },
  { 159, 9, 11, 9, 0, -11 },
  { 172, 9, 11, 9, 0, -11 },
  { 185, 9, 11, 9, 0, -11 },
  { 198, 8, 11, 9, 1, -11 },
  { 209, 8, 11, 9, 0, -11 },
  { 220, 8, 11, 9, 1, -11 },
  { 231, 9, 11, 9, 0, -11 },
  { 244, 8, 11, 9, 1, -11 },
  { 255, 5, 8, 9, 2, -8 },
  { 260, 6, 10, 9, 1, -8 },
  { 268, 8, 8, 9, 1, -9 },
  { 276, 7, 6, 9, 1, -8 },
  { 282, 7, 8, 9, 1, -9 },
  { 289, 7, 11, 9, 2, -11 },
  { 299, 9, 14, 9, 0, -11 },
  { 315, 8, 11, 9, 0, -11 },
  { 326, 9, 11, 9, 0, -11 },
  { 339, 8, 11, 9, 1, -11 },
  { 350, 9, 11, 9, 0, -11 },
  { 363, 8, 11, 9, 1, -11 },
  { 374, 9, 11, 9, 0, -11 },
  { 387, 8, 11, 9, 1, -11 },
  { 398, 9, 11, 9, 0, -11 },
  { 411, 8, 11, 9, 1, -11 },
  { 422, 9, 11, 9, 0, -11 },
  { 435, 10, 11, 9, 0, -11 },
  { 449, 7, 11, 9, 1, -11 },
  { 459, 9, 11, 9, 0, -11 },
  { 472, 9, 11, 9, 0, -11 },
  { 485, 8, 11, 9, 1, -11 },
  { 496, 9, 11, 9, 0, -11 },
  { 509, 8, 14, 9, 1, -11 },
  { 523, 9, 11, 9, 0, -11 },
  { 536, 9, 11, 9, 0, -11 },
  { 549, 8, 11, 9, 1, -11 },
  { 560, 8, 11, 9, 1, -11 },
  { 571, 9, 11, 9, 1, -11 },
  { 584, 9, 11, 9, 1, -11 },
  { 597, 10, 11, 9, 0, -11 },
  { 611, 9, 11, 9, 1, -11 },
  { 624, 9, 11, 9, 0, -11 },
  { 637, 6, 14, 9, 2, -12 },
  { 648, 5, 14, 9, 2, -12 },
  { 657, 7, 14, 9, 1, -12 },
  { 670, 7, 6, 9, 1, -11 },
  { 676, 7, 2, 9, 0, 0 },
  { 678, 4, 2, 9, 3, -12 },
  { 679, 9, 8, 9, 0, -8 },
  { 688, 8, 11, 9, 0, -11 },
  { 699, 8, 8, 9, 1, -8 },
  { 707, 9, 11, 9, 0, -11 },
  { 720, 7, 8, 9, 1, -8 },
  { 727, 10, 14, 9, -1, -11 },
  { 745, 8, 11, 9, 1, -8 },
  { 756, 8, 11, 9, 0, -11 },
  { 767, 8, 12, 9, 0, -12 },
  { 779, 8, 15, 9, 0, -12 },
  { 794, 9, 11, 9, 0, -11 },
  { 807, 7, 11, 9, 1, -11 },
  { 817, 9, 8, 9, 0, -8 },
  { 826, 8, 8, 9, 0, -8 },
  { 834, 7, 8, 9, 1, -8 },
  { 841, 8, 11, 9, 0, -8 },
  { 852, 9, 11, 9, 0, -8 },
  { 865, 8, 8, 9, 1, -8 },
  { 873, 9, 8, 9, 0, -8 },
  { 882, 8, 11, 9, 1, -11 },
  { 893, 8, 8, 9, 1, -8 },
  { 901, 8, 8, 9, 1, -8 },
  { 909, 9, 8, 9, 1, -8 },
  { 918, 9, 8, 9, 0, -8 },
  { 927, 8, 11, 9, 1, -8 },
  { 938, 8, 8, 9, 0, -8 },
  { 946, 8, 14, 9, 1, -12 },
  { 960, 5, 14, 9, 2, -12 },
  { 969, 8, 14, 9, 0, -12 },
  { 983, 8, 4, 9, 1, -7 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC15PT7B_H_
