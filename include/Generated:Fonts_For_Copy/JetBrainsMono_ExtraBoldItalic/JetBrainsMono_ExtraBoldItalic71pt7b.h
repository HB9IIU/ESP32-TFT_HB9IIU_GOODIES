#ifndef _JETBRAINSMONO_EXTRABOLDITALIC71PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF9, 0xFF, 0x81, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0xFF, 0xE0,
  0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0x3F, 0xF8, 0x1F, 0xF9, 0xFF, 0x81, 0xFF,
  0xCF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0, 0x7F, 0xF7, 0xFF, 0x03, 0xFF, 0x3F,
  0xF8, 0x1F, 0xF9, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFE, 0x7F, 0xE0,
  0x7F, 0xF3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0xFF, 0x80, 0xFF,
  0xC7, 0xFC, 0x07, 0xFE, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0xF9, 0xFF, 0xE0, 0x1F, 0xFC, 0x7C,
  0x7F, 0xF0, 0x0F, 0xFE, 0x3E, 0x3F, 0xFC, 0x0F, 0xFE, 0x1E, 0x0F, 0xFC,
  0x07, 0xFF, 0x0F, 0x07, 0xFE, 0x03, 0xFF, 0x87, 0x80, 0x00, 0x01, 0xFF,
  0xC7, 0xC0, 0x00, 0x00, 0xFF, 0xE3, 0xE0, 0x00, 0x00, 0x7F, 0xF1, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x78, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0x87, 0xFF, 0x80,
  0x00, 0x07, 0xC3, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0xFF, 0xE0, 0x00, 0x01,
  0xF0, 0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0xF0, 0x7F, 0xF0, 0x78, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3C, 0x1F, 0xFC, 0x1F, 0xFC, 0x3E, 0x0F, 0xFE, 0x0F,
  0xFF, 0x1F, 0x0F, 0xFE, 0x07, 0xFF, 0xCF, 0x9F, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x83, 0xFC,
  0x00, 0x00, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE1,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x9F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x8F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF3, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x9F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x8F, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x00,
  0x00, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xCF,
  0xFC, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xEF,
  0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF1, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7, 0xFF,
  0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x7F, 0xE3, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF,
  0xFE, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x08, 0x00,
  0x7F, 0x80, 0x08, 0x1E, 0x00, 0xFE, 0x00, 0xF0, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0xFF, 0x03, 0xF0, 0x3F, 0xE3, 0xFF, 0x87, 0xE1, 0xFF, 0xC7, 0xFF,
  0x8F, 0x87, 0xFF, 0x9F, 0xFF, 0x8F, 0x3F, 0xFF, 0x3F, 0xFF, 0x9C, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0x08, 0x00, 0x18, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xE0, 0x00, 0x40, 0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7F,
  0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE,
  0x1F, 0x07, 0xFE, 0x0F, 0xFC, 0xFF, 0x0F, 0xFC, 0x1F, 0xF9, 0xFF, 0x1F,
  0xF8, 0x7F, 0xE7, 0xFE, 0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0xFF, 0xC1, 0xFF,
  0x9F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xF3, 0xFF, 0x07, 0xFE, 0x3F, 0xE7,
  0xFE, 0x0F, 0xFC, 0x7F, 0x8F, 0xFC, 0x1F, 0xF0, 0x3E, 0x1F, 0xF8, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF0, 0x01,
  0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x07, 0xF8, 0x3F, 0xF0,
  0x01, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x01, 0xFF, 0xC0, 0x07, 0x80, 0x3F,
  0xF8, 0x00, 0xE0, 0x07, 0xFF, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0x04, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF,
  0x87, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x07,
  0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x7F, 0xFF, 0x80,
  0x07, 0xFE, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xE0, 0x00, 0x0F, 0xFF, 0x3F, 0xF8,
  0x00, 0x3F, 0xF9, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xF8,
  0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0xFE,
  0x7F, 0xF0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x87,
  0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFE, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0xBF,
  0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x01,
  0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x7F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xF3, 0xFF,
  0x80, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xC3, 0xFE, 0x0F, 0xF8, 0x03, 0xFF,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xFC, 0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xF7,
  0xF8, 0x3F, 0xE0, 0x3F, 0xFF, 0x9F, 0xC1, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x03,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x80, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xF7, 0xF0, 0x3F, 0xC0,
  0x3F, 0xFF, 0x3F, 0x81, 0xFE, 0x01, 0xFF, 0xF1, 0xFC, 0x0F, 0xF0, 0x07,
  0xFF, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFE,
  0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00,
  0x7F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0xC0, 0x00, 0xFF,
  0xC7, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF8,
  0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x1F,
  0xFB, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xF8,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F,
  0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87,
  0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFF, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x07,
  0xFE, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFD,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0x7E, 0x03, 0xF7, 0xF8, 0x07, 0xFB, 0xF0, 0x3F, 0xBF, 0xC0,
  0x3F, 0xDF, 0x81, 0xFB, 0xFE, 0x01, 0xFE, 0xFE, 0x0F, 0xDF, 0xF0, 0x0F,
  0xF7, 0xF0, 0xFE, 0xFF, 0x00, 0x7F, 0x9F, 0x87, 0xE7, 0xF8, 0x07, 0xFC,
  0xFC, 0x7F, 0x7F, 0xC0, 0x3F, 0xE7, 0xE3, 0xF3, 0xFE, 0x01, 0xFF, 0x3F,
  0x3F, 0x9F, 0xF0, 0x0F, 0xF9, 0xF9, 0xFC, 0xFF, 0x80, 0x7F, 0xCF, 0xCF,
  0xCF, 0xFC, 0x03, 0xFE, 0x7E, 0xFE, 0x7F, 0xC0, 0x1F, 0xF3, 0xFF, 0xE3,
  0xFE, 0x01, 0xFF, 0x9F, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xF0, 0xFF,
  0x80, 0x7F, 0xC3, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xFC, 0x7F, 0xE0,
  0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x80, 0x07,
  0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0xCF, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF3, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0xC7, 0xF8, 0x3F, 0xE0, 0x1F, 0xF1,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0x87, 0xFE, 0x03, 0xFF, 0x1F, 0xE1,
  0xFF, 0x00, 0xFF, 0xC7, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xC7, 0xFC, 0x03, 0xFE, 0x0F, 0xF1, 0xFF, 0x00, 0xFF,
  0x83, 0xFC, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0x1F, 0xE0, 0x1F, 0xF8, 0x3F,
  0xCF, 0xF8, 0x07, 0xFC, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xBF, 0xE0, 0x1F, 0xF0, 0x1F, 0xEF, 0xF8, 0x0F,
  0xFC, 0x07, 0xFB, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x7F, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC,
  0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF,
  0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01,
  0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x3F,
  0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x03, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0xFF,
  0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00,
  0x1F, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7D, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xF8,
  0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x03, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00,
  0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC3, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0xC0, 0x7F, 0x83, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x1F, 0x7C, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFB, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xDF, 0x07, 0xFC,
  0x0F, 0xF0, 0x3E, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xF7, 0xC1, 0xFE, 0x03,
  0xFC, 0x1F, 0x3E, 0x0F, 0xF0, 0x1F, 0xE0, 0xFB, 0xF0, 0xFF, 0x80, 0xFF,
  0x07, 0xDF, 0x87, 0xFC, 0x07, 0xF8, 0x7E, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3,
  0xE7, 0xE1, 0xFE, 0x03, 0xFE, 0x1F, 0x3E, 0x0F, 0xF0, 0x1F, 0xF1, 0xF9,
  0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0x8F, 0x87, 0xF8, 0x07, 0xF8, 0x7C, 0x7C,
  0x3F, 0xC0, 0x3F, 0xC3, 0xE3, 0xE1, 0xFE, 0x01, 0xFE, 0x3F, 0x1F, 0x1F,
  0xE0, 0x0F, 0xF1, 0xF0, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0x87, 0xC7, 0xF8,
  0x03, 0xFC, 0x7C, 0x3E, 0x3F, 0xC0, 0x1F, 0xE7, 0xE1, 0xF3, 0xFC, 0x00,
  0xFF, 0x3E, 0x0F, 0x9F, 0xE0, 0x07, 0xF9, 0xF0, 0x7C, 0xFF, 0x00, 0x3F,
  0xDF, 0x83, 0xE7, 0xF8, 0x01, 0xFE, 0xFC, 0x1F, 0x3F, 0x80, 0x0F, 0xE7,
  0xC1, 0xFB, 0xFC, 0x00, 0xFF, 0x3E, 0x0F, 0xDF, 0xE0, 0x07, 0xFB, 0xF0,
  0x7E, 0xFF, 0x00, 0x3F, 0xDF, 0x03, 0xF7, 0xF0, 0x01, 0xFE, 0xF8, 0x1F,
  0xFF, 0x80, 0x0F, 0xF7, 0xC0, 0xFB, 0xFC, 0x00, 0x7F, 0xFE, 0x07, 0xDF,
  0xE0, 0x03, 0xFF, 0xE0, 0x3E, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xF7, 0xF0,
  0x00, 0xFE, 0xF8, 0x0F, 0xBF, 0x80, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF3,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00,
  0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x3F, 0xE7, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xFD, 0xFF, 0x80, 0x7F,
  0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00,
  0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xEF, 0xFE,
  0x01, 0xFF, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xFF, 0x3F, 0xF0, 0x01, 0xFF,
  0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0x3E, 0x02, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xFC,
  0x01, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0xFF, 0x7F, 0xFF, 0xE0, 0x1F, 0xFB,
  0xFF, 0xFF, 0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F,
  0xF8, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x3F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF, 0xFF,
  0x80, 0xFF, 0xCF, 0xFF, 0xFC, 0x03, 0xFF, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC,
  0x7F, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x03,
  0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0x80, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00,
  0x7F, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xFF,
  0xCF, 0xFC, 0x00, 0xFF, 0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0xF9, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x3F,
  0xF0, 0x00, 0x03, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE3, 0xFF,
  0xF0, 0x7F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0xFF, 0xC0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00,
  0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xFF, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xF1,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xFF, 0x9F, 0xF8, 0x0F,
  0xFF, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0x81, 0xFF, 0xFF, 0xF7,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xFD, 0xFF, 0x80,
  0xFF, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xF8,
  0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0xFC, 0x01, 0xFF,
  0xCF, 0xFF, 0xF8, 0x07, 0xFF, 0x7F, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00,
  0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x1F,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF,
  0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x3F, 0xF0, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0xFF, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xCF,
  0xFC, 0x7F, 0xF0, 0x0F, 0xF7, 0xFF, 0x1F, 0xFE, 0x07, 0xFD, 0xFF, 0xCF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0xFF, 0x81, 0xFF,
  0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03,
  0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0x83,
  0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFC,
  0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF,
  0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC0, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0x83, 0xFF, 0x07, 0xFC, 0x1F,
  0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0xC1, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0, 0xFF, 0x83,
  0xFE, 0x07, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC,
  0x1F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF, 0xFC, 0x01, 0xFF, 0xCF, 0xFF, 0xF8,
  0x07, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0xFB, 0xFF, 0xFF, 0xC0, 0x7F, 0xEF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xC0,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x0F,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF,
  0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0x80,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xC7,
  0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xE7, 0xFF,
  0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xE0,
  0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xBF, 0xFF, 0xF8, 0x01, 0xFF, 0xDF, 0xFF, 0xF8, 0x00, 0xFF,
  0xC7, 0xFF, 0xF8, 0x00, 0x7F, 0xE3, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xFE, 0x3F, 0xF8,
  0x03, 0xFF, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFD, 0xFF, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0x01, 0xFF, 0xFF, 0xF7, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF,
  0x83, 0xFF, 0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F,
  0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF,
  0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x07,
  0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xFF, 0x9F, 0xF8, 0x01, 0xFF, 0xFE,
  0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xE1, 0xFF, 0xC0,
  0x00, 0x3E, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0xFF, 0x80,
  0x7F, 0xE7, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xFF, 0xFF, 0x01, 0xFF, 0xBF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF,
  0x83, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00,
  0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01,
  0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x7F,
  0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F,
  0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF,
  0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0xFF,
  0xF3, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01,
  0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFF, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF8, 0x07,
  0xF9, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x9F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0x0F, 0xF1, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x7B, 0xE0,
  0x7F, 0x87, 0xF8, 0x3E, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xBE, 0x0F, 0xF0,
  0x7F, 0x83, 0xEF, 0x83, 0xFC, 0x1F, 0xE1, 0xF3, 0xE0, 0xFF, 0x07, 0xF8,
  0x7C, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0x3E, 0x1F, 0xE0, 0x7F, 0x8F, 0x8F,
  0x87, 0xF8, 0x1F, 0xE3, 0xE3, 0xE3, 0xFE, 0x07, 0xF8, 0xF8, 0xF8, 0xFF,
  0x03, 0xFE, 0x3E, 0x3E, 0x3F, 0xC0, 0xFF, 0x9F, 0x0F, 0x8F, 0xF0, 0x3F,
  0xE7, 0xC3, 0xE7, 0xF8, 0x0F, 0xF9, 0xF0, 0xF9, 0xFE, 0x03, 0xFE, 0xF8,
  0x3E, 0x7F, 0x80, 0xFF, 0xBE, 0x0F, 0xBF, 0xC0, 0x3F, 0xCF, 0x83, 0xEF,
  0xF0, 0x0F, 0xF7, 0xE0, 0xFB, 0xFC, 0x03, 0xFD, 0xF0, 0x3E, 0xFF, 0x00,
  0xFF, 0x7C, 0x0F, 0xFF, 0x80, 0x3F, 0xDF, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xF3, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F,
  0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC,
  0x7F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xFC, 0x7F,
  0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0xFF, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xDF, 0xF8, 0x3F,
  0xFF, 0xFE, 0xFF, 0xC1, 0xFF, 0xFF, 0xEF, 0xFE, 0x07, 0xFF, 0xFF, 0x7F,
  0xF0, 0x1F, 0xFF, 0xF3, 0xFF, 0x00, 0x7F, 0xFF, 0x1F, 0xF8, 0x01, 0xFF,
  0xE0, 0xFF, 0xC0, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x08, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x04, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xFF, 0xC0, 0x1F, 0xE1, 0xFF, 0xFF,
  0xC0, 0x3F, 0xC7, 0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0xFF, 0x81, 0xFF,
  0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x7F, 0xC7, 0xFF, 0x07, 0xFC, 0xFF, 0x07,
  0xFF, 0x1F, 0xF3, 0xFE, 0x07, 0xFF, 0xFF, 0xE7, 0xFC, 0x0F, 0xFF, 0xFF,
  0xCF, 0xF8, 0x0F, 0xFF, 0xFF, 0x1F, 0xE0, 0x0F, 0xFF, 0xFC, 0x3F, 0xC0,
  0x1F, 0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 20, 52, 43, 12, -52 },
  { 131, 29, 21, 43, 11, -52 },
  { 208, 44, 52, 43, 0, -52 },
  { 494, 41, 72, 43, 1, -62 },
  { 863, 53, 52, 43, -4, -52 },
  { 1208, 42, 54, 43, 0, -53 },
  { 1492, 13, 21, 43, 19, -52 },
  { 1527, 32, 69, 43, 9, -60 },
  { 1803, 31, 69, 43, 4, -60 },
  { 2071, 39, 37, 43, 3, -43 },
  { 2252, 36, 34, 43, 4, -40 },
  { 2405, 22, 22, 43, 5, -11 },
  { 2466, 26, 10, 43, 9, -28 },
  { 2499, 16, 15, 43, 11, -14 },
  { 2529, 46, 67, 43, -1, -59 },
  { 2915, 39, 54, 43, 3, -53 },
  { 3179, 35, 52, 43, 3, -52 },
  { 3407, 39, 53, 43, 2, -53 },
  { 3666, 39, 53, 43, 2, -52 },
  { 3925, 39, 52, 43, 2, -52 },
  { 4179, 40, 53, 43, 2, -52 },
  { 4444, 38, 53, 43, 2, -52 },
  { 4696, 38, 52, 43, 6, -52 },
  { 4943, 40, 54, 43, 2, -53 },
  { 5213, 38, 53, 43, 5, -53 },
  { 5465, 20, 41, 43, 11, -40 },
  { 5568, 26, 51, 43, 5, -40 },
  { 5734, 36, 40, 43, 5, -43 },
  { 5914, 36, 27, 43, 4, -37 },
  { 6036, 37, 40, 43, 2, -43 },
  { 6221, 32, 52, 43, 8, -52 },
  { 6429, 45, 66, 43, -1, -53 },
  { 6801, 39, 52, 43, -1, -52 },
  { 7055, 41, 52, 43, 2, -52 },
  { 7322, 39, 54, 43, 3, -53 },
  { 7586, 41, 52, 43, 1, -52 },
  { 7853, 40, 52, 43, 3, -52 },
  { 8113, 41, 52, 43, 2, -52 },
  { 8380, 39, 54, 43, 3, -53 },
  { 8644, 41, 52, 43, 2, -52 },
  { 8911, 39, 52, 43, 3, -52 },
  { 9165, 42, 53, 43, 0, -52 },
  { 9444, 45, 52, 43, 1, -52 },
  { 9737, 33, 52, 43, 4, -52 },
  { 9952, 45, 52, 43, 0, -52 },
  { 10245, 42, 52, 43, 1, -52 },
  { 10518, 39, 54, 43, 3, -53 },
  { 10782, 42, 52, 43, 2, -52 },
  { 11055, 39, 66, 43, 3, -53 },
  { 11377, 42, 52, 43, 1, -52 },
  { 11650, 41, 54, 43, 1, -53 },
  { 11927, 39, 52, 43, 6, -52 },
  { 12181, 41, 53, 43, 2, -52 },
  { 12453, 39, 52, 43, 7, -52 },
  { 12707, 45, 52, 43, 2, -52 },
  { 13000, 47, 52, 43, -2, -52 },
  { 13306, 41, 52, 43, 6, -52 },
  { 13573, 40, 52, 43, 2, -52 },
  { 13833, 32, 67, 43, 8, -59 },
  { 14101, 25, 67, 43, 10, -59 },
  { 14311, 32, 67, 43, 5, -59 },
  { 14579, 34, 28, 43, 5, -52 },
  { 14698, 36, 10, 43, -1, 2 },
  { 14743, 17, 10, 43, 17, -56 },
  { 14765, 39, 41, 43, 2, -40 },
  { 14965, 38, 53, 43, 2, -52 },
  { 15217, 37, 41, 43, 3, -40 },
  { 15407, 41, 53, 43, 2, -52 },
  { 15679, 37, 41, 43, 3, -40 },
  { 15869, 48, 65, 43, -4, -52 },
  { 16259, 38, 53, 43, 3, -40 },
  { 16511, 38, 52, 43, 2, -52 },
  { 16758, 36, 56, 43, 2, -56 },
  { 17010, 40, 69, 43, 0, -56 },
  { 17355, 42, 52, 43, 2, -52 },
  { 17628, 33, 52, 43, 5, -52 },
  { 17843, 42, 40, 43, 0, -40 },
  { 18053, 38, 40, 43, 2, -40 },
  { 18243, 37, 41, 43, 3, -40 },
  { 18433, 41, 53, 43, -1, -40 },
  { 18705, 39, 53, 43, 2, -40 },
  { 18964, 39, 40, 43, 3, -40 },
  { 19159, 40, 41, 43, 1, -40 },
  { 19364, 37, 50, 43, 4, -50 },
  { 19596, 38, 40, 43, 3, -39 },
  { 19786, 39, 39, 43, 5, -39 },
  { 19977, 42, 39, 43, 3, -39 },
  { 20182, 44, 39, 43, -1, -39 },
  { 20397, 37, 52, 43, 3, -39 },
  { 20638, 38, 39, 43, 2, -39 },
  { 20824, 38, 67, 43, 5, -59 },
  { 21143, 21, 67, 43, 12, -59 },
  { 21319, 38, 67, 43, 1, -59 },
  { 21638, 39, 18, 43, 3, -34 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic71pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic71pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC71PT7B_H_
