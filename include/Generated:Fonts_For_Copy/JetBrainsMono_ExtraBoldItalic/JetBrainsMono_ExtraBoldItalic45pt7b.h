#ifndef _JETBRAINSMONO_EXTRABOLDITALIC45PT7B_H_
#define _JETBRAINSMONO_EXTRABOLDITALIC45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-ExtraBoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_ExtraBoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xDF, 0xC7, 0xF7, 0xE1, 0xFD, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xEF, 0xE1, 0xFB, 0xF8, 0xFE, 0xFC, 0x3F, 0xBF,
  0x0F, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0xC0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xC0, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x03, 0xE0,
  0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF7,
  0x3F, 0x83, 0xF9, 0xCF, 0xE1, 0xFC, 0x73, 0xF8, 0x7F, 0x1C, 0x00, 0x1F,
  0xCE, 0x00, 0x07, 0xFB, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xDF, 0xE0, 0x00,
  0x73, 0xFC, 0x00, 0x18, 0x7F, 0x00, 0x0E, 0x1F, 0x8F, 0xE3, 0x8F, 0xE3,
  0xF8, 0xE3, 0xF8, 0xFF, 0x39, 0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x3F, 0xF0, 0x03, 0xE0, 0x1F, 0xFE, 0x01, 0xF0, 0x07,
  0xFF, 0x80, 0xF8, 0x03, 0xE1, 0xE0, 0x7C, 0x00, 0xF0, 0x78, 0x3E, 0x00,
  0x3C, 0x1E, 0x0F, 0x00, 0x1F, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xE3, 0xE0,
  0x01, 0xF0, 0xF9, 0xF0, 0x00, 0x7C, 0x3C, 0xF8, 0x00, 0x1F, 0xFF, 0x7C,
  0x00, 0x03, 0xFF, 0xBE, 0x00, 0x00, 0x7F, 0xDF, 0x00, 0x00, 0x0F, 0xC7,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x7F, 0x80, 0x00,
  0x1F, 0x7F, 0xF0, 0x00, 0x0F, 0xBF, 0xFE, 0x00, 0x03, 0xCF, 0x8F, 0x80,
  0x01, 0xE3, 0xC1, 0xE0, 0x00, 0xF9, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x3E,
  0x00, 0x3E, 0x1F, 0x0F, 0x80, 0x1F, 0x07, 0x83, 0xC0, 0x0F, 0x81, 0xF0,
  0xF0, 0x07, 0xC0, 0x7F, 0xFC, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0xF0, 0x03,
  0xFF, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xC3, 0xF3, 0xFB, 0xF1, 0xF8, 0xFC, 0xFE, 0xFE,
  0x3F, 0x1F, 0xBF, 0x1F, 0xC7, 0xFF, 0x87, 0xF0, 0xFF, 0xE1, 0xF8, 0x3F,
  0xF0, 0x7E, 0x07, 0xF8, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xFC,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF9, 0xF8, 0x0F, 0xF8, 0x7F, 0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x7E, 0xFE, 0xFE, 0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x30, 0x1E, 0x02, 0x3C, 0x1E, 0x1F, 0x7F, 0x1E,
  0x7F, 0x7F, 0x9C, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xEF,
  0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0x87, 0xE0, 0x7F, 0x87,
  0xF0, 0x3F, 0x07, 0xE0, 0x1E, 0x03, 0xC0, 0x0C, 0x03, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xF8, 0x06, 0x0F, 0xE3, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xF9, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0xC0,
  0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE3, 0xF0, 0x07, 0xF1, 0xF8,
  0xC3, 0xF0, 0xFD, 0xF9, 0xF8, 0xFE, 0xFC, 0xFC, 0x7F, 0x7E, 0x7E, 0x3F,
  0x3F, 0x7F, 0x1F, 0x8F, 0xBF, 0x8F, 0xC3, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xFB, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xF3, 0xF8,
  0x1F, 0x8F, 0xE0, 0x78, 0x3F, 0x01, 0xC1, 0xFC, 0x04, 0x07, 0xF0, 0x20,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F,
  0x80, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0xFF, 0x87, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC0, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x81, 0x80, 0x1F, 0x9F, 0xF0,
  0x1F, 0xBF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0xDF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF3, 0xF0, 0x0F, 0xEF, 0xF8, 0x1F, 0xDF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x87, 0xFC,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xE7,
  0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x87, 0xE0,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0x3F,
  0xDF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xF8, 0x0F, 0xE1,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x0F, 0xF8, 0xFF, 0x87, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xF3, 0xFE, 0x3F, 0x80, 0xFE, 0x7F,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x83, 0xFE, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFB, 0xF0, 0x0F,
  0xE7, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x0F, 0xE0,
  0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x7E, 0x1F, 0x03, 0xF3, 0xF1, 0xF8, 0x3F, 0xDF, 0x0F, 0xC3,
  0xFF, 0x78, 0x7C, 0x3F, 0xFF, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0x83,
  0xF0, 0xF8, 0xFC, 0x1F, 0x8F, 0xC7, 0xE0, 0xF8, 0x7E, 0x3E, 0x07, 0xC3,
  0xF1, 0xF0, 0x3E, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x7C, 0x1F, 0x87, 0xC7,
  0xE0, 0xFC, 0x7E, 0x3F, 0x07, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE7,
  0xF0, 0xF8, 0x3F, 0xFF, 0x87, 0xC1, 0xFF, 0x7C, 0x3E, 0x07, 0xF3, 0xE1,
  0xF0, 0x04, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00,
  0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC,
  0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xF8,
  0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x1F, 0xE1, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80,
  0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0xFE,
  0x1F, 0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE0, 0xFE, 0x1F, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC0,
  0x3F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xF1, 0xFC,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x7F, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F,
  0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xFE, 0x7F, 0x0F,
  0xFE, 0x3F, 0x8F, 0xFF, 0x1F, 0xC7, 0xFF, 0x8F, 0xE3, 0xFF, 0xC7, 0xE1,
  0xFF, 0xE3, 0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xFB, 0xFF, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E,
  0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0,
  0xFE, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x04, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xE7, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x1F, 0xC7, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFF, 0x83, 0xFF, 0x0F, 0xB8, 0x3F, 0xE0, 0xFB, 0xC7, 0xBE, 0x0F, 0xBC,
  0x7B, 0xE0, 0xFB, 0xCF, 0xFE, 0x1F, 0xBC, 0xF7, 0xE1, 0xFB, 0xCF, 0x7E,
  0x1F, 0xBD, 0xE7, 0xC1, 0xFB, 0xDE, 0xFC, 0x1F, 0xBF, 0xCF, 0xC1, 0xFB,
  0xFC, 0xFC, 0x1F, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x9F,
  0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0xFF, 0x01, 0xF8, 0x1F, 0xE0, 0x3F,
  0x07, 0xFC, 0x07, 0xE0, 0xFF, 0x80, 0xFC, 0x1F, 0xF8, 0x1F, 0x83, 0xFF,
  0x03, 0xF0, 0x7F, 0xE0, 0xFC, 0x0F, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xF0,
  0x7E, 0xF8, 0x7E, 0x0F, 0xDF, 0x0F, 0xC1, 0xFB, 0xE1, 0xF8, 0x3F, 0x7C,
  0x7E, 0x07, 0xCF, 0x8F, 0xC1, 0xF9, 0xF1, 0xF8, 0x3F, 0x1F, 0x3F, 0x07,
  0xE3, 0xE7, 0xE0, 0xFC, 0x7C, 0xFC, 0x1F, 0x8F, 0x9F, 0x03, 0xF1, 0xF3,
  0xE0, 0x7E, 0x3F, 0x7C, 0x1F, 0x83, 0xFF, 0x83, 0xF0, 0x7F, 0xF0, 0x7E,
  0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xF0, 0x3F, 0x03, 0xFE,
  0x0F, 0xC0, 0x7F, 0xC1, 0xF8, 0x0F, 0xF8, 0x3F, 0x01, 0xFF, 0x07, 0xE0,
  0x3F, 0xE0, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xFB, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xF8,
  0x1F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x1F, 0xC0,
  0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F,
  0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xFB, 0xFF, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFE,
  0x07, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F,
  0xE1, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xC3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7E, 0x03,
  0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0xE1, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07,
  0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0,
  0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xF0, 0x3F, 0x83, 0xFF, 0x7F,
  0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xDF, 0x80, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xE3, 0xF8, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xF8,
  0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3E, 0x0F, 0x83, 0xF3, 0xE0, 0xF8, 0x3E, 0x3E, 0x1F, 0x83,
  0xE7, 0xE1, 0xF8, 0x7E, 0x7E, 0x1F, 0x87, 0xE7, 0xE1, 0xF8, 0x7C, 0x7E,
  0x3F, 0x87, 0xC7, 0xC3, 0xB8, 0x7C, 0x7C, 0x3B, 0x8F, 0xC7, 0xC3, 0xB8,
  0xF8, 0x7C, 0x7B, 0x8F, 0x87, 0xC7, 0x78, 0xF8, 0x7C, 0x77, 0x9F, 0x87,
  0xCF, 0x79, 0xF0, 0x7C, 0xF7, 0x9F, 0x07, 0xCE, 0x79, 0xF0, 0x7C, 0xE7,
  0xBF, 0x07, 0xDE, 0x73, 0xE0, 0xFD, 0xC7, 0x3E, 0x0F, 0x9C, 0x73, 0xE0,
  0xF9, 0xC7, 0x3E, 0x0F, 0xBC, 0x77, 0xC0, 0xFB, 0x87, 0x7C, 0x0F, 0xB8,
  0x77, 0xC0, 0xFF, 0x87, 0x78, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03,
  0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFF,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE7, 0xE0, 0x07, 0xF1,
  0xFC, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xE1, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0xFD, 0xF8, 0x03, 0xF3, 0xE0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x9F, 0xC0, 0x7E,
  0x7E, 0x01, 0xFB, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0xFF,
  0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80,
  0xFF, 0x9F, 0xC1, 0xFF, 0xEF, 0xE0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00,
  0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xFD, 0xFF, 0x87, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xE0, 0x3F, 0xF3, 0xF0, 0x0F,
  0xF1, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x0F, 0xCF, 0xFC, 0x0F, 0xDF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x81, 0xFC,
  0x7F, 0xEF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFE, 0xFF, 0xF0,
  0xFE, 0xFF, 0xE0, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x3F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFF, 0x03, 0xF8, 0xFF, 0xDF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0xFE, 0x3F, 0x80, 0x7F, 0xCF, 0xE0, 0x7F, 0xFB, 0xF8, 0x1F, 0xFE, 0xFC,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F,
  0xC1, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xDF, 0x80, 0x7F, 0xE7, 0xE0, 0x0F, 0xF1, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xF8, 0x3F, 0xCF, 0xE0, 0x3F, 0x9F, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE,
  0x01, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xBF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x0F, 0xE7, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x7F, 0x03, 0xFE, 0x7F, 0x0F, 0xFF, 0x7F, 0x0F, 0xFF, 0x7E,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x80, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFF, 0x03, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0xFD, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFB, 0xF8, 0x3F, 0xFB, 0xF8, 0x1F, 0xE3, 0xF0, 0x07, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x0F, 0xCF, 0xFC, 0x0F, 0xDF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF,
  0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E,
  0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x3F,
  0xC1, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x1F, 0xE0, 0x1F, 0x87, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07,
  0xF8, 0x1F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x00,
  0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0x9F, 0x0F, 0x81, 0xF7, 0xE7, 0xF8, 0x7F, 0xFE,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFD, 0xFD, 0xFC, 0x3F, 0x1F, 0x1F, 0x87,
  0xE3, 0xE3, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x0F, 0x0F, 0xC7, 0xE1, 0xE1,
  0xF8, 0xFC, 0x3C, 0x3F, 0x1F, 0x8F, 0x8F, 0xC3, 0xF1, 0xF1, 0xF8, 0x7E,
  0x3E, 0x3F, 0x0F, 0x87, 0xC7, 0xE3, 0xF0, 0xF0, 0xFC, 0x7E, 0x1E, 0x1F,
  0x8F, 0xC7, 0xC3, 0xE1, 0xF8, 0xF8, 0xFC, 0x3F, 0x1F, 0x1F, 0x87, 0xC3,
  0xE3, 0xF1, 0xF8, 0x78, 0x7E, 0x3F, 0x0F, 0x0F, 0xC7, 0xE3, 0xE1, 0xF0,
  0xFC, 0x7C, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x0F, 0xCF, 0xFC, 0x0F, 0xDF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80,
  0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xCF, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD,
  0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0xBF,
  0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xE7, 0xFE, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x03, 0xF3,
  0xFF, 0x01, 0xFB, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0,
  0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE1, 0xFD, 0xFF, 0xE0, 0xFE, 0xFF, 0xE0, 0x7F, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0xFF, 0x9F, 0xC1, 0xFF, 0xEF,
  0xE0, 0xFF, 0xF7, 0xE0, 0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x83,
  0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0,
  0x1F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF1, 0xFC,
  0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0xFF, 0x0F, 0xFD, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xF7, 0xE0, 0x3F, 0xF3, 0xF0, 0x0F, 0xF3, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC7, 0xF8, 0x0F, 0xE7, 0xFE, 0x07, 0xF7, 0xFF, 0x83, 0xF7, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x80, 0xFE,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x3F, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xC0, 0x7F,
  0x1F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7E,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x7F, 0x00, 0xFC, 0x7F, 0x01, 0xFC,
  0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8,
  0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0xDF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x9F, 0x80, 0x1F, 0xCF, 0xC0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xF0,
  0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x07, 0xFF, 0x07,
  0xC1, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xBF,
  0x1D, 0xC3, 0xEF, 0xC7, 0x71, 0xFB, 0xF1, 0xFC, 0x7C, 0xFC, 0xFF, 0x1F,
  0x3E, 0x3B, 0xCF, 0xCF, 0x8E, 0xF3, 0xE3, 0xE3, 0xBC, 0xF8, 0xF9, 0xCF,
  0x3E, 0x3E, 0x73, 0xDF, 0x0F, 0x9C, 0xF7, 0xC3, 0xEF, 0x3D, 0xF0, 0xFB,
  0x8F, 0xFC, 0x3E, 0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x3F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x1F,
  0xCF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xF9, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x07, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC,
  0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x01, 0xFC,
  0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFB, 0xF8,
  0x3F, 0xF3, 0xF0, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x1F, 0x3F, 0xFC, 0x1F, 0x7F,
  0xFC, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x7F, 0x7F, 0xFC, 0x3F, 0xFE, 0xF8,
  0x3F, 0xFE, 0xF8, 0x1F, 0xFC, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xC0,
};

const GFXglyph JetBrainsMono_ExtraBoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 12, 33, 27, 8, -33 },
  { 51, 18, 14, 27, 7, -33 },
  { 83, 28, 33, 27, 0, -33 },
  { 199, 26, 45, 27, 1, -39 },
  { 346, 34, 33, 27, -3, -33 },
  { 487, 26, 33, 27, 0, -33 },
  { 595, 8, 14, 27, 12, -33 },
  { 609, 20, 44, 27, 6, -38 },
  { 719, 20, 44, 27, 2, -38 },
  { 829, 24, 23, 27, 2, -27 },
  { 898, 23, 22, 27, 2, -26 },
  { 962, 14, 14, 27, 3, -7 },
  { 987, 17, 6, 27, 5, -18 },
  { 1000, 10, 9, 27, 7, -9 },
  { 1012, 30, 42, 27, -1, -37 },
  { 1170, 25, 33, 27, 2, -33 },
  { 1274, 22, 33, 27, 2, -33 },
  { 1365, 25, 33, 27, 1, -33 },
  { 1469, 25, 33, 27, 1, -33 },
  { 1573, 25, 33, 27, 1, -33 },
  { 1677, 24, 33, 27, 2, -33 },
  { 1776, 24, 33, 27, 1, -33 },
  { 1875, 24, 33, 27, 4, -33 },
  { 1974, 25, 33, 27, 1, -33 },
  { 2078, 24, 33, 27, 3, -33 },
  { 2177, 13, 25, 27, 7, -25 },
  { 2218, 17, 32, 27, 3, -25 },
  { 2286, 23, 25, 27, 3, -27 },
  { 2358, 22, 18, 27, 3, -24 },
  { 2408, 23, 25, 27, 2, -27 },
  { 2480, 21, 33, 27, 5, -33 },
  { 2567, 29, 41, 27, -1, -33 },
  { 2716, 25, 33, 27, -1, -33 },
  { 2820, 26, 33, 27, 1, -33 },
  { 2928, 25, 33, 27, 2, -33 },
  { 3032, 26, 33, 27, 1, -33 },
  { 3140, 25, 33, 27, 2, -33 },
  { 3244, 27, 33, 27, 1, -33 },
  { 3356, 25, 33, 27, 2, -33 },
  { 3460, 26, 33, 27, 1, -33 },
  { 3568, 25, 33, 27, 2, -33 },
  { 3672, 27, 34, 27, 0, -33 },
  { 3787, 28, 33, 27, 1, -33 },
  { 3903, 21, 33, 27, 2, -33 },
  { 3990, 28, 33, 27, 0, -33 },
  { 4106, 27, 33, 27, 1, -33 },
  { 4218, 25, 33, 27, 2, -33 },
  { 4322, 27, 33, 27, 1, -33 },
  { 4434, 25, 41, 27, 2, -33 },
  { 4563, 26, 33, 27, 1, -33 },
  { 4671, 26, 33, 27, 1, -33 },
  { 4779, 24, 33, 27, 4, -33 },
  { 4878, 26, 33, 27, 2, -33 },
  { 4986, 25, 33, 27, 4, -33 },
  { 5090, 28, 33, 27, 2, -33 },
  { 5206, 30, 33, 27, -1, -33 },
  { 5330, 26, 33, 27, 4, -33 },
  { 5438, 25, 33, 27, 1, -33 },
  { 5542, 20, 42, 27, 5, -37 },
  { 5647, 16, 42, 27, 6, -37 },
  { 5731, 20, 42, 27, 3, -37 },
  { 5836, 22, 18, 27, 3, -33 },
  { 5886, 22, 6, 27, 0, 1 },
  { 5903, 11, 6, 27, 10, -35 },
  { 5912, 25, 25, 27, 1, -25 },
  { 5991, 24, 33, 27, 1, -33 },
  { 6090, 24, 25, 27, 2, -25 },
  { 6165, 26, 33, 27, 1, -33 },
  { 6273, 23, 25, 27, 2, -25 },
  { 6345, 31, 41, 27, -3, -33 },
  { 6504, 24, 33, 27, 2, -25 },
  { 6603, 24, 33, 27, 1, -33 },
  { 6702, 23, 36, 27, 1, -36 },
  { 6806, 25, 44, 27, 0, -36 },
  { 6944, 27, 33, 27, 1, -33 },
  { 7056, 21, 33, 27, 3, -33 },
  { 7143, 27, 25, 27, 0, -25 },
  { 7228, 24, 25, 27, 1, -25 },
  { 7303, 23, 25, 27, 2, -25 },
  { 7375, 25, 33, 27, 0, -25 },
  { 7479, 25, 33, 27, 1, -25 },
  { 7583, 25, 25, 27, 2, -25 },
  { 7662, 25, 25, 27, 1, -25 },
  { 7741, 23, 32, 27, 3, -32 },
  { 7833, 24, 25, 27, 2, -25 },
  { 7908, 25, 25, 27, 3, -25 },
  { 7987, 26, 25, 27, 2, -25 },
  { 8069, 28, 25, 27, -1, -25 },
  { 8157, 24, 33, 27, 2, -25 },
  { 8256, 24, 25, 27, 1, -25 },
  { 8331, 25, 42, 27, 3, -37 },
  { 8463, 14, 42, 27, 7, -37 },
  { 8537, 24, 42, 27, 1, -37 },
  { 8663, 24, 12, 27, 2, -22 },
};

const GFXfont JetBrainsMono_ExtraBoldItalic45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_ExtraBoldItalic45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_ExtraBoldItalic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_EXTRABOLDITALIC45PT7B_H_
