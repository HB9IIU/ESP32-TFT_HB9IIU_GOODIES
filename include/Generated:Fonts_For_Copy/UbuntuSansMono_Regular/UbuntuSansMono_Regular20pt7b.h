#ifndef _UBUNTUSANSMONO_REGULAR20PT7B_H_
#define _UBUNTUSANSMONO_REGULAR20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular20pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x40, 0x2F, 0xC0, 0xCE, 0x73, 0x18, 0x80, 0x19,
  0x84, 0x61, 0x10, 0xC4, 0xFF, 0xCC, 0xC2, 0x30, 0x88, 0x62, 0x3F, 0xF6,
  0x61, 0x18, 0x44, 0x31, 0x00, 0x08, 0x04, 0x02, 0x07, 0xE6, 0x12, 0x01,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x30, 0x1C, 0x0F, 0xFC, 0x78, 0x08,
  0x04, 0x00, 0x70, 0x49, 0x1B, 0x22, 0x64, 0x84, 0xB0, 0xB4, 0x0D, 0x80,
  0x2C, 0x0B, 0x43, 0x4C, 0x48, 0x99, 0x32, 0x26, 0x83, 0x80, 0x3C, 0x19,
  0x84, 0x21, 0x18, 0x66, 0x1B, 0x03, 0x81, 0xE6, 0xCD, 0x31, 0xC8, 0x73,
  0x0C, 0xC7, 0x9F, 0x30, 0xFC, 0x08, 0xCC, 0x46, 0x23, 0x18, 0x84, 0x21,
  0x0C, 0x61, 0x0C, 0x31, 0x86, 0x10, 0x83, 0x06, 0x0C, 0x30, 0x61, 0x82,
  0x08, 0x20, 0xC2, 0x08, 0x61, 0x8C, 0x31, 0x8C, 0x20, 0x08, 0x04, 0x12,
  0x3F, 0xF1, 0xC0, 0xA0, 0xD8, 0xC6, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xFF,
  0xFC, 0x20, 0x10, 0x08, 0x04, 0x00, 0x31, 0xCE, 0x3B, 0x30, 0xF8, 0xFF,
  0x80, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x20, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0x80, 0x3E, 0x39, 0x98,
  0x48, 0x3C, 0x1E, 0x4F, 0x77, 0x9B, 0xC1, 0xE0, 0xD0, 0x6C, 0x26, 0x31,
  0xF0, 0x08, 0x18, 0x68, 0xC8, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x7F, 0x3E, 0x73, 0x90, 0xC0, 0x20, 0x10, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x0C, 0x0C, 0x04, 0x03, 0xFC, 0x7E, 0x23, 0x80, 0xC0, 0x20,
  0x30, 0x10, 0x70, 0x0E, 0x01, 0x80, 0xC0, 0x60, 0x34, 0x37, 0xF0, 0x03,
  0x03, 0x83, 0xC3, 0x61, 0x31, 0x19, 0x8C, 0x86, 0xC3, 0x7F, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x7F, 0x40, 0x40, 0x40, 0x40, 0x40, 0xFC, 0x06, 0x03,
  0x03, 0x03, 0x03, 0x86, 0xFC, 0x07, 0x0F, 0x0C, 0x0C, 0x06, 0x02, 0x03,
  0xFD, 0x83, 0xC1, 0xE0, 0xF0, 0x68, 0x36, 0x31, 0xF0, 0xFF, 0xFF, 0x02,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x30, 0x20, 0x20, 0x3E,
  0x31, 0x90, 0x68, 0x34, 0x1B, 0x18, 0xF8, 0x7E, 0x43, 0xE0, 0xF0, 0x78,
  0x36, 0x31, 0xF8, 0x3E, 0x31, 0xB0, 0x58, 0x3C, 0x1E, 0x0D, 0x86, 0xFF,
  0x01, 0x80, 0x80, 0xC0, 0xC1, 0xC3, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x77,
  0x70, 0x00, 0x03, 0x77, 0x36, 0xC0, 0x00, 0x83, 0xC7, 0x0E, 0x0C, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x18, 0x38, 0xF1, 0xC0, 0x80, 0x00, 0xFD,
  0x0C, 0x18, 0x30, 0x61, 0x86, 0x08, 0x30, 0x00, 0x00, 0x83, 0x06, 0x00,
  0x1F, 0x18, 0xD8, 0x28, 0x1C, 0x3E, 0x7F, 0x33, 0xB1, 0xD8, 0xEC, 0x72,
  0x39, 0x96, 0x7B, 0x00, 0xC0, 0x72, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x2C,
  0x0D, 0x81, 0x10, 0x23, 0x0C, 0x61, 0x04, 0x20, 0x8F, 0xF9, 0x81, 0x20,
  0x24, 0x07, 0x80, 0xC0, 0xFC, 0x63, 0xB0, 0xD8, 0x2C, 0x16, 0x1B, 0xF1,
  0x8E, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x37, 0xF0, 0x1F, 0x98, 0xD8, 0x0C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x03, 0x08, 0xFC,
  0xFC, 0x67, 0x30, 0xD8, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0,
  0x78, 0x6C, 0x67, 0xE0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x98, 0xD8, 0x0C,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x50, 0x2C, 0x13, 0x08, 0xFC,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x04, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x1F, 0xC0, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x43, 0xFE, 0x83, 0xC1, 0xA1, 0x91, 0x89,
  0x85, 0x83, 0x81, 0x60, 0x98, 0x46, 0x21, 0x90, 0x68, 0x34, 0x0C, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0x61, 0x31, 0xD8, 0xFC, 0x5F, 0x6E, 0xA7, 0x53, 0x99, 0xC8, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0xC1, 0xF0, 0xF8, 0x7E, 0x3D, 0x1E, 0xCF,
  0x27, 0x9B, 0xC5, 0xE3, 0xF0, 0xF8, 0x7C, 0x1E, 0x0C, 0x3E, 0x18, 0xCC,
  0x1B, 0x06, 0x80, 0xA0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x2C, 0x0B, 0x06,
  0x63, 0x0F, 0x80, 0xFC, 0x86, 0x83, 0x83, 0x83, 0x83, 0x83, 0xFE, 0xF8,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x3E, 0x18, 0xCC, 0x1B, 0x06, 0x80, 0xA0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x2C, 0x0B, 0x06, 0x63, 0x0F, 0x80, 0x80,
  0x30, 0x07, 0x80, 0x20, 0xFC, 0x63, 0xB0, 0x58, 0x2C, 0x1E, 0x0B, 0x0D,
  0xFC, 0xCC, 0x63, 0x30, 0x98, 0x6C, 0x16, 0x0C, 0x3F, 0x30, 0x90, 0x08,
  0x06, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x00, 0xC0, 0x60, 0x34, 0x37, 0xF0,
  0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x36, 0x31, 0xF0, 0xC0, 0x68, 0x0D, 0x81,
  0x30, 0x26, 0x0C, 0x41, 0x0C, 0x21, 0x8C, 0x11, 0x83, 0x20, 0x6C, 0x05,
  0x80, 0xE0, 0x1C, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x47, 0x73,
  0xA9, 0xD4, 0xEB, 0x78, 0xBC, 0x56, 0x3B, 0x08, 0xC1, 0x90, 0x66, 0x30,
  0x88, 0x36, 0x05, 0x01, 0xC0, 0x70, 0x36, 0x08, 0x86, 0x31, 0x04, 0xC1,
  0xB0, 0x30, 0xC0, 0x6C, 0x09, 0x83, 0x18, 0x43, 0x18, 0x32, 0x06, 0xC0,
  0x70, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x7F, 0x80,
  0xC0, 0x40, 0x60, 0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C,
  0x07, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0x81, 0x83, 0x02, 0x06, 0x0C, 0x08, 0x18,
  0x30, 0x20, 0x60, 0xC0, 0x81, 0x03, 0x02, 0x04, 0x0C, 0x18, 0x10, 0xFF,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xFF, 0xF0,
  0x08, 0x0E, 0x05, 0x86, 0x46, 0x32, 0x0B, 0x06, 0x82, 0xFF, 0xFF, 0xFC,
  0x99, 0x30, 0x5C, 0x1F, 0x80, 0xC0, 0x30, 0x19, 0xFD, 0x87, 0x83, 0xC1,
  0xB0, 0xCF, 0xE0, 0x40, 0x80, 0x80, 0x80, 0x80, 0x98, 0xFE, 0xC6, 0x83,
  0x83, 0x81, 0x81, 0x83, 0x83, 0x86, 0xFC, 0x06, 0x1F, 0xD8, 0x08, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0x60, 0x38, 0x47, 0xE0, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x6C, 0xFE, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1A, 0x0D,
  0xC6, 0x7F, 0x0C, 0x1F, 0x98, 0x78, 0x3C, 0x1F, 0xFF, 0x01, 0x80, 0xC0,
  0x38, 0x8F, 0xC0, 0x04, 0x0F, 0xCC, 0x04, 0x02, 0x01, 0x03, 0xF8, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x0C, 0x1F, 0xD8,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x61, 0xBF, 0xC7, 0x60, 0x20, 0x33,
  0xF9, 0xF0, 0x40, 0x80, 0x80, 0x80, 0x80, 0xB8, 0xFE, 0x86, 0x82, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x18, 0x1C, 0x04, 0x00, 0x00, 0x07,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x64, 0x3E, 0x0C,
  0x18, 0x30, 0x00, 0x0F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x05, 0xF9, 0xE0, 0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x0D,
  0x18, 0x98, 0x58, 0x38, 0x16, 0x09, 0xC4, 0x32, 0x0D, 0x07, 0xF8, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x64, 0x3E, 0x62, 0x7F, 0xF2, 0x39, 0x1C, 0x8E, 0x47, 0x23, 0x81,
  0xC0, 0xE0, 0x70, 0x20, 0x30, 0xFE, 0x86, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x0C, 0x1F, 0x98, 0xD8, 0x3C, 0x1E, 0x07, 0x03, 0x83,
  0x41, 0xB1, 0x8F, 0x80, 0x30, 0xFC, 0x86, 0x83, 0x83, 0x81, 0x81, 0x83,
  0x83, 0xC6, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x0C, 0x1F, 0xD8, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xB1, 0xCF, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x1D, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x18, 0xFE,
  0x80, 0x80, 0xE0, 0x78, 0x0E, 0x03, 0x03, 0x86, 0xFE, 0x20, 0x20, 0x20,
  0x20, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x31, 0x1F, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xC3, 0x7F, 0xC1, 0xE0, 0xD0,
  0x6C, 0x66, 0x31, 0x10, 0xD8, 0x28, 0x1C, 0x06, 0x00, 0xC0, 0x68, 0x0D,
  0x11, 0x23, 0x26, 0xE4, 0xD5, 0x9A, 0xF1, 0x8E, 0x31, 0x86, 0x10, 0xC1,
  0x98, 0xC3, 0x60, 0x70, 0x0C, 0x07, 0x83, 0x61, 0x8C, 0x41, 0xB0, 0x70,
  0xC1, 0xA0, 0xD8, 0x6C, 0x22, 0x31, 0x98, 0x48, 0x3C, 0x0E, 0x06, 0x03,
  0x01, 0x0F, 0x07, 0x00, 0xFE, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC0,
  0xC0, 0xFF, 0x0F, 0x1F, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0xE0,
  0xE0, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F, 0x0F, 0xFF, 0xFF,
  0xF0, 0xE1, 0xE0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x1C, 0x38, 0x41,
  0x83, 0x06, 0x0C, 0x18, 0x33, 0xC7, 0x00, 0x78, 0xC7, 0xC0, 0x80,
};

const GFXglyph UbuntuSansMono_Regular20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 5, 5, 11, 3, -15 },
  { 11, 10, 14, 11, 1, -14 },
  { 29, 9, 18, 11, 1, -16 },
  { 50, 11, 14, 11, 0, -14 },
  { 70, 10, 14, 11, 1, -14 },
  { 88, 1, 6, 11, 5, -15 },
  { 89, 5, 20, 11, 3, -16 },
  { 102, 6, 20, 11, 3, -16 },
  { 117, 9, 8, 11, 1, -14 },
  { 126, 9, 10, 11, 1, -11 },
  { 138, 5, 6, 11, 3, -3 },
  { 142, 5, 1, 11, 3, -6 },
  { 143, 3, 3, 11, 4, -3 },
  { 145, 8, 20, 11, 2, -16 },
  { 165, 9, 14, 11, 1, -14 },
  { 181, 8, 14, 11, 2, -14 },
  { 195, 9, 14, 11, 1, -14 },
  { 211, 9, 14, 11, 1, -14 },
  { 227, 9, 14, 11, 1, -14 },
  { 243, 8, 14, 11, 2, -14 },
  { 257, 9, 14, 11, 1, -14 },
  { 273, 8, 14, 11, 2, -14 },
  { 287, 9, 14, 11, 1, -14 },
  { 303, 9, 14, 11, 1, -14 },
  { 319, 3, 10, 11, 4, -10 },
  { 323, 4, 13, 11, 3, -10 },
  { 330, 9, 9, 11, 1, -10 },
  { 341, 9, 6, 11, 1, -9 },
  { 348, 9, 9, 11, 1, -10 },
  { 359, 7, 14, 11, 2, -14 },
  { 372, 9, 17, 11, 1, -14 },
  { 392, 11, 14, 11, 0, -14 },
  { 412, 9, 14, 11, 1, -14 },
  { 428, 9, 14, 11, 1, -14 },
  { 444, 9, 14, 11, 1, -14 },
  { 460, 8, 14, 11, 2, -14 },
  { 474, 8, 14, 11, 2, -14 },
  { 488, 9, 14, 11, 1, -14 },
  { 504, 9, 14, 11, 1, -14 },
  { 520, 7, 14, 11, 2, -14 },
  { 533, 8, 14, 11, 1, -14 },
  { 547, 9, 14, 11, 2, -14 },
  { 563, 8, 14, 11, 2, -14 },
  { 577, 9, 14, 11, 1, -14 },
  { 593, 9, 14, 11, 1, -14 },
  { 609, 10, 14, 11, 1, -14 },
  { 627, 8, 14, 11, 2, -14 },
  { 641, 10, 18, 11, 1, -14 },
  { 664, 9, 14, 11, 1, -14 },
  { 680, 9, 14, 11, 1, -14 },
  { 696, 9, 14, 11, 1, -14 },
  { 712, 9, 14, 11, 1, -14 },
  { 728, 11, 14, 11, 0, -14 },
  { 748, 9, 14, 11, 1, -14 },
  { 764, 10, 14, 11, 1, -14 },
  { 782, 11, 14, 11, 0, -14 },
  { 802, 9, 14, 11, 1, -14 },
  { 818, 6, 20, 11, 3, -16 },
  { 833, 7, 20, 11, 2, -16 },
  { 851, 5, 20, 11, 3, -16 },
  { 864, 9, 8, 11, 1, -14 },
  { 873, 11, 2, 11, 0, 2 },
  { 876, 3, 4, 11, 4, -16 },
  { 878, 9, 11, 11, 1, -11 },
  { 891, 8, 16, 11, 2, -16 },
  { 907, 9, 11, 11, 1, -11 },
  { 920, 9, 16, 11, 1, -16 },
  { 938, 9, 11, 11, 1, -11 },
  { 951, 9, 16, 11, 2, -16 },
  { 969, 9, 15, 11, 1, -11 },
  { 986, 8, 16, 11, 2, -16 },
  { 1002, 9, 15, 11, 1, -15 },
  { 1019, 7, 19, 11, 2, -15 },
  { 1036, 9, 16, 11, 2, -16 },
  { 1054, 9, 15, 11, 1, -15 },
  { 1071, 9, 11, 11, 1, -11 },
  { 1084, 8, 11, 11, 2, -11 },
  { 1095, 9, 11, 11, 1, -11 },
  { 1108, 8, 15, 11, 2, -11 },
  { 1123, 9, 15, 11, 1, -11 },
  { 1140, 7, 11, 11, 3, -11 },
  { 1150, 8, 11, 11, 2, -11 },
  { 1161, 8, 14, 11, 2, -14 },
  { 1175, 8, 10, 11, 2, -10 },
  { 1185, 9, 10, 11, 1, -10 },
  { 1197, 11, 10, 11, 0, -10 },
  { 1211, 10, 10, 11, 1, -10 },
  { 1224, 9, 14, 11, 1, -10 },
  { 1240, 8, 10, 11, 2, -10 },
  { 1250, 8, 20, 11, 2, -16 },
  { 1270, 1, 20, 11, 5, -16 },
  { 1273, 7, 20, 11, 2, -16 },
  { 1291, 9, 3, 11, 1, -7 },
};

const GFXfont UbuntuSansMono_Regular20pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular20pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular20pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUSANSMONO_REGULAR20PT7B_H_
