#ifndef _UBUNTUSANSMONO_REGULAR15PT7B_H_
#define _UBUNTUSANSMONO_REGULAR15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x54, 0xF0, 0x99, 0x99, 0x12, 0x12, 0xFF, 0x26, 0x24, 0x24,
  0xFF, 0x24, 0x4C, 0x48, 0x10, 0x47, 0xF0, 0x83, 0x07, 0x07, 0x04, 0x18,
  0xDE, 0x10, 0x40, 0x61, 0x52, 0x92, 0x94, 0x5C, 0x28, 0x16, 0x15, 0x29,
  0x69, 0x47, 0x30, 0xB2, 0x26, 0x45, 0x0C, 0xBD, 0x4E, 0x8D, 0x1B, 0xD8,
  0xF0, 0x13, 0x24, 0x48, 0x88, 0x88, 0x44, 0x23, 0x10, 0x8C, 0x62, 0x11,
  0x11, 0x11, 0x12, 0x6C, 0x80, 0x12, 0x5F, 0xCC, 0x6D, 0x20, 0x10, 0x20,
  0x47, 0xF1, 0x02, 0x04, 0x00, 0x6D, 0xE0, 0xF0, 0xF0, 0x04, 0x10, 0x82,
  0x08, 0x41, 0x04, 0x20, 0x82, 0x18, 0x41, 0x0C, 0x00, 0x30, 0xD3, 0x14,
  0x28, 0x56, 0xE5, 0xC2, 0x84, 0x99, 0xE0, 0x11, 0xC9, 0x04, 0x10, 0x41,
  0x04, 0x11, 0xF0, 0x33, 0x70, 0x41, 0x0C, 0x21, 0x08, 0x43, 0x0F, 0xC0,
  0x33, 0x70, 0x41, 0x08, 0xE0, 0xC1, 0x04, 0x1F, 0x80, 0x0C, 0x38, 0xB2,
  0x64, 0xD1, 0xBF, 0x86, 0x0C, 0x18, 0x7D, 0x04, 0x10, 0x78, 0x10, 0x41,
  0x07, 0xE0, 0x3C, 0xC1, 0x04, 0x0F, 0xD0, 0xA1, 0xC2, 0xC4, 0xF0, 0xFE,
  0x08, 0x20, 0x41, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x31, 0x38, 0x61, 0xC5,
  0xE4, 0xE1, 0x86, 0x17, 0xC0, 0x31, 0x38, 0x61, 0x87, 0x17, 0xC1, 0x0C,
  0x6E, 0x00, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x38, 0x02, 0x1C, 0xC6, 0x0E,
  0x03, 0x01, 0x80, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x81, 0xC0, 0xE0, 0x31,
  0xCE, 0x20, 0x00, 0x64, 0x82, 0x31, 0x11, 0x08, 0x03, 0x18, 0x18, 0xD9,
  0x1C, 0x19, 0xF6, 0x68, 0xD1, 0xB3, 0xBD, 0x03, 0x03, 0xC0, 0x18, 0x14,
  0x24, 0x24, 0x22, 0x62, 0x7E, 0x43, 0x41, 0x81, 0x23, 0x68, 0x61, 0x8F,
  0xE8, 0x61, 0x86, 0x1F, 0x80, 0x18, 0xED, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xC0, 0x80, 0xF8, 0x41, 0xF2, 0x14, 0x28, 0x70, 0xE1, 0xC3, 0x85, 0x1B,
  0xC0, 0xFA, 0x08, 0x20, 0xFA, 0x08, 0x20, 0x83, 0xF0, 0xFC, 0x21, 0x0F,
  0xC2, 0x10, 0x84, 0x00, 0x18, 0xCD, 0x04, 0x08, 0x10, 0x21, 0xC3, 0xC6,
  0x8C, 0xF8, 0x87, 0x0E, 0x1C, 0x3F, 0xF0, 0xE1, 0xC3, 0x87, 0x0C, 0xF9,
  0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x8F, 0xE0, 0x87, 0x12, 0x65, 0x8E, 0x16, 0x26, 0x46, 0x85, 0x04, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xC5, 0x9B, 0x35, 0x6B, 0x72,
  0x60, 0xC1, 0x83, 0x04, 0xC7, 0x1A, 0x69, 0x96, 0x58, 0xE3, 0x8E, 0x10,
  0x18, 0x26, 0x42, 0x43, 0x41, 0xC1, 0x41, 0x41, 0x43, 0x62, 0x3C, 0x21,
  0xFB, 0x16, 0x3C, 0x58, 0xBE, 0x60, 0xC1, 0x83, 0x00, 0x18, 0x26, 0x42,
  0x43, 0x41, 0xC1, 0x41, 0x41, 0x43, 0x62, 0x3C, 0x08, 0x0C, 0x02, 0x21,
  0xF2, 0x14, 0x28, 0x51, 0xBC, 0x44, 0x89, 0x0A, 0x18, 0x39, 0xBC, 0x20,
  0x40, 0xC0, 0xC1, 0x04, 0x1F, 0x80, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0xC4, 0xF8,
  0xC1, 0x41, 0x42, 0x42, 0x22, 0x26, 0x24, 0x14, 0x1C, 0x18, 0x83, 0x06,
  0x0C, 0x1B, 0x76, 0xAB, 0x66, 0xCD, 0x88, 0x43, 0x26, 0x24, 0x1C, 0x18,
  0x1C, 0x24, 0x26, 0x42, 0xC3, 0xC1, 0x42, 0x22, 0x24, 0x14, 0x18, 0x08,
  0x08, 0x08, 0x08, 0xFE, 0x08, 0x20, 0xC1, 0x04, 0x18, 0x20, 0xC1, 0xFC,
  0xF2, 0x49, 0x24, 0x92, 0x49, 0x38, 0xC1, 0x04, 0x10, 0x20, 0x82, 0x04,
  0x10, 0x40, 0x82, 0x08, 0x30, 0x40, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x30, 0x51, 0x26, 0x28, 0x60, 0xFF, 0xA4, 0x78, 0x10, 0x4F,
  0xC6, 0x18, 0x5F, 0x41, 0x02, 0x04, 0x0B, 0x99, 0xA1, 0x43, 0x87, 0x0E,
  0x17, 0xC0, 0x3C, 0x82, 0x04, 0x08, 0x10, 0x30, 0x3F, 0x04, 0x10, 0x41,
  0x7F, 0x18, 0x61, 0x86, 0x1C, 0x5F, 0x39, 0x8A, 0x17, 0xF8, 0x10, 0x30,
  0x3E, 0x0C, 0x64, 0x81, 0x0F, 0xC4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00,
  0x7F, 0x18, 0x61, 0x86, 0x1C, 0xCF, 0x06, 0x3F, 0x00, 0x42, 0x08, 0x20,
  0xFA, 0x38, 0x61, 0x86, 0x18, 0x61, 0x70, 0x80, 0x38, 0x20, 0x82, 0x08,
  0x20, 0xC1, 0xC0, 0x18, 0xC0, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x18, 0xB8,
  0x41, 0x02, 0x04, 0x08, 0x71, 0x24, 0x70, 0xB1, 0x32, 0x34, 0x30, 0xE0,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0x07, 0xFD, 0x2E, 0x4C, 0x99,
  0x30, 0x60, 0xC1, 0xFA, 0x38, 0x61, 0x86, 0x18, 0x61, 0x79, 0x9A, 0x14,
  0x38, 0x70, 0xF1, 0x3C, 0xF9, 0x1A, 0x14, 0x38, 0x70, 0xF1, 0x7C, 0x81,
  0x02, 0x00, 0x3F, 0x18, 0x61, 0x86, 0x1C, 0x5F, 0x04, 0x10, 0x40, 0xFC,
  0x21, 0x08, 0x42, 0x10, 0x7F, 0x0C, 0x18, 0x18, 0x10, 0x7F, 0x20, 0x8F,
  0xC8, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x86, 0x18, 0x61, 0x86, 0x1C, 0x5F,
  0x87, 0x0B, 0x12, 0x64, 0x8D, 0x0C, 0x18, 0xC1, 0x41, 0x49, 0x59, 0x5A,
  0x56, 0x66, 0x22, 0x86, 0x99, 0xA1, 0x83, 0x8D, 0x31, 0x43, 0x87, 0x89,
  0x12, 0x26, 0x85, 0x0A, 0x08, 0x10, 0x43, 0x00, 0xFC, 0x31, 0x84, 0x21,
  0x84, 0x3F, 0x1C, 0xC2, 0x08, 0x20, 0x82, 0x30, 0x20, 0x82, 0x08, 0x20,
  0xC1, 0xC0, 0xFF, 0xFE, 0xE0, 0x41, 0x04, 0x10, 0x41, 0x03, 0x10, 0x41,
  0x04, 0x10, 0x4E, 0x00, 0x41, 0x6E, 0x30,
};

const GFXglyph UbuntuSansMono_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -11 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 6, 14, 8, 1, -12 },
  { 27, 8, 11, 8, 0, -11 },
  { 38, 7, 11, 8, 1, -11 },
  { 48, 1, 4, 8, 4, -11 },
  { 49, 4, 15, 8, 2, -12 },
  { 57, 4, 15, 8, 2, -12 },
  { 65, 6, 6, 8, 1, -10 },
  { 70, 7, 7, 8, 1, -8 },
  { 77, 3, 4, 8, 3, -2 },
  { 79, 4, 1, 8, 2, -5 },
  { 80, 2, 2, 8, 3, -2 },
  { 81, 6, 15, 8, 1, -12 },
  { 93, 7, 11, 8, 1, -11 },
  { 103, 6, 10, 8, 1, -10 },
  { 111, 6, 11, 8, 1, -11 },
  { 120, 6, 11, 8, 1, -11 },
  { 129, 7, 10, 8, 1, -10 },
  { 138, 6, 10, 8, 1, -10 },
  { 146, 7, 10, 8, 1, -10 },
  { 155, 7, 10, 8, 1, -10 },
  { 164, 6, 11, 8, 1, -11 },
  { 173, 6, 11, 8, 1, -11 },
  { 182, 2, 8, 8, 3, -8 },
  { 184, 3, 10, 8, 2, -8 },
  { 188, 7, 7, 8, 1, -8 },
  { 195, 7, 5, 8, 1, -7 },
  { 200, 7, 7, 8, 1, -8 },
  { 207, 5, 11, 8, 2, -11 },
  { 214, 7, 13, 8, 1, -11 },
  { 226, 8, 10, 8, 0, -10 },
  { 236, 6, 11, 8, 1, -11 },
  { 245, 7, 11, 8, 1, -11 },
  { 255, 7, 11, 8, 1, -11 },
  { 265, 6, 10, 8, 2, -10 },
  { 273, 5, 10, 8, 2, -10 },
  { 280, 7, 11, 8, 1, -11 },
  { 290, 7, 10, 8, 1, -10 },
  { 299, 5, 10, 8, 2, -10 },
  { 306, 6, 10, 8, 1, -10 },
  { 314, 7, 10, 8, 1, -10 },
  { 323, 6, 10, 8, 2, -10 },
  { 331, 7, 10, 8, 1, -10 },
  { 340, 6, 10, 8, 1, -10 },
  { 348, 8, 11, 8, 0, -11 },
  { 359, 7, 11, 8, 1, -11 },
  { 369, 8, 14, 8, 0, -11 },
  { 383, 7, 11, 8, 1, -11 },
  { 393, 6, 11, 8, 1, -11 },
  { 402, 7, 10, 8, 1, -10 },
  { 411, 7, 10, 8, 1, -10 },
  { 420, 8, 10, 8, 0, -10 },
  { 430, 7, 10, 8, 1, -10 },
  { 439, 8, 10, 8, 0, -10 },
  { 449, 8, 10, 8, 0, -10 },
  { 459, 7, 10, 8, 1, -10 },
  { 468, 3, 15, 8, 3, -12 },
  { 474, 6, 15, 8, 1, -12 },
  { 486, 4, 15, 8, 2, -12 },
  { 494, 7, 5, 8, 1, -10 },
  { 499, 8, 1, 8, 0, 2 },
  { 500, 2, 3, 8, 3, -12 },
  { 501, 6, 8, 8, 1, -8 },
  { 507, 7, 12, 8, 1, -12 },
  { 518, 7, 8, 8, 1, -8 },
  { 525, 6, 12, 8, 1, -12 },
  { 534, 7, 8, 8, 1, -8 },
  { 541, 7, 12, 8, 1, -12 },
  { 552, 6, 11, 8, 1, -8 },
  { 561, 6, 12, 8, 1, -12 },
  { 570, 6, 11, 8, 1, -11 },
  { 579, 5, 14, 8, 1, -11 },
  { 588, 7, 12, 8, 1, -12 },
  { 599, 6, 12, 8, 1, -12 },
  { 608, 7, 8, 8, 1, -8 },
  { 615, 6, 8, 8, 1, -8 },
  { 621, 7, 8, 8, 1, -8 },
  { 628, 7, 11, 8, 1, -8 },
  { 638, 6, 11, 8, 1, -8 },
  { 647, 5, 8, 8, 2, -8 },
  { 652, 6, 8, 8, 1, -8 },
  { 658, 6, 10, 8, 1, -10 },
  { 666, 6, 8, 8, 1, -8 },
  { 672, 7, 8, 8, 1, -8 },
  { 679, 8, 8, 8, 0, -8 },
  { 687, 7, 8, 8, 1, -8 },
  { 694, 7, 11, 8, 1, -8 },
  { 704, 6, 8, 8, 1, -8 },
  { 710, 6, 15, 8, 1, -12 },
  { 722, 1, 15, 8, 4, -12 },
  { 724, 6, 15, 8, 1, -12 },
  { 736, 7, 3, 8, 1, -6 },
};

const GFXfont UbuntuSansMono_Regular15pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular15pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUSANSMONO_REGULAR15PT7B_H_
