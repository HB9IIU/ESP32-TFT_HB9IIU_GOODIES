#ifndef _UBUNTUSANSMONO_REGULAR40PT7B_H_
#define _UBUNTUSANSMONO_REGULAR40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3,
  0x0C, 0x30, 0xC3, 0x00, 0x00, 0x00, 0x1E, 0x7F, 0xFF, 0xDE, 0x10, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x76, 0x1D, 0x83, 0x60, 0xD8, 0x30,
  0x01, 0xC1, 0xE0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0x81,
  0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x03, 0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0,
  0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x83, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x7F, 0xF0, 0xFF,
  0xF8, 0xF8, 0x1C, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xB0, 0x03, 0xDF, 0x9F, 0xCF, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x77, 0xF0, 0x0E, 0x63, 0x80, 0xEE, 0x18, 0x1C, 0xE1,
  0x83, 0x8C, 0x1C, 0x38, 0xC1, 0xC7, 0x0C, 0x1C, 0x70, 0xE1, 0x8E, 0x0E,
  0x19, 0xC0, 0xE3, 0x9C, 0x07, 0xFB, 0x80, 0x3F, 0x38, 0x00, 0x87, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x7C, 0x01, 0xCF, 0xE0, 0x1C, 0xC7, 0x03, 0x9C,
  0x30, 0x71, 0xC3, 0x07, 0x18, 0x30, 0xE1, 0x83, 0x0E, 0x18, 0x31, 0xC1,
  0xC3, 0x18, 0x1C, 0x33, 0x81, 0xC7, 0x70, 0x0E, 0xEF, 0x00, 0x7E, 0x00,
  0x01, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xF9, 0xF0, 0x1C, 0x1E, 0x03,
  0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x38, 0x07,
  0x07, 0x00, 0x71, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0x0F,
  0xE0, 0xE1, 0xDE, 0x1C, 0x71, 0xE3, 0x9E, 0x1E, 0x73, 0x81, 0xEC, 0x70,
  0x1F, 0x8E, 0x01, 0xF1, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0xF8, 0xF0,
  0x3F, 0x8F, 0x9F, 0x78, 0xFF, 0xC7, 0x0F, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF,
  0xDB, 0x00, 0x00, 0x60, 0x0E, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06, 0x20,
  0x07, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x3C, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x08, 0x1C, 0x07, 0x0E, 0x3B, 0xF6, 0x7D, 0xFF,
  0xFF, 0x3F, 0xFC, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xEE, 0x01, 0xE7, 0x80,
  0xF1, 0xE0, 0xF0, 0xF8, 0x30, 0x30, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x0E, 0x0F, 0x87, 0xE7, 0xF1, 0xF8, 0xFC, 0x1C, 0x1E,
  0x1E, 0x7E, 0x3E, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x39, 0xFF, 0xFF,
  0xFD, 0xF1, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0x70, 0x3C, 0x3C, 0x07, 0x0E, 0x01, 0xE7, 0x80, 0x39, 0xC0,
  0x0E, 0x70, 0x03, 0xDC, 0x00, 0xFF, 0x00, 0x1F, 0xC3, 0x87, 0xF1, 0xF1,
  0xFC, 0x7C, 0x7F, 0x1F, 0x1F, 0xC7, 0x87, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0x9E, 0x00, 0xE7, 0x80, 0x78, 0xE0,
  0x1C, 0x3C, 0x0F, 0x07, 0xC7, 0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xB8,
  0x3C, 0x70, 0x70, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF,
  0x1E, 0x03, 0xC4, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF,
  0x0C, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x80, 0x0F, 0x78,
  0x3F, 0x3F, 0xFF, 0x0F, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x73,
  0x80, 0x1C, 0x70, 0x07, 0x8E, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x07, 0x07,
  0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E,
  0x1C, 0x01, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x40, 0x0F, 0x38, 0x3F, 0x3F, 0xFF,
  0x0F, 0xFF, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC7, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xC7, 0x80, 0xFB, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x1D,
  0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x80, 0x3C, 0xE0, 0x0E, 0x3C,
  0x07, 0x87, 0x83, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0x81, 0xE1, 0xF0, 0xF0, 0x1C, 0x78, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9E, 0x00, 0xE3, 0xC0, 0x70,
  0xF8, 0x3C, 0x1F, 0x9E, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x78, 0xFC, 0x38,
  0x0F, 0x9E, 0x01, 0xE7, 0x00, 0x3D, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x78, 0x07, 0x8F, 0x03, 0xE1, 0xFF, 0xF0,
  0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xF3, 0xE0,
  0xF0, 0x3C, 0x78, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x78, 0x01, 0xCF, 0x00,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x07, 0xF3, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x39, 0xFF, 0xFF, 0xFD,
  0xF1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFF, 0xFF, 0x7C,
  0x40, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F, 0x1F, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F, 0x1F, 0x07, 0x0F,
  0x1E, 0xFC, 0xF8, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x00, 0x0F, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xE3, 0xFF, 0xC7, 0x0F, 0x90, 0x0F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xC0, 0x02, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F,
  0x01, 0xC1, 0xC0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x7B, 0xC0, 0x07, 0x70,
  0x00, 0xEE, 0x03, 0xFD, 0xC1, 0xFF, 0xF8, 0x7E, 0xFF, 0x0E, 0x0F, 0xE3,
  0xC1, 0xFC, 0x70, 0x3F, 0x8E, 0x07, 0xF1, 0xC0, 0xFE, 0x38, 0x1F, 0xC7,
  0x03, 0xF8, 0xE0, 0x7F, 0x1C, 0x0F, 0xE3, 0xC1, 0xDC, 0x38, 0x3B, 0xC7,
  0xFF, 0x78, 0x7F, 0xE7, 0x03, 0xF8, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xEE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0,
  0x70, 0x03, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xE0,
  0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x00,
  0xE7, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x7F, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xC0, 0x7C, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E,
  0xF0, 0x07, 0xBC, 0x01, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xFF, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0E,
  0xF0, 0x0F, 0xBC, 0x3F, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xFF, 0x00,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x03, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x43, 0xF0, 0xF0, 0x7F, 0xFC, 0x07, 0xFE,
  0x00, 0x10, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xC0, 0xF8,
  0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x1E, 0x3F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0xFE, 0x7C, 0x3C, 0x02, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x78,
  0x01, 0xCE, 0x00, 0x73, 0xC0, 0x1C, 0x70, 0x07, 0x1F, 0x01, 0xC3, 0xF0,
  0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x18, 0x00, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x40, 0x1E, 0xF0, 0x7C, 0xFF, 0xF8, 0x7F, 0xF0, 0x03, 0x80, 0xE0, 0x03,
  0xDC, 0x00, 0xF3, 0x80, 0x1C, 0x70, 0x07, 0x8E, 0x01, 0xE1, 0xC0, 0x78,
  0x38, 0x1E, 0x07, 0x07, 0x80, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x8F, 0x00,
  0x73, 0xC0, 0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x3E, 0x00,
  0xE3, 0xE0, 0x1C, 0x3E, 0x03, 0x83, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0xC1,
  0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x00, 0x3C, 0xE0, 0x07, 0x9C, 0x00, 0x7B,
  0x80, 0x07, 0x70, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x03, 0x87, 0x00, 0xF1, 0xE0, 0x1E,
  0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0xD8, 0x1F, 0x1B, 0x83, 0x73, 0x70, 0xEE,
  0x66, 0x1D, 0xCC, 0xE3, 0x39, 0x9C, 0xE7, 0x31, 0x9C, 0xEE, 0x3B, 0x1D,
  0xC3, 0x63, 0xB8, 0x7C, 0x77, 0x0F, 0x0E, 0xE0, 0xE1, 0xDC, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x70,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3E, 0xE0,
  0x1F, 0x70, 0x0F, 0x9C, 0x07, 0xCE, 0x03, 0xE3, 0x81, 0xF1, 0xE0, 0xF8,
  0x70, 0x7C, 0x38, 0x3E, 0x0E, 0x1F, 0x07, 0x0F, 0x81, 0xC7, 0xC0, 0xE3,
  0xE0, 0x39, 0xF0, 0x1C, 0xF8, 0x07, 0x7C, 0x03, 0xBE, 0x00, 0xDF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0x9F, 0x81, 0xE0, 0x3C, 0x3C, 0x01,
  0xC3, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xF7, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x0F, 0x70, 0x00, 0xE7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x1C,
  0x1C, 0x03, 0xC1, 0xF0, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x30,
  0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0, 0x0E, 0xE0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0x9F, 0x81, 0xE0, 0x3C, 0x3C, 0x01, 0xC3, 0x80, 0x1E,
  0x78, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xF7, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F, 0x70,
  0x00, 0xE7, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x1C, 0x1C, 0x03, 0xC1,
  0xF0, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0xC0, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x07, 0xCE, 0x00, 0xE7,
  0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01,
  0xDC, 0x01, 0xEE, 0x00, 0xE7, 0x01, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE3,
  0x80, 0x79, 0xC0, 0x1C, 0xE0, 0x0F, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00,
  0x70, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xCF, 0x8F, 0x00, 0x47, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x40, 0x0F, 0x78, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF,
  0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0E,
  0x78, 0x07, 0x8F, 0x83, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x38, 0x00, 0x79, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0x0E, 0x0F, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x70,
  0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0xF0, 0xEE, 0x1E, 0x1D, 0xC3, 0xC3, 0xB8,
  0xFC, 0x77, 0x1D, 0x8E, 0xE3, 0x31, 0xDC, 0xE7, 0x39, 0x9C, 0x67, 0x33,
  0x0C, 0xE6, 0x61, 0xD8, 0xDC, 0x1B, 0x1B, 0x03, 0xE3, 0x60, 0x7C, 0x7C,
  0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E, 0x1C, 0x03, 0xC0, 0x70, 0x00, 0xF7,
  0x80, 0x1E, 0x38, 0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0x80, 0xE0, 0x78,
  0x0F, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x8E, 0x00, 0x39, 0xC0, 0x03, 0xDC,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0x9C, 0x00, 0x79, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0x70, 0x0E,
  0x07, 0x01, 0xE0, 0x38, 0x1C, 0x03, 0x83, 0xC0, 0x1C, 0x38, 0x01, 0xC7,
  0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xBC, 0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xF0,
  0x07, 0x03, 0x80, 0x78, 0x1E, 0x03, 0x80, 0x70, 0x38, 0x03, 0xC1, 0xC0,
  0x0E, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0x38, 0x01, 0xCF, 0x00, 0xE1,
  0xC0, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC3, 0x80, 0x71, 0xE0, 0x0E,
  0x70, 0x03, 0xB8, 0x00, 0x76, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x21, 0xE1, 0xE1, 0xC1, 0xC1, 0xC3, 0x82, 0x1F, 0xF0, 0x3F, 0xFC,
  0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0xC7, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x0F, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x7C, 0x0F, 0x3F, 0xFF,
  0x1F, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x39,
  0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC0, 0xFB, 0x80, 0x3D, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xDC,
  0x03, 0xEF, 0x87, 0xE7, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xFE, 0x3C, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xFE, 0xE1, 0xFF, 0xF1, 0xFF, 0xF9,
  0xE0, 0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xB8, 0x01, 0xDE, 0x00, 0xE7, 0x80, 0x71, 0xF9, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFB, 0xF0, 0xF0, 0x1E, 0x78,
  0x03, 0x9C, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1E, 0x01, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0x80, 0x77, 0x80, 0x3B, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xF0, 0x07, 0x7C, 0x07,
  0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x1C, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xEF, 0xF0,
  0xFF, 0xFC, 0xFF, 0xFE, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xDF, 0xFE, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xB8, 0x7D, 0xFF, 0xCF, 0xFC, 0x03, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3B, 0x80,
  0x1C, 0xE0, 0x0E, 0x38, 0x0F, 0x0E, 0x07, 0x83, 0x83, 0xC0, 0xE1, 0xE0,
  0x39, 0xF0, 0x0E, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3B, 0xE0, 0x0E,
  0x3E, 0x03, 0x87, 0xC0, 0xE0, 0xF8, 0x38, 0x0F, 0x0E, 0x01, 0xE3, 0x80,
  0x3C, 0xE0, 0x07, 0x38, 0x01, 0xEE, 0x00, 0x3C, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x78, 0x0F, 0xFC,
  0x03, 0xFE, 0x7F, 0x1F, 0x1F, 0xFF, 0xF3, 0xCF, 0xDF, 0x70, 0xF0, 0xEE,
  0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC,
  0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0E, 0x3F, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE, 0xE0, 0x1E,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x03, 0xF8,
  0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0x9C, 0x00, 0xEF,
  0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x0F, 0x78, 0x03,
  0x8F, 0x03, 0xE1, 0xFB, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x03, 0xCE, 0x00, 0xF7, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0x78, 0x07,
  0xBF, 0xDF, 0x9F, 0xFF, 0x8E, 0xFF, 0x87, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xFE,
  0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xC0, 0x77, 0x80, 0x3B, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x07, 0x78, 0x03, 0x9E, 0x03,
  0xCF, 0xEF, 0xE3, 0xFF, 0xF0, 0x7F, 0xB8, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0F,
  0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x70, 0x02, 0x70, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x40, 0x07, 0xF8,
  0x1F, 0xFF, 0xFE, 0x7F, 0xF8, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xF7, 0x81, 0xFF,
  0xC0, 0x7F, 0xE0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70,
  0x07, 0x78, 0x07, 0x3F, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x3B, 0xC0, 0x07, 0x78, 0x01, 0xE7, 0x00, 0x3C, 0xF0, 0x07, 0x1E,
  0x01, 0xE1, 0xC0, 0x3C, 0x3C, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x0F,
  0x07, 0x00, 0xE1, 0xC0, 0x1E, 0x38, 0x01, 0xCF, 0x00, 0x39, 0xC0, 0x07,
  0xB8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x77,
  0x07, 0x07, 0x70, 0x70, 0x77, 0x0F, 0x07, 0x70, 0xF0, 0xE7, 0x0F, 0x8E,
  0x71, 0xD8, 0xE7, 0x1D, 0x8E, 0x39, 0x9C, 0xE3, 0xB8, 0xCE, 0x3B, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x07, 0xC1, 0xE0, 0x7C, 0x1E, 0x03, 0xC1, 0xC0,
  0x38, 0x1C, 0x03, 0x80, 0x78, 0x00, 0xE3, 0x80, 0x1C, 0x3C, 0x03, 0xC1,
  0xE0, 0x78, 0x0F, 0x07, 0x00, 0x78, 0xE0, 0x03, 0x9E, 0x00, 0x3D, 0xC0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xDC,
  0x00, 0x39, 0xE0, 0x07, 0x0F, 0x00, 0xF0, 0x78, 0x1E, 0x03, 0x81, 0xC0,
  0x3C, 0x38, 0x01, 0xE7, 0x80, 0x0E, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x1D, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0xC0,
  0x38, 0x70, 0x1E, 0x1C, 0x07, 0x07, 0x81, 0xC0, 0xE0, 0xF0, 0x38, 0x38,
  0x07, 0x0E, 0x01, 0xC3, 0x80, 0x79, 0xC0, 0x0E, 0x70, 0x03, 0xDC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x21, 0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0x00,
  0x30, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x07,
  0xFC, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0x1C, 0x00, 0x0F, 0xE0, 0x37, 0xFE, 0x0F, 0x87,
  0xC7, 0xC0, 0x7F, 0xB0, 0x0F, 0xC0,
};

const GFXglyph UbuntuSansMono_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 29, 22, 8, -28 },
  { 23, 10, 10, 22, 6, -30 },
  { 36, 20, 28, 22, 1, -28 },
  { 106, 17, 35, 22, 3, -31 },
  { 181, 20, 29, 22, 1, -28 },
  { 254, 19, 28, 22, 2, -28 },
  { 321, 3, 11, 22, 10, -30 },
  { 326, 12, 38, 22, 5, -31 },
  { 383, 12, 38, 22, 5, -31 },
  { 440, 17, 16, 22, 3, -28 },
  { 474, 18, 20, 22, 2, -22 },
  { 519, 9, 12, 22, 7, -6 },
  { 533, 9, 3, 22, 7, -13 },
  { 537, 6, 7, 22, 8, -6 },
  { 543, 16, 38, 22, 3, -31 },
  { 619, 18, 29, 22, 2, -28 },
  { 685, 15, 28, 22, 4, -28 },
  { 738, 17, 28, 22, 3, -28 },
  { 798, 17, 29, 22, 3, -28 },
  { 860, 19, 28, 22, 2, -28 },
  { 927, 17, 29, 22, 3, -28 },
  { 989, 18, 29, 22, 2, -28 },
  { 1055, 17, 28, 22, 3, -28 },
  { 1115, 18, 29, 22, 2, -28 },
  { 1181, 18, 28, 22, 2, -28 },
  { 1244, 6, 22, 22, 8, -21 },
  { 1261, 8, 27, 22, 6, -21 },
  { 1288, 18, 17, 22, 2, -20 },
  { 1327, 18, 11, 22, 2, -17 },
  { 1352, 19, 17, 22, 2, -20 },
  { 1393, 14, 29, 22, 4, -28 },
  { 1444, 19, 34, 22, 2, -28 },
  { 1525, 22, 28, 22, 0, -28 },
  { 1602, 18, 28, 22, 2, -28 },
  { 1665, 18, 29, 22, 2, -28 },
  { 1731, 18, 28, 22, 2, -28 },
  { 1794, 17, 28, 22, 4, -28 },
  { 1854, 16, 28, 22, 4, -28 },
  { 1910, 18, 29, 22, 2, -28 },
  { 1976, 18, 28, 22, 2, -28 },
  { 2039, 14, 28, 22, 4, -28 },
  { 2088, 16, 29, 22, 3, -28 },
  { 2146, 19, 28, 22, 3, -28 },
  { 2213, 17, 28, 22, 4, -28 },
  { 2273, 19, 28, 22, 2, -28 },
  { 2340, 17, 28, 22, 3, -28 },
  { 2400, 20, 29, 22, 1, -28 },
  { 2473, 16, 28, 22, 4, -28 },
  { 2529, 20, 35, 22, 1, -28 },
  { 2617, 17, 28, 22, 3, -28 },
  { 2677, 17, 29, 22, 3, -28 },
  { 2739, 18, 28, 22, 2, -28 },
  { 2802, 18, 29, 22, 2, -28 },
  { 2868, 21, 28, 22, 1, -28 },
  { 2942, 19, 28, 22, 2, -28 },
  { 3009, 20, 28, 22, 1, -28 },
  { 3079, 21, 28, 22, 1, -28 },
  { 3153, 18, 28, 22, 2, -28 },
  { 3216, 10, 38, 22, 7, -31 },
  { 3264, 16, 38, 22, 3, -31 },
  { 3340, 11, 38, 22, 5, -31 },
  { 3393, 18, 15, 22, 2, -28 },
  { 3427, 22, 2, 22, 0, 5 },
  { 3433, 7, 8, 22, 7, -31 },
  { 3440, 16, 21, 22, 3, -21 },
  { 3482, 17, 31, 22, 3, -31 },
  { 3548, 18, 21, 22, 2, -21 },
  { 3596, 17, 31, 22, 2, -31 },
  { 3662, 18, 21, 22, 2, -21 },
  { 3710, 18, 31, 22, 3, -31 },
  { 3780, 17, 29, 22, 2, -21 },
  { 3842, 16, 31, 22, 3, -31 },
  { 3904, 17, 30, 22, 3, -30 },
  { 3968, 13, 38, 22, 4, -30 },
  { 4030, 18, 31, 22, 3, -31 },
  { 4100, 17, 31, 22, 3, -31 },
  { 4166, 19, 21, 22, 2, -21 },
  { 4216, 16, 21, 22, 3, -21 },
  { 4258, 18, 21, 22, 2, -21 },
  { 4306, 17, 28, 22, 3, -21 },
  { 4366, 17, 28, 22, 2, -21 },
  { 4426, 14, 21, 22, 5, -21 },
  { 4463, 16, 21, 22, 3, -21 },
  { 4505, 17, 27, 22, 3, -27 },
  { 4563, 16, 21, 22, 3, -21 },
  { 4605, 19, 21, 22, 2, -21 },
  { 4655, 20, 21, 22, 1, -21 },
  { 4708, 20, 21, 22, 1, -21 },
  { 4761, 18, 29, 22, 2, -21 },
  { 4827, 16, 21, 22, 3, -21 },
  { 4869, 15, 38, 22, 4, -31 },
  { 4941, 3, 38, 22, 10, -31 },
  { 4956, 16, 38, 22, 3, -31 },
  { 5032, 18, 6, 22, 2, -15 },
};

const GFXfont UbuntuSansMono_Regular40pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular40pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular40pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUSANSMONO_REGULAR40PT7B_H_
