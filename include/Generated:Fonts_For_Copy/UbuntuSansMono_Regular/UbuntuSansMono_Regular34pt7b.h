#ifndef _UBUNTUSANSMONO_REGULAR34PT7B_H_
#define _UBUNTUSANSMONO_REGULAR34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0x84, 0x00,
  0x00, 0x07, 0x7F, 0xEE, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3B, 0x19, 0x84,
  0x82, 0x41, 0x00, 0x03, 0x07, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xE1, 0xC0,
  0x70, 0xE0, 0x38, 0x70, 0x18, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E,
  0x03, 0x87, 0x01, 0x83, 0x80, 0xC1, 0x80, 0xE0, 0xC0, 0x70, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x0C, 0x07, 0x0E, 0x03, 0x87, 0x01,
  0x83, 0x80, 0xC1, 0x80, 0xE0, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x01, 0xFF, 0x87, 0xFF, 0x1E, 0x02, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x98,
  0x0F, 0x7F, 0xFC, 0x7F, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x3C, 0x03, 0xBF, 0x01, 0xB9, 0x81, 0xD8, 0x61, 0xCC,
  0x30, 0xC6, 0x18, 0xE3, 0x0C, 0x61, 0x86, 0x70, 0xC7, 0x70, 0x73, 0x30,
  0x1F, 0xB8, 0x03, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0xF8, 0x0C, 0xFC, 0x0E,
  0x63, 0x06, 0x61, 0x87, 0x30, 0xC7, 0x18, 0x63, 0x0C, 0x33, 0x86, 0x19,
  0x83, 0x8D, 0xC0, 0xCD, 0xC0, 0x3E, 0x00, 0x04, 0x00, 0x07, 0xC0, 0x0F,
  0xF8, 0x07, 0x1C, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xC0,
  0x70, 0xE0, 0x18, 0x60, 0x0E, 0x70, 0x03, 0xF0, 0x01, 0xE0, 0x81, 0xF8,
  0x61, 0xDC, 0x31, 0xC7, 0x18, 0xE1, 0xDC, 0x60, 0x7C, 0x70, 0x1E, 0x38,
  0x0F, 0x1C, 0x03, 0x87, 0x03, 0xE3, 0xC3, 0xF8, 0xFF, 0x9C, 0x3F, 0x87,
  0xFF, 0xFF, 0xFF, 0xE8, 0x01, 0x01, 0xC1, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x70, 0x70, 0x38, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0x00, 0x40, 0x60, 0x3C, 0x0E, 0x03, 0x80,
  0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x03,
  0x83, 0x83, 0xC3, 0xC3, 0xC1, 0xC0, 0x40, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x04, 0x38, 0x4F, 0x37, 0xBF, 0xFF, 0x8F, 0xF8, 0x03,
  0x80, 0x0D, 0x80, 0x3B, 0x80, 0xE3, 0x83, 0xC7, 0x81, 0x04, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1C, 0x7C, 0xF9, 0xF1, 0xE1, 0xC3, 0x1E,
  0xF9, 0xC0, 0xFF, 0xFF, 0xF8, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xF1, 0xE1, 0xC1, 0xC7, 0x01,
  0xCE, 0x03, 0x98, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC2, 0x1F, 0x8E, 0x3F,
  0x3E, 0x7E, 0x7C, 0xFC, 0x71, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1D, 0xC0, 0x73, 0x80, 0xE7, 0x81, 0xC7, 0x87, 0x07, 0xFC, 0x07, 0xF0,
  0x01, 0x00, 0x01, 0x80, 0x1C, 0x01, 0xE0, 0x1F, 0x03, 0xF8, 0x7D, 0xC1,
  0x8E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC1, 0xFF, 0xEF, 0xFF, 0x1F, 0xC0, 0x7F, 0xE3, 0xE3, 0xE3, 0x01,
  0xC4, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xFF,
  0xBF, 0xFF, 0x1F, 0xC0, 0xFF, 0xE1, 0xF3, 0xE1, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC8, 0x07, 0x9F, 0xFE, 0x7F, 0xF0, 0x02,
  0x00, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0D, 0xC0,
  0x0C, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x0E, 0x07, 0x07,
  0x03, 0x03, 0x83, 0x81, 0xC1, 0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0xF8, 0x1F,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3B, 0x01, 0xEF, 0xFF, 0x3F, 0xF0, 0x0E, 0x00,
  0x00, 0x08, 0x03, 0xF0, 0x0F, 0xF0, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0xBF, 0xC7, 0xFF, 0xCF, 0x03,
  0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x3B,
  0x80, 0x77, 0x01, 0xC7, 0x07, 0x87, 0xFE, 0x07, 0xF8, 0x01, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0xF1, 0xE3, 0x80,
  0xE7, 0x01, 0xCC, 0x01, 0x98, 0x03, 0x30, 0x06, 0x70, 0x1C, 0xF0, 0x30,
  0xF1, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0x0F, 0x1C, 0x07, 0x30, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEE, 0x07, 0x8F, 0xFE,
  0x0F, 0xF8, 0x03, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xE1, 0xE3, 0x81, 0xE6,
  0x01, 0xDC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3B, 0x80, 0x73, 0xFF, 0xE3, 0xFF, 0xC0, 0xC3, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0xF8, 0x1F, 0xE0, 0x3E,
  0x00, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFB,
  0xC0, 0x1C, 0x7C, 0xF9, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x8F, 0x9F, 0x3E, 0x7C, 0x38, 0xE3, 0xDF, 0x38, 0x00, 0x00, 0x06,
  0x00, 0x3C, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x1E, 0x00,
  0x20, 0x00, 0x00, 0x7F, 0x1F, 0xFB, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0,
  0x03, 0xF0, 0x0F, 0xF8, 0x1E, 0x3C, 0x3C, 0x0E, 0x38, 0x0E, 0x70, 0x06,
  0x70, 0x07, 0x70, 0x07, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC7, 0xE3, 0x87,
  0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x07,
  0xE3, 0x87, 0xE3, 0x87, 0x71, 0xFF, 0x70, 0xFF, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x84, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xDC, 0x00, 0x3B, 0x80, 0x06, 0x30,
  0x01, 0xC7, 0x00, 0x38, 0xE0, 0x06, 0x0C, 0x00, 0xC1, 0xC0, 0x38, 0x38,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0E, 0x06, 0x01, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x1C,
  0xE0, 0x03, 0x98, 0x00, 0x37, 0x00, 0x07, 0x7F, 0x81, 0xFF, 0xC3, 0xCF,
  0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x19,
  0xC0, 0x73, 0x8F, 0xC7, 0xFF, 0x0F, 0xFF, 0x9C, 0x07, 0xB8, 0x07, 0x70,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xDC, 0x0F,
  0xBF, 0xFE, 0x7F, 0xF0, 0x03, 0xF8, 0x1F, 0xFC, 0x7E, 0x79, 0xE0, 0x13,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xC3, 0xFF, 0x83,
  0xFF, 0x00, 0x40, 0x7E, 0x01, 0xFF, 0x83, 0xFF, 0xC7, 0x03, 0xCE, 0x03,
  0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x77, 0x00, 0xEE, 0x03, 0x9C, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0,
  0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xB0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xFF, 0xEF, 0xFF, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x03, 0xF8, 0x1F,
  0xFC, 0x7C, 0x79, 0xE0, 0x13, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0xC0, 0x33, 0x80,
  0x63, 0xC0, 0xC3, 0xFF, 0x83, 0xFF, 0x00, 0xC0, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x40, 0x39, 0x81, 0xEF, 0xFF, 0x0F, 0xF8, 0x02, 0x00, 0xC0, 0x0E,
  0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x78, 0xC0, 0xF0, 0xC0, 0xE0, 0xC1, 0xC0,
  0xC3, 0x80, 0xC7, 0x00, 0xCE, 0x00, 0xDC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xCF, 0x00, 0xC7, 0x80, 0xC3, 0xC0, 0xC1, 0xE0, 0xC0, 0xF0, 0xC0, 0x70,
  0xC0, 0x38, 0xC0, 0x3C, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x0F, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x83,
  0xC3, 0xC1, 0xF1, 0xE0, 0xF9, 0xF8, 0xEC, 0xEC, 0x66, 0x76, 0x33, 0x31,
  0xB9, 0x98, 0xD8, 0xCC, 0x6C, 0x66, 0x1E, 0x33, 0x0E, 0x19, 0x87, 0x0C,
  0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x00, 0xDC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFB, 0x03, 0xF7, 0x07, 0xE6, 0x0F,
  0xCE, 0x1F, 0x8C, 0x3F, 0x1C, 0x7E, 0x18, 0xFC, 0x39, 0xF8, 0x33, 0xF0,
  0x77, 0xE0, 0x6F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01,
  0xC7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x0C, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE3, 0x80,
  0xE1, 0xE0, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0x80, 0x00, 0x7F, 0x83,
  0xFF, 0x8F, 0xFF, 0x38, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0E, 0xE0, 0xF3, 0xFF, 0x8F, 0xF8,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01,
  0xC7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x0C, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE3, 0x80,
  0xE1, 0xE0, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x70, 0x7F, 0x01, 0xFF, 0xC3,
  0xFF, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0,
  0x70, 0x70, 0xE0, 0x61, 0xC0, 0xE3, 0x80, 0xE7, 0x01, 0xCE, 0x01, 0xDC,
  0x03, 0xB8, 0x03, 0xF0, 0x07, 0x07, 0xF0, 0x3F, 0xF8, 0xF8, 0xF3, 0xC0,
  0x47, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xCC, 0x07, 0xBF, 0xFE,
  0x1F, 0xF8, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x77, 0x01, 0xCF, 0x07, 0x8F, 0xFE, 0x0F, 0xF8, 0x01, 0x00,
  0xC0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x3B, 0x80, 0x0E, 0x60, 0x03, 0x9C,
  0x00, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x30, 0x06, 0x0E, 0x03, 0x83, 0x80,
  0xE0, 0x60, 0x38, 0x1C, 0x0C, 0x07, 0x07, 0x00, 0xC1, 0xC0, 0x30, 0x60,
  0x0E, 0x38, 0x03, 0x8E, 0x00, 0x63, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x00,
  0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x76, 0x00, 0x3B, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60,
  0x03, 0x30, 0x01, 0x98, 0x70, 0xCC, 0x38, 0x66, 0x36, 0x33, 0x1B, 0x19,
  0x8D, 0x8C, 0xCC, 0x66, 0x66, 0x33, 0x3B, 0x19, 0x9F, 0x07, 0xC7, 0x83,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xE0, 0x38, 0x70, 0x1C, 0xF0, 0x03, 0xB8,
  0x03, 0x8E, 0x03, 0x87, 0x01, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x38, 0xE0,
  0x1C, 0x70, 0x07, 0x70, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x3E,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x0E, 0x07,
  0x07, 0x07, 0x01, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x1C, 0x70, 0x07, 0x0E,
  0x03, 0x83, 0x80, 0xE0, 0x70, 0x70, 0x1C, 0x1C, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x1D, 0xC0, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x36, 0x00, 0xEE,
  0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x1C, 0x30, 0x18, 0xE0, 0x39, 0x80, 0x37,
  0x00, 0x74, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x63, 0xC7, 0x0E,
  0x1C, 0x30, 0x1F, 0xE0, 0xFF, 0xE3, 0x87, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0xF3, 0x1F, 0xFC, 0xFF, 0xF7, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x37, 0x00, 0xDE, 0x03, 0x3F, 0xFC, 0x7F, 0xF0, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xEF, 0xC3, 0xFF, 0x8F, 0x9F, 0x38, 0x0E, 0xE0, 0x3F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xB8, 0x3C, 0xFF, 0xE3, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xFC,
  0xFC, 0x71, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1F, 0x01, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x07, 0xCC, 0x7F, 0xF3,
  0xE7, 0xDC, 0x07, 0x70, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x37, 0x00, 0xCF, 0x03,
  0x1F, 0xFC, 0x3F, 0xF0, 0x07, 0xE0, 0x3F, 0xF0, 0xF1, 0xF3, 0xC0, 0xE7,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x02, 0x1F, 0xFC,
  0x1F, 0xF8, 0x03, 0xFE, 0x0F, 0xFC, 0x3C, 0x08, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xEF, 0xDE, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x37, 0x83, 0xCF, 0xFF, 0x1F, 0xFC, 0x04, 0x30, 0x01,
  0xC0, 0x07, 0x00, 0x1D, 0x01, 0xE7, 0xFF, 0x1F, 0xF8, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xDF, 0xC7,
  0xFF, 0x3E, 0x7D, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xC0, 0x06, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC1, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x83, 0xFF, 0xF7,
  0xFC, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x1D, 0x80, 0x73, 0x01, 0xC6, 0x07, 0x0C,
  0x1C, 0x18, 0xF0, 0x33, 0xC0, 0x6F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0x3C,
  0x06, 0x3C, 0x0C, 0x1C, 0x18, 0x1C, 0x30, 0x1C, 0x60, 0x1C, 0xC0, 0x1D,
  0x80, 0x1C, 0xFF, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC1, 0x03,
  0xFE, 0x03, 0xFC, 0x7C, 0x78, 0xFF, 0xFC, 0xC7, 0xCE, 0xC3, 0x86, 0xC3,
  0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3,
  0x87, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x7F, 0x87, 0xFF, 0x3E, 0x7D, 0x80, 0xFC, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x07, 0xC0, 0x3F,
  0xE0, 0xFB, 0xE3, 0x81, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xDC,
  0x07, 0x1E, 0x1C, 0x3F, 0xF0, 0x1F, 0xC0, 0x3F, 0x83, 0xFF, 0x8F, 0xBF,
  0x30, 0x1E, 0xC0, 0x3B, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x03, 0xBC, 0x1E, 0xFF,
  0xF3, 0x7F, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x07, 0xF0, 0x7F, 0xF3, 0xF7, 0xDE, 0x03, 0x70, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x37, 0x00, 0xDE, 0x0F, 0x3F, 0xFC, 0x3F, 0xB0, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x1F, 0xFF, 0xFF, 0xF8, 0x1E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x1F, 0xFB,
  0xFF, 0x9E, 0x0D, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x78, 0x07,
  0xFF, 0xF7, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x04, 0x3F, 0xF0, 0x3F, 0xC0, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x6F, 0x03, 0x3F,
  0xF8, 0xFF, 0xC0, 0xE0, 0x03, 0xB8, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE3,
  0x80, 0x61, 0xC0, 0x70, 0xE0, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x0E, 0x0E,
  0x03, 0x8E, 0x01, 0xC7, 0x00, 0x63, 0x00, 0x3B, 0x80, 0x0D, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x0E, 0x1D, 0x87, 0x0C, 0xC3, 0xC6, 0x63,
  0x63, 0x39, 0xB3, 0x9C, 0xDD, 0xCE, 0xC6, 0xE3, 0x63, 0x61, 0xF1, 0xF0,
  0xF0, 0x78, 0x78, 0x3C, 0x38, 0x0E, 0x0C, 0x06, 0x00, 0x70, 0x07, 0x3C,
  0x07, 0x0E, 0x03, 0x83, 0x83, 0x80, 0xE3, 0x80, 0x79, 0x80, 0x1D, 0xC0,
  0x07, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xEF, 0x00, 0xE3,
  0x80, 0xE0, 0xE0, 0xE0, 0x38, 0x70, 0x1C, 0x70, 0x07, 0x70, 0x01, 0xC0,
  0xE0, 0x07, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xC6, 0x03, 0x8E,
  0x07, 0x1C, 0x0E, 0x18, 0x38, 0x38, 0x70, 0x70, 0xE0, 0x71, 0x80, 0xE7,
  0x00, 0xCE, 0x01, 0xD8, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x1F, 0xC1, 0xF0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x80, 0xF8, 0x07, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xFF, 0x01, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x07,
  0xF0, 0x07, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xF8, 0x07, 0xC0, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x1F, 0xE0, 0xFE, 0x00, 0x08, 0x00, 0xFC, 0x0F, 0xFE, 0x1E, 0x1F, 0xFC,
  0x0F, 0xC0, 0x04, 0x00,
};

const GFXglyph UbuntuSansMono_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 24, 19, 7, -24 },
  { 16, 9, 9, 19, 5, -26 },
  { 27, 17, 24, 19, 1, -24 },
  { 78, 15, 30, 19, 2, -26 },
  { 135, 17, 25, 19, 1, -24 },
  { 189, 17, 24, 19, 1, -24 },
  { 240, 3, 10, 19, 8, -26 },
  { 244, 9, 33, 19, 5, -27 },
  { 282, 9, 33, 19, 5, -27 },
  { 320, 15, 14, 19, 2, -24 },
  { 347, 15, 16, 19, 2, -18 },
  { 377, 7, 10, 19, 6, -5 },
  { 386, 7, 3, 19, 6, -11 },
  { 389, 5, 5, 19, 7, -5 },
  { 393, 13, 33, 19, 3, -27 },
  { 447, 15, 25, 19, 2, -24 },
  { 494, 13, 24, 19, 3, -24 },
  { 533, 15, 24, 19, 2, -24 },
  { 578, 15, 25, 19, 2, -24 },
  { 625, 17, 24, 19, 1, -24 },
  { 676, 14, 25, 19, 3, -24 },
  { 720, 15, 25, 19, 2, -24 },
  { 767, 14, 24, 19, 3, -24 },
  { 809, 15, 25, 19, 2, -24 },
  { 856, 15, 24, 19, 2, -24 },
  { 901, 5, 18, 19, 7, -18 },
  { 913, 7, 23, 19, 5, -18 },
  { 934, 15, 15, 19, 2, -17 },
  { 963, 15, 10, 19, 2, -15 },
  { 982, 15, 15, 19, 2, -17 },
  { 1011, 11, 24, 19, 4, -24 },
  { 1044, 16, 29, 19, 2, -24 },
  { 1102, 19, 24, 19, 0, -24 },
  { 1159, 15, 24, 19, 2, -24 },
  { 1204, 15, 25, 19, 2, -24 },
  { 1251, 15, 24, 19, 2, -24 },
  { 1296, 14, 24, 19, 4, -24 },
  { 1338, 13, 24, 19, 4, -24 },
  { 1377, 15, 25, 19, 2, -24 },
  { 1424, 15, 24, 19, 2, -24 },
  { 1469, 11, 24, 19, 4, -24 },
  { 1502, 14, 25, 19, 2, -24 },
  { 1546, 16, 24, 19, 3, -24 },
  { 1594, 14, 24, 19, 4, -24 },
  { 1636, 17, 24, 19, 1, -24 },
  { 1687, 15, 24, 19, 2, -24 },
  { 1732, 17, 25, 19, 1, -24 },
  { 1786, 14, 24, 19, 3, -24 },
  { 1828, 17, 30, 19, 1, -24 },
  { 1892, 15, 24, 19, 2, -24 },
  { 1937, 15, 25, 19, 2, -24 },
  { 1984, 15, 24, 19, 2, -24 },
  { 2029, 15, 25, 19, 2, -24 },
  { 2076, 18, 24, 19, 1, -24 },
  { 2130, 17, 24, 19, 1, -24 },
  { 2181, 17, 24, 19, 1, -24 },
  { 2232, 18, 24, 19, 1, -24 },
  { 2286, 15, 24, 19, 2, -24 },
  { 2331, 8, 33, 19, 6, -27 },
  { 2364, 13, 33, 19, 3, -27 },
  { 2418, 8, 33, 19, 5, -27 },
  { 2451, 15, 13, 19, 2, -24 },
  { 2476, 19, 2, 19, 0, 4 },
  { 2481, 6, 6, 19, 6, -26 },
  { 2486, 14, 18, 19, 2, -18 },
  { 2518, 14, 26, 19, 3, -26 },
  { 2564, 15, 18, 19, 2, -18 },
  { 2598, 14, 26, 19, 2, -26 },
  { 2644, 15, 18, 19, 2, -18 },
  { 2678, 15, 26, 19, 3, -26 },
  { 2727, 14, 24, 19, 2, -18 },
  { 2769, 13, 26, 19, 3, -26 },
  { 2812, 15, 26, 19, 2, -26 },
  { 2861, 11, 32, 19, 3, -26 },
  { 2905, 15, 26, 19, 3, -26 },
  { 2954, 15, 26, 19, 2, -26 },
  { 3003, 16, 18, 19, 2, -18 },
  { 3039, 13, 18, 19, 3, -18 },
  { 3069, 15, 18, 19, 2, -18 },
  { 3103, 14, 24, 19, 3, -18 },
  { 3145, 14, 24, 19, 2, -18 },
  { 3187, 12, 18, 19, 4, -18 },
  { 3214, 13, 18, 19, 3, -18 },
  { 3244, 14, 23, 19, 3, -23 },
  { 3285, 13, 18, 19, 3, -18 },
  { 3315, 17, 18, 19, 1, -18 },
  { 3354, 17, 18, 19, 1, -18 },
  { 3393, 17, 18, 19, 1, -18 },
  { 3432, 15, 24, 19, 2, -18 },
  { 3477, 13, 18, 19, 3, -18 },
  { 3507, 13, 33, 19, 3, -27 },
  { 3561, 3, 33, 19, 8, -27 },
  { 3574, 13, 33, 19, 3, -27 },
  { 3628, 15, 6, 19, 2, -13 },
};

const GFXfont UbuntuSansMono_Regular34pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular34pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular34pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUSANSMONO_REGULAR34PT7B_H_
