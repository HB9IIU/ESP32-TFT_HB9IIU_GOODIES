#ifndef _UBUNTUSANSMONO_REGULAR8PT7B_H_
#define _UBUNTUSANSMONO_REGULAR8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x55, 0xF5, 0xFA, 0x56, 0x23, 0x90, 0x5D, 0xE3, 0x7B,
  0x66, 0x65, 0xB7, 0xC0, 0x6A, 0xA4, 0x95, 0x5C, 0x55, 0x70, 0x2F, 0x22,
  0x70, 0xC0, 0x80, 0x29, 0x29, 0x20, 0x25, 0x9B, 0x96, 0x59, 0x25, 0xC0,
  0xC4, 0xA9, 0xC0, 0xC4, 0xB3, 0xC0, 0x12, 0x59, 0xF1, 0xF2, 0x33, 0xC0,
  0x34, 0xAD, 0x97, 0xE5, 0x25, 0x00, 0x69, 0x57, 0x97, 0x69, 0x97, 0x16,
  0x90, 0x41, 0xC0, 0x3C, 0x30, 0xFF, 0xC3, 0xE0, 0xC5, 0x21, 0x80, 0x25,
  0xBB, 0xB5, 0x70, 0x26, 0x55, 0xF9, 0x69, 0x9F, 0x9F, 0x34, 0x88, 0x87,
  0x69, 0x99, 0x9E, 0xF2, 0x79, 0xC0, 0xF2, 0x79, 0x00, 0x34, 0x89, 0x97,
  0x99, 0x9F, 0x99, 0xE9, 0x25, 0xC0, 0xE4, 0x93, 0x80, 0xB7, 0x6B, 0x40,
  0x92, 0x49, 0xC0, 0x55, 0x5B, 0x99, 0xB6, 0xFB, 0x40, 0x69, 0x99, 0x97,
  0xD6, 0xE9, 0x00, 0x69, 0x99, 0x95, 0x30, 0x69, 0x9E, 0xA9, 0xF2, 0x23,
  0xC0, 0xF2, 0x22, 0x22, 0x99, 0x99, 0x97, 0x99, 0x95, 0x62, 0x99, 0x9B,
  0x55, 0x95, 0x62, 0x59, 0x99, 0x52, 0x22, 0x71, 0x24, 0x4F, 0xEA, 0xAC,
  0x92, 0x24, 0x88, 0xD5, 0x5C, 0x26, 0xD0, 0xF0, 0xC0, 0xEE, 0xF0, 0x93,
  0xDB, 0xC0, 0x78, 0x87, 0x11, 0x79, 0x97, 0x7F, 0x87, 0x73, 0xC9, 0x00,
  0x79, 0x97, 0x16, 0x93, 0xDB, 0x40, 0x83, 0x24, 0xC0, 0x4D, 0x56, 0x92,
  0xED, 0x40, 0xC9, 0x24, 0xC0, 0xFB, 0x99, 0xF6, 0xD0, 0x79, 0x97, 0xF6,
  0xF8, 0x79, 0x97, 0x10, 0xF2, 0x40, 0xF8, 0xF0, 0x9E, 0x46, 0xB6, 0xF0,
  0x95, 0x62, 0x9B, 0x55, 0xD2, 0x69, 0x95, 0x52, 0x2C, 0xEA, 0x70, 0x69,
  0x48, 0x98, 0xFE, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph UbuntuSansMono_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 6, 4, 2, -6 },
  { 2, 2, 2, 4, 1, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 7, 4, 1, -6 },
  { 9, 4, 6, 4, 0, -6 },
  { 12, 4, 6, 4, 0, -6 },
  { 15, 1, 2, 4, 2, -6 },
  { 16, 2, 7, 4, 1, -6 },
  { 18, 2, 7, 4, 1, -6 },
  { 20, 3, 4, 4, 1, -6 },
  { 22, 4, 4, 4, 0, -4 },
  { 24, 2, 2, 4, 1, -1 },
  { 25, 2, 1, 4, 1, -3 },
  { 26, 1, 1, 4, 2, -1 },
  { 27, 3, 7, 4, 1, -6 },
  { 30, 4, 6, 4, 0, -6 },
  { 33, 3, 6, 4, 1, -6 },
  { 36, 3, 6, 4, 1, -6 },
  { 39, 3, 6, 4, 1, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 3, 6, 4, 1, -6 },
  { 48, 4, 6, 4, 0, -6 },
  { 51, 3, 6, 4, 1, -6 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 1, 4, 4, 2, -4 },
  { 61, 2, 5, 4, 1, -4 },
  { 63, 4, 3, 4, 0, -4 },
  { 65, 4, 2, 4, 0, -3 },
  { 66, 4, 3, 4, 0, -4 },
  { 68, 3, 6, 4, 1, -6 },
  { 71, 4, 7, 4, 0, -6 },
  { 75, 4, 6, 4, 0, -6 },
  { 78, 4, 6, 4, 0, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 4, 6, 4, 0, -6 },
  { 87, 3, 6, 4, 1, -6 },
  { 90, 3, 6, 4, 1, -6 },
  { 93, 4, 6, 4, 0, -6 },
  { 96, 4, 6, 4, 0, -6 },
  { 99, 3, 6, 4, 1, -6 },
  { 102, 3, 6, 4, 1, -6 },
  { 105, 3, 6, 4, 1, -6 },
  { 108, 3, 6, 4, 1, -6 },
  { 111, 4, 6, 4, 0, -6 },
  { 114, 3, 6, 4, 1, -6 },
  { 117, 4, 6, 4, 0, -6 },
  { 120, 3, 6, 4, 1, -6 },
  { 123, 4, 7, 4, 0, -6 },
  { 127, 4, 6, 4, 0, -6 },
  { 130, 3, 6, 4, 1, -6 },
  { 133, 4, 6, 4, 0, -6 },
  { 136, 4, 6, 4, 0, -6 },
  { 139, 4, 6, 4, 0, -6 },
  { 142, 4, 6, 4, 0, -6 },
  { 145, 4, 6, 4, 0, -6 },
  { 148, 4, 6, 4, 0, -6 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 2, 7, 4, 1, -6 },
  { 156, 3, 7, 4, 1, -6 },
  { 159, 2, 7, 4, 1, -6 },
  { 161, 4, 3, 4, 0, -6 },
  { 163, 4, 1, 4, 0, 1 },
  { 164, 2, 1, 4, 1, -6 },
  { 165, 3, 4, 4, 1, -4 },
  { 167, 3, 6, 4, 1, -6 },
  { 170, 4, 4, 4, 0, -4 },
  { 172, 4, 6, 4, 0, -6 },
  { 175, 4, 4, 4, 0, -4 },
  { 177, 3, 6, 4, 1, -6 },
  { 180, 4, 6, 4, 0, -4 },
  { 183, 3, 6, 4, 1, -6 },
  { 186, 3, 6, 4, 1, -6 },
  { 189, 2, 8, 4, 1, -6 },
  { 191, 3, 6, 4, 1, -6 },
  { 194, 3, 6, 4, 1, -6 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 3, 4, 4, 1, -4 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 3, 5, 4, 1, -4 },
  { 205, 4, 5, 4, 0, -4 },
  { 208, 3, 4, 4, 1, -4 },
  { 210, 3, 4, 4, 1, -4 },
  { 212, 3, 5, 4, 1, -5 },
  { 214, 3, 4, 4, 1, -4 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 4, 4, 4, 0, -4 },
  { 220, 4, 4, 4, 0, -4 },
  { 222, 4, 6, 4, 0, -4 },
  { 225, 3, 4, 4, 1, -4 },
  { 227, 3, 7, 4, 1, -6 },
  { 230, 1, 7, 4, 2, -6 },
  { 231, 3, 7, 4, 1, -6 },
  { 234, 4, 1, 4, 0, -3 },
};

const GFXfont UbuntuSansMono_Regular8pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular8pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUSANSMONO_REGULAR8PT7B_H_
