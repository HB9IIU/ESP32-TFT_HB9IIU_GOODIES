#ifndef _UBUNTUSANSMONO_REGULAR61PT7B_H_
#define _UBUNTUSANSMONO_REGULAR61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x38, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x07,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x03, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x78, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0xFE, 0x00, 0x38, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFD, 0x00, 0x00, 0x3E,
  0x70, 0x00, 0x3F, 0x9F, 0xC0, 0x7F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x3F, 0xF8, 0x00, 0x7C, 0x3C, 0x7C,
  0x00, 0x78, 0x78, 0x3C, 0x00, 0xF8, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x1E,
  0x01, 0xE0, 0x70, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x1E,
  0x1F, 0x00, 0x70, 0x1E, 0x1E, 0x00, 0x78, 0x1E, 0x3E, 0x00, 0x78, 0x1C,
  0x3C, 0x00, 0x78, 0x3C, 0x78, 0x00, 0x3C, 0x7C, 0xF8, 0x00, 0x3F, 0xF8,
  0xF0, 0x00, 0x1F, 0xF1, 0xF0, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x0F,
  0x8F, 0xF8, 0x00, 0x0F, 0x1F, 0xFC, 0x00, 0x1E, 0x3E, 0x3C, 0x00, 0x3E,
  0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x1E, 0x00, 0x7C, 0x78, 0x0E, 0x00, 0x78,
  0x78, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x07, 0x80,
  0x78, 0x0F, 0x0F, 0x80, 0x78, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x1F, 0x00,
  0x3C, 0x1E, 0x1E, 0x00, 0x1E, 0x3C, 0x3C, 0x00, 0x1F, 0xFC, 0x7C, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x01,
  0x00, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x03, 0xEF, 0xC0, 0x78,
  0x1F, 0x1F, 0x81, 0xE0, 0xFC, 0x3F, 0x07, 0x83, 0xE0, 0x7E, 0x3C, 0x1F,
  0x80, 0xFC, 0xF0, 0x7C, 0x01, 0xFB, 0xC1, 0xF0, 0x07, 0xEF, 0x07, 0xC0,
  0x0F, 0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x3F,
  0xC1, 0xF8, 0x01, 0xFF, 0x83, 0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xFE, 0x7C,
  0x1F, 0xFF, 0xF1, 0xF8, 0x1F, 0xFF, 0x03, 0xE0, 0x3F, 0xF0, 0x07, 0xC0,
  0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF0, 0x00, 0x02, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01,
  0xC0, 0x00, 0x30, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x02,
  0x01, 0xE0, 0x11, 0xE0, 0x78, 0x1E, 0x7E, 0x1E, 0x1F, 0x9F, 0xF3, 0x9F,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x7C, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0x78, 0x07, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0x83, 0xFC,
  0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0x80,
  0x7C, 0x07, 0xC0, 0x7E, 0x0F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xC0,
  0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E,
  0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x03, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0xF8, 0x3F,
  0xFC, 0x1F, 0x83, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x3F, 0xC1, 0xFF, 0xC3,
  0xFC, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x0F, 0x83,
  0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xDF, 0x00, 0xFF, 0x1F, 0x00, 0xFC, 0x1F,
  0x00, 0x70, 0x1F, 0x00, 0x40, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0x00, 0x1F, 0x83, 0x80, 0x03, 0xF0,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0x03,
  0xFE, 0x06, 0x00, 0x1F, 0x81, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE7, 0x00, 0x07, 0xF1, 0xFE, 0x3F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x78,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x02, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE4, 0x00, 0x03,
  0xF3, 0x80, 0x07, 0xF1, 0xFE, 0x7F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x03, 0xE7, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xE3, 0xFE, 0x3F, 0x80,
  0x0F, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07,
  0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x3C, 0x3F, 0x00,
  0x1F, 0x0F, 0xE0, 0x0F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0xE7, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x1F, 0xF8,
  0x1F, 0x00, 0xFF, 0x0F, 0x80, 0x0F, 0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7, 0xF0, 0x03,
  0xF8, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7E, 0x00,
  0x07, 0xCF, 0xE0, 0x0F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1E, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x3F,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x9F, 0xE7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xF7, 0xF8, 0xFC, 0x0E, 0x00, 0x03, 0xC0, 0x3F, 0x83, 0xFC,
  0x1F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xE0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x07, 0xF0,
  0x7F, 0x83, 0xFE, 0x1F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0xC1, 0xFC, 0x7F, 0xC3, 0xFC, 0x1F, 0xC0,
  0xF8, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0x00, 0xFE,
  0x20, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xC1,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0xFF, 0xEF, 0x80, 0x1F, 0xFF, 0x7C, 0x03, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF,
  0xDF, 0x03, 0xF8, 0x3E, 0xF8, 0x1F, 0x01, 0xFF, 0xC1, 0xF8, 0x0F, 0xFE,
  0x0F, 0x80, 0x7F, 0xF0, 0xFC, 0x03, 0xFF, 0x87, 0xC0, 0x1F, 0xFC, 0x3E,
  0x00, 0xFF, 0xE1, 0xF0, 0x07, 0xFF, 0x0F, 0x80, 0x3F, 0xF8, 0x7C, 0x01,
  0xFF, 0xC3, 0xE0, 0x0F, 0xFE, 0x1F, 0x00, 0x7F, 0xF0, 0xF8, 0x03, 0xEF,
  0x87, 0xE0, 0x1F, 0x7C, 0x1F, 0x00, 0xFB, 0xE0, 0xF8, 0x07, 0xDF, 0x83,
  0xE0, 0x3E, 0xFC, 0x1F, 0x81, 0xF3, 0xE0, 0x7F, 0xFF, 0x9F, 0x01, 0xFF,
  0xFC, 0xFC, 0x07, 0xFF, 0xE3, 0xE0, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x30, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0x3E,
  0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xF8,
  0x0F, 0xFC, 0x3C, 0x00, 0x3F, 0x8F, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0xFC,
  0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x78, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x3F, 0x0F, 0x00, 0x7F, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xC0, 0x03, 0xFC, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xBC, 0x00,
  0x0F, 0xEF, 0x00, 0x0F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x03, 0x83, 0xF0, 0x00, 0x10, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x83, 0xFC, 0x00, 0x70, 0x3F, 0xFD, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x0F, 0xCF, 0xFF, 0x81, 0xE0, 0x07, 0xF8, 0x3C, 0x00, 0x3F, 0x87, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x3E,
  0x78, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0,
  0x00, 0x0F, 0xDE, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7E, 0x78, 0x00, 0x1F,
  0x8F, 0x00, 0x07, 0xE1, 0xE0, 0x01, 0xFC, 0x3C, 0x01, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x80,
  0x7C, 0x0F, 0xC0, 0x03, 0x03, 0xF0, 0x00, 0x20, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF8, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xC1, 0xFC, 0x00, 0xF8, 0x3F, 0xF0, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x60, 0x00, 0x7E, 0x78, 0x00, 0xFC, 0xFF, 0x07, 0xFC, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xF8, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x1F,
  0x00, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x01,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x1F, 0x80,
  0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xEF, 0xF0, 0x00, 0x1F, 0x1F, 0xC0,
  0x00, 0xF8, 0x7F, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x3E, 0x07, 0xF0, 0x01,
  0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03,
  0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC,
  0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0xFF, 0x07, 0x78, 0x07, 0xBC, 0x1D, 0xE0, 0x1E, 0xF0, 0x77,
  0x80, 0x7B, 0xC3, 0xCF, 0x01, 0xCF, 0x0F, 0x3C, 0x0F, 0x3C, 0x3C, 0xF0,
  0x3C, 0xF0, 0xF1, 0xE0, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E,
  0x3C, 0x3C, 0x3C, 0x70, 0xF0, 0xF0, 0xF3, 0xC3, 0xE3, 0xC3, 0xCF, 0x0F,
  0x8F, 0x07, 0xB8, 0x3E, 0x3C, 0x1F, 0xE0, 0xF9, 0xF0, 0x3F, 0x83, 0xE7,
  0xC0, 0xFE, 0x0F, 0x9F, 0x03, 0xF0, 0x3E, 0x7C, 0x07, 0xC0, 0xF9, 0xF0,
  0x1F, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0x7C, 0x00,
  0x00, 0x79, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xDF, 0x00, 0x0F, 0xF7, 0xC0, 0x03, 0xFC, 0xF8, 0x00, 0xFF,
  0x3E, 0x00, 0x3F, 0xC7, 0xC0, 0x0F, 0xF1, 0xF0, 0x03, 0xFC, 0x3E, 0x00,
  0xFF, 0x0F, 0x80, 0x3F, 0xC1, 0xF0, 0x0F, 0xF0, 0x7C, 0x03, 0xFC, 0x0F,
  0x80, 0xFF, 0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x0F, 0xF0, 0x1F, 0x03, 0xFC,
  0x03, 0xE0, 0xFF, 0x00, 0xF8, 0x3F, 0xC0, 0x1E, 0x0F, 0xF0, 0x07, 0xC3,
  0xFC, 0x00, 0xF0, 0xFF, 0x00, 0x3E, 0x3F, 0xC0, 0x07, 0x8F, 0xF0, 0x01,
  0xE3, 0xFC, 0x00, 0x7C, 0xFF, 0x00, 0x0F, 0x3F, 0xC0, 0x03, 0xEF, 0xF0,
  0x00, 0x7B, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x00, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0x0F, 0xFE, 0x3E, 0x00, 0x1F,
  0x8F, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x3F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xE1, 0xFF, 0xC1, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0,
  0x07, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x01, 0x83, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x98, 0x00, 0x07, 0xE7, 0x80, 0x03, 0xF9, 0xFE, 0x07, 0xFC,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x78, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x07,
  0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x01,
  0xF0, 0x07, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x7C, 0x1E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0x7C,
  0x07, 0x80, 0xF9, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x03,
  0xF0, 0x3E, 0x7C, 0x1F, 0xE0, 0xF9, 0xF0, 0x7F, 0x83, 0xC3, 0xC1, 0xCE,
  0x0F, 0x0F, 0x0F, 0x3C, 0x3C, 0x3C, 0x3C, 0xF0, 0xF0, 0xF0, 0xE1, 0xC3,
  0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x70, 0x38, 0xF0,
  0xF3, 0xC0, 0xF3, 0xC3, 0xCF, 0x03, 0xCF, 0x0F, 0x3C, 0x0F, 0x3C, 0x3D,
  0xE0, 0x1E, 0xF0, 0xF7, 0x80, 0x7B, 0x81, 0xDE, 0x01, 0xEE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F,
  0x80, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF3, 0x00, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x07, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x06, 0x00, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xC0, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x03, 0xFF, 0xBC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x9F, 0xE0, 0x1F, 0xDF, 0xC0, 0x01, 0xEF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0xE0, 0x00,
  0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE7, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xF8, 0xFE, 0x00,
  0x7E, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x1F,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x01, 0xC0, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x06, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFD, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x01, 0xFF, 0x9F, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x01,
  0xF3, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0xDF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3F,
  0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF0, 0xFE, 0x00, 0x7C, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0xE0, 0x0F, 0x80, 0x02, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xF0, 0x1F, 0xC7, 0xE0,
  0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F,
  0x3F, 0x00, 0x07, 0xCF, 0xE0, 0x07, 0xF1, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFC, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE3, 0x80, 0x07,
  0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFB,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0x01, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x30, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x80, 0x03,
  0xE7, 0x00, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x81, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x07, 0xC0,
  0x7E, 0x00, 0xF8, 0x3F, 0x80, 0x1F, 0x0F, 0xC0, 0x03, 0xE3, 0xF0, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFB, 0xFC, 0x00, 0x1F, 0x3F, 0xC0, 0x03,
  0xE1, 0xFC, 0x00, 0x7C, 0x1F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x1F,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xFD, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF8, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0xF0, 0x7F, 0x07,
  0xFF, 0xCF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0x81,
  0xF8, 0x3F, 0x7C, 0x0F, 0x80, 0xFB, 0xE0, 0x3C, 0x03, 0xDF, 0x01, 0xF0,
  0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F,
  0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0,
  0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C,
  0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0xFC, 0x03, 0xFC, 0x3E, 0x00, 0x3F, 0x8F, 0x80, 0x03, 0xF3, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07,
  0xCF, 0xC0, 0x03, 0xF3, 0xFC, 0x03, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xEF, 0xFF, 0x00, 0xF8, 0x7E, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xF0, 0x0F,
  0xC7, 0xF0, 0x01, 0xF3, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x7E, 0x00,
  0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xDF, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFC, 0x00, 0x0B, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0x00, 0x0C, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x40, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x87, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x0C, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3F,
  0x80, 0x1F, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0x3E, 0x7C, 0x03, 0xC0, 0x3E, 0x3C, 0x03, 0xE0, 0x3E, 0x3C, 0x03, 0xE0,
  0x3C, 0x3C, 0x07, 0xE0, 0x3C, 0x3E, 0x07, 0xE0, 0x3C, 0x3E, 0x07, 0xF0,
  0x3C, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF0, 0x7C, 0x1E, 0x0E, 0x78,
  0x78, 0x1E, 0x1E, 0x78, 0x78, 0x1F, 0x1E, 0x78, 0x78, 0x1F, 0x3C, 0x3C,
  0x78, 0x1F, 0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x1E, 0xF8, 0x0F, 0x78, 0x1E,
  0xF0, 0x0F, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F,
  0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x06, 0x1F, 0xFC, 0x00, 0xF3, 0xFF, 0xE0, 0x0F, 0x7C, 0xFF, 0x81, 0xE7,
  0x81, 0xFE, 0x3E, 0xF0, 0x07, 0xFF, 0xCF, 0x00, 0x3F, 0xFC, 0x60, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xC0,
};

const GFXglyph UbuntuSansMono_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 8, 43, 34, 13, -42 },
  { 44, 14, 16, 34, 10, -46 },
  { 72, 30, 42, 34, 2, -42 },
  { 230, 26, 54, 34, 4, -47 },
  { 406, 32, 44, 34, 1, -43 },
  { 582, 30, 44, 34, 2, -43 },
  { 747, 5, 17, 34, 15, -46 },
  { 758, 18, 59, 34, 8, -48 },
  { 891, 18, 59, 34, 8, -48 },
  { 1024, 26, 24, 34, 4, -42 },
  { 1102, 28, 30, 34, 3, -33 },
  { 1207, 13, 19, 34, 11, -9 },
  { 1238, 14, 5, 34, 10, -20 },
  { 1247, 10, 10, 34, 12, -9 },
  { 1260, 24, 59, 34, 5, -48 },
  { 1437, 28, 44, 34, 3, -43 },
  { 1591, 24, 42, 34, 6, -42 },
  { 1717, 26, 43, 34, 4, -43 },
  { 1857, 26, 44, 34, 4, -43 },
  { 2000, 29, 42, 34, 3, -42 },
  { 2153, 25, 43, 34, 5, -42 },
  { 2288, 27, 44, 34, 4, -43 },
  { 2437, 26, 42, 34, 5, -42 },
  { 2574, 26, 44, 34, 4, -43 },
  { 2717, 26, 43, 34, 4, -43 },
  { 2857, 10, 33, 34, 12, -32 },
  { 2899, 13, 42, 34, 9, -32 },
  { 2968, 28, 27, 34, 3, -31 },
  { 3063, 28, 17, 34, 3, -26 },
  { 3123, 27, 27, 34, 4, -31 },
  { 3215, 21, 44, 34, 7, -43 },
  { 3331, 29, 52, 34, 3, -43 },
  { 3520, 33, 42, 34, 1, -42 },
  { 3694, 26, 43, 34, 4, -43 },
  { 3834, 27, 44, 34, 4, -43 },
  { 3983, 27, 43, 34, 4, -43 },
  { 4129, 24, 42, 34, 7, -42 },
  { 4255, 23, 42, 34, 7, -42 },
  { 4376, 27, 44, 34, 4, -43 },
  { 4525, 28, 42, 34, 3, -42 },
  { 4672, 20, 42, 34, 7, -42 },
  { 4777, 24, 43, 34, 4, -42 },
  { 4906, 29, 42, 34, 5, -42 },
  { 5059, 24, 42, 34, 7, -42 },
  { 5185, 30, 42, 34, 2, -42 },
  { 5343, 26, 42, 34, 4, -42 },
  { 5480, 30, 44, 34, 2, -43 },
  { 5645, 26, 43, 34, 5, -43 },
  { 5785, 30, 54, 34, 2, -43 },
  { 5988, 27, 43, 34, 4, -43 },
  { 6134, 26, 44, 34, 4, -43 },
  { 6277, 28, 42, 34, 3, -42 },
  { 6424, 28, 43, 34, 3, -42 },
  { 6575, 32, 42, 34, 1, -42 },
  { 6743, 30, 42, 34, 2, -42 },
  { 6901, 30, 42, 34, 2, -42 },
  { 7059, 32, 42, 34, 1, -42 },
  { 7227, 27, 42, 34, 4, -42 },
  { 7369, 16, 59, 34, 10, -48 },
  { 7487, 24, 59, 34, 5, -48 },
  { 7664, 16, 59, 34, 8, -48 },
  { 7782, 28, 22, 34, 3, -42 },
  { 7859, 33, 4, 34, 1, 7 },
  { 7876, 11, 12, 34, 11, -47 },
  { 7893, 25, 33, 34, 4, -32 },
  { 7997, 26, 48, 34, 5, -47 },
  { 8153, 28, 33, 34, 3, -32 },
  { 8269, 26, 48, 34, 3, -47 },
  { 8425, 28, 33, 34, 3, -32 },
  { 8541, 28, 47, 34, 5, -47 },
  { 8706, 26, 43, 34, 3, -32 },
  { 8846, 24, 47, 34, 5, -47 },
  { 8987, 26, 47, 34, 4, -46 },
  { 9140, 21, 58, 34, 5, -46 },
  { 9293, 27, 47, 34, 5, -47 },
  { 9452, 26, 48, 34, 4, -47 },
  { 9608, 29, 32, 34, 3, -32 },
  { 9724, 24, 32, 34, 5, -32 },
  { 9820, 28, 33, 34, 3, -32 },
  { 9936, 26, 43, 34, 5, -32 },
  { 10076, 26, 43, 34, 3, -32 },
  { 10216, 22, 32, 34, 8, -32 },
  { 10304, 24, 33, 34, 5, -32 },
  { 10403, 25, 43, 34, 5, -42 },
  { 10538, 24, 33, 34, 5, -32 },
  { 10637, 30, 32, 34, 2, -32 },
  { 10757, 32, 32, 34, 1, -32 },
  { 10885, 30, 32, 34, 2, -32 },
  { 11005, 28, 43, 34, 3, -32 },
  { 11156, 24, 32, 34, 5, -32 },
  { 11252, 23, 59, 34, 6, -48 },
  { 11422, 4, 59, 34, 15, -48 },
  { 11452, 23, 59, 34, 5, -48 },
  { 11622, 28, 10, 34, 3, -23 },
};

const GFXfont UbuntuSansMono_Regular61pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular61pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular61pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _UBUNTUSANSMONO_REGULAR61PT7B_H_
