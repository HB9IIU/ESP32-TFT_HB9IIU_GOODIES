#ifndef _UBUNTUSANSMONO_REGULAR49PT7B_H_
#define _UBUNTUSANSMONO_REGULAR49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xCF, 0xFF, 0xFF, 0xFE, 0xF8, 0x40, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x0E, 0xE0, 0x6E, 0x06, 0xE0,
  0x6E, 0x06, 0xC0, 0x60, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x3C, 0x00, 0xE0,
  0x38, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0xF0, 0x07, 0x80, 0xE0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x01, 0xE0, 0x0F, 0x01,
  0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x1C, 0x07, 0x80, 0x1C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0x03,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x60, 0x01,
  0xF3, 0xE0, 0x3F, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xCF, 0xF0, 0x03,
  0xCF, 0x1C, 0x01, 0xC7, 0x0E, 0x01, 0xE7, 0x87, 0x81, 0xE3, 0x81, 0xC0,
  0xE1, 0xC0, 0xE0, 0xF0, 0xE0, 0x70, 0x70, 0x70, 0x38, 0x78, 0x38, 0x1C,
  0x78, 0x1C, 0x0E, 0x38, 0x07, 0x0F, 0x3C, 0x03, 0x87, 0x1C, 0x01, 0xE7,
  0x9E, 0x00, 0x7F, 0x9E, 0x00, 0x1F, 0x8E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x8F, 0x80, 0x07, 0x9F, 0xE0, 0x03, 0x8F, 0x78,
  0x03, 0xCF, 0x1E, 0x01, 0xC7, 0x07, 0x01, 0xE3, 0x83, 0x81, 0xE1, 0xC1,
  0xC0, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x70, 0x70, 0x38, 0x38, 0x78, 0x1C,
  0x1C, 0x78, 0x0E, 0x0E, 0x38, 0x07, 0x07, 0x3C, 0x03, 0xC7, 0x1C, 0x00,
  0xFF, 0x9E, 0x00, 0x3F, 0x80, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0x07, 0x80, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x1C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x3C, 0x1F, 0xF0, 0x38, 0x1E, 0xF8, 0x38, 0x3C, 0x7C, 0x38, 0x78,
  0x3C, 0x38, 0x78, 0x3E, 0x38, 0xF8, 0x1F, 0x70, 0xF0, 0x0F, 0xF0, 0xF0,
  0x07, 0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF8,
  0x03, 0xF8, 0x7C, 0x07, 0xF8, 0x7E, 0x1F, 0xFC, 0x3F, 0xFF, 0x3C, 0x1F,
  0xFE, 0x1E, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE,
  0x00, 0x30, 0x01, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0x00, 0x60,
  0x01, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x20,
  0x38, 0x09, 0xE1, 0xC1, 0xCF, 0xCE, 0x7F, 0xFF, 0xBF, 0xFB, 0xFF, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xEF, 0x00, 0x1F,
  0x3C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x03, 0x80, 0xE0,
  0x04, 0x02, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x87, 0xE1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x0F, 0x07, 0x83, 0xE1, 0xF3, 0xF8,
  0xFC, 0x3E, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x7E,
  0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0x07, 0xE0,
  0xF8, 0x07, 0x83, 0xC0, 0x1F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0,
  0x01, 0xEF, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x07, 0x87, 0xFC, 0x3E, 0x1F, 0xF0, 0xFC, 0x7F, 0xC3, 0xF1, 0xFF,
  0x0F, 0xC3, 0xFC, 0x3E, 0x1F, 0xF0, 0x70, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0xF0, 0x07, 0xC3, 0xE0, 0x1E, 0x07,
  0xC1, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0xE0, 0x1F, 0x9C, 0x07, 0xE3, 0x80, 0xF0, 0x70, 0x08, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x01, 0xF8,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xC0, 0x7E, 0x38,
  0x01, 0xF0, 0x80, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x70, 0x0F, 0xC4, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xEE,
  0x00, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0x70, 0x00,
  0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x1E, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E,
  0x0E, 0x00, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x60, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x83, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x07, 0x7F, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xF0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00,
  0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x7C,
  0x00, 0xF8, 0xF0, 0x03, 0xC1, 0xF0, 0x1F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xE0, 0x3E, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xE7, 0x80, 0x0F, 0x3E,
  0x00, 0x78, 0xF8, 0x07, 0x83, 0xF0, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3E, 0x3F, 0xC3, 0xE0, 0x3F, 0x3E, 0x00, 0xF9, 0xE0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x80,
  0x3E, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0,
  0x3E, 0x3E, 0x00, 0xF1, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x7C, 0x00, 0x79, 0xF0, 0x07, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x7E, 0xFE, 0xFF,
  0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x7E, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0x0F, 0x81,
  0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x07, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x0F, 0xC0, 0x78, 0x0F, 0x03,
  0xC1, 0xF9, 0xFE, 0x3F, 0x87, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE6, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0,
  0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3E,
  0x0F, 0xF0, 0xF8, 0x1F, 0xE1, 0xE0, 0x3F, 0xC3, 0xC0, 0x7F, 0x87, 0x80,
  0xFF, 0x1F, 0x01, 0xFE, 0x3C, 0x03, 0xFC, 0x78, 0x07, 0xF8, 0xF8, 0x0F,
  0xF0, 0xF0, 0x1F, 0xE1, 0xE0, 0x3F, 0xC3, 0xC0, 0x7F, 0xC7, 0xC0, 0xFF,
  0x87, 0x81, 0xEF, 0x07, 0xEF, 0xDE, 0x07, 0xFF, 0xBE, 0x07, 0xFE, 0x3C,
  0x00, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x08, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07, 0x80,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xE0, 0x1F, 0x8F, 0x00, 0x3E,
  0x78, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x03, 0xE3,
  0xC1, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3C, 0x01,
  0xF9, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x1F, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xC0, 0x38, 0x7E, 0x00, 0x21, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x83, 0xF0, 0x06, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3C, 0x0F, 0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x0F,
  0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00,
  0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x03, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xF3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xC0, 0x38, 0x7E, 0x00, 0x21, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x3E, 0x00, 0x3C,
  0x78, 0x00, 0xF1, 0xF0, 0x03, 0xC3, 0xF0, 0x0F, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE6, 0x00,
  0x3E, 0x70, 0x07, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x07, 0xC7, 0x80,
  0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x78, 0x0F,
  0x80, 0xF0, 0x3E, 0x01, 0xE0, 0xF8, 0x03, 0xC3, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xDF, 0x80, 0x07, 0x8F, 0x80, 0x0F,
  0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x81, 0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00,
  0x1F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x01, 0xDC, 0x3F, 0x81, 0xDC, 0x3B, 0x81, 0xDC, 0x7B, 0x83, 0x9C, 0x7B,
  0xC3, 0x9C, 0x71, 0xC3, 0x9C, 0x71, 0xC7, 0x1C, 0x71, 0xE7, 0x1C, 0x70,
  0xE7, 0x1E, 0x70, 0xEE, 0x1E, 0x70, 0x7E, 0x1E, 0x70, 0x7E, 0x1E, 0x70,
  0x7C, 0x1E, 0x70, 0x3C, 0x1E, 0x70, 0x3C, 0x1E, 0x70, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0xF0, 0x07, 0xF7, 0x80, 0x3F, 0x9E,
  0x01, 0xFC, 0xF0, 0x0F, 0xE3, 0xC0, 0x7F, 0x1E, 0x03, 0xF8, 0x78, 0x1F,
  0xC3, 0xC0, 0xFE, 0x0F, 0x07, 0xF0, 0x78, 0x3F, 0x81, 0xC1, 0xFC, 0x0F,
  0x0F, 0xE0, 0x38, 0x7F, 0x01, 0xE3, 0xF8, 0x07, 0x1F, 0xC0, 0x3C, 0xFE,
  0x01, 0xE7, 0xF0, 0x07, 0x3F, 0x80, 0x3D, 0xFC, 0x00, 0xEF, 0xE0, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3C,
  0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xE0, 0x1F, 0xCF, 0x00, 0x3E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3E, 0xF0,
  0x03, 0xE7, 0x80, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x18, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3C, 0x03, 0xF0, 0xF0, 0x03,
  0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0xF0, 0x07, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x0F,
  0x00, 0xF0, 0x3C, 0x01, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xF0, 0x0E, 0x1E, 0x00,
  0x10, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3D, 0x00, 0x03, 0xCF, 0x00, 0x7E, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x07,
  0xBC, 0x00, 0x1E, 0x78, 0x00, 0xF9, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0,
  0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x1E, 0x01, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x0E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1D, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x3C, 0x1E, 0x70, 0x7C, 0x1E, 0x70,
  0x7C, 0x1E, 0x70, 0x7E, 0x1E, 0x70, 0xEE, 0x1E, 0x70, 0xEE, 0x1C, 0x70,
  0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x9C, 0x73,
  0x83, 0x9C, 0x7B, 0x83, 0x9C, 0x7B, 0x83, 0xDC, 0x7F, 0x81, 0xDC, 0x3F,
  0x01, 0xDC, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x78,
  0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x07,
  0x83, 0xC0, 0x03, 0xC7, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xEF, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x00, 0x03, 0xC7, 0x80, 0x03,
  0xC7, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xDE,
  0x00, 0x0F, 0x38, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xE1, 0xE0,
  0x03, 0xC7, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0x80, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x20, 0x70, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x07, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3E, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFC, 0x03,
  0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xF8, 0x01, 0xE7, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x1F, 0x80, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFC, 0x07, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x7D, 0xE0, 0x01,
  0xEF, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80,
  0x1F, 0x3C, 0x03, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xFF, 0xFE, 0x1F, 0x80, 0x08, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x0F, 0xE3, 0x81, 0xFF, 0xDC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00, 0x0E, 0xF8, 0x00, 0x77, 0x80,
  0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00,
  0x1D, 0xE0, 0x00, 0xE7, 0x80, 0x07, 0x3E, 0x00, 0x38, 0xF8, 0x01, 0xC7,
  0xF0, 0x1E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0x1F,
  0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x0F, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x1C, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x06, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x7E, 0x1F, 0x03, 0xE0, 0x04, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xF0, 0x03, 0x9F, 0x00, 0x1C, 0xF0, 0x00, 0xEF, 0x00,
  0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0x78, 0x00,
  0x3B, 0xC0, 0x01, 0xDF, 0x00, 0x0E, 0x78, 0x00, 0x73, 0xE0, 0x07, 0x8F,
  0xE1, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC7, 0x80, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x03, 0xFF, 0x80,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF3, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x20, 0x07, 0x9E, 0x0F, 0xCF, 0xFF,
  0xCF, 0xFF, 0xC1, 0xFF, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x0B, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00,
  0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x1F, 0x00,
  0xF0, 0xF8, 0x03, 0xCF, 0x80, 0x0F, 0x7C, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0x7E, 0x00, 0x3C, 0x7E, 0x00, 0xF0, 0xFC,
  0x03, 0xC1, 0xF8, 0x0F, 0x03, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0xC3,
  0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xC0,
  0x01, 0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x06, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x04, 0x00, 0x1F, 0x83, 0xE1,
  0xFF, 0xDF, 0xF3, 0xFF, 0xFF, 0xF7, 0xC7, 0xF1, 0xFF, 0x07, 0xC1, 0xFE,
  0x07, 0x83, 0xFC, 0x0F, 0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x3C, 0x0F, 0xE0,
  0x78, 0x1F, 0xC0, 0xF0, 0x3F, 0x81, 0xE0, 0x7F, 0x03, 0xC0, 0xFE, 0x07,
  0x81, 0xFC, 0x0F, 0x03, 0xF8, 0x1E, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1C,
  0x0F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x07,
  0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF0, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0x00,
  0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xB8, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3,
  0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x83, 0xC0, 0x1F, 0x07, 0xE0, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00, 0x7C,
  0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x7C, 0x01, 0xF3, 0xF8, 0x1F, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xBF, 0xF0, 0x3C, 0x38, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xF8, 0x03, 0x9F, 0x00, 0x1C, 0xF0,
  0x00, 0xEF, 0x80, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xF8, 0x00, 0x73,
  0xC0, 0x03, 0x9F, 0x00, 0x3C, 0x7E, 0x07, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xF9, 0xC0, 0x06, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0x06,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0x7C,
  0x78, 0x00, 0x4F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0xF0, 0x03, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x03, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x70, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xBC, 0x00, 0x77, 0xC0,
  0x0E, 0x7C, 0x01, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x18,
  0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3E, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0xC3,
  0xC0, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0,
  0x78, 0x1C, 0xF0, 0x3C, 0x0E, 0x78, 0x1E, 0x07, 0x3C, 0x1F, 0x07, 0x8E,
  0x0F, 0xC3, 0xC7, 0x07, 0xE1, 0xE3, 0xC7, 0x70, 0xF1, 0xE3, 0x9C, 0x70,
  0xF3, 0xCE, 0x38, 0x79, 0xC7, 0xBC, 0x1C, 0xE1, 0xDE, 0x0E, 0xE0, 0xEF,
  0x07, 0x70, 0x7F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x3C, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x00, 0xF8,
  0x00, 0x3E, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F,
  0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xE7, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x03,
  0xC3, 0xC0, 0x07, 0x83, 0xE0, 0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xCE, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x10, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF0,
  0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x1F, 0xFC,
  0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00,
  0x0F, 0xC0, 0x08, 0x3F, 0xC0, 0x1C, 0xFF, 0xE0, 0x3B, 0xC7, 0xF0, 0xE7,
  0x03, 0xFF, 0xDC, 0x01, 0xFF, 0x08, 0x01, 0xFC, 0x00,
};

const GFXglyph UbuntuSansMono_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 35, 27, 10, -34 },
  { 32, 12, 13, 27, 8, -37 },
  { 52, 24, 34, 27, 2, -34 },
  { 154, 21, 43, 27, 3, -38 },
  { 267, 25, 36, 27, 1, -35 },
  { 380, 24, 35, 27, 2, -35 },
  { 485, 4, 14, 27, 12, -37 },
  { 492, 14, 47, 27, 7, -38 },
  { 575, 14, 47, 27, 7, -38 },
  { 658, 21, 20, 27, 3, -34 },
  { 711, 22, 24, 27, 3, -26 },
  { 777, 10, 15, 27, 9, -7 },
  { 796, 11, 4, 27, 8, -16 },
  { 802, 8, 8, 27, 10, -7 },
  { 810, 19, 47, 27, 4, -38 },
  { 922, 22, 36, 27, 3, -35 },
  { 1021, 19, 34, 27, 5, -34 },
  { 1102, 21, 35, 27, 3, -35 },
  { 1194, 20, 36, 27, 4, -35 },
  { 1284, 23, 34, 27, 2, -34 },
  { 1382, 20, 35, 27, 4, -34 },
  { 1470, 22, 35, 27, 3, -34 },
  { 1567, 21, 34, 27, 4, -34 },
  { 1657, 21, 36, 27, 3, -35 },
  { 1752, 21, 35, 27, 3, -35 },
  { 1844, 8, 26, 27, 10, -25 },
  { 1870, 11, 33, 27, 7, -25 },
  { 1916, 22, 22, 27, 3, -25 },
  { 1977, 22, 13, 27, 3, -21 },
  { 2013, 22, 22, 27, 3, -25 },
  { 2074, 17, 36, 27, 5, -35 },
  { 2151, 23, 42, 27, 3, -35 },
  { 2272, 27, 34, 27, 0, -34 },
  { 2387, 21, 34, 27, 3, -34 },
  { 2477, 22, 36, 27, 3, -35 },
  { 2576, 22, 34, 27, 3, -34 },
  { 2670, 20, 34, 27, 5, -34 },
  { 2755, 19, 34, 27, 5, -34 },
  { 2836, 22, 36, 27, 3, -35 },
  { 2935, 23, 34, 27, 2, -34 },
  { 3033, 17, 34, 27, 5, -34 },
  { 3106, 20, 35, 27, 3, -34 },
  { 3194, 23, 34, 27, 4, -34 },
  { 3292, 20, 34, 27, 5, -34 },
  { 3377, 24, 34, 27, 2, -34 },
  { 3479, 21, 34, 27, 3, -34 },
  { 3569, 24, 36, 27, 2, -35 },
  { 3677, 21, 34, 27, 4, -34 },
  { 3767, 24, 44, 27, 2, -35 },
  { 3899, 22, 34, 27, 3, -34 },
  { 3993, 21, 36, 27, 3, -35 },
  { 4088, 23, 34, 27, 2, -34 },
  { 4186, 22, 35, 27, 3, -34 },
  { 4283, 26, 34, 27, 1, -34 },
  { 4394, 24, 34, 27, 2, -34 },
  { 4496, 24, 34, 27, 2, -34 },
  { 4598, 26, 34, 27, 1, -34 },
  { 4709, 22, 34, 27, 3, -34 },
  { 4803, 13, 47, 27, 8, -38 },
  { 4880, 19, 47, 27, 4, -38 },
  { 4992, 12, 47, 27, 7, -38 },
  { 5063, 22, 18, 27, 3, -34 },
  { 5113, 27, 3, 27, 0, 6 },
  { 5124, 8, 9, 27, 9, -38 },
  { 5133, 21, 27, 27, 3, -26 },
  { 5204, 21, 39, 27, 4, -38 },
  { 5307, 22, 27, 27, 3, -26 },
  { 5382, 21, 39, 27, 2, -38 },
  { 5485, 23, 27, 27, 2, -26 },
  { 5563, 22, 38, 27, 4, -38 },
  { 5668, 21, 35, 27, 2, -26 },
  { 5760, 20, 38, 27, 4, -38 },
  { 5855, 21, 38, 27, 3, -37 },
  { 5955, 17, 46, 27, 4, -37 },
  { 6053, 22, 38, 27, 4, -38 },
  { 6158, 21, 39, 27, 3, -38 },
  { 6261, 23, 26, 27, 2, -26 },
  { 6336, 20, 26, 27, 4, -26 },
  { 6401, 23, 27, 27, 2, -26 },
  { 6479, 21, 35, 27, 4, -26 },
  { 6571, 21, 35, 27, 2, -26 },
  { 6663, 18, 26, 27, 6, -26 },
  { 6722, 20, 27, 27, 4, -26 },
  { 6790, 20, 34, 27, 4, -33 },
  { 6875, 19, 26, 27, 4, -25 },
  { 6937, 24, 25, 27, 2, -25 },
  { 7012, 25, 25, 27, 1, -25 },
  { 7091, 24, 25, 27, 2, -25 },
  { 7166, 23, 34, 27, 2, -25 },
  { 7264, 19, 25, 27, 4, -25 },
  { 7324, 18, 47, 27, 5, -38 },
  { 7430, 3, 47, 27, 12, -38 },
  { 7448, 19, 47, 27, 4, -38 },
  { 7560, 23, 7, 27, 2, -18 },
};

const GFXfont UbuntuSansMono_Regular49pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular49pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular49pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _UBUNTUSANSMONO_REGULAR49PT7B_H_
