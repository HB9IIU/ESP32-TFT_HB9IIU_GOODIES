#ifndef _UBUNTUSANSMONO_REGULAR17PT7B_H_
#define _UBUNTUSANSMONO_REGULAR17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0x0F, 0x99, 0x99, 0x90, 0x32, 0x32, 0x22, 0xFF, 0x26,
  0x64, 0x64, 0x44, 0xFF, 0x4C, 0xC8, 0xC8, 0x10, 0x21, 0xFA, 0x0C, 0x18,
  0x1C, 0x0E, 0x06, 0x04, 0x0F, 0x73, 0x82, 0x04, 0x00, 0x71, 0xA8, 0xA4,
  0xD2, 0x45, 0x43, 0xE0, 0x2C, 0x3D, 0x14, 0x92, 0x49, 0x28, 0x70, 0x38,
  0x4C, 0xC4, 0x4C, 0x48, 0x30, 0x72, 0x9A, 0x8E, 0x84, 0xCE, 0x7B, 0xF8,
  0x18, 0x88, 0xC4, 0x23, 0x18, 0xC6, 0x10, 0x86, 0x18, 0x61, 0xC3, 0x0C,
  0x21, 0x84, 0x21, 0x08, 0x42, 0x31, 0x19, 0x98, 0x18, 0x23, 0x4B, 0xF1,
  0x85, 0x99, 0x00, 0x10, 0x10, 0x10, 0xFF, 0xFF, 0x10, 0x10, 0x10, 0x27,
  0x72, 0xE8, 0xF0, 0x5D, 0x80, 0x06, 0x0C, 0x10, 0x20, 0xC1, 0x02, 0x0C,
  0x10, 0x20, 0xC1, 0x02, 0x0C, 0x10, 0x60, 0x3C, 0x66, 0xC2, 0xC2, 0x82,
  0x9B, 0x9B, 0x82, 0xC2, 0xC2, 0x46, 0x3C, 0x10, 0xCD, 0x24, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x3F, 0x7D, 0x8C, 0x18, 0x10, 0x60, 0x82, 0x08, 0x20,
  0xC1, 0x07, 0xF0, 0xFC, 0x8C, 0x18, 0x30, 0x47, 0x03, 0x81, 0x02, 0x06,
  0x1F, 0xE0, 0x04, 0x0C, 0x14, 0x34, 0x24, 0x44, 0xC4, 0x84, 0xFF, 0x04,
  0x04, 0x04, 0x3E, 0xC1, 0x83, 0x04, 0x0F, 0x81, 0x81, 0x02, 0x06, 0x1F,
  0xE0, 0x0E, 0x38, 0x60, 0x40, 0xC0, 0xFC, 0x86, 0x82, 0xC3, 0xC2, 0x46,
  0x3C, 0xFF, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x10, 0x30, 0x30,
  0x30, 0x3C, 0x8F, 0x0E, 0x14, 0x6F, 0x9B, 0x61, 0x83, 0x07, 0x0B, 0xE0,
  0x3C, 0x8F, 0x0C, 0x18, 0x38, 0x5F, 0x81, 0x06, 0x08, 0x73, 0x80, 0x5D,
  0x80, 0x17, 0x60, 0x27, 0x30, 0x00, 0x27, 0x33, 0xE4, 0x01, 0x07, 0x18,
  0xE0, 0xC0, 0x38, 0x0E, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x38,
  0x06, 0x07, 0x1C, 0x70, 0x80, 0xFA, 0x20, 0xC3, 0x08, 0x42, 0x08, 0x00,
  0x06, 0x1C, 0x3C, 0x62, 0x43, 0xC1, 0xCF, 0x99, 0x91, 0x91, 0x91, 0xD1,
  0xCF, 0x40, 0x60, 0x3E, 0x0C, 0x0C, 0x0E, 0x05, 0x82, 0x43, 0x21, 0x18,
  0x84, 0xC2, 0x7F, 0x20, 0xD0, 0x38, 0x10, 0xF9, 0x1E, 0x1C, 0x18, 0x7F,
  0xA3, 0xC1, 0x83, 0x06, 0x1F, 0xE0, 0x1F, 0x62, 0x40, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0xC0, 0x40, 0x61, 0x3F, 0xF8, 0x8C, 0x86, 0x82, 0x83, 0x83,
  0x83, 0x83, 0x82, 0x82, 0x8C, 0xF8, 0xFD, 0x02, 0x04, 0x08, 0x1F, 0xA0,
  0x40, 0x81, 0x02, 0x07, 0xF0, 0xFE, 0x08, 0x20, 0x83, 0xF8, 0x20, 0x82,
  0x08, 0x20, 0x1F, 0x62, 0x40, 0xC0, 0xC0, 0x80, 0x83, 0x83, 0xC3, 0x43,
  0x63, 0x3F, 0x83, 0x83, 0x83, 0x83, 0x83, 0xFF, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x3F, 0x3E,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0E, 0x17, 0xE0, 0xC3, 0xC6,
  0xC4, 0xC8, 0xD0, 0xE0, 0xF0, 0xD8, 0xCC, 0xC6, 0xC3, 0xC1, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF0, 0x42, 0xC6, 0xE6,
  0xA6, 0xAA, 0x9B, 0x9B, 0x83, 0x83, 0x83, 0x83, 0x81, 0xC3, 0x86, 0x8D,
  0x19, 0x32, 0x62, 0xC5, 0x8F, 0x0E, 0x1C, 0x10, 0x3C, 0x46, 0xC2, 0x83,
  0x81, 0x81, 0x81, 0x81, 0x83, 0x82, 0x46, 0x7C, 0xF9, 0x1A, 0x14, 0x38,
  0x50, 0xBE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x3C, 0x46, 0xC2, 0x83, 0x81,
  0x81, 0x81, 0x81, 0x83, 0x82, 0x46, 0x7C, 0x18, 0x0C, 0x06, 0xF8, 0x84,
  0x82, 0x82, 0x82, 0x86, 0xFC, 0x88, 0x8C, 0x84, 0x82, 0x83, 0x3E, 0xC7,
  0x06, 0x04, 0x06, 0x03, 0x03, 0x02, 0x06, 0x0F, 0xE0, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC2, 0xC6, 0x7C, 0xC0, 0xA0, 0x50,
  0x68, 0x26, 0x11, 0x08, 0x8C, 0x64, 0x12, 0x0B, 0x07, 0x01, 0x80, 0x81,
  0x83, 0x83, 0x83, 0x83, 0x9B, 0x9A, 0xAA, 0xA6, 0xA6, 0xC6, 0xC6, 0x83,
  0xC2, 0x44, 0x2C, 0x28, 0x18, 0x38, 0x2C, 0x64, 0x46, 0xC2, 0x83, 0xC0,
  0xA0, 0xD8, 0x44, 0x63, 0x20, 0xB0, 0x70, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xFF, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0xC0,
  0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x81, 0x81,
  0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x60, 0x40, 0x81, 0x83, 0xF8,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0x18, 0x38, 0x2C,
  0x64, 0x46, 0x83, 0xFF, 0x80, 0xC8, 0x80, 0x7C, 0x8C, 0x08, 0x17, 0xF8,
  0x70, 0xE1, 0x7E, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0xC6, 0xC2, 0xC3, 0xC3,
  0xC3, 0xC2, 0xC6, 0xFC, 0x3E, 0x62, 0xC0, 0x80, 0x80, 0x80, 0xC0, 0x60,
  0x3F, 0x02, 0x04, 0x08, 0x13, 0xEC, 0xF0, 0xC1, 0x83, 0x07, 0x0A, 0x13,
  0xE0, 0x3C, 0x66, 0xC2, 0x83, 0xFF, 0x80, 0xC0, 0x60, 0x3E, 0x1F, 0x30,
  0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E,
  0xC7, 0x0C, 0x18, 0x30, 0x70, 0xB7, 0x3A, 0x04, 0x1F, 0xE0, 0xC1, 0x83,
  0x06, 0x0F, 0xD8, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x20, 0x30, 0x60,
  0x80, 0x0F, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xE0, 0x0C, 0x30,
  0x80, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC3, 0xC4, 0xC8, 0xF0, 0xF0, 0xD8, 0xCC, 0xC6, 0xC3, 0xF0,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0xE0, 0xFE,
  0x93, 0x91, 0x91, 0x91, 0x91, 0x81, 0x81, 0x81, 0xFD, 0x8F, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC2, 0x3C, 0x66, 0xC2, 0x83, 0x83, 0x83, 0xC2, 0x46,
  0x3C, 0xFC, 0xC6, 0xC2, 0xC3, 0xC3, 0xC3, 0xC2, 0xC6, 0xFC, 0xC0, 0xC0,
  0xC0, 0x3E, 0xC7, 0x0C, 0x18, 0x30, 0x70, 0xA3, 0x7E, 0x04, 0x08, 0x10,
  0x7E, 0x08, 0x20, 0x82, 0x08, 0x20, 0x80, 0x3E, 0x87, 0x03, 0x03, 0x80,
  0xC0, 0xC1, 0xFC, 0x10, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10, 0x20, 0x60,
  0xC0, 0xF0, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xA1, 0x3E, 0x83, 0xC2,
  0xC2, 0x46, 0x64, 0x24, 0x2C, 0x38, 0x18, 0xC0, 0xA0, 0x52, 0x29, 0xB4,
  0xDA, 0xA9, 0xCC, 0x66, 0x23, 0x00, 0xC3, 0x46, 0x2C, 0x38, 0x18, 0x3C,
  0x64, 0x42, 0x83, 0xC3, 0xC2, 0x42, 0x46, 0x66, 0x24, 0x34, 0x18, 0x18,
  0x18, 0x10, 0xE0, 0x7E, 0x0C, 0x30, 0xC1, 0x06, 0x18, 0x20, 0xFE, 0x3C,
  0x82, 0x08, 0x20, 0x86, 0x30, 0x40, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xFF,
  0xFF, 0xF0, 0x30, 0x20, 0x40, 0x81, 0x02, 0x07, 0x0C, 0x10, 0x20, 0x40,
  0x81, 0x06, 0x78, 0xF1, 0x9E,
};

const GFXglyph UbuntuSansMono_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 5, 10, 3, -13 },
  { 7, 8, 12, 10, 1, -12 },
  { 19, 7, 15, 10, 1, -13 },
  { 33, 9, 12, 10, 0, -12 },
  { 47, 8, 12, 10, 1, -12 },
  { 59, 1, 5, 10, 4, -13 },
  { 60, 5, 16, 10, 2, -13 },
  { 70, 5, 16, 10, 2, -13 },
  { 80, 7, 7, 10, 1, -12 },
  { 87, 8, 8, 10, 1, -9 },
  { 95, 4, 6, 10, 3, -3 },
  { 98, 4, 1, 10, 3, -5 },
  { 99, 3, 3, 10, 3, -3 },
  { 101, 7, 16, 10, 1, -13 },
  { 115, 8, 12, 10, 1, -12 },
  { 127, 6, 12, 10, 2, -12 },
  { 136, 7, 12, 10, 1, -12 },
  { 147, 7, 12, 10, 1, -12 },
  { 158, 8, 12, 10, 1, -12 },
  { 170, 7, 12, 10, 1, -12 },
  { 181, 8, 12, 10, 1, -12 },
  { 193, 8, 12, 10, 1, -12 },
  { 205, 7, 12, 10, 1, -12 },
  { 216, 7, 12, 10, 1, -12 },
  { 227, 3, 9, 10, 3, -9 },
  { 231, 4, 12, 10, 2, -9 },
  { 237, 8, 8, 10, 1, -9 },
  { 245, 8, 4, 10, 1, -7 },
  { 249, 8, 8, 10, 1, -9 },
  { 257, 6, 12, 10, 2, -12 },
  { 266, 8, 15, 10, 1, -12 },
  { 281, 9, 12, 10, 0, -12 },
  { 295, 7, 12, 10, 1, -12 },
  { 306, 8, 12, 10, 1, -12 },
  { 318, 8, 12, 10, 1, -12 },
  { 330, 7, 12, 10, 2, -12 },
  { 341, 6, 12, 10, 2, -12 },
  { 350, 8, 12, 10, 1, -12 },
  { 362, 8, 12, 10, 1, -12 },
  { 374, 6, 12, 10, 2, -12 },
  { 383, 7, 12, 10, 1, -12 },
  { 394, 8, 12, 10, 1, -12 },
  { 406, 7, 12, 10, 2, -12 },
  { 417, 8, 12, 10, 1, -12 },
  { 429, 7, 12, 10, 1, -12 },
  { 440, 8, 12, 10, 1, -12 },
  { 452, 7, 12, 10, 2, -12 },
  { 463, 8, 15, 10, 1, -12 },
  { 478, 8, 12, 10, 1, -12 },
  { 490, 7, 12, 10, 1, -12 },
  { 501, 8, 12, 10, 1, -12 },
  { 513, 8, 12, 10, 1, -12 },
  { 525, 9, 12, 10, 0, -12 },
  { 539, 8, 12, 10, 1, -12 },
  { 551, 8, 12, 10, 1, -12 },
  { 563, 9, 12, 10, 0, -12 },
  { 577, 8, 12, 10, 1, -12 },
  { 589, 4, 16, 10, 3, -13 },
  { 597, 7, 16, 10, 1, -13 },
  { 611, 5, 16, 10, 2, -13 },
  { 621, 8, 6, 10, 1, -12 },
  { 627, 9, 1, 10, 0, 2 },
  { 629, 3, 3, 10, 3, -13 },
  { 631, 7, 9, 10, 1, -9 },
  { 639, 8, 13, 10, 1, -13 },
  { 652, 8, 9, 10, 1, -9 },
  { 661, 7, 13, 10, 1, -13 },
  { 673, 8, 9, 10, 1, -9 },
  { 682, 8, 13, 10, 1, -13 },
  { 695, 7, 12, 10, 1, -9 },
  { 706, 7, 13, 10, 1, -13 },
  { 718, 7, 13, 10, 1, -13 },
  { 730, 6, 16, 10, 1, -13 },
  { 742, 8, 13, 10, 1, -13 },
  { 755, 7, 13, 10, 1, -13 },
  { 767, 8, 9, 10, 1, -9 },
  { 776, 7, 9, 10, 1, -9 },
  { 784, 8, 9, 10, 1, -9 },
  { 793, 8, 12, 10, 1, -9 },
  { 805, 7, 12, 10, 1, -9 },
  { 816, 6, 9, 10, 2, -9 },
  { 823, 7, 9, 10, 1, -9 },
  { 831, 7, 12, 10, 1, -12 },
  { 842, 7, 9, 10, 1, -9 },
  { 850, 8, 9, 10, 1, -9 },
  { 859, 9, 9, 10, 0, -9 },
  { 870, 8, 9, 10, 1, -9 },
  { 879, 8, 12, 10, 1, -9 },
  { 891, 7, 9, 10, 1, -9 },
  { 899, 6, 16, 10, 2, -13 },
  { 911, 1, 16, 10, 4, -13 },
  { 913, 7, 16, 10, 1, -13 },
  { 927, 8, 2, 10, 1, -6 },
};

const GFXfont UbuntuSansMono_Regular17pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular17pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUSANSMONO_REGULAR17PT7B_H_
