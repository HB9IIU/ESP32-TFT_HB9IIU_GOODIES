#ifndef _UBUNTUSANSMONO_REGULAR23PT7B_H_
#define _UBUNTUSANSMONO_REGULAR23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB2, 0x49, 0x01, 0xFF, 0x8C, 0x63, 0x18, 0xC4, 0x08,
  0xC3, 0x18, 0x63, 0x0C, 0x6F, 0xFF, 0xFF, 0xCC, 0x61, 0x8C, 0x31, 0x86,
  0x23, 0xFF, 0xFF, 0xF6, 0x30, 0xC6, 0x18, 0x82, 0x30, 0x08, 0x04, 0x02,
  0x07, 0xEE, 0x16, 0x03, 0x01, 0x80, 0xE0, 0x3E, 0x07, 0xC0, 0x70, 0x18,
  0x0C, 0x07, 0x03, 0xFF, 0x0C, 0x02, 0x01, 0x00, 0x80, 0xF0, 0x73, 0x1A,
  0x23, 0x44, 0xC8, 0x91, 0x36, 0x35, 0x83, 0x30, 0x0C, 0xC1, 0x7C, 0x6C,
  0x89, 0x13, 0x22, 0xC4, 0x50, 0xCE, 0x0E, 0x3E, 0x06, 0x61, 0x8C, 0x30,
  0x86, 0x30, 0xC4, 0x0F, 0x81, 0xC4, 0x7C, 0xCD, 0xDB, 0x1B, 0x61, 0xCC,
  0x19, 0x87, 0x99, 0xF1, 0xF3, 0xF5, 0x50, 0x04, 0x1C, 0x61, 0xC3, 0x0C,
  0x18, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x60, 0xE0,
  0xC0, 0xE0, 0x80, 0x41, 0xC1, 0xC1, 0x81, 0x81, 0x83, 0x06, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x30, 0xE1, 0x8E, 0x08, 0x00, 0x18,
  0x04, 0x22, 0x3D, 0x7F, 0xF8, 0xE0, 0xD8, 0xEE, 0x63, 0x00, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x0F, 0xFF, 0xFF, 0xC1, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x00, 0x3B, 0xCE, 0x33, 0x72, 0x00, 0xF8, 0xFF, 0x80, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x00, 0x1F,
  0x06, 0x71, 0x83, 0x30, 0x66, 0x0D, 0x81, 0xB3, 0x1E, 0x73, 0xCE, 0x78,
  0x0F, 0x03, 0x30, 0x66, 0x0C, 0xC1, 0x8C, 0x60, 0xF8, 0x0C, 0x0E, 0x0F,
  0x1D, 0x88, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x61, 0xFE, 0xFF, 0x7E, 0x73, 0xA0, 0xE0, 0x30, 0x18, 0x08, 0x0C, 0x0C,
  0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x03, 0xFF, 0xFF, 0x7E, 0x63, 0x80,
  0xC0, 0x30, 0x18, 0x18, 0x18, 0x3C, 0x07, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x0F, 0x1D, 0xFC, 0x01, 0x80, 0x70, 0x1E, 0x06, 0xC0, 0x98, 0x33, 0x0C,
  0x61, 0x0C, 0x61, 0x88, 0x33, 0xFF, 0xFF, 0xF0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x7F, 0xBF, 0xD8, 0x0C, 0x06, 0x03, 0x01, 0xE0, 0xFC, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x0F, 0x1D, 0xFC, 0x03, 0x81, 0xF8, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x1B, 0x83, 0xFC, 0xC0, 0xD8, 0x1B, 0x01, 0x20, 0x36,
  0x0C, 0xC1, 0x8C, 0x60, 0xF8, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x1F, 0x0C, 0x66, 0x0D, 0x83, 0x60, 0xD8, 0x37, 0x18, 0xFC, 0x37,
  0x98, 0x76, 0x0F, 0x01, 0xC0, 0x58, 0x37, 0x1C, 0xFE, 0x3F, 0x1C, 0x66,
  0x0D, 0x03, 0xC0, 0xF0, 0x16, 0x05, 0x81, 0x3F, 0xC3, 0xB0, 0x0C, 0x03,
  0x01, 0x80, 0xC3, 0xE1, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x39, 0xCE,
  0x00, 0x00, 0x00, 0x39, 0xCE, 0x33, 0x71, 0x00, 0x00, 0x20, 0x1C, 0x0E,
  0x0F, 0x07, 0x81, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0xC0, 0xF0, 0x78, 0x78, 0x1C, 0x00, 0xFD, 0x1C, 0x18,
  0x10, 0x60, 0xC3, 0x0C, 0x30, 0x60, 0x80, 0x00, 0x06, 0x1C, 0x38, 0x0F,
  0x87, 0x38, 0xC1, 0x30, 0x36, 0x06, 0xC7, 0xF1, 0xDE, 0x63, 0xCC, 0x79,
  0x8F, 0x31, 0xE6, 0x3E, 0xC6, 0xCF, 0xD8, 0xFB, 0x80, 0x30, 0x03, 0x80,
  0x3F, 0x00, 0x07, 0x00, 0x38, 0x03, 0x60, 0x1B, 0x00, 0x88, 0x0C, 0x60,
  0x63, 0x02, 0x18, 0x30, 0x61, 0x83, 0x0F, 0xF8, 0xFF, 0xC6, 0x03, 0x30,
  0x19, 0x00, 0xD8, 0x03, 0xFF, 0x31, 0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x2C,
  0x3B, 0xF8, 0xC3, 0xB0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x3B, 0xFC,
  0x0F, 0xE3, 0x98, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0F, 0x18, 0x7F, 0xFE, 0x1D,
  0xE3, 0x06, 0x60, 0x6C, 0x0D, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x6C, 0x0D, 0x83, 0x39, 0xC7, 0xF0, 0xFF, 0x7F, 0xA0, 0x10,
  0x08, 0x04, 0x02, 0x01, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x0F, 0xE3, 0x18, 0xC0, 0x30, 0x06,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x78, 0x0D, 0x01, 0xB0, 0x36, 0x06,
  0x60, 0xCE, 0x18, 0x7F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1F, 0xFF, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x3F, 0xFF, 0x3F, 0xCF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x66, 0x3B, 0xFC,
  0xC0, 0xD8, 0x33, 0x0C, 0x63, 0x0C, 0xE1, 0xB8, 0x3E, 0x07, 0x80, 0xF8,
  0x1B, 0x83, 0x38, 0x63, 0x8C, 0x39, 0x83, 0x30, 0x36, 0x07, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0x60, 0xCC, 0x19, 0xC7, 0x38, 0xA5,
  0x14, 0xB6, 0xB2, 0x96, 0x53, 0xCE, 0x78, 0x8F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x78, 0x1F, 0x07, 0x41, 0xD8, 0x72, 0x1C,
  0xC7, 0x11, 0xC6, 0x70, 0x9C, 0x37, 0x0D, 0xC1, 0xF0, 0x7C, 0x0F, 0x03,
  0x1F, 0x0E, 0x31, 0x83, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0xC1, 0x9C, 0x60, 0xF8, 0xFE, 0x31,
  0xCC, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xFF, 0x3F, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1F, 0x0E, 0x31, 0x83, 0x60, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x06,
  0xC1, 0x9C, 0x60, 0xF8, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0xFF, 0x1C,
  0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0xFF, 0x1F, 0xC3,
  0x0C, 0x60, 0x8C, 0x19, 0x81, 0x30, 0x36, 0x03, 0x3F, 0xB1, 0xB0, 0x18,
  0x0C, 0x06, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x60, 0x10, 0x08, 0x0F,
  0x0F, 0xFE, 0xFF, 0xFF, 0xFC, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x04, 0xC1, 0x9C, 0x71, 0xFC, 0xC0, 0x1B,
  0x01, 0x98, 0x0C, 0xC0, 0x62, 0x02, 0x18, 0x30, 0xC1, 0x86, 0x08, 0x18,
  0xC0, 0xC6, 0x06, 0x30, 0x11, 0x00, 0xD8, 0x06, 0xC0, 0x14, 0x00, 0xE0,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF3, 0x1E, 0x73, 0xCA,
  0x5B, 0x4B, 0x6D, 0x28, 0xA7, 0x14, 0xE3, 0x98, 0x33, 0x06, 0xC0, 0x6C,
  0x19, 0x82, 0x18, 0xC3, 0x30, 0x36, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x60,
  0xCC, 0x18, 0xC6, 0x08, 0xC1, 0xB0, 0x36, 0x03, 0xE0, 0x3B, 0x01, 0x98,
  0x0C, 0x60, 0xC3, 0x06, 0x0C, 0x60, 0x62, 0x01, 0xB0, 0x07, 0x00, 0x38,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x7F, 0xEF,
  0xFC, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0xF0, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C,
  0x06, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60,
  0x10, 0x0C, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xF0, 0x0C, 0x01, 0xC0, 0x6C, 0x09,
  0x83, 0x18, 0x41, 0x18, 0x36, 0x03, 0x40, 0x40, 0xFF, 0xF8, 0x4E, 0x63,
  0x10, 0x7E, 0x21, 0x80, 0x60, 0x30, 0x1B, 0xFF, 0x8F, 0x83, 0x81, 0xE0,
  0xF8, 0x6F, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xE3,
  0xDC, 0xC1, 0xB0, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xC7,
  0x3F, 0x80, 0x0F, 0xC7, 0x99, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xF1, 0x0F, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x31, 0xFC, 0xEF, 0x60, 0xD0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0D, 0x83, 0x39, 0xC7, 0xF0, 0x1F, 0x07, 0x39, 0x83, 0x20, 0x2C,
  0x07, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xE3, 0x0F, 0xE0, 0x07,
  0x87, 0xF1, 0x80, 0xC0, 0x30, 0x0C, 0x0F, 0xFB, 0xFE, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0xCE,
  0xF6, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xDC, 0x33, 0xFC,
  0x3B, 0x00, 0xC0, 0x34, 0x39, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0xF9, 0xEE, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xC0, 0x38, 0x1C, 0x0C, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x39, 0x0F, 0x80, 0x06,
  0x0F, 0x06, 0x00, 0x00, 0x7F, 0x7F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xC6, 0xFC, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x1F, 0x0C, 0xC6, 0x33, 0x0D, 0x83, 0xC0, 0xF8,
  0x33, 0x0C, 0x63, 0x0C, 0xC1, 0xB0, 0x30, 0xF8, 0x7C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x1C, 0x87, 0xC0, 0xFB, 0xD9, 0xDF, 0x11, 0xE2, 0x3C, 0x47, 0x88,
  0xF1, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30, 0xFE, 0x73, 0xB0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x1F,
  0x07, 0x71, 0x83, 0x20, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xCC,
  0x18, 0xEE, 0x0F, 0x80, 0xFE, 0x39, 0xCC, 0x1B, 0x06, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xB0, 0x6F, 0x73, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x1F, 0xCE, 0x76, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8,
  0x33, 0xBC, 0x7F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x7F, 0xE1, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x70, 0xB0, 0x18,
  0x0E, 0x03, 0xE0, 0x7C, 0x07, 0x01, 0x80, 0xF0, 0xFF, 0xE0, 0x10, 0x18,
  0x0C, 0x06, 0x0F, 0xFF, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0x72, 0x1F, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xDC, 0x67, 0xF0, 0xC0, 0x78, 0x0D, 0x83, 0x30, 0x66,
  0x0C, 0x63, 0x0C, 0x61, 0x98, 0x1B, 0x03, 0x40, 0x38, 0x06, 0x00, 0x80,
  0x30, 0x07, 0x01, 0xE2, 0x3C, 0xE7, 0x9C, 0xF2, 0x92, 0xDA, 0x51, 0xCE,
  0x39, 0xC7, 0x30, 0x40, 0xC0, 0xEC, 0x18, 0xC6, 0x0D, 0x81, 0xE0, 0x1C,
  0x03, 0x80, 0xD8, 0x31, 0x8C, 0x39, 0x83, 0x60, 0x30, 0xC0, 0x6C, 0x09,
  0x83, 0x30, 0x63, 0x0C, 0x63, 0x04, 0x60, 0xCC, 0x19, 0x01, 0xE0, 0x3C,
  0x03, 0x00, 0x60, 0x08, 0x07, 0x07, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x3F, 0xFF, 0xF0, 0x0F, 0x8E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x3C, 0x1E, 0x03, 0x00,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x7C, 0xFF, 0xFF,
  0xFC, 0xF0, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x02,
  0x01, 0xE0, 0xF0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81,
  0xC7, 0xC0, 0x10, 0x0F, 0x8F, 0x3F, 0x41, 0xC0,
};

const GFXglyph UbuntuSansMono_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 5, 6, 13, 4, -17 },
  { 11, 11, 16, 13, 1, -16 },
  { 33, 9, 21, 13, 2, -18 },
  { 57, 11, 16, 13, 1, -16 },
  { 79, 11, 16, 13, 1, -16 },
  { 101, 2, 6, 13, 5, -17 },
  { 103, 7, 22, 13, 3, -18 },
  { 123, 7, 22, 13, 3, -18 },
  { 143, 9, 9, 13, 2, -16 },
  { 154, 11, 11, 13, 1, -12 },
  { 170, 5, 7, 13, 4, -3 },
  { 175, 5, 1, 13, 4, -7 },
  { 176, 3, 3, 13, 5, -3 },
  { 178, 9, 22, 13, 2, -18 },
  { 203, 11, 16, 13, 1, -16 },
  { 225, 9, 16, 13, 2, -16 },
  { 243, 9, 16, 13, 2, -16 },
  { 261, 9, 16, 13, 2, -16 },
  { 279, 11, 16, 13, 1, -16 },
  { 301, 9, 16, 13, 2, -16 },
  { 319, 11, 16, 13, 1, -16 },
  { 341, 10, 16, 13, 2, -16 },
  { 361, 10, 16, 13, 1, -16 },
  { 381, 10, 16, 13, 1, -16 },
  { 401, 3, 11, 13, 5, -11 },
  { 406, 5, 15, 13, 3, -11 },
  { 416, 11, 10, 13, 1, -12 },
  { 430, 11, 6, 13, 1, -10 },
  { 439, 11, 10, 13, 1, -12 },
  { 453, 7, 16, 13, 3, -16 },
  { 467, 11, 19, 13, 1, -16 },
  { 494, 13, 16, 13, 0, -16 },
  { 520, 10, 16, 13, 1, -16 },
  { 540, 11, 16, 13, 1, -16 },
  { 562, 11, 16, 13, 1, -16 },
  { 584, 9, 16, 13, 3, -16 },
  { 602, 8, 16, 13, 3, -16 },
  { 618, 11, 16, 13, 1, -16 },
  { 640, 11, 16, 13, 1, -16 },
  { 662, 7, 16, 13, 3, -16 },
  { 676, 10, 16, 13, 1, -16 },
  { 696, 11, 16, 13, 2, -16 },
  { 718, 10, 16, 13, 2, -16 },
  { 738, 11, 16, 13, 1, -16 },
  { 760, 10, 16, 13, 1, -16 },
  { 780, 11, 16, 13, 1, -16 },
  { 802, 10, 16, 13, 2, -16 },
  { 822, 11, 20, 13, 1, -16 },
  { 850, 11, 16, 13, 1, -16 },
  { 872, 9, 16, 13, 2, -16 },
  { 890, 11, 16, 13, 1, -16 },
  { 912, 11, 16, 13, 1, -16 },
  { 934, 13, 16, 13, 0, -16 },
  { 960, 11, 16, 13, 1, -16 },
  { 982, 11, 16, 13, 1, -16 },
  { 1004, 13, 16, 13, 0, -16 },
  { 1030, 11, 16, 13, 1, -16 },
  { 1052, 6, 22, 13, 4, -18 },
  { 1069, 9, 22, 13, 2, -18 },
  { 1094, 6, 22, 13, 3, -18 },
  { 1111, 11, 9, 13, 1, -16 },
  { 1124, 13, 1, 13, 0, 3 },
  { 1126, 4, 5, 13, 4, -18 },
  { 1129, 9, 12, 13, 2, -12 },
  { 1143, 10, 18, 13, 2, -18 },
  { 1166, 11, 12, 13, 1, -12 },
  { 1183, 10, 18, 13, 1, -18 },
  { 1206, 11, 12, 13, 1, -12 },
  { 1223, 10, 18, 13, 2, -18 },
  { 1246, 10, 16, 13, 1, -12 },
  { 1266, 9, 18, 13, 2, -18 },
  { 1287, 9, 17, 13, 2, -17 },
  { 1307, 8, 21, 13, 2, -17 },
  { 1328, 10, 18, 13, 2, -18 },
  { 1351, 9, 18, 13, 2, -18 },
  { 1372, 11, 12, 13, 1, -12 },
  { 1389, 9, 12, 13, 2, -12 },
  { 1403, 11, 12, 13, 1, -12 },
  { 1420, 10, 16, 13, 2, -12 },
  { 1440, 10, 16, 13, 1, -12 },
  { 1460, 8, 12, 13, 3, -12 },
  { 1472, 9, 12, 13, 2, -12 },
  { 1486, 9, 16, 13, 2, -16 },
  { 1504, 9, 12, 13, 2, -12 },
  { 1518, 11, 12, 13, 1, -12 },
  { 1535, 11, 12, 13, 1, -12 },
  { 1552, 11, 12, 13, 1, -12 },
  { 1569, 11, 16, 13, 1, -12 },
  { 1591, 9, 12, 13, 2, -12 },
  { 1605, 9, 22, 13, 2, -18 },
  { 1630, 1, 22, 13, 6, -18 },
  { 1633, 9, 22, 13, 2, -18 },
  { 1658, 11, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_Regular23pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular23pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular23pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUSANSMONO_REGULAR23PT7B_H_
