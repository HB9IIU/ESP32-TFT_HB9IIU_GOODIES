#ifndef _UBUNTUSANSMONO_REGULAR38PT7B_H_
#define _UBUNTUSANSMONO_REGULAR38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x30,
  0x00, 0x00, 0x3B, 0xFF, 0xFF, 0xC8, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xC0, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x0E,
  0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x06, 0x01, 0xC1, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0x1C, 0x1C, 0x07, 0x07, 0x00, 0xE0,
  0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8E, 0x0E, 0x01, 0xC1, 0xC0, 0x30, 0x30, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x0F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7C, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0E, 0xF8, 0x7E,
  0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x1C, 0x00, 0x2F, 0xE0, 0x19, 0x8C, 0x07, 0x71, 0xC1, 0xCC,
  0x38, 0x39, 0x83, 0x0E, 0x30, 0x61, 0x86, 0x0C, 0x70, 0xC1, 0x9C, 0x1C,
  0x73, 0x83, 0x8C, 0xE0, 0x3F, 0x98, 0x03, 0xE7, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0xC0, 0x0E, 0x7E, 0x01, 0x9D, 0xC0, 0x73, 0x1C, 0x1C, 0xE1, 0x83,
  0x9C, 0x30, 0xE3, 0x86, 0x18, 0x70, 0xC7, 0x0E, 0x19, 0xC1, 0xC3, 0x38,
  0x18, 0xEE, 0x03, 0xBB, 0x80, 0x3F, 0x00, 0x01, 0x00, 0x03, 0xE0, 0x01,
  0xFF, 0x00, 0x7F, 0xF0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x79, 0xC0, 0x07,
  0x70, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0x07, 0xF0, 0x61, 0xCF, 0x1C, 0x38,
  0xF3, 0x8E, 0x0F, 0x71, 0xC0, 0xEC, 0x38, 0x0F, 0x8F, 0x01, 0xF1, 0xE0,
  0x1E, 0x1C, 0x03, 0xC3, 0xC0, 0xFC, 0x3C, 0x7B, 0xC7, 0xFF, 0x38, 0x3F,
  0x87, 0x80, 0xFF, 0xFF, 0xFF, 0xFD, 0x80, 0x00, 0x40, 0x18, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x04, 0x40, 0x0C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x83, 0xE0, 0x38, 0x06,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xE3, 0x86, 0xF9,
  0xBE, 0xFF, 0xFF, 0x3F, 0xF8, 0x03, 0x80, 0x07, 0xE0, 0x0E, 0xF0, 0x1E,
  0x70, 0x3C, 0x78, 0x38, 0x3C, 0x18, 0x10, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x08, 0x1E,
  0x3F, 0x3F, 0x3F, 0x1F, 0x0E, 0x0E, 0x1C, 0xFC, 0xF0, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x23, 0xEF, 0xBF, 0xFB, 0xE2, 0x00, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0x83, 0xC3, 0x80, 0xE3, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x3C, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F,
  0x87, 0x8F, 0xC3, 0x87, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00,
  0xF7, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x3C, 0x78, 0x1C, 0x1E, 0x3E, 0x07,
  0xFE, 0x01, 0xFC, 0x00, 0x30, 0x00, 0x01, 0x80, 0x0E, 0x00, 0xF8, 0x07,
  0xE0, 0x7D, 0x83, 0xC6, 0x0C, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x1F, 0xFF,
  0x7F, 0xFD, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xF0, 0xFF, 0xF8, 0xF0, 0x3C,
  0x40, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0x7F, 0xF0, 0xFF, 0xF8, 0x60, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0xE0, 0x7C,
  0xFF, 0xF8, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x1C, 0x38,
  0x0E, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0x60, 0x38, 0x38, 0x0E, 0x1C,
  0x03, 0x87, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x1F, 0xFE, 0x1F, 0xFE, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x60, 0x7C, 0xFF, 0xF8, 0x7F, 0xF0, 0x02, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0xE7, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0xC0, 0x38, 0xE0, 0x3C,
  0x7C, 0x3C, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x81, 0xC7, 0x80, 0x73,
  0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x3C, 0x03, 0x8E, 0x03,
  0x87, 0xC3, 0xC1, 0xFB, 0xC0, 0x7F, 0xC0, 0x7F, 0xF0, 0x78, 0x3C, 0x78,
  0x0F, 0x38, 0x03, 0xDC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1D,
  0xC0, 0x1E, 0xE0, 0x0E, 0x7C, 0x1F, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x10,
  0x00, 0x07, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0x03, 0xC7, 0x80, 0xF3,
  0x80, 0x3B, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xEE, 0x00, 0x77, 0x80, 0x39, 0xE0, 0x7C, 0xFF, 0xFE, 0x1F, 0xF7, 0x00,
  0x87, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x01, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0x80, 0x00, 0x23,
  0xEF, 0xBF, 0xFB, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x3E, 0xFB,
  0xFF, 0xBE, 0x20, 0x04, 0x0F, 0x87, 0xC3, 0xF1, 0xF0, 0xF8, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x1E, 0x1F, 0x0F, 0xC7,
  0xE3, 0xF0, 0x70, 0x38, 0x79, 0xF8, 0x78, 0x30, 0x00, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x01, 0x80, 0x00, 0x1F, 0x87, 0xFF, 0x1F, 0xFC, 0x80, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xC0, 0x08, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x1C,
  0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xC7, 0xE1, 0xE1, 0xF8, 0x70, 0x7E, 0x3C,
  0x1F, 0x8E, 0x07, 0xE3, 0x81, 0xF8, 0xE0, 0x7E, 0x38, 0x1F, 0xCE, 0x07,
  0xF1, 0xC1, 0xDC, 0x70, 0x77, 0x0F, 0x1D, 0xE3, 0xFF, 0x78, 0x3F, 0x8E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x37, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xC0, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x07, 0x03, 0x80, 0x38,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x18, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x77,
  0x80, 0x01, 0xC0, 0x0F, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x1C, 0x07, 0xCE,
  0x01, 0xE7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07,
  0x38, 0x07, 0x9C, 0x07, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0x87, 0xF9, 0xC0,
  0x1E, 0xE0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x1E, 0xE0, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0x71, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0x0F, 0x83, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x0C,
  0x00, 0x0C, 0x00, 0x7F, 0xF0, 0x3F, 0xFE, 0x1C, 0x0F, 0x8E, 0x01, 0xE7,
  0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x77, 0x00, 0x3B,
  0x80, 0x39, 0xC0, 0x7C, 0xF1, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0,
  0x21, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x77, 0x80,
  0x39, 0xC0, 0x1C, 0xF0, 0x0E, 0x3C, 0x07, 0x0F, 0x83, 0x83, 0xFF, 0xC0,
  0xFF, 0xE0, 0x05, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x40, 0x1E, 0x70, 0x3C, 0xFF, 0xF8, 0x3F, 0xF0, 0x01,
  0x00, 0xE0, 0x07, 0xB8, 0x03, 0xCE, 0x01, 0xE3, 0x80, 0xF0, 0xE0, 0x38,
  0x38, 0x1C, 0x0E, 0x0F, 0x03, 0x87, 0x80, 0xE3, 0xC0, 0x39, 0xE0, 0x0E,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0E, 0x78, 0x03, 0x8F,
  0x00, 0xE1, 0xE0, 0x38, 0x3C, 0x0E, 0x07, 0x83, 0x80, 0xF0, 0xE0, 0x1E,
  0x38, 0x03, 0x8E, 0x00, 0xF3, 0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0xF0,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1F,
  0x03, 0xC3, 0xE0, 0xF8, 0x6C, 0x1B, 0x8D, 0xC3, 0x71, 0xB8, 0xEE, 0x33,
  0x1D, 0xCE, 0x73, 0x39, 0xCE, 0x67, 0x38, 0xDC, 0xE7, 0x1F, 0x1C, 0xE1,
  0xE3, 0x9C, 0x3C, 0x73, 0x87, 0x06, 0x70, 0x00, 0xCE, 0x00, 0x19, 0xC0,
  0x03, 0x38, 0x00, 0x67, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x07, 0x60, 0x00, 0xFC, 0x00, 0x1C, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0x70, 0x1F, 0xB8, 0x0F, 0xCE, 0x07, 0xE3,
  0x83, 0xF1, 0xC1, 0xF8, 0x60, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x07, 0x1F,
  0x83, 0x8F, 0xC0, 0xE7, 0xE0, 0x73, 0xF0, 0x1D, 0xF8, 0x0E, 0xFC, 0x03,
  0x7E, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0x07, 0xC3,
  0xC0, 0x38, 0x70, 0x07, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x00, 0xEE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x03, 0xB8,
  0x00, 0xF7, 0x00, 0x1C, 0xF0, 0x03, 0x8E, 0x00, 0xF1, 0xE0, 0x3C, 0x1E,
  0x0F, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x07, 0x00, 0xFF,
  0xF0, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0,
  0x1E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0x07,
  0xC3, 0xC0, 0x38, 0x70, 0x07, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x00,
  0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0xF7, 0x00, 0x1C, 0xF0, 0x03, 0x8E, 0x00, 0xF1, 0xE0, 0x3C,
  0x1E, 0x0F, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x30,
  0x0F, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x1C, 0x07, 0xCE, 0x00, 0xE7, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC,
  0x01, 0xEE, 0x00, 0xE7, 0x01, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xE0, 0xF0,
  0x70, 0x38, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x00, 0xE0, 0x07, 0xF0,
  0x1F, 0xFE, 0x3F, 0xFE, 0x78, 0x0C, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x80, 0x0E, 0xF0, 0x3E,
  0xFF, 0xFC, 0x7F, 0xF0, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x39, 0xE0, 0x1C, 0x78, 0x3E, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0x20, 0x00,
  0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0x83, 0x80,
  0x38, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x33, 0x80, 0x06,
  0x70, 0x00, 0xCE, 0x00, 0x39, 0xC3, 0x87, 0x38, 0x78, 0xE7, 0x1F, 0x1C,
  0xE3, 0x63, 0x9C, 0x6E, 0x73, 0x9D, 0xCE, 0x73, 0x19, 0xCE, 0x63, 0xB8,
  0xDC, 0x77, 0x1B, 0x06, 0xC3, 0x60, 0xF8, 0x7C, 0x1F, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0x70, 0x70, 0x01, 0xE7, 0x00, 0x78,
  0xE0, 0x0E, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x1C, 0x03, 0xC3, 0x80,
  0x38, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0x1C, 0x01,
  0xE1, 0xC0, 0x38, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x78, 0x07, 0x0E,
  0x00, 0xE3, 0xC0, 0x0E, 0x70, 0x01, 0xDE, 0x00, 0x3C, 0xE0, 0x00, 0xFF,
  0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0x38, 0x03, 0xC3, 0x80, 0x38,
  0x1C, 0x07, 0x81, 0xC0, 0x70, 0x0E, 0x0F, 0x00, 0xE0, 0xE0, 0x07, 0x1C,
  0x00, 0x79, 0xC0, 0x03, 0xB8, 0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0xEE, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x38,
  0x0E, 0x1C, 0x03, 0x1C, 0x01, 0xCE, 0x00, 0x7E, 0x00, 0x39, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x20, 0xC3, 0xC3, 0x83,
  0x83, 0x83, 0x84, 0x3F, 0xF0, 0x7F, 0xF0, 0xF3, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0xFE, 0x7F, 0xFD, 0xFF, 0xFF,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0xF0,
  0x1D, 0xFF, 0xF8, 0xFF, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xEF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0xFC, 0xFF,
  0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xC7, 0xC0, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xC1, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x07, 0xF7, 0x1F, 0xFF, 0x3F, 0xFF, 0x3C, 0x0F,
  0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x78, 0x07,
  0x3C, 0x07, 0x3F, 0x0F, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xF8, 0x07, 0xFE,
  0x07, 0xCF, 0x87, 0x81, 0xE7, 0x80, 0x73, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xC3, 0x87, 0xFF,
  0xC0, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xF0, 0x60, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0x3C,
  0x07, 0x78, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78,
  0x07, 0x3E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x1E, 0x7F, 0xFE, 0x7F, 0xF8, 0x3F, 0xE0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xDF, 0xC3, 0xFF, 0xE7, 0xFF, 0xEE, 0x01, 0xDC,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0, 0x06, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xE7,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x60, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x7F, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x40, 0x7B, 0xDF, 0xBF,
  0xF8, 0x7F, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x03,
  0xB8, 0x03, 0x9C, 0x03, 0x8E, 0x03, 0x87, 0x07, 0x83, 0x87, 0x81, 0xC7,
  0x80, 0xE7, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0E, 0x78, 0x07,
  0x1F, 0x03, 0x87, 0xC1, 0xC0, 0xF0, 0xE0, 0x3C, 0x70, 0x0F, 0x38, 0x03,
  0x9C, 0x00, 0xEE, 0x00, 0x78, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xE7, 0x01,
  0xFF, 0x00, 0xFF, 0x7E, 0x3E, 0x3F, 0xFF, 0xCF, 0x3F, 0x7B, 0x87, 0x0E,
  0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8,
  0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0x3F, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x01, 0xEE, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x70, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0x81, 0xE7, 0x80,
  0x73, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1D, 0xC0, 0x1E, 0xE0, 0x0E,
  0x78, 0x0F, 0x1F, 0x1F, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xF0, 0x1E, 0xFC, 0x7C, 0xFF, 0xF8, 0xEF,
  0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x3C, 0x07, 0x78,
  0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78,
  0x07, 0x3E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0F, 0xFC, 0x7F, 0xF9, 0xF8, 0xF3,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0xE0, 0x7F, 0xFF, 0xF3, 0xFF, 0x80, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0xC7, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xB8, 0x07, 0x78, 0x0E, 0xF8, 0x3C, 0xFF, 0xF8,
  0x7F, 0xF0, 0xF0, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x3C, 0x00, 0xE3,
  0x80, 0x3C, 0x70, 0x07, 0x0F, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x38, 0x07, 0x07, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x00,
  0xE7, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0E, 0xC1, 0xC1, 0xDC, 0x38, 0x3B, 0x87, 0x86, 0x71, 0xF0, 0xCE,
  0x3E, 0x39, 0xC6, 0xE7, 0x39, 0xDC, 0xE3, 0x31, 0x9C, 0x76, 0x3B, 0x0F,
  0xC3, 0x61, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0x80, 0xF0, 0x70, 0x1C, 0x0E,
  0x01, 0x80, 0x70, 0x01, 0xC7, 0x00, 0x70, 0xF0, 0x1E, 0x0F, 0x03, 0x80,
  0xF0, 0xE0, 0x0E, 0x38, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x39, 0xC0, 0x0E, 0x3C, 0x03,
  0x83, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x87, 0x00, 0x79, 0xC0, 0x07, 0x78,
  0x00, 0xF0, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xF7, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x78, 0x1E, 0x1C, 0x0E, 0x0E, 0x07, 0x03,
  0x83, 0x81, 0xC3, 0x80, 0xF1, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x07, 0x70,
  0x03, 0xB8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x8F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x03, 0xF0, 0x0F, 0x80, 0x3F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x7C, 0x00, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x01, 0xFE,
  0x03, 0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x1E, 0x07, 0xFC, 0x0F, 0xE0, 0x00, 0x3E, 0x01, 0x3F, 0xC0, 0xDD,
  0xF8, 0xFC, 0x3F, 0xEC, 0x07, 0xF0, 0x00, 0xE0,
};

const GFXglyph UbuntuSansMono_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 27, 21, 8, -26 },
  { 18, 9, 10, 21, 6, -29 },
  { 30, 19, 26, 21, 1, -26 },
  { 92, 16, 33, 21, 3, -29 },
  { 158, 19, 28, 21, 1, -27 },
  { 225, 19, 27, 21, 1, -27 },
  { 290, 3, 11, 21, 9, -29 },
  { 295, 11, 37, 21, 5, -30 },
  { 346, 11, 37, 21, 5, -30 },
  { 397, 16, 15, 21, 3, -26 },
  { 427, 17, 18, 21, 2, -20 },
  { 466, 8, 12, 21, 7, -6 },
  { 478, 9, 3, 21, 6, -12 },
  { 482, 6, 7, 21, 8, -6 },
  { 488, 15, 37, 21, 3, -30 },
  { 558, 17, 28, 21, 2, -27 },
  { 618, 14, 26, 21, 4, -26 },
  { 664, 16, 27, 21, 3, -27 },
  { 718, 16, 28, 21, 3, -27 },
  { 774, 18, 26, 21, 2, -26 },
  { 833, 16, 27, 21, 3, -26 },
  { 887, 17, 27, 21, 2, -26 },
  { 945, 16, 26, 21, 3, -26 },
  { 997, 17, 28, 21, 2, -27 },
  { 1057, 17, 27, 21, 2, -27 },
  { 1115, 6, 21, 21, 8, -20 },
  { 1131, 9, 26, 21, 5, -20 },
  { 1161, 17, 16, 21, 2, -19 },
  { 1195, 17, 10, 21, 2, -16 },
  { 1217, 18, 16, 21, 2, -19 },
  { 1253, 13, 28, 21, 4, -27 },
  { 1299, 18, 33, 21, 2, -27 },
  { 1374, 21, 26, 21, 0, -26 },
  { 1443, 17, 27, 21, 2, -27 },
  { 1501, 17, 28, 21, 2, -27 },
  { 1561, 17, 27, 21, 2, -27 },
  { 1619, 16, 26, 21, 4, -26 },
  { 1671, 15, 26, 21, 4, -26 },
  { 1720, 17, 28, 21, 2, -27 },
  { 1780, 17, 26, 21, 2, -26 },
  { 1836, 13, 26, 21, 4, -26 },
  { 1879, 16, 27, 21, 2, -26 },
  { 1933, 18, 26, 21, 3, -26 },
  { 1992, 16, 26, 21, 4, -26 },
  { 2044, 19, 26, 21, 1, -26 },
  { 2106, 17, 26, 21, 2, -26 },
  { 2162, 19, 28, 21, 1, -27 },
  { 2229, 16, 27, 21, 3, -27 },
  { 2283, 19, 34, 21, 1, -27 },
  { 2364, 17, 27, 21, 2, -27 },
  { 2422, 16, 28, 21, 3, -27 },
  { 2478, 17, 26, 21, 2, -26 },
  { 2534, 17, 27, 21, 2, -26 },
  { 2592, 20, 26, 21, 1, -26 },
  { 2657, 19, 26, 21, 1, -26 },
  { 2719, 19, 26, 21, 1, -26 },
  { 2781, 20, 26, 21, 1, -26 },
  { 2846, 17, 26, 21, 2, -26 },
  { 2902, 10, 37, 21, 6, -30 },
  { 2949, 15, 37, 21, 3, -30 },
  { 3019, 10, 37, 21, 5, -30 },
  { 3066, 17, 14, 21, 2, -26 },
  { 3096, 21, 3, 21, 0, 4 },
  { 3104, 7, 8, 21, 7, -30 },
  { 3111, 15, 20, 21, 3, -20 },
  { 3149, 16, 29, 21, 3, -29 },
  { 3207, 17, 20, 21, 2, -20 },
  { 3250, 16, 29, 21, 2, -29 },
  { 3308, 17, 20, 21, 2, -20 },
  { 3351, 17, 29, 21, 3, -29 },
  { 3413, 16, 27, 21, 2, -20 },
  { 3467, 15, 29, 21, 3, -29 },
  { 3522, 16, 29, 21, 3, -29 },
  { 3580, 13, 36, 21, 3, -29 },
  { 3639, 17, 29, 21, 3, -29 },
  { 3701, 16, 29, 21, 3, -29 },
  { 3759, 18, 20, 21, 2, -20 },
  { 3804, 15, 20, 21, 3, -20 },
  { 3842, 17, 20, 21, 2, -20 },
  { 3885, 16, 27, 21, 3, -20 },
  { 3939, 16, 27, 21, 2, -20 },
  { 3993, 13, 20, 21, 5, -20 },
  { 4026, 15, 20, 21, 3, -20 },
  { 4064, 16, 26, 21, 3, -26 },
  { 4116, 15, 20, 21, 3, -20 },
  { 4154, 19, 20, 21, 1, -20 },
  { 4202, 19, 20, 21, 1, -20 },
  { 4250, 19, 20, 21, 1, -20 },
  { 4298, 17, 27, 21, 2, -20 },
  { 4356, 15, 20, 21, 3, -20 },
  { 4394, 14, 37, 21, 4, -30 },
  { 4459, 3, 37, 21, 9, -30 },
  { 4473, 15, 37, 21, 3, -30 },
  { 4543, 17, 6, 21, 2, -14 },
};

const GFXfont UbuntuSansMono_Regular38pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular38pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular38pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUSANSMONO_REGULAR38PT7B_H_
