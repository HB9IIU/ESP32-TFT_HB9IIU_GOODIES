#ifndef _UBUNTUSANSMONO_REGULAR9PT7B_H_
#define _UBUNTUSANSMONO_REGULAR9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x37, 0xD4, 0xAF, 0xB0, 0x5E, 0x62, 0x7A, 0xFD,
  0x98, 0x76, 0xCC, 0x72, 0x99, 0x69, 0x34, 0xE0, 0x2A, 0x49, 0x12, 0x20,
  0x88, 0x92, 0x52, 0x80, 0x5E, 0x80, 0x21, 0x3E, 0x42, 0x00, 0xE0, 0xE0,
  0x80, 0x24, 0xA4, 0xA4, 0x80, 0x72, 0x6B, 0x15, 0x38, 0x59, 0x25, 0xC0,
  0xE4, 0xA9, 0xC0, 0xE5, 0x13, 0xC0, 0x11, 0x95, 0x27, 0x88, 0xF3, 0x13,
  0xC0, 0x68, 0xE9, 0x9E, 0xF2, 0x44, 0x44, 0xF7, 0xDB, 0xC0, 0xF6, 0xB3,
  0x80, 0x90, 0x41, 0xC0, 0x16, 0x87, 0xF8, 0x3E, 0x84, 0x3C, 0xE5, 0x20,
  0x80, 0x72, 0x6F, 0x5A, 0xA9, 0xC0, 0x22, 0x94, 0xAA, 0xC4, 0xF7, 0xDB,
  0xC0, 0xF8, 0x88, 0x8F, 0xE9, 0x99, 0xAE, 0xE8, 0xE8, 0x8F, 0xF3, 0xC9,
  0x00, 0xF8, 0x89, 0x9F, 0x8C, 0x7F, 0x18, 0xC4, 0xE9, 0x25, 0xC0, 0xE4,
  0x93, 0xC0, 0xBC, 0x8C, 0xA9, 0x88, 0x88, 0x8F, 0x52, 0xAB, 0x58, 0xC4,
  0xB7, 0xFB, 0x40, 0x74, 0x63, 0x18, 0xB8, 0xE9, 0xAC, 0x88, 0x74, 0x63,
  0x18, 0xA8, 0x82, 0xEA, 0xAC, 0xAB, 0xF3, 0x13, 0xC0, 0xF9, 0x08, 0x42,
  0x10, 0x99, 0x99, 0x9E, 0x8C, 0x54, 0xA5, 0x10, 0x8C, 0x6B, 0x55, 0x28,
  0xDA, 0x88, 0xA5, 0x44, 0x8A, 0x94, 0x42, 0x10, 0xF2, 0x44, 0x8F, 0xEA,
  0xAA, 0xC0, 0x92, 0x24, 0x89, 0x20, 0xE4, 0x92, 0x49, 0xE0, 0x22, 0xA2,
  0xF8, 0xC0, 0xE7, 0xDE, 0x88, 0xE9, 0x99, 0xE0, 0x68, 0x88, 0xF0, 0x11,
  0x75, 0x99, 0x70, 0x32, 0x7F, 0x07, 0x00, 0x74, 0xE4, 0x44, 0x40, 0x75,
  0x99, 0x71, 0x60, 0x93, 0xDB, 0x68, 0x43, 0x24, 0x98, 0x63, 0x92, 0x49,
  0xC0, 0x88, 0x9E, 0x8E, 0xB0, 0xC9, 0x24, 0x98, 0xD5, 0x6B, 0x18, 0x80,
  0xF6, 0xDA, 0x32, 0xA3, 0x17, 0x00, 0xCA, 0x99, 0xE8, 0x80, 0x35, 0x99,
  0x71, 0x10, 0xF2, 0x48, 0xF3, 0x1E, 0x5D, 0x24, 0xC0, 0xB6, 0xDE, 0x8A,
  0x94, 0xA2, 0x00, 0x8D, 0x6B, 0xA5, 0x00, 0x8A, 0x88, 0xA8, 0x80, 0x8A,
  0x94, 0x62, 0x13, 0x00, 0xE5, 0x4E, 0x69, 0x28, 0x92, 0x20, 0xFF, 0x80,
  0xC9, 0x22, 0x92, 0x80, 0xF8,
};

const GFXglyph UbuntuSansMono_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -7 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 3, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 3, 5, 2, -7 },
  { 20, 3, 9, 5, 1, -7 },
  { 24, 3, 9, 5, 1, -7 },
  { 28, 3, 3, 5, 1, -6 },
  { 30, 5, 5, 5, 0, -5 },
  { 34, 2, 2, 5, 2, -1 },
  { 35, 3, 1, 5, 1, -3 },
  { 36, 1, 1, 5, 2, -1 },
  { 37, 3, 9, 5, 1, -7 },
  { 41, 5, 6, 5, 0, -6 },
  { 45, 3, 6, 5, 1, -6 },
  { 48, 3, 6, 5, 1, -6 },
  { 51, 3, 6, 5, 1, -6 },
  { 54, 5, 6, 5, 0, -6 },
  { 58, 3, 6, 5, 1, -6 },
  { 61, 4, 6, 5, 1, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 3, 6, 5, 1, -6 },
  { 70, 3, 6, 5, 1, -6 },
  { 73, 1, 4, 5, 2, -4 },
  { 74, 2, 5, 5, 1, -4 },
  { 76, 4, 4, 5, 1, -5 },
  { 78, 5, 3, 5, 0, -4 },
  { 80, 4, 4, 5, 1, -5 },
  { 82, 3, 6, 5, 1, -6 },
  { 85, 5, 7, 5, 0, -6 },
  { 90, 5, 6, 5, 0, -6 },
  { 94, 3, 6, 5, 1, -6 },
  { 97, 4, 6, 5, 1, -6 },
  { 100, 4, 6, 5, 1, -6 },
  { 103, 4, 6, 5, 1, -6 },
  { 106, 3, 6, 5, 1, -6 },
  { 109, 4, 6, 5, 1, -6 },
  { 112, 5, 6, 5, 0, -6 },
  { 116, 3, 6, 5, 1, -6 },
  { 119, 3, 6, 5, 1, -6 },
  { 122, 4, 6, 5, 1, -6 },
  { 125, 4, 6, 5, 1, -6 },
  { 128, 5, 6, 5, 0, -6 },
  { 132, 3, 6, 5, 1, -6 },
  { 135, 5, 6, 5, 0, -6 },
  { 139, 4, 6, 5, 1, -6 },
  { 142, 5, 8, 5, 0, -6 },
  { 147, 4, 6, 5, 1, -6 },
  { 150, 3, 6, 5, 1, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 4, 6, 5, 1, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 5, 6, 5, 0, -6 },
  { 168, 5, 6, 5, 0, -6 },
  { 172, 5, 6, 5, 0, -6 },
  { 176, 4, 6, 5, 1, -6 },
  { 179, 2, 9, 5, 2, -7 },
  { 182, 3, 9, 5, 1, -7 },
  { 186, 3, 9, 5, 1, -7 },
  { 190, 5, 3, 5, 0, -6 },
  { 192, 5, 1, 5, 0, 1 },
  { 193, 1, 2, 5, 2, -7 },
  { 194, 3, 5, 5, 1, -5 },
  { 196, 4, 7, 5, 1, -7 },
  { 200, 4, 5, 5, 1, -5 },
  { 203, 4, 7, 5, 0, -7 },
  { 207, 5, 5, 5, 0, -5 },
  { 211, 4, 7, 5, 1, -7 },
  { 215, 4, 7, 5, 0, -5 },
  { 219, 3, 7, 5, 1, -7 },
  { 222, 3, 7, 5, 1, -7 },
  { 225, 3, 9, 5, 1, -7 },
  { 229, 4, 7, 5, 1, -7 },
  { 233, 3, 7, 5, 1, -7 },
  { 236, 5, 5, 5, 0, -5 },
  { 240, 3, 5, 5, 1, -5 },
  { 242, 5, 5, 5, 0, -5 },
  { 246, 4, 7, 5, 1, -5 },
  { 250, 4, 7, 5, 0, -5 },
  { 254, 3, 5, 5, 1, -5 },
  { 256, 3, 5, 5, 1, -5 },
  { 258, 3, 6, 5, 1, -6 },
  { 261, 3, 5, 5, 1, -5 },
  { 263, 5, 5, 5, 0, -5 },
  { 267, 5, 5, 5, 0, -5 },
  { 271, 5, 5, 5, 0, -5 },
  { 275, 5, 7, 5, 0, -5 },
  { 280, 3, 5, 5, 1, -5 },
  { 282, 3, 9, 5, 1, -7 },
  { 286, 1, 9, 5, 2, -7 },
  { 288, 3, 9, 5, 1, -7 },
  { 292, 5, 1, 5, 0, -3 },
};

const GFXfont UbuntuSansMono_Regular9pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular9pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUSANSMONO_REGULAR9PT7B_H_
