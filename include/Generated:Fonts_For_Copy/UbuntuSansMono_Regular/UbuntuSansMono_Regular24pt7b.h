#ifndef _UBUNTUSANSMONO_REGULAR24PT7B_H_
#define _UBUNTUSANSMONO_REGULAR24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x69, 0x00, 0x3F, 0xE0, 0x8E, 0x38, 0xE3, 0x8A,
  0x20, 0x0C, 0x60, 0xC6, 0x18, 0x41, 0x8C, 0x18, 0xCF, 0xFF, 0x18, 0xC3,
  0x08, 0x31, 0x83, 0x18, 0x31, 0x8F, 0xFF, 0xFF, 0xF6, 0x30, 0x63, 0x06,
  0x30, 0x63, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x7C, 0x7F, 0xB0, 0x0C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x81,
  0xBF, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x70, 0x3D, 0x86, 0x88, 0x48,
  0x8C, 0x89, 0x88, 0x90, 0xDB, 0x07, 0x20, 0x06, 0x00, 0xDE, 0x09, 0x21,
  0xB3, 0x13, 0x33, 0x33, 0x63, 0x34, 0x33, 0xC1, 0xE0, 0x1E, 0x03, 0xF0,
  0x61, 0x86, 0x18, 0x61, 0x06, 0x30, 0x36, 0x03, 0xC0, 0x38, 0x66, 0xC4,
  0x66, 0x4C, 0x3C, 0xC1, 0xCC, 0x1C, 0xC1, 0xC7, 0x76, 0x3E, 0x70, 0xFF,
  0xE8, 0x04, 0x0C, 0x30, 0xC3, 0x06, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x30, 0x60, 0xC0, 0xC1, 0xC1, 0xC1, 0xC1, 0x80, 0x41, 0xC1,
  0xC1, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x0C, 0x18, 0x70, 0xC3, 0x0C, 0x38, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0x32,
  0xFB, 0xCF, 0x81, 0xC0, 0xD8, 0x73, 0x88, 0xC0, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x11, 0xCE, 0x71, 0x9F, 0xD8, 0xFF, 0xC0, 0x4E, 0xFE, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x00,
  0x0F, 0x07, 0xF0, 0xC3, 0x30, 0x66, 0x06, 0xC0, 0xF8, 0x1E, 0x73, 0xCE,
  0x78, 0xCF, 0x01, 0xB0, 0x36, 0x06, 0xC1, 0x9C, 0x31, 0xCC, 0x1F, 0x00,
  0x06, 0x03, 0x81, 0xE1, 0xD8, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x61, 0xFF, 0x7F, 0xC0, 0x3E, 0x3F,
  0xCC, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x18, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0x3F, 0xC8, 0x38,
  0x06, 0x01, 0x80, 0x60, 0x30, 0x78, 0x1F, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0xC0, 0x30, 0x1B, 0x9E, 0xFF, 0x00, 0x01, 0x80, 0x70, 0x0E, 0x03, 0x40,
  0xC8, 0x31, 0x06, 0x21, 0x84, 0x60, 0x8C, 0x13, 0x02, 0x7F, 0xFF, 0xFE,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x3F, 0x9F, 0xE6, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xF8, 0x3F, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x30,
  0x1B, 0x9E, 0xFF, 0x00, 0x00, 0xC0, 0xF8, 0x70, 0x1C, 0x03, 0x00, 0xC0,
  0x18, 0x03, 0xFC, 0x7F, 0xD8, 0x1F, 0x01, 0xB0, 0x36, 0x06, 0xC0, 0xD8,
  0x31, 0xCE, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x40,
  0x30, 0x00, 0x1F, 0x07, 0xF9, 0x83, 0x30, 0x26, 0x06, 0xC0, 0x9C, 0x31,
  0xCC, 0x1F, 0x06, 0x79, 0x83, 0x30, 0x3C, 0x06, 0x80, 0xD8, 0x1B, 0xCE,
  0x3F, 0x80, 0x1F, 0x07, 0xF1, 0x83, 0x30, 0x6C, 0x07, 0x80, 0xD0, 0x1B,
  0x03, 0x70, 0xE7, 0xFC, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE3, 0xF0,
  0x78, 0x00, 0x4E, 0xFE, 0x00, 0x00, 0x04, 0xEF, 0xE0, 0x10, 0xE3, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x43, 0x8F, 0x3C, 0x63, 0xBC, 0x40, 0x00, 0x60,
  0x3C, 0x1E, 0x1E, 0x0F, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0C,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x40, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0xF0, 0x78, 0xF8, 0x0C, 0x00, 0x7C,
  0xFE, 0x07, 0x03, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x00, 0x00,
  0x00, 0x30, 0x78, 0x38, 0x0F, 0x81, 0xFC, 0x30, 0x63, 0x06, 0x60, 0x26,
  0x03, 0x63, 0xFC, 0x63, 0xCE, 0x3C, 0xC3, 0xCC, 0x3C, 0xC3, 0xEC, 0x36,
  0x63, 0x67, 0xF6, 0x1E, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x03, 0x80,
  0x07, 0x00, 0x38, 0x01, 0x60, 0x1B, 0x00, 0xCC, 0x04, 0x60, 0x63, 0x03,
  0x08, 0x10, 0x61, 0x83, 0x0C, 0x08, 0x7F, 0xE7, 0xFF, 0x30, 0x19, 0x80,
  0x6C, 0x03, 0xC0, 0x18, 0x7E, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x81,
  0xB0, 0x36, 0x7C, 0xFF, 0x98, 0x3B, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x37, 0x3E, 0xFF, 0x00, 0x07, 0xC3, 0xFC, 0xE0, 0x98, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xE3, 0x0F, 0xE0, 0x7C, 0x1F, 0xE3, 0x06, 0x60, 0x6C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xB0,
  0x77, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xFE, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x07, 0xC3, 0xFC, 0xE0,
  0x98, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x0D, 0x01, 0xB0,
  0x36, 0x06, 0xC0, 0xCC, 0x18, 0xE3, 0x0F, 0xE0, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0xFF, 0xFF, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF,
  0xFF, 0x3F, 0x9F, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0xCE, 0xFE, 0x00, 0xC0, 0xF8, 0x1B,
  0x06, 0x61, 0x8C, 0x61, 0x98, 0x37, 0x07, 0xC0, 0xF0, 0x1B, 0x83, 0x38,
  0x63, 0x8C, 0x31, 0x83, 0x30, 0x76, 0x06, 0xC0, 0x60, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0xFF, 0xFF, 0x80, 0x60, 0xC6, 0x0C, 0x70, 0xE7, 0x1E, 0x51,
  0xE5, 0x96, 0x5B, 0x6C, 0xB6, 0xCE, 0x6C, 0x66, 0xC6, 0x6C, 0x06, 0xC0,
  0x6C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x30, 0xC0, 0xF0, 0x3E, 0x0F, 0x83,
  0xB0, 0xE4, 0x39, 0x8E, 0x23, 0x8C, 0xE3, 0x38, 0x6E, 0x1B, 0x83, 0xE0,
  0xF8, 0x1E, 0x07, 0x80, 0xC0, 0x1F, 0x03, 0xFC, 0x60, 0xC6, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x66, 0x06, 0x60, 0xE3, 0x1C, 0x1F, 0x80, 0x7E, 0x3F, 0xEC, 0x1B, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xBF, 0xCF, 0x83, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1F, 0x03, 0xFC, 0x60, 0xC6, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02, 0xC0,
  0x6E, 0x06, 0x60, 0xE3, 0x1C, 0x1F, 0x80, 0x60, 0x06, 0x00, 0x38, 0x01,
  0xE0, 0xFC, 0x3F, 0xC8, 0x3A, 0x06, 0x81, 0xA0, 0x28, 0x1A, 0x06, 0x87,
  0x3F, 0x88, 0x62, 0x18, 0x83, 0x20, 0x48, 0x1A, 0x03, 0x80, 0xC0, 0x3F,
  0x1F, 0xEE, 0x0B, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0x8E, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x06, 0xC0, 0xD8, 0x3B, 0xCE, 0x3F, 0x80, 0xC0, 0x1B, 0x00,
  0xD8, 0x06, 0xC0, 0x66, 0x03, 0x18, 0x18, 0xC0, 0x86, 0x0C, 0x18, 0x60,
  0xC3, 0x06, 0x30, 0x11, 0x80, 0xCC, 0x06, 0xC0, 0x16, 0x00, 0xF0, 0x07,
  0x00, 0xC0, 0x3C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x6C,
  0x66, 0xCE, 0x6C, 0xA6, 0xCB, 0x65, 0x96, 0x51, 0xE5, 0x1E, 0x70, 0xE7,
  0x0C, 0x60, 0xC0, 0xC0, 0x66, 0x06, 0x60, 0xC3, 0x0C, 0x31, 0x81, 0xB0,
  0x1B, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x1B, 0x03, 0x18, 0x31, 0x86, 0x0C,
  0x60, 0xCE, 0x06, 0xC0, 0x70, 0xE0, 0x1B, 0x00, 0xD8, 0x0C, 0x60, 0x63,
  0x06, 0x0C, 0x30, 0x63, 0x01, 0x98, 0x0D, 0x80, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x7F, 0xEF, 0xFC,
  0x03, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0F, 0xC0, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60,
  0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x00,
  0xC0, 0x60, 0x10, 0x0C, 0x06, 0xFF, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x1F, 0xC0, 0x06,
  0x01, 0xC0, 0x3C, 0x0D, 0x83, 0x18, 0x61, 0x18, 0x33, 0x03, 0xC0, 0x60,
  0xFF, 0xF8, 0x47, 0x18, 0x61, 0x80, 0x3E, 0x1F, 0xC0, 0x18, 0x06, 0x00,
  0xC1, 0x37, 0xFF, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x87, 0x7F, 0xC0, 0x40,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xC3, 0xFC, 0xE1, 0xB0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xB9, 0xEF, 0xE0, 0x03,
  0x83, 0xFC, 0xE0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x1F, 0x31, 0xFE, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC3, 0x99, 0xFF, 0x70, 0xEC, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1B, 0x03, 0x60, 0x67, 0xBC, 0x7F, 0x80, 0x0F, 0x07, 0xF1, 0xC3,
  0x30, 0x3C, 0x07, 0x80, 0xFF, 0xFE, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x1E,
  0xE1, 0xFC, 0x01, 0x01, 0xFC, 0x70, 0x8C, 0x03, 0x00, 0x60, 0x0C, 0x07,
  0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0x8F, 0xF7, 0x05, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x58, 0x17, 0x0C, 0xFF, 0x0E, 0x40, 0x30, 0x0D,
  0x07, 0x7F, 0x82, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D,
  0xC3, 0xFC, 0xC3, 0xB0, 0x6C, 0x0B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0C, 0x38, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x0E, 0xC3, 0xF0, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x47,
  0xFE, 0x10, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x0E, 0xC3, 0x18, 0xC3, 0x30, 0x7C, 0x0F, 0x01, 0xB8, 0x33, 0x86, 0x38,
  0xC3, 0x98, 0x3B, 0x03, 0x80, 0xF8, 0x3E, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x03, 0xB0, 0xFC, 0x79, 0x9F, 0xFF, 0x19, 0xE3, 0x1C, 0x63,
  0x8C, 0x71, 0x8E, 0x31, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x3C,
  0x3F, 0xCC, 0x3B, 0x06, 0xC0, 0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xC0, 0x0E, 0x07, 0xF1, 0xC7, 0x30, 0x7C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x6C, 0x0D, 0x83, 0x1D, 0xE1, 0xF8, 0x3C, 0x3F,
  0xCC, 0x3B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B,
  0xFE, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0x0F, 0xF7, 0x05,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x58, 0x16, 0x04, 0xFF, 0x1F,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0xFF, 0xB0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x0F, 0x1F, 0xEC,
  0x0B, 0x00, 0xC0, 0x1C, 0x03, 0xE0, 0x3C, 0x01, 0x80, 0x30, 0x0F, 0x8E,
  0xFF, 0x00, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xFF, 0xCC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0xEC, 0x3F, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x5E, 0xE7, 0xF0,
  0xC0, 0x7E, 0x06, 0x60, 0x66, 0x0C, 0x30, 0xC3, 0x18, 0x31, 0x81, 0x98,
  0x1B, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x62,
  0xCE, 0x6C, 0xE6, 0x4B, 0x65, 0x96, 0x79, 0xE7, 0x1C, 0x70, 0xC6, 0x0C,
  0xE0, 0xE3, 0x0C, 0x39, 0x81, 0xB0, 0x0F, 0x00, 0x60, 0x0F, 0x01, 0xB8,
  0x31, 0x87, 0x0C, 0x60, 0x6C, 0x07, 0xE0, 0x6C, 0x0D, 0x81, 0x98, 0x63,
  0x0C, 0x61, 0x86, 0x60, 0xCC, 0x0D, 0x81, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x03, 0x07, 0xC0, 0x40, 0x00, 0xFF, 0x81, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE0, 0x60, 0x60, 0x60, 0x30, 0x3F, 0xFF, 0xF0, 0x03, 0x87, 0xC6, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x1E, 0x0F, 0x00, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x7E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x04, 0x02, 0x01, 0x80, 0x70, 0x78, 0x30, 0x10, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x63, 0xE0, 0x38, 0x2F, 0xCF, 0x1F, 0xA0, 0xC0,
};

const GFXglyph UbuntuSansMono_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 17, 13, 5, -17 },
  { 8, 6, 6, 13, 4, -18 },
  { 13, 12, 17, 13, 1, -17 },
  { 39, 10, 22, 13, 2, -19 },
  { 67, 12, 17, 13, 1, -17 },
  { 93, 12, 17, 13, 1, -17 },
  { 119, 2, 7, 13, 6, -18 },
  { 121, 7, 23, 13, 3, -19 },
  { 142, 7, 23, 13, 3, -19 },
  { 163, 10, 10, 13, 2, -17 },
  { 176, 11, 12, 13, 1, -13 },
  { 193, 5, 8, 13, 4, -4 },
  { 198, 5, 2, 13, 4, -8 },
  { 200, 4, 4, 13, 5, -4 },
  { 202, 9, 23, 13, 2, -19 },
  { 228, 11, 17, 13, 1, -17 },
  { 252, 10, 17, 13, 2, -17 },
  { 274, 10, 17, 13, 2, -17 },
  { 296, 10, 17, 13, 2, -17 },
  { 318, 11, 17, 13, 1, -17 },
  { 342, 10, 17, 13, 2, -17 },
  { 364, 11, 17, 13, 1, -17 },
  { 388, 10, 17, 13, 2, -17 },
  { 410, 11, 17, 13, 1, -17 },
  { 434, 11, 17, 13, 1, -17 },
  { 458, 4, 13, 13, 5, -13 },
  { 465, 6, 17, 13, 3, -13 },
  { 478, 11, 10, 13, 1, -12 },
  { 492, 11, 6, 13, 1, -10 },
  { 501, 11, 10, 13, 1, -12 },
  { 515, 8, 17, 13, 3, -17 },
  { 532, 12, 21, 13, 1, -17 },
  { 564, 13, 17, 13, 0, -17 },
  { 592, 11, 17, 13, 1, -17 },
  { 616, 11, 17, 13, 1, -17 },
  { 640, 11, 17, 13, 1, -17 },
  { 664, 9, 17, 13, 3, -17 },
  { 684, 9, 17, 13, 3, -17 },
  { 704, 11, 17, 13, 1, -17 },
  { 728, 11, 17, 13, 1, -17 },
  { 752, 8, 17, 13, 3, -17 },
  { 769, 9, 17, 13, 2, -17 },
  { 789, 11, 17, 13, 2, -17 },
  { 813, 9, 17, 13, 3, -17 },
  { 833, 12, 17, 13, 1, -17 },
  { 859, 10, 17, 13, 2, -17 },
  { 881, 12, 17, 13, 1, -17 },
  { 907, 10, 17, 13, 2, -17 },
  { 929, 12, 21, 13, 1, -17 },
  { 961, 10, 17, 13, 2, -17 },
  { 983, 10, 17, 13, 2, -17 },
  { 1005, 11, 17, 13, 1, -17 },
  { 1029, 11, 17, 13, 1, -17 },
  { 1053, 13, 17, 13, 0, -17 },
  { 1081, 12, 17, 13, 1, -17 },
  { 1107, 12, 17, 13, 1, -17 },
  { 1133, 13, 17, 13, 0, -17 },
  { 1161, 11, 17, 13, 1, -17 },
  { 1185, 6, 23, 13, 4, -19 },
  { 1203, 9, 23, 13, 2, -19 },
  { 1229, 6, 23, 13, 3, -19 },
  { 1247, 11, 9, 13, 1, -17 },
  { 1260, 13, 1, 13, 0, 3 },
  { 1262, 5, 5, 13, 4, -19 },
  { 1266, 10, 13, 13, 2, -13 },
  { 1283, 10, 19, 13, 2, -19 },
  { 1307, 11, 13, 13, 1, -13 },
  { 1325, 11, 19, 13, 1, -19 },
  { 1352, 11, 13, 13, 1, -13 },
  { 1370, 11, 19, 13, 2, -19 },
  { 1397, 10, 18, 13, 1, -13 },
  { 1420, 10, 19, 13, 2, -19 },
  { 1444, 10, 18, 13, 2, -18 },
  { 1467, 8, 23, 13, 2, -18 },
  { 1490, 11, 19, 13, 2, -19 },
  { 1517, 10, 19, 13, 2, -19 },
  { 1541, 11, 13, 13, 1, -13 },
  { 1559, 10, 13, 13, 2, -13 },
  { 1576, 11, 13, 13, 1, -13 },
  { 1594, 10, 17, 13, 2, -13 },
  { 1616, 10, 17, 13, 1, -13 },
  { 1638, 9, 13, 13, 3, -13 },
  { 1653, 10, 13, 13, 2, -13 },
  { 1670, 10, 16, 13, 2, -16 },
  { 1690, 9, 12, 13, 2, -12 },
  { 1704, 12, 12, 13, 1, -12 },
  { 1722, 12, 12, 13, 1, -12 },
  { 1740, 12, 12, 13, 1, -12 },
  { 1758, 11, 17, 13, 1, -12 },
  { 1782, 9, 12, 13, 2, -12 },
  { 1796, 9, 23, 13, 2, -19 },
  { 1822, 2, 23, 13, 6, -19 },
  { 1828, 9, 23, 13, 2, -19 },
  { 1854, 11, 4, 13, 1, -9 },
};

const GFXfont UbuntuSansMono_Regular24pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular24pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular24pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUSANSMONO_REGULAR24PT7B_H_
