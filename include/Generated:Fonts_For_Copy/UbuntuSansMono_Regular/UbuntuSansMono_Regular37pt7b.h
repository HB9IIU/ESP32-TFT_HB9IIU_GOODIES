#ifndef _UBUNTUSANSMONO_REGULAR37PT7B_H_
#define _UBUNTUSANSMONO_REGULAR37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0x8C, 0x60,
  0x00, 0x00, 0x33, 0xDF, 0xFF, 0x80, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x07, 0x83, 0xC1, 0x60, 0x80, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E,
  0x0E, 0x01, 0xC1, 0x80, 0x38, 0x30, 0x06, 0x0E, 0x01, 0xC1, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x18, 0x38, 0x07, 0x07, 0x00, 0xE0,
  0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x60, 0xE0, 0x1C, 0x1C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8E, 0x0C, 0x01, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0x38, 0x30, 0x07, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0xFE, 0x1F, 0xFE, 0x3C, 0x04,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x40, 0x0F, 0x78, 0x3E,
  0xFF, 0xFC, 0x3F, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x3E, 0x00, 0xCF, 0xE0, 0x3B, 0x8C, 0x0E, 0x71, 0x81, 0x8C,
  0x38, 0x71, 0x87, 0x0C, 0x30, 0xE3, 0x86, 0x1C, 0xE0, 0xC3, 0x98, 0x1C,
  0x67, 0x01, 0x9C, 0xC0, 0x3F, 0x38, 0x01, 0x8E, 0x00, 0x01, 0x80, 0x00,
  0x73, 0xE0, 0x0C, 0xFE, 0x03, 0x98, 0xC0, 0xE7, 0x1C, 0x18, 0xC3, 0x87,
  0x18, 0x30, 0xC3, 0x06, 0x38, 0x61, 0xCE, 0x0E, 0x39, 0x81, 0xC6, 0x70,
  0x1D, 0xDC, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00,
  0x78, 0xE0, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xC0, 0x1C, 0x38, 0x03, 0x8E, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x30, 0x3F, 0x07, 0x0F, 0x70, 0xE1, 0xCF, 0x18, 0x70, 0xF3, 0x0E,
  0x0F, 0xE1, 0xC0, 0xFC, 0x78, 0x0F, 0x0F, 0x00, 0xE0, 0xE0, 0x3E, 0x1E,
  0x07, 0xE3, 0xE3, 0xDC, 0x3F, 0xF3, 0xC1, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF,
  0xDB, 0x00, 0x00, 0x80, 0x38, 0x0F, 0x83, 0xC0, 0xF0, 0x1C, 0x07, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x00, 0x40, 0x40, 0x0C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x01, 0x80, 0x20, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x41, 0xC2, 0x79, 0xCF, 0x7F, 0xBF, 0xFF, 0xFE, 0x03, 0xC0,
  0x03, 0xE0, 0x07, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x1C, 0x3C, 0x0C, 0x18,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x0F, 0x0F, 0x87, 0xE3, 0xF1, 0xF0, 0x38, 0x3C, 0x3C,
  0xFC, 0x3C, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x27, 0xFF, 0xFF, 0xFC,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFC,
  0x07, 0xDF, 0x07, 0x83, 0xC3, 0x80, 0xE3, 0x80, 0x79, 0xC0, 0x1C, 0xE0,
  0x0E, 0xF0, 0x07, 0x70, 0x03, 0xB8, 0x71, 0xFC, 0x7C, 0xFE, 0x3E, 0x7F,
  0x1F, 0x3F, 0x87, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0xF3, 0xC0, 0x70, 0xE0, 0x78, 0x3C, 0x78, 0x1F,
  0xF8, 0x03, 0xF8, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x3E, 0x01, 0xFC, 0x1F, 0xB8, 0x1C, 0x70, 0x20, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x3F, 0xFE, 0x7F, 0xFC, 0x1F, 0xE0, 0xFF, 0xE3, 0xE7,
  0xE7, 0x01, 0xE4, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0xE1,
  0xE7, 0xE2, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x70, 0x3E, 0xFF, 0xF9, 0xFF, 0xC0, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0E, 0xE0,
  0x0E, 0x70, 0x0E, 0x38, 0x06, 0x1C, 0x07, 0x0E, 0x07, 0x07, 0x03, 0x03,
  0x83, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF9, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x70, 0x3E, 0xFF, 0xF8, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x0E,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x70, 0x0F, 0xFF, 0x0F,
  0xFF, 0xE7, 0xC0, 0xF3, 0x80, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xBC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x3C, 0x78,
  0x3C, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x3E, 0x38, 0x0E, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78, 0x0E, 0x3C, 0x1E, 0x1E, 0x3C,
  0x0F, 0xF8, 0x0F, 0xFC, 0x3C, 0x7E, 0x38, 0x1E, 0x70, 0x0F, 0x70, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x1E,
  0x3F, 0xFE, 0x1F, 0xF8, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x3C,
  0x78, 0x1E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x07, 0x3F, 0xFF, 0x1F, 0xFF,
  0x07, 0xC7, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x3E, 0x00, 0x27, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9F, 0xFF, 0xFF, 0xF0, 0x04,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x07, 0x0E, 0x1E, 0xFC, 0x78,
  0x40, 0x00, 0x00, 0x80, 0x01, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x06, 0x00,
  0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0x30, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x1F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0xC7, 0xFF, 0x18, 0x7C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x03, 0xEF, 0x83, 0xC0, 0xE3, 0xC0, 0x39, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x0F, 0xB8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3C, 0x7E, 0x3C, 0x3F,
  0x1C, 0x1F, 0x8E, 0x0F, 0xC7, 0x07, 0xE3, 0x83, 0xF1, 0xC1, 0xF8, 0xE0,
  0xFE, 0x70, 0x7F, 0x1C, 0x3B, 0x8F, 0x1D, 0xC3, 0xFE, 0xF0, 0x7F, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x20, 0x3F, 0xF0,
  0x07, 0xF8, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1D, 0xC0, 0x01, 0xDC, 0x00, 0x39, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x81, 0xC0, 0x18, 0x1C, 0x01, 0xC1, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x7F, 0xC0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xFC, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF,
  0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xF7, 0xC3, 0xC0, 0x23, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3F, 0x06, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x08, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1C, 0x07, 0x8E, 0x01, 0xE7, 0x00, 0x73,
  0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0xF1,
  0xC3, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xF7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEE, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xE3,
  0xC3, 0xC0, 0x23, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00,
  0x73, 0x80, 0x39, 0xE0, 0x1C, 0x78, 0x0E, 0x3E, 0x07, 0x0F, 0xFF, 0x81,
  0xFF, 0x80, 0x08, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xD0, 0x07, 0x38, 0x1E, 0xFF, 0xF8, 0x7F, 0xE0, 0x0C, 0x00, 0xE0, 0x07,
  0xF0, 0x07, 0xB8, 0x07, 0x9C, 0x03, 0x8E, 0x03, 0x87, 0x03, 0xC3, 0x83,
  0xC1, 0xC3, 0xC0, 0xE3, 0xC0, 0x73, 0xC0, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xF8, 0x03, 0xBE, 0x01, 0xC7, 0x80, 0xE1, 0xE0, 0x70, 0x78,
  0x38, 0x1E, 0x1C, 0x07, 0x0E, 0x03, 0xC7, 0x00, 0xF3, 0x80, 0x39, 0xC0,
  0x0E, 0xE0, 0x07, 0xF0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x0F, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x0F, 0x8F, 0x83, 0x63, 0x60, 0xD8, 0xDC,
  0x76, 0x37, 0x19, 0x9C, 0xC6, 0x67, 0x33, 0x99, 0xCE, 0xC7, 0x71, 0xB1,
  0xDC, 0x7C, 0x77, 0x0E, 0x1D, 0xC3, 0x87, 0x70, 0x01, 0xDC, 0x00, 0x77,
  0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xEC, 0x03, 0xEE, 0x03, 0xE6, 0x03, 0xE7, 0x03,
  0xE3, 0x03, 0xE3, 0x83, 0xE1, 0x83, 0xE1, 0xC3, 0xE0, 0xC3, 0xE0, 0xE3,
  0xE0, 0xE3, 0xE0, 0x73, 0xE0, 0x73, 0xE0, 0x3B, 0xE0, 0x3B, 0xE0, 0x1B,
  0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7C, 0x7C, 0x1E, 0x03, 0x83, 0x80, 0x38, 0xF0, 0x07,
  0x1C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0E,
  0xE0, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x3C,
  0x70, 0x07, 0x0F, 0x01, 0xE0, 0xF0, 0x78, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF, 0xFC, 0xE0, 0x1C, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0,
  0x7C, 0x7C, 0x1E, 0x03, 0x83, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0E, 0xE0, 0x01, 0xCE,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38, 0x70, 0x07, 0x0F,
  0x01, 0xE0, 0xF0, 0x78, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00,
  0x01, 0x80, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1C, 0x03, 0xCE, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8,
  0x03, 0x9C, 0x01, 0xCE, 0x03, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0,
  0xE0, 0x70, 0x70, 0x38, 0x38, 0x0E, 0x1C, 0x03, 0x0E, 0x01, 0xC7, 0x00,
  0x73, 0x80, 0x39, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xC0, 0x07, 0xFC,
  0x1F, 0xFE, 0x3F, 0x1E, 0x38, 0x02, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x40, 0x0F, 0x70, 0x1E, 0xFF, 0xFC,
  0x3F, 0xF8, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x6E, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x3C, 0x78, 0x3C, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x20, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03,
  0x9C, 0x00, 0x73, 0x80, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0C,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x03, 0x80, 0x70, 0x70,
  0x0E, 0x0E, 0x00, 0xC3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x73, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x0E,
  0x1D, 0xC7, 0x87, 0x71, 0xE1, 0xDC, 0x7C, 0x77, 0x1B, 0x19, 0xCC, 0xC6,
  0x73, 0x39, 0x9C, 0xC6, 0x67, 0x71, 0x98, 0xD8, 0x76, 0x36, 0x0D, 0x8F,
  0x83, 0x63, 0xC0, 0xF8, 0xF0, 0x1E, 0x3C, 0x07, 0x0E, 0x01, 0xC0, 0x70,
  0x01, 0xCE, 0x00, 0x78, 0xE0, 0x0E, 0x1E, 0x03, 0x81, 0xC0, 0x70, 0x3C,
  0x1C, 0x03, 0x87, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0x77, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3D,
  0xC0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x70, 0x0E, 0x0E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x01, 0xDE, 0x00,
  0x3C, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x80,
  0x38, 0x70, 0x07, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x01, 0xC1,
  0xC0, 0x3C, 0x70, 0x03, 0x8E, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x71, 0xC0, 0x30, 0xE0,
  0x38, 0x38, 0x38, 0x1C, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0xEE, 0x00,
  0x3A, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x43,
  0x8F, 0x1C, 0x38, 0x70, 0xC0, 0x03, 0x80, 0x7F, 0xE0, 0xFF, 0xE1, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x03, 0x8E, 0x3F, 0xFD,
  0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xF0, 0x1D, 0xFF, 0xF8, 0xFF, 0xF0, 0x20, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE1, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xF8, 0x3C, 0xE0, 0x1E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C, 0xF0,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x70, 0x03, 0xFF, 0x83, 0xFF, 0xC7,
  0xE0, 0x23, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x81, 0x83, 0xFF, 0xC0, 0x7F, 0xF0,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x01, 0x87, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3C, 0x1F, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0x70, 0x07, 0x78, 0x07, 0x3F, 0x0F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xC0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x3B, 0x80,
  0x1D, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x83,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0xFF, 0xE0,
  0xF0, 0x20, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3C, 0x0F, 0x78, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0x78, 0x07, 0x3C, 0x3F, 0x3F, 0xFF, 0x0F, 0xF7, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x40, 0x1E, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F,
  0xC0, 0x20, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC6, 0x03, 0xFF, 0xC7, 0xFF, 0xCF,
  0x07, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE3,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC8, 0x0E, 0x7F, 0xF7, 0xFF, 0x0F,
  0xE0, 0x20, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x03,
  0xDC, 0x03, 0x8E, 0x03, 0x87, 0x03, 0x83, 0x87, 0x81, 0xC7, 0x80, 0xE7,
  0x80, 0x77, 0x80, 0x3F, 0x00, 0x1F, 0xE0, 0x0E, 0xF8, 0x07, 0x1E, 0x03,
  0x87, 0x81, 0xC1, 0xE0, 0xE0, 0x78, 0x70, 0x1E, 0x38, 0x07, 0x9C, 0x01,
  0xEE, 0x00, 0x78, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE3, 0x01, 0xFF, 0x00,
  0xFF, 0x18, 0x08, 0x7F, 0xBF, 0x3F, 0xFF, 0xDC, 0x38, 0x7E, 0x1C, 0x3F,
  0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70,
  0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x70, 0x07, 0x01, 0xFF, 0xE3,
  0xFF, 0xE7, 0x03, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x70, 0x01, 0x80,
  0x07, 0xF8, 0x07, 0xFF, 0x07, 0x87, 0xC7, 0x80, 0xE3, 0x80, 0x3B, 0x80,
  0x1D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x1C, 0xE0, 0x0E, 0x78, 0x0E, 0x1F, 0x1F,
  0x07, 0xFF, 0x01, 0xFE, 0x00, 0x02, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0,
  0x7C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x1C, 0xFC, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0x1F, 0xFF, 0x3E, 0x07, 0x78, 0x07, 0x70, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x0F, 0x3E, 0x3F, 0x1F,
  0xFF, 0x0F, 0xF7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x01, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x3F, 0xF9, 0xFF, 0xF3, 0x80, 0x4E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0xC0, 0x7B,
  0xFF, 0xF3, 0xFF, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE1, 0x83,
  0xFF, 0x03, 0xFE, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xB8, 0x07, 0x7C, 0x1E, 0x7F,
  0xFC, 0x7F, 0xF8, 0xF0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x3C, 0xE0, 0x0E,
  0x38, 0x03, 0x8E, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x03,
  0x83, 0x80, 0xE0, 0xE0, 0x3C, 0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0x3B,
  0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x6E, 0x0E, 0x0C, 0xC1, 0xC3,
  0x9C, 0x38, 0x73, 0x8F, 0x0E, 0x71, 0xF1, 0xCE, 0x36, 0x39, 0xCE, 0xE6,
  0x19, 0x9D, 0xC3, 0x31, 0xB8, 0x7E, 0x3F, 0x0F, 0x83, 0xE1, 0xF0, 0x78,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x60, 0x1C, 0x00, 0x78, 0x03, 0xCE, 0x01,
  0xE1, 0xC0, 0x70, 0x78, 0x38, 0x0F, 0x1C, 0x01, 0xEF, 0x00, 0x3B, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0E, 0xF0, 0x07,
  0x1C, 0x03, 0x83, 0x81, 0xC0, 0xF0, 0xF0, 0x1C, 0x38, 0x03, 0x9C, 0x00,
  0xFF, 0x00, 0x1C, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCE, 0x00, 0xE3,
  0x80, 0x71, 0xC0, 0x70, 0xE0, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E,
  0x03, 0x87, 0x01, 0xC3, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x0C, 0xE0, 0x07,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x01, 0xBE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xFC, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFE, 0x03, 0xFC, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x07, 0x00, 0x1E, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0xC0, 0x07, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x03, 0xFC,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x3E, 0x0F, 0xF0, 0x3F, 0x00,
  0x18, 0x00, 0x1F, 0x80, 0xDF, 0xF0, 0xFC, 0x3E, 0xEC, 0x0F, 0xE2, 0x01,
  0xE0,
};

const GFXglyph UbuntuSansMono_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 26, 21, 8, -26 },
  { 18, 9, 10, 21, 6, -28 },
  { 30, 19, 26, 21, 1, -26 },
  { 92, 16, 33, 21, 2, -29 },
  { 158, 19, 27, 21, 1, -26 },
  { 223, 19, 26, 21, 1, -26 },
  { 285, 3, 11, 21, 9, -28 },
  { 290, 11, 36, 21, 5, -29 },
  { 340, 11, 36, 21, 5, -29 },
  { 390, 16, 15, 21, 2, -26 },
  { 420, 17, 18, 21, 2, -20 },
  { 459, 9, 11, 21, 6, -5 },
  { 472, 9, 3, 21, 6, -12 },
  { 476, 5, 6, 21, 8, -6 },
  { 480, 15, 36, 21, 3, -29 },
  { 548, 17, 27, 21, 2, -26 },
  { 606, 15, 26, 21, 3, -26 },
  { 655, 15, 26, 21, 3, -26 },
  { 704, 15, 27, 21, 3, -26 },
  { 755, 17, 26, 21, 2, -26 },
  { 811, 15, 27, 21, 3, -26 },
  { 862, 17, 27, 21, 2, -26 },
  { 920, 16, 26, 21, 3, -26 },
  { 972, 16, 27, 21, 2, -26 },
  { 1026, 16, 26, 21, 2, -26 },
  { 1078, 5, 20, 21, 8, -20 },
  { 1091, 8, 26, 21, 5, -20 },
  { 1117, 17, 17, 21, 2, -19 },
  { 1154, 17, 10, 21, 2, -16 },
  { 1176, 17, 17, 21, 2, -19 },
  { 1213, 13, 26, 21, 4, -26 },
  { 1256, 17, 32, 21, 2, -26 },
  { 1324, 20, 26, 21, 0, -26 },
  { 1389, 16, 26, 21, 2, -26 },
  { 1441, 17, 27, 21, 2, -26 },
  { 1499, 17, 26, 21, 2, -26 },
  { 1555, 15, 26, 21, 4, -26 },
  { 1604, 14, 26, 21, 4, -26 },
  { 1650, 17, 27, 21, 2, -26 },
  { 1708, 17, 26, 21, 2, -26 },
  { 1764, 13, 26, 21, 4, -26 },
  { 1807, 15, 27, 21, 2, -26 },
  { 1858, 17, 26, 21, 3, -26 },
  { 1914, 15, 26, 21, 4, -26 },
  { 1963, 18, 26, 21, 1, -26 },
  { 2022, 16, 26, 21, 2, -26 },
  { 2074, 19, 27, 21, 1, -26 },
  { 2139, 16, 26, 21, 3, -26 },
  { 2191, 19, 33, 21, 1, -26 },
  { 2270, 17, 26, 21, 2, -26 },
  { 2326, 16, 27, 21, 2, -26 },
  { 2380, 17, 26, 21, 2, -26 },
  { 2436, 17, 27, 21, 2, -26 },
  { 2494, 19, 26, 21, 1, -26 },
  { 2556, 18, 26, 21, 1, -26 },
  { 2615, 19, 26, 21, 1, -26 },
  { 2677, 19, 26, 21, 1, -26 },
  { 2739, 17, 26, 21, 2, -26 },
  { 2795, 10, 36, 21, 6, -29 },
  { 2840, 15, 36, 21, 3, -29 },
  { 2908, 9, 36, 21, 5, -29 },
  { 2949, 17, 14, 21, 2, -26 },
  { 2979, 20, 3, 21, 0, 4 },
  { 2987, 6, 7, 21, 7, -29 },
  { 2993, 15, 20, 21, 3, -20 },
  { 3031, 16, 29, 21, 3, -29 },
  { 3089, 17, 20, 21, 2, -20 },
  { 3132, 16, 29, 21, 2, -29 },
  { 3190, 17, 20, 21, 2, -20 },
  { 3233, 17, 29, 21, 3, -29 },
  { 3295, 16, 27, 21, 2, -20 },
  { 3349, 15, 29, 21, 3, -29 },
  { 3404, 16, 28, 21, 2, -28 },
  { 3460, 13, 35, 21, 3, -28 },
  { 3517, 17, 29, 21, 3, -29 },
  { 3579, 16, 29, 21, 2, -29 },
  { 3637, 17, 20, 21, 2, -20 },
  { 3680, 15, 20, 21, 3, -20 },
  { 3718, 17, 20, 21, 2, -20 },
  { 3761, 16, 27, 21, 3, -20 },
  { 3815, 16, 27, 21, 2, -20 },
  { 3869, 13, 20, 21, 5, -20 },
  { 3902, 15, 20, 21, 3, -20 },
  { 3940, 15, 25, 21, 3, -25 },
  { 3987, 15, 19, 21, 3, -19 },
  { 4023, 18, 19, 21, 1, -19 },
  { 4066, 19, 19, 21, 1, -19 },
  { 4112, 18, 19, 21, 1, -19 },
  { 4155, 17, 26, 21, 2, -19 },
  { 4211, 15, 19, 21, 3, -19 },
  { 4247, 15, 36, 21, 3, -29 },
  { 4315, 3, 36, 21, 9, -29 },
  { 4329, 14, 36, 21, 3, -29 },
  { 4392, 17, 6, 21, 2, -14 },
};

const GFXfont UbuntuSansMono_Regular37pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_Regular37pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_Regular37pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUSANSMONO_REGULAR37PT7B_H_
