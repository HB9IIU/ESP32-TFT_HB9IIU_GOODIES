#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0xFE,
  0x7E, 0xFC, 0x7E, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xFC, 0xF8, 0xF8, 0x00,
  0x3E, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x78,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x78, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x0F,
  0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x81, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x7C, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xC7,
  0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xB3, 0x83, 0xE6, 0x20, 0x7D, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xDF, 0x84, 0x1B, 0xF0, 0xC3, 0x7E, 0x3C,
  0x7F, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03,
  0xC0, 0x0F, 0x80, 0x7F, 0x80, 0xF8, 0x07, 0xFC, 0x07, 0xC0, 0x3F, 0xF0,
  0x7C, 0x03, 0xFF, 0x83, 0xE0, 0x1E, 0x7C, 0x3E, 0x01, 0xF3, 0xE1, 0xF0,
  0x0F, 0x9F, 0x1F, 0x00, 0x78, 0xF9, 0xF0, 0x07, 0xC7, 0xCF, 0x80, 0x3E,
  0x7C, 0xF8, 0x01, 0xF3, 0xE7, 0xC3, 0x0F, 0x9F, 0x7C, 0x7E, 0x7F, 0xF3,
  0xEF, 0xFB, 0xFF, 0xBE, 0x7F, 0xCF, 0xF9, 0xF7, 0xFF, 0x7F, 0x9F, 0x3C,
  0xF8, 0xF1, 0xF3, 0xE7, 0xC0, 0x0F, 0x9F, 0x3E, 0x00, 0xF9, 0xF1, 0xF0,
  0x07, 0xCF, 0x8F, 0x80, 0x7C, 0x7C, 0xF8, 0x03, 0xE3, 0xE7, 0xC0, 0x3E,
  0x1F, 0x3E, 0x03, 0xE0, 0xFB, 0xE0, 0x1F, 0x07, 0xFF, 0x01, 0xF0, 0x1F,
  0xF0, 0x0F, 0x80, 0xFF, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x03, 0xF3, 0xF0, 0x07, 0xF3, 0xF0, 0x07, 0xF3, 0xF0, 0x07, 0xF7, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x7F, 0x07, 0xFE, 0x7F, 0x1F, 0xFE, 0xFE, 0x3F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0x7F, 0xFC, 0x7E, 0x7F, 0xF8, 0xFE, 0x3F, 0xF0,
  0xFE, 0x3F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFF, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x03, 0xF0, 0x03,
  0xF0, 0x43, 0xE0, 0x73, 0xE0, 0x7B, 0xE3, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF8, 0xFE,
  0xFC, 0x3C, 0xFE, 0x1C, 0x78, 0x08, 0x70, 0x00, 0x40, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC7,
  0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE0, 0x3F, 0xF7, 0xFF, 0x7F, 0xE7,
  0xFE, 0x7F, 0xEF, 0xFE, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFC, 0xFC, 0x7F,
  0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x7F, 0x7F, 0x1F,
  0xDF, 0xC7, 0xF7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x8F, 0xEF,
  0xE3, 0xF3, 0xF8, 0xFC, 0xFC, 0x7F, 0x3F, 0x1F, 0x8F, 0xCF, 0xE3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x87, 0xFF, 0x1F, 0xFE, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xE3, 0xDF, 0xC3,
  0x3F, 0x04, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xC7, 0xF0, 0x38, 0x7F, 0x01, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0,
  0xC3, 0xF8, 0x20, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x20, 0x1F, 0xC7, 0xCF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0xC0, 0x7B,
  0xF8, 0x1F, 0x7F, 0x07, 0xCF, 0xC0, 0xF1, 0xF8, 0x3E, 0x3F, 0x0F, 0x8F,
  0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x10, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x20, 0x3F, 0x87, 0x9F, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0xF8, 0x1F, 0xBF, 0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0xCF,
  0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7, 0xF7, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFF, 0x07, 0xF7, 0xF0, 0xFC, 0xFE, 0x3F, 0x8F, 0xC7, 0xE1, 0xF9,
  0xFC, 0x3F, 0x3F, 0x8F, 0xE7, 0xF1, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFB, 0xF8,
  0xFE, 0x3F, 0x1F, 0xC7, 0xE3, 0xF1, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7, 0xF3,
  0xF8, 0xFE, 0x7F, 0x3F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x3F, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x86, 0x1F, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x3F,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0xFF, 0xF9,
  0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0xF1,
  0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x18, 0x7F, 0x10, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x7C, 0x1F, 0x0F, 0x1F, 0x0F, 0xF9, 0xE3, 0xE7, 0xFF,
  0x3C, 0xF8, 0xFF, 0xE7, 0x9E, 0x3E, 0x7C, 0xF7, 0xCF, 0x8F, 0x1E, 0xF9,
  0xF1, 0xE3, 0xDE, 0x7C, 0x7C, 0x7B, 0xCF, 0x8F, 0x9F, 0xF9, 0xF1, 0xE3,
  0xDE, 0x3C, 0x3C, 0x7B, 0xC7, 0x8F, 0x8F, 0x78, 0xF1, 0xF3, 0xCF, 0x1F,
  0x7E, 0xF9, 0xE3, 0xFF, 0xFE, 0x3C, 0x7F, 0xFF, 0x87, 0x87, 0xE7, 0xE0,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x80, 0x3F, 0x80,
  0x70, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xF0, 0x1F,
  0x9F, 0x81, 0xFC, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xFB, 0xF8, 0x1F, 0xDF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF1,
  0xFC, 0x3F, 0x9F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xF0, 0xC1, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x02, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7E, 0x7F, 0x83, 0xF8, 0xFF,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0x83,
  0xF8, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x0F, 0xE1,
  0xFC, 0x7F, 0x87, 0xF3, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x81, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0x87, 0x07,
  0xF8, 0x04, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x9F, 0xF1, 0xFC, 0x7F, 0xC7, 0xF1, 0xFF, 0x1F, 0xCF, 0xFC,
  0x7F, 0x3F, 0xF1, 0xFC, 0xFF, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFE,
  0x0F, 0xE3, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xF0,
  0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFE, 0x1F, 0xC0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x81, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x1F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xF7, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8,
  0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x1F,
  0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07,
  0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xFF, 0x07, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xE0,
  0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0xDF, 0xFF, 0x07,
  0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0x7D, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xEF, 0xE0, 0xFD, 0xFF, 0xDF, 0x81, 0xFB, 0xFF, 0x3F, 0x03, 0xF3,
  0xFE, 0x7E, 0x0F, 0xE7, 0xF9, 0xFC, 0x1F, 0x8F, 0xF3, 0xF8, 0x3F, 0x1F,
  0xE7, 0xE0, 0x7E, 0x3F, 0x8F, 0xC0, 0xFC, 0x7F, 0x3F, 0x83, 0xF8, 0xFC,
  0x7F, 0x07, 0xE1, 0xF8, 0xFE, 0x0F, 0xC3, 0xE1, 0xF8, 0x00, 0x03, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0xC1, 0xF8, 0x1F, 0xF0, 0x7E, 0x07,
  0xFC, 0x1F, 0x81, 0xFF, 0x0F, 0xE0, 0x7F, 0xC3, 0xF8, 0x3F, 0xF8, 0xFC,
  0x0F, 0xFE, 0x3F, 0x03, 0xFF, 0x8F, 0xC0, 0xFF, 0xE7, 0xF0, 0x7F, 0xF9,
  0xFC, 0x1F, 0xFE, 0x7E, 0x07, 0xEF, 0xDF, 0x81, 0xFB, 0xF7, 0xE0, 0x7E,
  0xFF, 0xF8, 0x3F, 0xBF, 0xFC, 0x0F, 0xEF, 0xFF, 0x03, 0xF1, 0xFF, 0xC0,
  0xFC, 0x7F, 0xF0, 0x3F, 0x1F, 0xFC, 0x1F, 0xC7, 0xFE, 0x07, 0xE1, 0xFF,
  0x81, 0xF8, 0x7F, 0xE0, 0x7E, 0x0F, 0xF8, 0x1F, 0x83, 0xFE, 0x0F, 0xE0,
  0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0xFF, 0x07,
  0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x7F, 0x81, 0xFD, 0xFC, 0x07, 0xF7,
  0xF0, 0x3F, 0xDF, 0xC0, 0xFE, 0x7F, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0,
  0x7F, 0xBF, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x87, 0xF1, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xE7, 0xF0, 0xFE,
  0x3F, 0x0F, 0xE3, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xCF, 0xF1, 0xFD, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0x3F, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x1F,
  0xCF, 0xE0, 0x7F, 0x7F, 0x81, 0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x3F, 0xDF,
  0xC0, 0xFE, 0x7F, 0x03, 0xFB, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x81,
  0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xFC, 0x1F, 0x9F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7E,
  0xFE, 0x03, 0xF3, 0xF0, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0,
  0x7E, 0x3F, 0x83, 0xF1, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xC7, 0x01, 0xFC, 0x08, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x10, 0x1F, 0xC1,
  0xE1, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE,
  0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0,
  0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xC1, 0xFC,
  0xFC, 0x1F, 0xCF, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F,
  0x0F, 0xC7, 0xF0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF,
  0xC0, 0xFD, 0xF8, 0x0F, 0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0xFD, 0xF8, 0x3F, 0x07, 0xF7, 0xE0, 0xFC, 0x1F, 0xDF, 0x83, 0xF0,
  0x7E, 0x7E, 0x1F, 0xC3, 0xF9, 0xF8, 0x7F, 0x0F, 0xEF, 0xE3, 0xFC, 0x7F,
  0x3F, 0x8F, 0xF1, 0xFC, 0xFE, 0x3F, 0xC7, 0xE3, 0xF9, 0xFF, 0x3F, 0x8F,
  0xE7, 0xFC, 0xFE, 0x3F, 0xBF, 0xF3, 0xF0, 0xFE, 0xFF, 0xDF, 0xC3, 0xF3,
  0xFF, 0x7F, 0x0F, 0xDF, 0xFD, 0xF8, 0x3F, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFB, 0xFF,
  0x80, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0,
  0x1F, 0xCF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F,
  0x9F, 0x80, 0x1F, 0xCF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE1, 0xFC, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x7F, 0x7F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFC, 0xFE, 0x1F, 0x9F, 0xC3, 0xF7,
  0xF0, 0x7E, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x40, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xFC,
  0x07, 0xC7, 0xC0, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x03,
  0xE7, 0xE0, 0x3E, 0xFE, 0x03, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE0, 0xFE, 0xFE, 0x7E, 0x7F, 0x3F, 0x1F, 0x1F, 0x00, 0x80,
  0x00, 0xFC, 0xFC, 0x3F, 0xDF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF,
  0x8F, 0xEF, 0xF3, 0xF8, 0xFE, 0x7F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF8, 0x7E,
  0x7F, 0x1F, 0xCF, 0xE3, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF8,
  0xFC, 0x7F, 0x1F, 0x9F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFE, 0xFC, 0x0F, 0x9F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x10, 0x07, 0xEF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7F, 0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF9, 0xFC, 0x3F, 0x9F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0x7D, 0xFE, 0x0F, 0xCF, 0xC0, 0x00, 0x20, 0x03, 0xFE,
  0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0x8C, 0x7F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x10, 0xFE, 0x70, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x30, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xDF, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0,
  0x7E, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF0, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0xFF, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xF7, 0xE0, 0x1F, 0x3E,
  0x00, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9,
  0xF8, 0xFD, 0xFC, 0x7E, 0xFC, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0x9F, 0xFF, 0x8F, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x0C, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0F, 0xCF, 0xC0, 0xFF, 0x7E, 0x0F, 0xFB, 0xE0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xBF, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0,
  0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0x87,
  0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xFD, 0xFE, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7E, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x30, 0x3F, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x10, 0x07,
  0xEF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x8F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7E, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF0,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0x07, 0xE1, 0xFC, 0x0F,
  0xC7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0xFE, 0x01, 0xFB,
  0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x3F, 0x3F, 0x80, 0xFE, 0x7F, 0x01,
  0xFC, 0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0x01, 0x00, 0x80, 0x3E, 0x7F, 0x1F, 0x81, 0xF7, 0xFB, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F,
  0xDF, 0xEF, 0xE1, 0xFC, 0xFE, 0x3F, 0x0F, 0xC7, 0xF3, 0xF8, 0xFE, 0x3F,
  0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F,
  0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F,
  0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F,
  0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F,
  0x00, 0x00, 0x01, 0x00, 0x7C, 0xFC, 0x07, 0xDF, 0xE0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF1,
  0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x80, 0x00,
  0x20, 0x01, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFE, 0x7E, 0xFE, 0x3F, 0x7F, 0x1F, 0xBF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7E, 0xFC, 0x7F, 0x7F,
  0x7F, 0x3F, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80,
  0x00, 0x00, 0x40, 0x07, 0xCF, 0xC0, 0x1F, 0x7F, 0x80, 0x7D, 0xFE, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF1,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE7, 0xF0, 0x3F,
  0x9F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7E, 0xFE,
  0x01, 0xF9, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFC, 0xFC,
  0x3F, 0xDF, 0x8F, 0xFB, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xEF, 0xF3,
  0xF8, 0xFE, 0x7F, 0x1F, 0x8F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7F, 0x1F, 0xCF,
  0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7F, 0x1F,
  0xDF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xBF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x02, 0x0F, 0x9F, 0x0F, 0xBF, 0x0F, 0xBE, 0x1F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xF4, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x40, 0x07, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE,
  0x3F, 0x84, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x81, 0xFC, 0xE3, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x8F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x23, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x1F, 0xC7, 0xE3, 0xF1, 0xFC, 0x7E,
  0x3F, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC, 0x7E, 0x1F, 0x8F, 0xC7, 0xF3, 0xF8,
  0xFE, 0x7F, 0x1F, 0x8F, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xCF, 0xE3,
  0xF9, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7, 0xF3, 0xF8, 0xFE, 0xFF, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xF7, 0xE0, 0x7C, 0xFC, 0x00, 0xFE,
  0x1F, 0xEF, 0xC3, 0xF9, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC,
  0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0xFE, 0x0F, 0xDF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x87, 0xEF, 0xC7, 0xF1, 0xFF, 0xF9,
  0xFE, 0x3F, 0x7F, 0x3F, 0xC7, 0xEF, 0xEF, 0xF9, 0xF9, 0xF9, 0xFF, 0x3F,
  0x3F, 0x3F, 0xE7, 0xE7, 0xEF, 0xFD, 0xF8, 0xFD, 0xFF, 0xBF, 0x1F, 0xBF,
  0xFF, 0xC3, 0xFF, 0xBF, 0xF8, 0x7F, 0xF7, 0xFF, 0x0F, 0xFE, 0xFF, 0xC1,
  0xFF, 0x9F, 0xF8, 0x3F, 0xF3, 0xFE, 0x07, 0xFC, 0xFF, 0xC0, 0xFF, 0x9F,
  0xF8, 0x1F, 0xF3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x1F, 0xCF,
  0xE0, 0x7F, 0x3F, 0x80, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7E, 0xFE, 0x03, 0xFB, 0xF8, 0x1F,
  0xC7, 0xE0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC,
  0xFE, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF,
  0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x30, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xE1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x80,
  0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x03, 0xF0, 0x03, 0xF8,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x03, 0xFD, 0x00, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 13, 29, 10, 0, -29 },
  { 49, 16, 11, 18, 4, -29 },
  { 71, 22, 29, 21, 0, -29 },
  { 151, 19, 32, 19, 1, -30 },
  { 227, 29, 29, 32, 2, -29 },
  { 333, 24, 29, 24, 0, -29 },
  { 420, 8, 11, 10, 4, -29 },
  { 431, 15, 35, 11, 0, -29 },
  { 497, 14, 35, 11, -3, -29 },
  { 559, 16, 19, 18, 3, -31 },
  { 597, 17, 20, 20, 2, -24 },
  { 640, 10, 12, 10, -2, -6 },
  { 655, 12, 6, 12, 0, -14 },
  { 664, 7, 7, 10, 0, -7 },
  { 671, 22, 29, 16, -2, -29 },
  { 751, 18, 29, 19, 1, -29 },
  { 817, 15, 29, 19, 4, -29 },
  { 872, 20, 29, 19, -1, -29 },
  { 945, 19, 29, 19, 0, -29 },
  { 1014, 19, 29, 19, 0, -29 },
  { 1083, 19, 29, 19, 1, -29 },
  { 1152, 19, 29, 19, 1, -29 },
  { 1221, 20, 29, 19, 1, -29 },
  { 1294, 19, 29, 19, 0, -29 },
  { 1363, 19, 29, 19, 0, -29 },
  { 1432, 11, 22, 11, 0, -22 },
  { 1463, 13, 28, 11, -2, -22 },
  { 1509, 17, 20, 20, 2, -24 },
  { 1552, 17, 14, 20, 2, -21 },
  { 1582, 17, 20, 20, 2, -24 },
  { 1625, 16, 29, 15, 1, -29 },
  { 1683, 27, 32, 28, 1, -29 },
  { 1791, 21, 29, 21, -2, -29 },
  { 1868, 21, 29, 21, 0, -29 },
  { 1945, 20, 29, 19, 1, -29 },
  { 2018, 22, 29, 22, 0, -29 },
  { 2098, 19, 29, 17, 0, -29 },
  { 2167, 19, 29, 16, 0, -29 },
  { 2236, 22, 29, 22, 1, -29 },
  { 2316, 24, 29, 23, 0, -29 },
  { 2403, 19, 29, 15, -1, -29 },
  { 2472, 19, 38, 11, -6, -29 },
  { 2563, 25, 29, 20, 0, -29 },
  { 2654, 14, 29, 16, 0, -29 },
  { 2705, 31, 29, 30, 0, -29 },
  { 2818, 26, 29, 24, 0, -29 },
  { 2913, 22, 29, 23, 1, -29 },
  { 2993, 20, 29, 19, 0, -29 },
  { 3066, 22, 36, 23, 1, -29 },
  { 3165, 21, 29, 20, 0, -29 },
  { 3242, 21, 29, 17, -1, -29 },
  { 3319, 17, 29, 17, 3, -29 },
  { 3381, 23, 29, 22, 1, -29 },
  { 3465, 20, 29, 21, 4, -29 },
  { 3538, 30, 29, 30, 3, -29 },
  { 3647, 25, 29, 20, -2, -29 },
  { 3738, 19, 29, 20, 4, -29 },
  { 3807, 22, 29, 18, -2, -29 },
  { 3887, 17, 36, 11, -2, -29 },
  { 3964, 9, 29, 16, 4, -29 },
  { 3997, 17, 36, 11, -3, -29 },
  { 4074, 20, 19, 19, -1, -29 },
  { 4122, 17, 4, 15, -4, 3 },
  { 4131, 8, 7, 13, 6, -31 },
  { 4138, 19, 23, 19, 1, -23 },
  { 4193, 20, 30, 19, -1, -30 },
  { 4268, 16, 23, 16, 1, -23 },
  { 4314, 21, 30, 19, 1, -30 },
  { 4393, 17, 22, 18, 1, -22 },
  { 4440, 21, 41, 12, -4, -31 },
  { 4548, 21, 33, 19, -1, -23 },
  { 4635, 20, 30, 20, -1, -30 },
  { 4710, 12, 31, 10, 0, -31 },
  { 4757, 17, 41, 10, -5, -31 },
  { 4845, 23, 30, 19, -1, -30 },
  { 4932, 13, 30, 10, -1, -30 },
  { 4981, 29, 23, 29, -1, -23 },
  { 5065, 20, 23, 20, -1, -23 },
  { 5123, 17, 23, 19, 1, -23 },
  { 5172, 22, 33, 19, -3, -23 },
  { 5263, 19, 33, 19, 1, -23 },
  { 5342, 16, 23, 14, 0, -23 },
  { 5388, 16, 23, 15, 0, -23 },
  { 5434, 13, 27, 14, 2, -27 },
  { 5478, 19, 22, 20, 1, -22 },
  { 5531, 19, 22, 18, 2, -22 },
  { 5584, 27, 22, 27, 2, -22 },
  { 5659, 22, 22, 18, -2, -22 },
  { 5720, 23, 32, 18, -2, -22 },
  { 5812, 19, 22, 16, -2, -22 },
  { 5865, 17, 35, 14, 0, -29 },
  { 5940, 6, 40, 16, 5, -31 },
  { 5970, 16, 35, 14, -2, -29 },
  { 6040, 17, 8, 20, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC40PT7B_H_
