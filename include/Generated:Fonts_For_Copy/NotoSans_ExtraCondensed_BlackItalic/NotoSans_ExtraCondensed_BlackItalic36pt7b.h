#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC36PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x00, 0x3F, 0x7E, 0xFC, 0xFD, 0xF9, 0xFB, 0xF3, 0xE7, 0xE7, 0xCF, 0x9F,
  0x9F, 0x3F, 0x3E, 0x7C, 0xF8, 0xF9, 0xF1, 0xF0, 0x00, 0x79, 0xF0, 0x0F,
  0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C, 0x01,
  0xE7, 0xC1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF2,
  0x7C, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x0F, 0x9E, 0x07, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xE7, 0xC0, 0x3E, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x9F,
  0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x3E, 0xDC, 0x1F, 0x61, 0x07, 0xD8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x2F, 0x84, 0x1B, 0xE1, 0xC6, 0xF8, 0x7D, 0xFE,
  0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xE0, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x07, 0xF8,
  0x1F, 0x03, 0xFE, 0x07, 0x80, 0xFF, 0x83, 0xE0, 0x7D, 0xE1, 0xF0, 0x1E,
  0x7C, 0x78, 0x07, 0x9E, 0x3E, 0x03, 0xE7, 0x8F, 0x00, 0xF9, 0xE7, 0xC0,
  0x3C, 0xF9, 0xE0, 0x0F, 0x3E, 0xF8, 0xE3, 0xCF, 0x3C, 0xFE, 0xFF, 0xDE,
  0x7F, 0xBF, 0xEF, 0xBF, 0xF7, 0xF3, 0xCF, 0x7C, 0xF9, 0xF7, 0xDF, 0x00,
  0x79, 0xE7, 0xC0, 0x3E, 0x79, 0xF0, 0x0F, 0x3E, 0x78, 0x07, 0xCF, 0x9E,
  0x03, 0xE3, 0xE7, 0x80, 0xF0, 0xFB, 0xE0, 0x7C, 0x3F, 0xF0, 0x1E, 0x07,
  0xF8, 0x0F, 0x81, 0xFE, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0x9F,
  0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x01, 0x07, 0xF9, 0xF8, 0x7F, 0xE7, 0xE3, 0xFF,
  0xDF, 0x0F, 0xFF, 0xFC, 0x7E, 0xFF, 0xE1, 0xFB, 0xFF, 0x8F, 0xC7, 0xFC,
  0x3F, 0x1F, 0xF0, 0xFC, 0x3F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0x3F, 0xC0, 0x3F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0x10, 0x07, 0xC0, 0x0F, 0x81, 0x1F, 0x03, 0x3E, 0x0F,
  0xF9, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x0F, 0xFC, 0x3F, 0x80, 0xFF,
  0x87, 0xEF, 0x87, 0xDF, 0x07, 0x3F, 0x06, 0x38, 0x08, 0x40, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3, 0xE3,
  0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x00, 0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xEF,
  0xFC, 0x7C, 0xFB, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xBF,
  0x1F, 0x9F, 0x3F, 0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C,
  0xFC, 0xFC, 0xFC, 0xFC, 0xFD, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x3F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0xFF, 0xF1, 0xFF, 0xC3, 0xBF, 0x0C,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xF7, 0xF0, 0x30, 0xFC, 0x08, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0x01, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x38, 0xFC, 0x10, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x81, 0xFF,
  0x80, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x90, 0x1F, 0xCC, 0x0F, 0xE7, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0x81, 0xEF, 0xC1, 0xF7,
  0xE0, 0xF3, 0xF0, 0xF1, 0xF0, 0xF9, 0xF8, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x67,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x10, 0x3F, 0x8C,
  0x1F, 0xC7, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF0,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xBC, 0x0F, 0xBF,
  0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9, 0xF9, 0xFC, 0xFC, 0xFC,
  0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x9F, 0x8F, 0xCF, 0xC7, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF3, 0xF0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x9F, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF0, 0x03,
  0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E, 0x7E, 0x1F, 0x8F,
  0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0xBF, 0x87, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFE, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F,
  0x1F, 0x9F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xF3, 0xFF, 0xF9, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xBF, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xC0, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC1, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC3, 0xE0, 0x01, 0xE0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07,
  0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7F, 0x01, 0xFF, 0x07, 0xFF, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x01, 0xC0, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x1F, 0xF8, 0xFF, 0xCF, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x7C,
  0x00, 0xE0, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0xE3, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFC, 0xE3, 0xF2, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x03, 0xFC, 0xFE, 0x07, 0xE0, 0x1E, 0x0F, 0x80, 0x0F, 0x0F, 0x06, 0x0F,
  0x1E, 0x3F, 0xEF, 0x3E, 0x7F, 0xE7, 0x3C, 0xFF, 0xE7, 0x3C, 0xF3, 0xC7,
  0x79, 0xE3, 0xC7, 0x79, 0xE3, 0xCF, 0x73, 0xE3, 0xCF, 0xF3, 0xC7, 0x8F,
  0xF3, 0xC7, 0x8E, 0xF3, 0xC7, 0x9E, 0xF3, 0xCF, 0x9E, 0xF3, 0xFF, 0xFC,
  0xF3, 0xFF, 0xF8, 0xF1, 0xFB, 0xF0, 0xF0, 0xE1, 0xE0, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0xFC, 0x07, 0xDF, 0x81, 0xFB, 0xF0, 0x3E,
  0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x7F, 0x3F, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7E, 0x0F, 0xDF, 0xC1,
  0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x9F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xE3, 0xF1, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF,
  0xC1, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xF9, 0xFC, 0x3F, 0x1F,
  0x87, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x1F, 0xC7, 0xE7, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0xC1,
  0xFC, 0x10, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x18, 0x1F, 0xFE, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF1, 0xF8, 0x7F, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xF0,
  0xFE, 0x3F, 0x0F, 0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0x7E,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x83, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0x1C, 0x1F, 0xC0, 0x41,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF3, 0xFC,
  0x7E, 0x3F, 0xC7, 0xE7, 0xFC, 0x7E, 0x7F, 0xCF, 0xE7, 0xF8, 0xFE, 0x1F,
  0x8F, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xF0, 0x7E, 0x3F, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7E, 0x0F, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07,
  0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x04, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x1F,
  0x87, 0xE0, 0x7E, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F,
  0x80, 0xFD, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x7E, 0xFC, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0x9F, 0x80, 0x7E, 0x7F, 0x01, 0xF9, 0xFC, 0x07, 0xE3, 0xF0, 0x3F,
  0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF7, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8,
  0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF,
  0x8F, 0xFC, 0x1F, 0xF9, 0xFF, 0xC1, 0xFF, 0x9F, 0xFC, 0x1F, 0xF9, 0xFF,
  0xC3, 0xFF, 0xBE, 0xF8, 0x3F, 0xFB, 0xFF, 0x83, 0xFF, 0xFD, 0xF8, 0x3F,
  0x7F, 0xDF, 0x83, 0xE7, 0xF9, 0xF8, 0x7E, 0x7F, 0xBF, 0x07, 0xE7, 0xF3,
  0xF0, 0x7E, 0x7F, 0x3F, 0x07, 0xC7, 0xF3, 0xF0, 0x7C, 0x7E, 0x3E, 0x0F,
  0xC7, 0xE7, 0xE0, 0xFC, 0x7C, 0x7E, 0x0F, 0xC7, 0xC7, 0xE0, 0x07, 0xF0,
  0x3E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0xC3, 0xF0, 0xFF, 0x87,
  0xC1, 0xFF, 0x1F, 0x83, 0xFE, 0x3F, 0x07, 0xFC, 0x7E, 0x0F, 0xF8, 0xFC,
  0x3F, 0xF9, 0xF0, 0x7F, 0xF7, 0xE0, 0xFB, 0xEF, 0xC1, 0xF7, 0xDF, 0x87,
  0xEF, 0xBE, 0x0F, 0xDF, 0x7C, 0x1F, 0xBF, 0xF8, 0x3E, 0x7F, 0xF0, 0x7C,
  0x7F, 0xE1, 0xF8, 0xFF, 0x83, 0xF1, 0xFF, 0x07, 0xE3, 0xFE, 0x0F, 0x87,
  0xFC, 0x1F, 0x07, 0xF8, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFE, 0x7E, 0x1F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x07, 0xF3,
  0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFE, 0x1F,
  0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF7, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x7E, 0x1F, 0xC7, 0xF3, 0xF8,
  0x7F, 0x3F, 0x07, 0xF3, 0xF0, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xCF,
  0xE0, 0xFC, 0xFE, 0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x7F, 0x87, 0xFF, 0xF0,
  0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xBF, 0xC3, 0xF3, 0xF8, 0x7E, 0x7F, 0x0F, 0xCF, 0xE3, 0xF1,
  0xF8, 0x7E, 0x7F, 0x0F, 0xDF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xF9, 0xF8, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0xC7, 0xE3, 0xF8, 0xFC, 0x3F,
  0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x03, 0xF0, 0x40, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x30, 0x3F, 0x07, 0x8F, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0x83, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFE, 0x7F, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7E, 0x0F, 0xEF, 0xC1, 0xF9, 0xF8,
  0x7F, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C, 0x7E, 0x0F, 0x8F, 0xC1, 0xF3,
  0xF8, 0x3E, 0x7E, 0x07, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xEF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x0F, 0x83, 0xF7, 0xE0, 0xF8, 0x3F, 0x7E, 0x1F, 0x87, 0xE7,
  0xE1, 0xF8, 0x7E, 0x7E, 0x1F, 0x87, 0xE7, 0xE3, 0xF8, 0xFC, 0x7E, 0x3F,
  0x8F, 0xC7, 0xE7, 0xF9, 0xF8, 0x7E, 0x7F, 0x9F, 0x87, 0xE7, 0xF9, 0xF8,
  0x7E, 0xFF, 0xBF, 0x07, 0xEF, 0xFB, 0xF0, 0x7D, 0xFF, 0xBE, 0x07, 0xDF,
  0xFF, 0xE0, 0x7D, 0xEF, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC,
  0x07, 0xFC, 0xFF, 0xC0, 0x7F, 0xCF, 0xF8, 0x07, 0xFC, 0xFF, 0x80, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x07,
  0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x0F,
  0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0xFE,
  0x1F, 0xDF, 0x87, 0xE7, 0xE3, 0xF9, 0xF8, 0xFC, 0x7E, 0x7F, 0x1F, 0x9F,
  0x87, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3F, 0x1F,
  0x1F, 0x1F, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0x7D, 0xF0, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xE3, 0xE0, 0xF9,
  0xF8, 0x3F, 0xFC, 0x07, 0xC0, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x7E, 0x7E, 0x3E, 0x3F, 0x1F, 0x03, 0xE7, 0xC1,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xCF, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7C, 0x3E, 0x1F, 0x1F, 0x8F, 0xE7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F,
  0xFF, 0x07, 0xF7, 0xC0, 0xF9, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x7C, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0xFC,
  0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x9F, 0x0F, 0xDF, 0x8F, 0xCF, 0xC7,
  0xE7, 0xE3, 0xF3, 0xF3, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xFC, 0x7D,
  0xFC, 0x3C, 0x7C, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF9, 0xFC, 0x47, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC2, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x87,
  0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0xFC, 0x07,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x3F, 0x83,
  0xF1, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xF0,
  0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x7C, 0x7E, 0x0F, 0xE7, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xF7, 0xC0, 0x3E, 0x7C, 0x00, 0x03,
  0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF3, 0xF7, 0xEF, 0xC7, 0xDF, 0x8F,
  0xBE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x02, 0x7E, 0x38, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF,
  0x00, 0x00, 0x02, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFC, 0x00, 0xFC, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x05, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x7F, 0x7C, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7C,
  0x3F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0,
  0xFC, 0x7E, 0x1F, 0xCF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xBF, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x20, 0x3F, 0x07,
  0x0F, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xE0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x7C, 0x1F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E,
  0x3F, 0x3F, 0x1F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xE3,
  0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x3E, 0x3F, 0x00,
  0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0xC3, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x9F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x00, 0xFE, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x3F,
  0x1F, 0x8F, 0xC3, 0xF3, 0xF8, 0x7E, 0x7E, 0x0F, 0xDF, 0x81, 0xF7, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xF9, 0xF8, 0x3F, 0x3F, 0x07,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xE1, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x00,
  0x0F, 0x3F, 0x1F, 0x07, 0xDF, 0xCF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xE7, 0xF7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC,
  0x7E, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE3, 0xF1, 0xF1,
  0xF8, 0xFC, 0xFC, 0x7E, 0x3E, 0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE3,
  0xF3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x1F, 0x8F, 0xCF,
  0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0x0F, 0x3E, 0x0F, 0xBF, 0x87, 0xFF, 0xE3,
  0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F,
  0x1F, 0x9F, 0x8F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF1, 0xF9,
  0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x3F, 0x1F, 0x1F, 0x1F, 0x80,
  0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3F,
  0x7E, 0x3F, 0x7C, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0xFC, 0x7E, 0xFC, 0x7E,
  0xF8, 0x7E, 0xF8, 0xFC, 0xFC, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x03, 0xCF, 0x80, 0xFB, 0xF8, 0x1F, 0x7F, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC7, 0xE1, 0xF0, 0xFC, 0x3E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x87, 0xE7, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFB,
  0xF8, 0x1F, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE7, 0xC1, 0xFD, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F, 0x8F, 0xE7, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFB, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x0F, 0x3E, 0x3E, 0xF8, 0x7D,
  0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFB, 0x87, 0xE1, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x20,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x00, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xFF, 0x9F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x7F, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFE,
  0x07, 0xF0, 0x1F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE3, 0xE3, 0xF3,
  0xF1, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3E, 0x3E, 0x3F, 0x3F,
  0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7, 0xE7, 0xE3, 0xF3, 0xF1, 0xFF, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xDF, 0x00, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC, 0xFC, 0x7C, 0xF8, 0x7D,
  0xF8, 0x7D, 0xF8, 0x7D, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0xFC, 0x7F, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC, 0xFE, 0x3E, 0xFC, 0xFE,
  0x7E, 0xFD, 0xFE, 0x7E, 0xFD, 0xFE, 0x7C, 0xFD, 0xFE, 0xFC, 0xFB, 0xFE,
  0xF8, 0xFB, 0xDE, 0xF8, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xBF,
  0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F,
  0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F,
  0x80, 0x0F, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x7E, 0x3F,
  0x0F, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0x80, 0x7D, 0xF8, 0x07,
  0xDF, 0x80, 0x7D, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x00,
  0x0E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x7C, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x80, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x30, 0x00, 0x3F, 0x01,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 11, 26, 9, 0, -26 },
  { 37, 15, 10, 16, 3, -26 },
  { 56, 20, 26, 19, 0, -26 },
  { 121, 18, 29, 17, 0, -27 },
  { 187, 26, 26, 28, 2, -26 },
  { 272, 22, 26, 22, 0, -26 },
  { 344, 8, 10, 9, 3, -26 },
  { 354, 13, 32, 10, 0, -26 },
  { 406, 13, 32, 10, -3, -26 },
  { 458, 15, 17, 16, 2, -28 },
  { 490, 15, 17, 18, 2, -21 },
  { 522, 9, 10, 9, -2, -5 },
  { 534, 11, 5, 11, 0, -12 },
  { 541, 7, 6, 9, 0, -6 },
  { 547, 20, 26, 14, -2, -26 },
  { 612, 16, 26, 17, 1, -26 },
  { 664, 14, 26, 17, 3, -26 },
  { 710, 18, 26, 17, -1, -26 },
  { 769, 17, 26, 17, 0, -26 },
  { 825, 17, 26, 17, 0, -26 },
  { 881, 17, 26, 17, 1, -26 },
  { 937, 17, 26, 17, 1, -26 },
  { 993, 18, 26, 17, 1, -26 },
  { 1052, 18, 26, 17, 0, -26 },
  { 1111, 17, 26, 17, 0, -26 },
  { 1167, 10, 20, 10, 0, -20 },
  { 1192, 12, 25, 10, -2, -20 },
  { 1230, 16, 18, 18, 1, -22 },
  { 1266, 15, 13, 18, 2, -19 },
  { 1291, 15, 18, 18, 2, -22 },
  { 1325, 14, 26, 14, 1, -26 },
  { 1371, 24, 29, 25, 1, -26 },
  { 1458, 19, 26, 19, -2, -26 },
  { 1520, 19, 26, 19, 0, -26 },
  { 1582, 18, 26, 17, 1, -26 },
  { 1641, 20, 26, 20, 0, -26 },
  { 1706, 17, 26, 15, 0, -26 },
  { 1762, 17, 26, 15, 0, -26 },
  { 1818, 20, 26, 20, 1, -26 },
  { 1883, 22, 26, 20, 0, -26 },
  { 1955, 17, 26, 13, -1, -26 },
  { 2011, 17, 34, 10, -6, -26 },
  { 2084, 22, 26, 18, 0, -26 },
  { 2156, 13, 26, 14, 0, -26 },
  { 2199, 28, 26, 27, 0, -26 },
  { 2290, 23, 26, 22, 0, -26 },
  { 2365, 20, 26, 21, 1, -26 },
  { 2430, 18, 26, 17, 0, -26 },
  { 2489, 20, 32, 21, 1, -26 },
  { 2569, 19, 26, 18, 0, -26 },
  { 2631, 19, 26, 16, -1, -26 },
  { 2693, 15, 26, 15, 3, -26 },
  { 2742, 20, 26, 20, 1, -26 },
  { 2807, 19, 26, 19, 3, -26 },
  { 2869, 28, 26, 27, 2, -26 },
  { 2960, 23, 26, 18, -2, -26 },
  { 3035, 18, 26, 18, 3, -26 },
  { 3094, 19, 26, 16, -1, -26 },
  { 3156, 15, 32, 10, -2, -26 },
  { 3216, 8, 26, 14, 4, -26 },
  { 3242, 15, 32, 10, -3, -26 },
  { 3302, 18, 17, 17, -1, -26 },
  { 3341, 15, 5, 14, -4, 2 },
  { 3351, 8, 6, 12, 5, -28 },
  { 3357, 18, 20, 18, 0, -20 },
  { 3402, 17, 27, 18, 0, -27 },
  { 3460, 14, 20, 14, 1, -20 },
  { 3495, 20, 27, 18, 0, -27 },
  { 3563, 15, 20, 17, 1, -20 },
  { 3601, 19, 37, 11, -4, -28 },
  { 3689, 19, 29, 18, -1, -20 },
  { 3758, 17, 27, 18, 0, -27 },
  { 3816, 11, 28, 9, 0, -28 },
  { 3855, 16, 37, 9, -5, -28 },
  { 3929, 19, 27, 17, 0, -27 },
  { 3994, 11, 27, 9, 0, -27 },
  { 4032, 26, 20, 26, 0, -20 },
  { 4097, 17, 20, 18, 0, -20 },
  { 4140, 16, 20, 17, 1, -20 },
  { 4180, 19, 29, 18, -2, -20 },
  { 4249, 18, 29, 18, 0, -20 },
  { 4315, 15, 20, 13, 0, -20 },
  { 4353, 15, 20, 14, 0, -20 },
  { 4391, 13, 24, 12, 1, -24 },
  { 4430, 17, 20, 18, 1, -20 },
  { 4473, 16, 20, 16, 2, -20 },
  { 4513, 24, 20, 24, 2, -20 },
  { 4573, 20, 20, 17, -2, -20 },
  { 4623, 20, 29, 16, -2, -20 },
  { 4696, 17, 20, 14, -2, -20 },
  { 4739, 15, 32, 12, 0, -26 },
  { 4799, 6, 36, 14, 4, -28 },
  { 4826, 14, 32, 12, -2, -26 },
  { 4882, 16, 7, 18, 1, -16 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC36PT7B_H_
