#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC25PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x00, 0x00, 0x70, 0xF8, 0xF0, 0xF0, 0x7B, 0xEF, 0x79, 0xEF, 0x3D,
  0xE7, 0x39, 0xE7, 0x3C, 0xE0, 0x03, 0xBC, 0x0E, 0xE0, 0x73, 0x81, 0xCE,
  0x07, 0x70, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x0C, 0xE0, 0x73, 0x87, 0xFF,
  0x3F, 0xFC, 0xFF, 0xF0, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x77, 0x01, 0xDC,
  0x00, 0x00, 0x80, 0x08, 0x07, 0xF0, 0xFF, 0x1F, 0xF1, 0xD6, 0x3D, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC4, 0x5C, 0x77, 0xC7,
  0xFC, 0xFF, 0x87, 0xF0, 0x08, 0x00, 0x80, 0x1E, 0x07, 0x0F, 0xC3, 0x83,
  0xF1, 0xE1, 0xDC, 0x70, 0x77, 0x38, 0x1D, 0xCE, 0x0E, 0x77, 0x03, 0x9D,
  0xDE, 0xFE, 0xEF, 0xDF, 0x7B, 0xF7, 0x9D, 0xDC, 0x0F, 0x77, 0x03, 0xBD,
  0xC1, 0xCE, 0x70, 0x73, 0x9C, 0x38, 0xFE, 0x0E, 0x1F, 0x07, 0x07, 0x80,
  0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0xDE, 0x07,
  0xF8, 0x07, 0xE0, 0x1F, 0x9E, 0x7F, 0x79, 0xFF, 0xF3, 0xDF, 0xCF, 0x3F,
  0x9E, 0x3E, 0x3E, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x7D, 0xF8, 0x7B, 0xDE,
  0xF7, 0x7B, 0xC0, 0x07, 0x87, 0x83, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x70,
  0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x07, 0x03, 0x80, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x1E,
  0x0F, 0x0F, 0x07, 0x07, 0x80, 0x0E, 0x03, 0x84, 0xE3, 0xFF, 0xFF, 0xDF,
  0xF3, 0xE1, 0xFC, 0xF7, 0x1D, 0xE2, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0x3C, 0xE7, 0x9E, 0x73, 0xCE, 0x00, 0x7E, 0xFD, 0xFF, 0xF0, 0x77, 0xFD,
  0xE0, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x00, 0x07, 0x83, 0xF8, 0x7F, 0x9F,
  0xF3, 0xDE, 0xF3, 0xDE, 0x7B, 0xCF, 0xF1, 0xFE, 0x7B, 0xCF, 0x79, 0xEF,
  0x3D, 0xEF, 0x3F, 0xE7, 0xF8, 0xFE, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0xF8,
  0x7E, 0x3F, 0xBF, 0xE7, 0xF9, 0xBC, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x3F, 0x87, 0xFE,
  0x1F, 0xF0, 0xCF, 0x84, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFF, 0x8F, 0xFC, 0x7F, 0xC7, 0xFE,
  0x00, 0x07, 0xC1, 0xFE, 0x1F, 0xF1, 0xFF, 0x10, 0xF0, 0x0F, 0x01, 0xE0,
  0xFC, 0x1F, 0x01, 0xFC, 0x1F, 0xC0, 0x3C, 0x03, 0xE8, 0x3C, 0xE7, 0xCF,
  0xF8, 0xFF, 0x8F, 0xE0, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE1, 0xDE, 0x3B, 0xC3, 0xBC, 0x73, 0xCF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFF, 0x1E, 0x01, 0xE0, 0x1F, 0x83, 0xFC, 0x3F, 0xC3, 0xFE, 0x03, 0xE0,
  0x3E, 0x03, 0xE8, 0x3C, 0xE7, 0xCF, 0xF8, 0xFF, 0x8F, 0xE0, 0x03, 0xF0,
  0xFE, 0x1F, 0xE1, 0xF2, 0x3C, 0x07, 0xC0, 0x7B, 0x87, 0xFC, 0xFF, 0xCF,
  0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x7C, 0xF7, 0x8F, 0xF8, 0x7F, 0x03,
  0xE0, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFE, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0xF8, 0x0F, 0x00, 0x07, 0xE0, 0xFF, 0x1F, 0xF1, 0xEF, 0x1C, 0xF1,
  0xCF, 0x1F, 0xE1, 0xFC, 0x0F, 0x81, 0xFC, 0x3F, 0xC7, 0xBE, 0xF9, 0xEF,
  0x1E, 0xF3, 0xCF, 0xFC, 0x7F, 0x83, 0xF0, 0x07, 0xC0, 0xFE, 0x1F, 0xE1,
  0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xDF, 0x7F, 0xF3, 0xFE, 0x3F, 0xE1,
  0xDE, 0x03, 0xC0, 0x3C, 0x8F, 0x8F, 0xF8, 0xFF, 0x0F, 0xC0, 0x1C, 0x7C,
  0xF9, 0xE1, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC7, 0xCF, 0x1E, 0x00, 0x0E,
  0x1F, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x78,
  0x78, 0x70, 0xF0, 0xE0, 0x00, 0x60, 0x3C, 0x1F, 0x8F, 0xF7, 0xF1, 0xF8,
  0x3F, 0x03, 0xF8, 0x1F, 0xE0, 0xFC, 0x07, 0x80, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x1E,
  0x03, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xC1, 0xF8, 0xFE, 0xFF, 0x1F, 0x83,
  0xC0, 0x60, 0x00, 0x1F, 0x1F, 0xE7, 0xFD, 0xFF, 0x43, 0x81, 0xE0, 0xF8,
  0x7C, 0x3E, 0x0F, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x07, 0x03, 0xC0, 0xF0,
  0x3C, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xE7, 0xC3, 0xC0, 0xE3, 0x84,
  0x39, 0xDF, 0xDD, 0xCF, 0xEE, 0xCE, 0x67, 0xEE, 0x73, 0xF7, 0x39, 0xB3,
  0x9D, 0xD9, 0xCC, 0xEC, 0xEE, 0xE6, 0x7F, 0xE3, 0x1C, 0xE1, 0xC0, 0x00,
  0xE0, 0x10, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78,
  0xF3, 0xC7, 0x9E, 0x7F, 0xF3, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x1F, 0xF8,
  0xFF, 0x87, 0xC0, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xE7, 0x8F,
  0x3C, 0xF3, 0xE7, 0xFE, 0x3F, 0xC1, 0xFF, 0x1F, 0x7C, 0xF1, 0xE7, 0x9F,
  0x3C, 0xF9, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0x07, 0xE0, 0xFF,
  0x1F, 0xF3, 0xFE, 0x3E, 0x07, 0xC0, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFB, 0x8F, 0xF8, 0x7F, 0x83, 0xF0,
  0x0F, 0xC0, 0x7F, 0xC1, 0xFF, 0x87, 0xFE, 0x1E, 0x78, 0x79, 0xF3, 0xC7,
  0xCF, 0x1F, 0x3C, 0x78, 0xF1, 0xE7, 0xC7, 0x9E, 0x3E, 0x78, 0xF1, 0xE7,
  0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F,
  0x87, 0x80, 0x78, 0x07, 0x80, 0x7F, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3F,
  0xC3, 0xF8, 0x7F, 0x87, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0x03, 0xF0, 0x7F, 0xC7, 0xFE, 0x7F, 0xE3, 0xE1, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xFB, 0xF7, 0xDF, 0xBC, 0xFD, 0xE3, 0xEF, 0x1E, 0x78,
  0xF3, 0xFF, 0x9F, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x0F, 0x1E, 0x3E, 0x3C,
  0x78, 0xF8, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x8F, 0x8F, 0x1F, 0xFE, 0x3F,
  0xF8, 0x7F, 0xF1, 0xFF, 0xE3, 0xC7, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x3C,
  0x7C, 0x78, 0xF1, 0xF1, 0xE3, 0xC0, 0x0F, 0xF0, 0xFF, 0x1F, 0xE0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xF0, 0xFF, 0x8F, 0xF8, 0x00, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x01, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x06, 0x00, 0x0F, 0x1E, 0x3E,
  0x78, 0x79, 0xF0, 0xF3, 0xC1, 0xEF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0x7C, 0x1E,
  0xF8, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xE0, 0x0F, 0x0F, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x83, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xF9, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC,
  0x3F, 0xBF, 0xC3, 0xFB, 0xBC, 0x7B, 0xFF, 0x87, 0xBF, 0x78, 0x7B, 0xF7,
  0x87, 0xBE, 0x78, 0x7B, 0xEF, 0x8F, 0x3E, 0xF0, 0xF3, 0xCF, 0x0F, 0x3C,
  0xF0, 0x0F, 0x0F, 0x1F, 0x8F, 0x1F, 0x8F, 0x1F, 0x9E, 0x1F, 0x9E, 0x1F,
  0x9E, 0x3F, 0x9E, 0x3F, 0xDE, 0x3F, 0xFC, 0x3F, 0xFC, 0x7B, 0xFC, 0x79,
  0xFC, 0x79, 0xFC, 0x79, 0xF8, 0x79, 0xF8, 0xF1, 0xF8, 0xF1, 0xF8, 0xF0,
  0xF0, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x7F, 0xF3, 0xC7, 0xBE, 0x3D, 0xE1,
  0xEF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xEF, 0x0F, 0x78, 0xFB,
  0xFF, 0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xFC,
  0x3F, 0xF1, 0xEF, 0x8F, 0x7C, 0xFB, 0xE7, 0x9E, 0x3F, 0xF1, 0xFF, 0x1F,
  0xF0, 0xFF, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x7F, 0xF3, 0xC7, 0xBE, 0x3D, 0xE1,
  0xEF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xE1, 0xEF, 0x0F, 0x78, 0xFB,
  0xFF, 0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0xC0, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xEF, 0x8F, 0x7C, 0xFB,
  0xE7, 0x9E, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE1,
  0xEF, 0x9F, 0x7C, 0xF1, 0xE7, 0x8F, 0x80, 0x07, 0xE0, 0xFF, 0x1F, 0xF3,
  0xFE, 0x3E, 0x23, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7C, 0x03, 0xC8, 0x7C, 0xFF, 0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF,
  0xFB, 0xFF, 0x7F, 0xE1, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x1E,
  0x7C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xF3, 0xE7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x8F,
  0xFC, 0x3F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0xF8, 0x7F, 0xC7, 0xFE, 0x3D,
  0xF3, 0xEF, 0x9E, 0x7C, 0xF3, 0xCF, 0x9E, 0x78, 0xF7, 0xC3, 0xBC, 0x1D,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x00, 0xF0, 0xE1, 0xFE, 0x3C, 0x7B, 0xC7, 0x8F, 0x78, 0xF3, 0xEF, 0x3E,
  0x79, 0xE7, 0xCF, 0x3D, 0xFB, 0xE7, 0xBF, 0x78, 0xFF, 0xEF, 0x1F, 0xFF,
  0xC3, 0xFB, 0xF8, 0x7F, 0xFF, 0x0F, 0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0x7E,
  0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x00, 0x0F, 0x1E, 0x1E, 0x7C,
  0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0x78,
  0x3E, 0xF8, 0xF9, 0xF1, 0xE3, 0xE0, 0xF8, 0xFB, 0xCF, 0x9E, 0x78, 0xF7,
  0xC7, 0xBC, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xC3, 0xF0, 0xFC,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xF0, 0xFC, 0x3F, 0x00,
  0xF1, 0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x3C, 0xF3, 0xCF,
  0x1C, 0x70, 0x07, 0xE1, 0xF8, 0x3F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x3E, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xC0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0xC3, 0xDE, 0x1C, 0xF1,
  0xE3, 0x9E, 0x1D, 0xF0, 0xF0, 0xFF, 0xFF, 0xEF, 0xF8, 0xF7, 0x9E, 0x70,
  0x0E, 0x78, 0xFF, 0x8F, 0xFC, 0x7F, 0xE7, 0xDF, 0x3C, 0xF1, 0xE7, 0x8F,
  0x3C, 0xF9, 0xE7, 0x9F, 0x3E, 0xF1, 0xFF, 0x87, 0xFC, 0x3D, 0xE0, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xFE, 0x3F, 0xE3, 0xFF, 0x3F,
  0xF3, 0xCF, 0x78, 0xF7, 0x8F, 0x79, 0xE7, 0x9E, 0x79, 0xEF, 0xBE, 0xFF,
  0xCF, 0xF8, 0xEF, 0x00, 0x07, 0xC3, 0xFC, 0xFF, 0x1F, 0x47, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE4, 0x3F, 0x87, 0xF0, 0x7C, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xC1, 0xFF,
  0x0F, 0xFC, 0x3D, 0xF1, 0xF7, 0xC7, 0x9E, 0x1E, 0x78, 0x79, 0xE3, 0xE7,
  0x8F, 0x3E, 0x3E, 0xF0, 0xFF, 0xC1, 0xFF, 0x07, 0xBC, 0x00, 0x07, 0xC3,
  0xFC, 0xFF, 0x9E, 0x77, 0x8E, 0xFF, 0xDF, 0xF3, 0xFC, 0xF0, 0x1E, 0x03,
  0xE2, 0x3F, 0xC7, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFA, 0x03, 0xC0, 0x0F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF0, 0x00, 0x07, 0xBC, 0x3E, 0xE1, 0xFF, 0x87, 0xBE, 0x3E, 0xF8, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xF1, 0xE7, 0xC7, 0xDE, 0x1F, 0xF8, 0x3F,
  0xE0, 0xF7, 0x80, 0x3C, 0x00, 0xF0, 0xE7, 0xC3, 0xFE, 0x0F, 0xF8, 0x1F,
  0x80, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xDE, 0x3F, 0xE3,
  0xFF, 0x3F, 0xF3, 0xCF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xEF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xC0, 0x0E, 0x1F, 0x1E, 0x0C, 0x00, 0x1E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0,
  0xF0, 0x01, 0xC0, 0x7C, 0x0F, 0x00, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF0, 0x00,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x79, 0xF3, 0xCF,
  0x0F, 0x7C, 0x3D, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xFC, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3E, 0x00, 0x0F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0x1D, 0xE7, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3C, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xC0, 0x1D, 0xE3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3C, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0x07, 0xC1,
  0xFE, 0x3F, 0xE3, 0xDE, 0x7C, 0xF7, 0x9F, 0x79, 0xE7, 0x9E, 0xF9, 0xEF,
  0x1E, 0x7B, 0xC7, 0xFC, 0x7F, 0x83, 0xF0, 0x07, 0x78, 0x3F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x0F, 0x3C, 0x7C, 0xF1, 0xE3, 0xC7, 0x9E, 0x1E, 0x78, 0x79,
  0xE3, 0xEF, 0x8F, 0xFC, 0x3F, 0xE0, 0xF7, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x78, 0xFB, 0x8F, 0xFC, 0x7B,
  0xE7, 0xDF, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xF9, 0xE7, 0x9F, 0x3E, 0xF1,
  0xFF, 0x87, 0xFC, 0x3D, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0x1D, 0xCF, 0xF3, 0xF8, 0xFE, 0x3E, 0x9F, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x1F, 0x8F, 0xF3,
  0xF9, 0xF2, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xEC, 0xF3, 0xFC,
  0xFF, 0x3F, 0x00, 0x0E, 0x1C, 0x1C, 0x3F, 0x7F, 0xFF, 0xFF, 0x78, 0x78,
  0x78, 0x78, 0xF0, 0xF0, 0xF2, 0xFC, 0xFC, 0x7C, 0x3E, 0x79, 0xE7, 0x8F,
  0x3C, 0x79, 0xE3, 0xCF, 0x3C, 0xF9, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xDF,
  0x3E, 0xF1, 0xFF, 0x87, 0xDC, 0x3D, 0xE0, 0xF3, 0xFE, 0x7B, 0xCF, 0x7B,
  0xCF, 0x79, 0xDE, 0x3B, 0xC7, 0x70, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x00, 0x7B, 0xE7, 0xB9, 0xF3, 0xDC, 0xFB, 0xDE, 0xFD, 0xEF,
  0x7E, 0xF7, 0xBF, 0xF3, 0xFB, 0xF9, 0xFD, 0xF8, 0xFE, 0xFC, 0x7E, 0xFE,
  0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x9F, 0x07, 0xCF, 0x80, 0x1E, 0x7C, 0x79,
  0xE1, 0xEF, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x1E, 0xF0, 0x7B, 0xE3, 0xC7, 0x80, 0x0F, 0x3E,
  0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x81, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x1F, 0xF1, 0xFE, 0x1F, 0xE3, 0xFE, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0x47, 0xF8, 0xFF, 0x8F, 0xF8, 0x01, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0xC1, 0xE0,
  0x7C, 0x0F, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xF0, 0x3E,
  0x03, 0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xF0, 0x78, 0x3E, 0x1F, 0x8F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x0F, 0x83, 0xE0, 0xF8, 0x38, 0x00, 0x7C, 0x3F, 0xFF,
  0xFF, 0xC7, 0xF8, 0x08,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 8, 18, 6, 0, -18 },
  { 19, 11, 7, 11, 2, -18 },
  { 29, 14, 18, 13, 0, -18 },
  { 61, 12, 20, 12, 0, -19 },
  { 91, 18, 18, 20, 1, -18 },
  { 132, 15, 18, 15, 0, -18 },
  { 166, 5, 7, 6, 2, -18 },
  { 171, 9, 22, 7, 0, -18 },
  { 196, 9, 22, 7, -2, -18 },
  { 221, 10, 11, 11, 2, -19 },
  { 235, 11, 12, 13, 1, -15 },
  { 252, 6, 7, 7, -1, -4 },
  { 258, 7, 4, 8, 0, -9 },
  { 262, 5, 4, 7, 0, -4 },
  { 265, 13, 18, 10, -1, -18 },
  { 295, 11, 18, 12, 1, -18 },
  { 320, 10, 18, 12, 2, -18 },
  { 343, 13, 18, 12, -1, -18 },
  { 373, 12, 18, 12, 0, -18 },
  { 400, 12, 18, 12, 0, -18 },
  { 427, 12, 18, 12, 0, -18 },
  { 454, 12, 18, 12, 1, -18 },
  { 481, 12, 18, 12, 1, -18 },
  { 508, 12, 18, 12, 0, -18 },
  { 535, 12, 18, 12, 0, -18 },
  { 562, 7, 14, 7, 0, -14 },
  { 575, 8, 17, 7, -1, -14 },
  { 592, 11, 12, 13, 1, -15 },
  { 609, 11, 9, 13, 1, -13 },
  { 622, 11, 12, 13, 1, -15 },
  { 639, 10, 18, 9, 1, -18 },
  { 662, 17, 20, 18, 1, -18 },
  { 705, 13, 18, 13, -1, -18 },
  { 735, 13, 18, 13, 0, -18 },
  { 765, 12, 18, 12, 1, -18 },
  { 792, 14, 18, 14, 0, -18 },
  { 824, 12, 18, 10, 0, -18 },
  { 851, 12, 18, 10, 0, -18 },
  { 878, 13, 18, 14, 1, -18 },
  { 908, 15, 18, 14, 0, -18 },
  { 942, 12, 18, 9, -1, -18 },
  { 969, 12, 24, 7, -4, -18 },
  { 1005, 15, 18, 13, 0, -18 },
  { 1039, 9, 18, 10, 0, -18 },
  { 1060, 20, 18, 19, 0, -18 },
  { 1105, 16, 18, 15, 0, -18 },
  { 1141, 13, 18, 14, 1, -18 },
  { 1171, 13, 18, 12, 0, -18 },
  { 1201, 13, 22, 14, 1, -18 },
  { 1237, 13, 18, 13, 0, -18 },
  { 1267, 12, 18, 11, 0, -18 },
  { 1294, 11, 18, 11, 2, -18 },
  { 1319, 14, 18, 14, 1, -18 },
  { 1351, 13, 18, 13, 2, -18 },
  { 1381, 19, 18, 19, 2, -18 },
  { 1424, 15, 18, 13, -1, -18 },
  { 1458, 13, 18, 12, 2, -18 },
  { 1488, 14, 18, 11, -1, -18 },
  { 1520, 10, 22, 7, -1, -18 },
  { 1548, 6, 18, 10, 2, -18 },
  { 1562, 11, 22, 7, -2, -18 },
  { 1593, 13, 12, 12, -1, -18 },
  { 1613, 10, 3, 10, -2, 2 },
  { 1617, 5, 4, 8, 4, -19 },
  { 1620, 13, 14, 12, 0, -14 },
  { 1643, 12, 19, 12, 0, -19 },
  { 1672, 11, 14, 10, 0, -14 },
  { 1692, 14, 19, 12, 0, -19 },
  { 1726, 11, 14, 12, 0, -14 },
  { 1746, 14, 25, 8, -3, -19 },
  { 1790, 14, 20, 12, -1, -14 },
  { 1825, 12, 19, 12, 0, -19 },
  { 1854, 8, 19, 6, 0, -19 },
  { 1873, 11, 25, 6, -3, -19 },
  { 1908, 14, 19, 12, 0, -19 },
  { 1942, 8, 19, 6, 0, -19 },
  { 1961, 18, 14, 18, 0, -14 },
  { 1993, 12, 14, 12, 0, -14 },
  { 2014, 12, 14, 12, 0, -14 },
  { 2035, 14, 20, 12, -2, -14 },
  { 2070, 13, 20, 12, 0, -14 },
  { 2103, 10, 14, 9, 0, -14 },
  { 2121, 10, 14, 10, 0, -14 },
  { 2139, 8, 17, 9, 1, -17 },
  { 2156, 13, 14, 12, 0, -14 },
  { 2179, 11, 14, 11, 2, -14 },
  { 2199, 17, 14, 17, 1, -14 },
  { 2229, 14, 14, 12, -1, -14 },
  { 2254, 15, 20, 11, -2, -14 },
  { 2292, 12, 14, 10, -1, -14 },
  { 2313, 11, 22, 9, 0, -18 },
  { 2344, 4, 25, 10, 3, -19 },
  { 2357, 10, 22, 9, -1, -18 },
  { 2385, 11, 5, 13, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC25PT7B_H_
