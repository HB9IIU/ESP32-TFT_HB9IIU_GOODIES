#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC11PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x36, 0xDE, 0xBC, 0x14, 0xF7, 0xDF, 0x7B, 0xE5, 0x3C,
  0x1B, 0xD8, 0xE3, 0xDF, 0xCC, 0x40, 0x65, 0x5A, 0xA7, 0xFD, 0xE5, 0x5A,
  0xA7, 0x38, 0x51, 0xA1, 0x97, 0xDB, 0xB6, 0x7E, 0xFC, 0x32, 0x64, 0xCC,
  0xCC, 0xCC, 0x33, 0x33, 0x33, 0x26, 0x4C, 0xAF, 0x6F, 0x60, 0x31, 0xBF,
  0xF3, 0x18, 0x6D, 0x60, 0xFC, 0xF0, 0x04, 0x31, 0x86, 0x30, 0x86, 0x30,
  0x3B, 0xDA, 0xBD, 0xEF, 0xCE, 0x37, 0xFB, 0x66, 0x66, 0x3B, 0xD6, 0x33,
  0x33, 0xDE, 0x3B, 0xC6, 0x67, 0x0E, 0xDE, 0x18, 0xCE, 0xF5, 0x7C, 0xC6,
  0x39, 0xD8, 0xE5, 0x8E, 0xDE, 0x1C, 0xE6, 0x1E, 0xFB, 0x6F, 0x9C, 0x7D,
  0xE1, 0x84, 0x30, 0x86, 0x30, 0x3B, 0xDE, 0xE7, 0x6F, 0x6E, 0x3B, 0xDE,
  0xF7, 0x8E, 0xDC, 0x6C, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x4C, 0x08, 0xDD,
  0xE1, 0x84, 0xFF, 0xC1, 0xF0, 0x87, 0x0E, 0x7E, 0x40, 0x73, 0xC4, 0x66,
  0x01, 0x18, 0x1E, 0x33, 0x5D, 0x55, 0xEF, 0xAA, 0x94, 0x44, 0x38, 0x0C,
  0x71, 0x4F, 0x3D, 0xF6, 0xFB, 0x39, 0xF6, 0xDE, 0x7B, 0x6F, 0xBC, 0x1C,
  0xE6, 0x18, 0xC3, 0x0F, 0x1C, 0x39, 0xF6, 0xDB, 0x6F, 0x6F, 0xBC, 0x3B,
  0xD8, 0xE7, 0x63, 0xDE, 0x3B, 0xD8, 0xE7, 0x63, 0x18, 0x1C, 0xF6, 0x1F,
  0xDF, 0x27, 0x9E, 0x26, 0xC9, 0xB3, 0xE7, 0xD9, 0xB6, 0x6C, 0x79, 0x88,
  0xC6, 0x31, 0x9C, 0x08, 0xC6, 0x31, 0x88, 0xC6, 0x37, 0x00, 0x26, 0xD9,
  0xE3, 0xC7, 0x1B, 0x36, 0x6C, 0x26, 0x66, 0x6C, 0xFF, 0x33, 0xBB, 0x9D,
  0xCE, 0xE5, 0xF6, 0xD3, 0x79, 0xAC, 0x36, 0xED, 0xDB, 0xA5, 0x5B, 0xB7,
  0x6E, 0x1C, 0xF6, 0xDB, 0xCF, 0x3F, 0x9C, 0x39, 0xF6, 0xDE, 0x7B, 0x0C,
  0x30, 0x1C, 0xF6, 0xDB, 0xCF, 0x3F, 0x9C, 0x30, 0x60, 0x39, 0xF6, 0xDE,
  0x7B, 0x4D, 0xB6, 0x3B, 0xD8, 0xE3, 0x1B, 0xDE, 0xFF, 0x98, 0xC4, 0x63,
  0x18, 0x25, 0xB6, 0xDB, 0x4F, 0x6F, 0x9C, 0xCF, 0x6D, 0xBC, 0xF3, 0x8E,
  0x38, 0xDB, 0xDB, 0xFE, 0xFE, 0xFE, 0xFC, 0xDC, 0xD8, 0x36, 0x68, 0x70,
  0xC1, 0x87, 0x1B, 0x76, 0xDE, 0xFC, 0xC6, 0x23, 0x18, 0x7D, 0xE1, 0x8C,
  0x61, 0x8F, 0x3C, 0x39, 0x8C, 0x42, 0x31, 0x8C, 0x67, 0x00, 0xDB, 0x24,
  0x93, 0x38, 0x84, 0x63, 0x18, 0x84, 0xE7, 0x00, 0x11, 0x8E, 0xFD, 0x80,
  0xF0, 0xC0, 0x7D, 0xED, 0xB6, 0xDB, 0xC0, 0x63, 0x1E, 0xF5, 0xEF, 0x7E,
  0x7B, 0xB1, 0x8D, 0x38, 0x0C, 0x37, 0x9E, 0xDB, 0x6F, 0xBC, 0x7B, 0xFF,
  0xCD, 0x38, 0x1C, 0xC3, 0x9C, 0x30, 0x86, 0x18, 0x63, 0x08, 0x00, 0x7D,
  0xED, 0xB6, 0xFB, 0xC3, 0x3C, 0xC0, 0x63, 0x1E, 0xF5, 0xEF, 0x7A, 0x2C,
  0x36, 0xB6, 0xC0, 0x13, 0x03, 0x32, 0x66, 0x66, 0xC8, 0x61, 0x86, 0xDE,
  0x73, 0xCF, 0x36, 0x6D, 0xB5, 0xB6, 0x7F, 0x7B, 0x5B, 0xDA, 0xDE, 0xF6,
  0x7B, 0xD7, 0xBD, 0xE8, 0x7B, 0xF7, 0xBD, 0x38, 0x3C, 0xF2, 0xDB, 0x6D,
  0xE6, 0x10, 0xC0, 0x7D, 0xED, 0xB6, 0xFB, 0xC3, 0x0C, 0x30, 0x77, 0x4C,
  0xCC, 0x75, 0x63, 0xBE, 0x27, 0xE6, 0x4D, 0x60, 0x6D, 0xE5, 0xB6, 0xFB,
  0xC0, 0x9D, 0xA9, 0xCE, 0x60, 0xB7, 0x6B, 0xF6, 0xED, 0x9B, 0x00, 0x3E,
  0x78, 0xE1, 0xC7, 0x9F, 0x00, 0x26, 0x58, 0xA1, 0xC3, 0x06, 0x0C, 0x30,
  0xC0, 0x79, 0x88, 0xCC, 0x78, 0x19, 0x88, 0xCE, 0x61, 0x88, 0x63, 0x00,
  0xFF, 0xFF, 0xFC, 0x31, 0x8C, 0x63, 0x98, 0x8C, 0xE6, 0x00, 0x6F, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 5, 3, 5, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 7, 8, 9, 1, -8 },
  { 25, 7, 8, 7, 0, -8 },
  { 32, 2, 3, 3, 1, -8 },
  { 33, 4, 10, 3, 0, -8 },
  { 38, 4, 10, 3, -1, -8 },
  { 43, 4, 5, 5, 1, -8 },
  { 46, 5, 6, 6, 0, -7 },
  { 50, 3, 4, 3, -1, -2 },
  { 52, 3, 2, 3, 0, -4 },
  { 53, 2, 2, 3, 0, -2 },
  { 54, 6, 8, 4, -1, -8 },
  { 60, 5, 8, 5, 0, -8 },
  { 65, 4, 8, 5, 1, -8 },
  { 69, 5, 8, 5, 0, -8 },
  { 74, 5, 8, 5, 0, -8 },
  { 79, 5, 8, 5, 0, -8 },
  { 84, 5, 8, 5, 0, -8 },
  { 89, 6, 8, 5, 0, -8 },
  { 95, 6, 8, 5, 0, -8 },
  { 101, 5, 8, 5, 0, -8 },
  { 106, 5, 8, 5, 0, -8 },
  { 111, 3, 6, 3, 0, -6 },
  { 114, 4, 8, 3, -1, -6 },
  { 118, 5, 6, 6, 0, -7 },
  { 122, 5, 4, 6, 0, -6 },
  { 125, 5, 6, 6, 0, -7 },
  { 129, 5, 8, 4, 0, -8 },
  { 134, 8, 9, 8, 0, -8 },
  { 143, 6, 8, 6, -1, -8 },
  { 149, 6, 8, 6, 0, -8 },
  { 155, 6, 8, 5, 0, -8 },
  { 161, 6, 8, 6, 0, -8 },
  { 167, 5, 8, 5, 0, -8 },
  { 172, 5, 8, 4, 0, -8 },
  { 177, 6, 8, 6, 0, -8 },
  { 183, 7, 8, 6, 0, -8 },
  { 190, 5, 8, 4, 0, -8 },
  { 195, 5, 10, 3, -2, -8 },
  { 202, 7, 8, 6, 0, -8 },
  { 209, 4, 8, 4, 0, -8 },
  { 213, 9, 8, 8, 0, -8 },
  { 222, 7, 8, 7, 0, -8 },
  { 229, 6, 8, 6, 0, -8 },
  { 235, 6, 8, 5, 0, -8 },
  { 241, 6, 10, 6, 0, -8 },
  { 249, 6, 8, 6, 0, -8 },
  { 255, 5, 8, 5, 0, -8 },
  { 260, 5, 8, 5, 1, -8 },
  { 265, 6, 8, 6, 0, -8 },
  { 271, 6, 8, 6, 1, -8 },
  { 277, 8, 8, 8, 1, -8 },
  { 285, 7, 8, 6, -1, -8 },
  { 292, 5, 8, 5, 1, -8 },
  { 297, 6, 8, 5, 0, -8 },
  { 303, 5, 10, 3, -1, -8 },
  { 310, 3, 8, 4, 1, -8 },
  { 313, 5, 10, 3, -1, -8 },
  { 320, 5, 5, 5, 0, -8 },
  { 324, 4, 1, 4, -1, 1 },
  { 325, 2, 1, 4, 2, -8 },
  { 326, 6, 6, 5, 0, -6 },
  { 331, 5, 8, 5, 0, -8 },
  { 336, 5, 6, 4, 0, -6 },
  { 340, 6, 8, 5, 0, -8 },
  { 346, 5, 6, 5, 0, -6 },
  { 350, 6, 11, 3, -1, -8 },
  { 359, 6, 9, 5, 0, -6 },
  { 366, 5, 8, 5, 0, -8 },
  { 371, 3, 9, 3, 0, -9 },
  { 375, 4, 12, 3, -1, -9 },
  { 381, 6, 8, 5, 0, -8 },
  { 387, 3, 8, 3, 0, -8 },
  { 390, 8, 6, 8, 0, -6 },
  { 396, 5, 6, 5, 0, -6 },
  { 400, 5, 6, 5, 0, -6 },
  { 404, 6, 9, 5, -1, -6 },
  { 411, 6, 9, 5, 0, -6 },
  { 418, 4, 6, 4, 0, -6 },
  { 421, 4, 6, 4, 0, -6 },
  { 424, 4, 7, 4, 0, -7 },
  { 428, 6, 6, 5, 0, -6 },
  { 433, 5, 6, 5, 1, -6 },
  { 437, 7, 6, 7, 1, -6 },
  { 443, 7, 6, 5, -1, -6 },
  { 449, 7, 9, 5, -1, -6 },
  { 457, 5, 6, 4, 0, -6 },
  { 461, 5, 10, 4, 0, -8 },
  { 468, 2, 11, 4, 1, -8 },
  { 471, 5, 10, 4, -1, -8 },
  { 478, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC11PT7B_H_
