#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC41PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x00, 0x7F, 0x3F, 0xBF, 0x9F, 0x9F, 0x9F, 0xCF, 0xCF, 0xE7, 0xE7, 0xE7,
  0xF3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x7E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x78, 0xF8, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3E, 0x7C,
  0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x03,
  0xE3, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x3E, 0x3C, 0x00, 0x7C,
  0xF8, 0x00, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xF7, 0x83, 0xF6, 0x30, 0x7E,
  0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x83, 0x3E, 0x18, 0x6F, 0xC7, 0xCF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x40, 0x1F, 0xC0,
  0x3E, 0x00, 0xFF, 0x80, 0xF8, 0x07, 0xFE, 0x07, 0xC0, 0x3F, 0xF8, 0x3F,
  0x00, 0xFB, 0xE0, 0xF8, 0x07, 0xCF, 0x87, 0xC0, 0x1F, 0x3E, 0x1F, 0x00,
  0x7C, 0xF8, 0xF8, 0x01, 0xF3, 0xE3, 0xE0, 0x0F, 0x8F, 0x9F, 0x00, 0x3E,
  0x3E, 0x7C, 0x00, 0xF9, 0xF3, 0xE3, 0xE3, 0xE7, 0xDF, 0x1F, 0xCF, 0xFE,
  0x7C, 0xFF, 0x9F, 0xFB, 0xE7, 0xFE, 0x7F, 0xCF, 0xBF, 0xF8, 0xFE, 0x7C,
  0xF9, 0xF0, 0xE1, 0xF7, 0xC7, 0xC0, 0x0F, 0x9F, 0x1F, 0x00, 0x7E, 0x7C,
  0x78, 0x01, 0xF1, 0xF3, 0xE0, 0x0F, 0x87, 0xCF, 0x80, 0x3E, 0x1E, 0x3E,
  0x01, 0xF0, 0x79, 0xF0, 0x07, 0xC1, 0xF7, 0xC0, 0x3E, 0x07, 0xFE, 0x00,
  0xF8, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x3E, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0,
  0x07, 0xF3, 0xF0, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x04, 0x0F, 0xF8, 0xFC, 0x1F, 0xFC,
  0xFE, 0x1F, 0xFF, 0x7F, 0x1F, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0x0F, 0xEF,
  0xFF, 0x87, 0xE3, 0xFF, 0x87, 0xF1, 0xFF, 0xC3, 0xF8, 0x7F, 0xC1, 0xFC,
  0x3F, 0xC0, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0x7F, 0x7F, 0x7E,
  0x7E, 0x7E, 0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x02, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x06, 0x3F, 0x03, 0xDF, 0x09, 0xFF, 0x9D, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE1, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFD, 0xF8, 0x3C, 0x7E, 0x0E, 0x3C, 0x02, 0x1C, 0x00, 0x08,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC7, 0xF1, 0xF8,
  0xFE, 0x3F, 0x0F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE0, 0x3F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFE, 0x7F, 0xEF, 0xFE, 0x3E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFB, 0xF0, 0xFE, 0x7E, 0x1F, 0xCF, 0xE3,
  0xF1, 0xFC, 0xFE, 0x3F, 0x1F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F,
  0xC7, 0xF3, 0xF8, 0xFE, 0x7E, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFE, 0x7F,
  0x1F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7, 0xF3, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFD, 0xFB, 0xF1, 0xFF, 0xE3, 0xDF,
  0xC2, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xEF, 0xF0, 0x3C, 0x7F, 0x01, 0x07, 0xF0, 0x10, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xCF, 0xF0, 0x20, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x80, 0x3F, 0x8C, 0x07, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7D, 0xF8, 0x07, 0x9F, 0x80,
  0xFB, 0xF8, 0x1F, 0x3F, 0x83, 0xE3, 0xF8, 0x3E, 0x3F, 0x07, 0xC7, 0xF0,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF1, 0x00, 0xFE, 0x20, 0x3F, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF8, 0x20, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x88, 0x03, 0xFB, 0xF0, 0x3F, 0x7F, 0x03, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xBF, 0x87, 0xF3, 0xF8, 0xFF, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xEF,
  0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xBF, 0x87, 0xF1, 0xF8, 0x7F,
  0x1F, 0x87, 0xE1, 0xF8, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE, 0x3F, 0x87,
  0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xE7, 0xE0, 0xFE, 0x7E, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7D, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0xC3, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x3F, 0x83,
  0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x0F, 0xC3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x00, 0x00,
  0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0x80, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x0F, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x1E, 0x7F, 0x18, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x0F, 0x87, 0xF9, 0xF1, 0xF1,
  0xFF, 0xCF, 0x1E, 0x3F, 0xFC, 0xF3, 0xE3, 0xFF, 0x8F, 0x3C, 0x7C, 0xF8,
  0xF7, 0xCF, 0x8F, 0x9F, 0x7C, 0xF8, 0xF9, 0xF7, 0x8F, 0x0F, 0x1E, 0x79,
  0xF1, 0xF1, 0xEF, 0x9F, 0x1F, 0x1E, 0xF9, 0xF1, 0xF3, 0xEF, 0x1F, 0x1E,
  0x3C, 0xF1, 0xF3, 0xE7, 0xCF, 0x1F, 0xFF, 0xF8, 0xF1, 0xFF, 0xFF, 0x0F,
  0x0F, 0xEF, 0xF0, 0xF8, 0xFC, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0x00, 0x7F, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x07,
  0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFC,
  0x0F, 0xE7, 0xE0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7,
  0xF0, 0x7F, 0x3F, 0x83, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xDF, 0xF0, 0x7E, 0x3F, 0xC3,
  0xF8, 0xFF, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xE7, 0x01, 0xFE, 0x08, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x40, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7E, 0x3F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F,
  0xC7, 0xF0, 0xFF, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x8F,
  0xE1, 0xFC, 0x3F, 0x0F, 0xF1, 0xFC, 0x7F, 0x87, 0xF3, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0x3E, 0x07, 0xF8, 0x08, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF3,
  0xFF, 0x1F, 0xC7, 0xFE, 0x3F, 0x8F, 0xF8, 0x7F, 0x1F, 0xF0, 0xFE, 0x7F,
  0xE1, 0xFC, 0xFF, 0xC7, 0xF8, 0x3F, 0x8F, 0xF0, 0x7E, 0x1F, 0xE1, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC1,
  0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x81, 0xF8, 0x7F, 0x81, 0xFC, 0x3F,
  0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0x9F,
  0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xE1, 0xFE, 0x00, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xFF, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFC, 0x0F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF8, 0x1F, 0xBE, 0x7D,
  0xF8, 0x1F, 0xBE, 0xFF, 0xF8, 0x1F, 0xBE, 0xFB, 0xF8, 0x3F, 0xBF, 0xFB,
  0xF0, 0x3F, 0xBF, 0xFB, 0xF0, 0x3F, 0x3F, 0xF7, 0xF0, 0x3F, 0x3F, 0xF7,
  0xF0, 0x3F, 0x3F, 0xE7, 0xF0, 0x7F, 0x3F, 0xE7, 0xE0, 0x7F, 0x3F, 0xC7,
  0xE0, 0x7E, 0x3F, 0xCF, 0xE0, 0x7E, 0x3F, 0x8F, 0xE0, 0x7E, 0x3F, 0x8F,
  0xE0, 0xFE, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x1F, 0xC0, 0xFC, 0x3F, 0x1F,
  0xC0, 0x03, 0xFC, 0x0F, 0xC0, 0xFF, 0x03, 0xF0, 0x7F, 0xC1, 0xFC, 0x1F,
  0xF0, 0x7F, 0x07, 0xFC, 0x1F, 0x81, 0xFF, 0x87, 0xE0, 0x7F, 0xE1, 0xF8,
  0x3F, 0xF8, 0xFE, 0x0F, 0xFE, 0x3F, 0x83, 0xFF, 0x8F, 0xC0, 0xFF, 0xF3,
  0xF0, 0x7F, 0xFC, 0xFC, 0x1F, 0xBF, 0x7F, 0x07, 0xEF, 0xDF, 0xC1, 0xFB,
  0xF7, 0xE0, 0x7E, 0xFD, 0xF8, 0x3F, 0xBF, 0xFE, 0x0F, 0xE7, 0xFF, 0x83,
  0xF1, 0xFF, 0xE0, 0xFC, 0x7F, 0xF0, 0x3F, 0x1F, 0xFC, 0x1F, 0xC7, 0xFF,
  0x07, 0xF0, 0xFF, 0xC1, 0xF8, 0x3F, 0xE0, 0x7E, 0x0F, 0xF8, 0x1F, 0x83,
  0xFE, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x3F, 0xE0, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x07, 0xF0, 0xFE, 0x1F,
  0xE1, 0xFC, 0x3F, 0x83, 0xFC, 0xFF, 0x07, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x03,
  0xFC, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xF0, 0x7F,
  0x9F, 0xE0, 0xFE, 0x1F, 0xC3, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0x8F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE1, 0xFC,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFE, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x3F, 0x83,
  0xFC, 0xFF, 0x07, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F,
  0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xFB,
  0xFC, 0x0F, 0xE7, 0xF8, 0x1F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0, 0xFE, 0x1F,
  0xC3, 0xFC, 0x3F, 0x8F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0x8F, 0xE1, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE,
  0x3F, 0x8F, 0xE1, 0xFD, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7E, 0x03,
  0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F,
  0xC3, 0xF0, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0xCF, 0xE1, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x1C, 0x0F, 0xF0, 0x40,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x80, 0xFE,
  0x0F, 0x0F, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7,
  0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x0F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F,
  0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xE0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0xC7, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x1F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x0F, 0xF3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F,
  0x87, 0xF1, 0xFC, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xE0, 0x7F,
  0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x07, 0xEF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0xFE, 0xFC, 0x1F,
  0xC1, 0xFD, 0xF8, 0x3F, 0x87, 0xF3, 0xF0, 0x7F, 0x0F, 0xE7, 0xE1, 0xFE,
  0x1F, 0xCF, 0xC3, 0xFC, 0x7F, 0x1F, 0x8F, 0xF8, 0xFE, 0x7F, 0x1F, 0xF1,
  0xF8, 0xFE, 0x3F, 0xE7, 0xF1, 0xFC, 0xFF, 0x8F, 0xE3, 0xF9, 0xFF, 0x3F,
  0x87, 0xF7, 0xFE, 0x7F, 0x0F, 0xEF, 0xFC, 0xFC, 0x1F, 0xDF, 0xFB, 0xF8,
  0x3F, 0xFF, 0xF7, 0xF0, 0x7E, 0xFF, 0xEF, 0xC0, 0xFF, 0xF7, 0xFF, 0x81,
  0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0x3F, 0xF8, 0x0F,
  0xFE, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x80, 0x7F,
  0xC7, 0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFC,
  0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFE, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0x7E, 0x3F, 0x87, 0xE3,
  0xF8, 0x7F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C,
  0x1F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF7, 0xC0, 0x7E, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0x3F, 0x3F, 0x03, 0xF7, 0xE0, 0x3F,
  0xFE, 0x03, 0xF0, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0xFE, 0x3F, 0x9F, 0xC7, 0xE1, 0xF0, 0xFC, 0x03, 0xE3, 0xF0,
  0x7F, 0x7E, 0x0F, 0xF7, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x3F, 0x9F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F,
  0x8F, 0xE1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC7,
  0xF0, 0xFC, 0x7F, 0x0F, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xF7, 0xE0, 0x3E, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF7, 0xC0, 0x7E, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F,
  0xC3, 0xF1, 0xFC, 0x3F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF3,
  0xF8, 0x7F, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF9, 0xFC,
  0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xEF, 0xF0, 0xFC, 0x7C,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFE, 0x10, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x18, 0x7F, 0x3C, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x03,
  0xE7, 0xF0, 0x3F, 0xBF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF0,
  0xFE, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3,
  0xF0, 0xFE, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xF7, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF, 0x00, 0xF9, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF,
  0xE7, 0xF3, 0xF0, 0xFD, 0xFC, 0x7F, 0x7E, 0x3F, 0x9F, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x02, 0x3F, 0x83, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x40, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0xFC,
  0x07, 0xF7, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFE, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7E, 0x1F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x83,
  0xF0, 0xFE, 0x0F, 0xC7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFE, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0x7E, 0x00, 0xFB, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x0C, 0x07, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF7, 0xC0, 0x7E, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x80, 0x00, 0xE0,
  0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0,
  0x3F, 0x1F, 0xC0, 0xFE, 0x7F, 0x01, 0xFD, 0xFC, 0x03, 0xF7, 0xF0, 0x07,
  0xEF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x3F, 0xBF, 0x80, 0x7E, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0xFE,
  0x07, 0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE7, 0xC1, 0xF0, 0x1F, 0xBF, 0xDF,
  0xE0, 0x7D, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0x9F, 0xC3, 0xF9, 0xFC, 0x7F, 0x0F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xF1,
  0xF8, 0xFE, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xF8, 0x7F, 0x1F, 0x8F, 0xE1,
  0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x00, 0x07, 0xE7, 0xC0, 0x7E,
  0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xE1, 0xF8, 0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF9, 0xFD, 0xFC, 0x7F,
  0x7F, 0x1F, 0xDF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xBF,
  0x0F, 0xEF, 0xC3, 0xFB, 0xF0, 0xFE, 0xFC, 0x7F, 0x3F, 0x9F, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xF9,
  0xF0, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x1F,
  0xC3, 0xF0, 0x7F, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xFC, 0x1F, 0x87,
  0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x9F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7E, 0xFF, 0x01, 0xF9,
  0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0x7F, 0x7E, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0x9F, 0xC7, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8, 0xFE,
  0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x0F,
  0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xF7, 0xE0,
  0x3E, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x0F, 0x8F, 0x87, 0xCF, 0x83, 0xEF, 0xC1, 0xF7,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xE1, 0xFC, 0x70, 0xFE, 0x10, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x81, 0xFC, 0x79, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0,
  0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7F, 0x63, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x1F, 0xE0, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFE,
  0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x7F, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFB, 0xE0, 0x3F, 0x3E, 0x00,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFB, 0xF0, 0xFE, 0xFC, 0x7F, 0x3F,
  0x1F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF8, 0xFC, 0xFC, 0x3F, 0x7F, 0x0F, 0xDF,
  0x83, 0xF7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x7E, 0x3F, 0xC7, 0xF7, 0xE3, 0xFC, 0x7F, 0x7E,
  0x3F, 0xC7, 0xE7, 0xE7, 0xFC, 0xFE, 0x7E, 0x7F, 0xCF, 0xCF, 0xE7, 0xFC,
  0xFC, 0xFE, 0xFF, 0xDF, 0xCF, 0xEF, 0xFD, 0xF8, 0xFF, 0xFF, 0x9F, 0x8F,
  0xDF, 0xFB, 0xF0, 0xFD, 0xFF, 0xBF, 0x0F, 0xDE, 0xFB, 0xF0, 0xFF, 0xEF,
  0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x07, 0xF1, 0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xCF, 0xE0, 0x1F, 0x9F,
  0xC0, 0x3F, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0x7E, 0x01, 0xFC, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x3F, 0x80, 0xFC,
  0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xDF,
  0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0x80, 0x3E, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3E,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8,
  0x07, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 13, 29, 11, 0, -29 },
  { 49, 17, 10, 18, 4, -29 },
  { 71, 23, 29, 22, 0, -29 },
  { 155, 19, 33, 19, 1, -31 },
  { 234, 30, 30, 32, 2, -30 },
  { 347, 25, 30, 25, 0, -30 },
  { 441, 8, 10, 10, 4, -29 },
  { 451, 15, 36, 12, 0, -30 },
  { 519, 14, 36, 12, -3, -30 },
  { 582, 17, 20, 18, 3, -32 },
  { 625, 18, 19, 21, 2, -24 },
  { 668, 10, 12, 11, -2, -6 },
  { 683, 12, 6, 13, 0, -14 },
  { 692, 7, 7, 11, 0, -7 },
  { 699, 22, 30, 16, -2, -30 },
  { 782, 19, 30, 19, 1, -30 },
  { 854, 15, 29, 19, 4, -29 },
  { 909, 20, 30, 19, -1, -30 },
  { 984, 20, 30, 19, 0, -30 },
  { 1059, 20, 29, 19, 0, -29 },
  { 1132, 19, 29, 19, 1, -29 },
  { 1201, 20, 30, 19, 1, -30 },
  { 1276, 21, 29, 19, 1, -29 },
  { 1353, 20, 30, 19, 0, -30 },
  { 1428, 20, 30, 19, 0, -30 },
  { 1503, 11, 23, 11, 0, -23 },
  { 1535, 13, 29, 11, -2, -23 },
  { 1583, 18, 20, 21, 2, -25 },
  { 1628, 18, 15, 21, 2, -22 },
  { 1662, 18, 20, 21, 2, -25 },
  { 1707, 16, 30, 15, 1, -30 },
  { 1767, 28, 33, 29, 1, -30 },
  { 1883, 21, 29, 22, -2, -29 },
  { 1960, 22, 29, 21, 0, -29 },
  { 2040, 21, 30, 19, 1, -30 },
  { 2119, 22, 29, 22, 0, -29 },
  { 2199, 19, 29, 17, 0, -29 },
  { 2268, 19, 29, 17, 0, -29 },
  { 2337, 23, 30, 22, 1, -30 },
  { 2424, 25, 29, 23, 0, -29 },
  { 2515, 20, 29, 15, -2, -29 },
  { 2588, 19, 38, 11, -6, -29 },
  { 2679, 25, 29, 21, 0, -29 },
  { 2770, 15, 29, 16, 0, -29 },
  { 2825, 32, 29, 30, 0, -29 },
  { 2941, 26, 29, 25, 0, -29 },
  { 3036, 23, 30, 24, 1, -30 },
  { 3123, 21, 29, 20, 0, -29 },
  { 3200, 23, 37, 24, 1, -30 },
  { 3307, 21, 29, 21, 0, -29 },
  { 3384, 21, 30, 18, -1, -30 },
  { 3463, 18, 29, 18, 3, -29 },
  { 3529, 23, 29, 22, 1, -29 },
  { 3613, 21, 29, 21, 4, -29 },
  { 3690, 31, 29, 31, 3, -29 },
  { 3803, 26, 29, 21, -2, -29 },
  { 3898, 20, 29, 20, 4, -29 },
  { 3971, 23, 29, 18, -2, -29 },
  { 4055, 17, 37, 12, -2, -30 },
  { 4134, 10, 30, 16, 4, -30 },
  { 4172, 17, 37, 12, -3, -30 },
  { 4251, 20, 19, 19, -1, -29 },
  { 4299, 17, 5, 16, -4, 3 },
  { 4310, 9, 6, 14, 6, -31 },
  { 4317, 20, 23, 20, 1, -23 },
  { 4375, 20, 31, 20, -1, -31 },
  { 4453, 17, 23, 16, 1, -23 },
  { 4502, 21, 31, 20, 1, -31 },
  { 4584, 18, 23, 19, 1, -23 },
  { 4636, 22, 41, 13, -5, -31 },
  { 4749, 22, 33, 20, -1, -23 },
  { 4840, 20, 31, 20, -1, -31 },
  { 4918, 12, 32, 10, 0, -32 },
  { 4966, 17, 42, 10, -5, -32 },
  { 5056, 23, 31, 20, -1, -31 },
  { 5146, 14, 31, 10, -1, -31 },
  { 5201, 30, 23, 30, -1, -23 },
  { 5288, 20, 23, 20, -1, -23 },
  { 5346, 18, 23, 20, 1, -23 },
  { 5398, 22, 33, 20, -3, -23 },
  { 5489, 20, 33, 20, 1, -23 },
  { 5572, 17, 23, 14, 0, -23 },
  { 5621, 17, 23, 16, 0, -23 },
  { 5670, 13, 27, 14, 2, -27 },
  { 5714, 20, 23, 20, 1, -23 },
  { 5772, 18, 23, 19, 3, -23 },
  { 5824, 28, 23, 28, 2, -23 },
  { 5905, 23, 23, 19, -2, -23 },
  { 5972, 23, 33, 19, -2, -23 },
  { 6067, 19, 23, 16, -2, -23 },
  { 6122, 17, 35, 14, 0, -29 },
  { 6197, 6, 41, 16, 5, -32 },
  { 6228, 16, 35, 14, -2, -29 },
  { 6298, 18, 7, 21, 2, -18 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC41PT7B_H_
