#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC37PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0x3F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0x00, 0x79,
  0xF0, 0x07, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xF9, 0xE0, 0x07, 0x9F, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x80, 0x3E,
  0x78, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x3C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x9F,
  0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0xB1, 0x03, 0xEC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x86, 0xF8, 0x71, 0xBE, 0x1F, 0x7F, 0x87, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x02, 0x01, 0xFC, 0x07, 0x80, 0x7F, 0x81,
  0xF0, 0x1F, 0xF8, 0x3C, 0x03, 0xDF, 0x0F, 0x80, 0xFB, 0xE1, 0xE0, 0x1E,
  0x7C, 0x7C, 0x03, 0xCF, 0x9F, 0x00, 0xF9, 0xF3, 0xE0, 0x1F, 0x3C, 0xF8,
  0x03, 0xC7, 0x9E, 0x00, 0x79, 0xF7, 0xCF, 0xCF, 0xBC, 0xF3, 0xFD, 0xFF,
  0xBE, 0xFF, 0x9F, 0xE7, 0x9F, 0xF3, 0xF9, 0xF7, 0xDE, 0x1C, 0x7C, 0xF3,
  0xE0, 0x0F, 0x3E, 0x78, 0x03, 0xE7, 0xCF, 0x00, 0x78, 0xF1, 0xE0, 0x1F,
  0x1E, 0x7C, 0x03, 0xC3, 0xCF, 0x80, 0xF8, 0x79, 0xE0, 0x3E, 0x0F, 0xFC,
  0x07, 0xC1, 0xFF, 0x01, 0xF0, 0x1F, 0xC0, 0x3C, 0x03, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0xFC, 0x3F,
  0xE3, 0xF1, 0xFF, 0xDF, 0x8F, 0xFF, 0x7E, 0x3F, 0xFF, 0xF1, 0xFB, 0xFF,
  0xC7, 0xE7, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x3F, 0xC3, 0xF8, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFE,
  0x7F, 0x00, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x21, 0xE0, 0x31, 0xE0, 0x3D,
  0xE2, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x0F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xF8, 0x7E, 0xF8, 0x3E, 0xFC, 0x1C, 0x78, 0x0C, 0x70, 0x00,
  0x40, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C,
  0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x3F, 0xE7, 0xFD, 0xFF, 0x80, 0x7D, 0xFF,
  0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x7E, 0x7E, 0x3F, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0xCF, 0xC7, 0xCF,
  0xC7, 0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7E, 0xFC, 0x7E,
  0x7E, 0x3F, 0x3F, 0x1F, 0x9F, 0x9F, 0x8F, 0xCF, 0xC7, 0xEF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F,
  0xFC, 0xFD, 0xF8, 0xF7, 0xE0, 0xCF, 0xC0, 0x9F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF0, 0x38, 0xFC, 0x0C, 0x3F, 0x02, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x47, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0x61, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07,
  0xF0, 0x1F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x80, 0x7E, 0x30,
  0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x7B, 0xF0, 0x3D, 0xF8, 0x1F, 0x7E, 0x0F, 0x9F, 0x83, 0xC7, 0xE1, 0xF1,
  0xF8, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0x43, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x90, 0x1F, 0x8C, 0x1F, 0xC7, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFE, 0x60, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC4, 0x03, 0xFF, 0xC1, 0xFB, 0xF8, 0x7F,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F, 0x0F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xF3,
  0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0xCF, 0x83, 0xF7, 0xE0, 0xFF, 0xF0,
  0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0x7E, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x1F,
  0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE1, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFC, 0x7E, 0x3F, 0xBF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xEF, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x00, 0x03, 0x03, 0xF0, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7E, 0x3F, 0x8F,
  0xE3, 0xF0, 0xF8, 0x00, 0x00, 0xC0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0,
  0x7E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0xF1,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xC4, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x01,
  0xF0, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x3E, 0x1F, 0x8F, 0x1E, 0x3F,
  0xF7, 0x9F, 0x3F, 0xF3, 0xCF, 0x3F, 0x79, 0xEF, 0x9E, 0x3C, 0xF7, 0x9F,
  0x3E, 0x7B, 0xCF, 0x1E, 0x3F, 0xC7, 0x8F, 0x1F, 0xE7, 0xC7, 0x9E, 0xF3,
  0xC7, 0xCF, 0x79, 0xE3, 0xC7, 0xBC, 0xF3, 0xE7, 0x9E, 0x7F, 0xFF, 0x8F,
  0x3F, 0xFF, 0xC7, 0x8F, 0xDF, 0xC3, 0xC3, 0x83, 0x81, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x40, 0x3F, 0x00, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFB, 0xE0, 0x1F, 0xBE, 0x01, 0xFB, 0xE0, 0x1F,
  0x3E, 0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x07, 0xE3, 0xE0, 0x7E, 0x7E, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7F, 0x07, 0xEF, 0xE0, 0x7F,
  0xFE, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x7E, 0x0F,
  0xCF, 0xE1, 0xF8, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xFC,
  0x7F, 0x1F, 0x87, 0xE3, 0xF8, 0x7E, 0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xF8,
  0x40, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x38,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1,
  0xF8, 0x3F, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0x1F, 0x87, 0xF3, 0xF8, 0x7F,
  0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x0F, 0xE3, 0xF0, 0xFC, 0x7F, 0x1F,
  0xC7, 0xE3, 0xF8, 0x7E, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x83, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xE0, 0x41, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x3F, 0xE7, 0xE3, 0xFC, 0x7E, 0x3F, 0xC7,
  0xE7, 0xFC, 0xFE, 0x7F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8,
  0xFE, 0x1F, 0x87, 0xF1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0xFE, 0x0F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x47, 0xE0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF1,
  0xFE, 0x0F, 0xC3, 0xF0, 0x1F, 0x8F, 0xE0, 0x3F, 0x3F, 0x80, 0xFE, 0x7E,
  0x01, 0xF9, 0xFC, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7E,
  0xFC, 0x01, 0xFD, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x8F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F,
  0x00, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8,
  0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F,
  0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x3F, 0xF8,
  0x3F, 0xFB, 0xEF, 0x81, 0xF7, 0xDF, 0xFC, 0x1F, 0xBF, 0xFF, 0xE0, 0xFD,
  0xFF, 0xBF, 0x07, 0xEF, 0xFD, 0xF8, 0x3F, 0x7F, 0xDF, 0x81, 0xF3, 0xFE,
  0xFC, 0x1F, 0x9F, 0xE7, 0xE0, 0xFC, 0xFF, 0x3F, 0x07, 0xE7, 0xF3, 0xF0,
  0x3F, 0x3F, 0x9F, 0x81, 0xF1, 0xFC, 0xFC, 0x1F, 0x8F, 0xC7, 0xE0, 0xFC,
  0x7E, 0x3F, 0x07, 0xE3, 0xE3, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x07, 0xF8,
  0x3F, 0x07, 0xF8, 0x7E, 0x07, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8,
  0x7E, 0x0F, 0xFC, 0x7C, 0x0F, 0xFC, 0xFC, 0x0F, 0xFC, 0xFC, 0x1F, 0xFC,
  0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0x7C, 0xF8, 0x1F, 0x7F, 0xF8, 0x3F, 0x7F,
  0xF8, 0x3F, 0x7F, 0xF8, 0x3F, 0x3F, 0xF8, 0x3F, 0x3F, 0xF0, 0x3E, 0x3F,
  0xF0, 0x7E, 0x3F, 0xF0, 0x7E, 0x3F, 0xF0, 0x7E, 0x3F, 0xF0, 0x7E, 0x1F,
  0xE0, 0x7C, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F, 0xE0, 0xFC, 0x1F,
  0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x3F, 0x83, 0xF3,
  0xF8, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F,
  0x7E, 0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F,
  0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0xC7, 0xE3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x9F, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xCF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x3F, 0x83, 0xF3, 0xF8, 0x3F,
  0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07,
  0xFF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF, 0xE1,
  0xFC, 0xFE, 0x1F, 0xC7, 0xE3, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x9F,
  0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xE3, 0xF9, 0xFC, 0x7E, 0x7F,
  0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFE, 0x07, 0xEF, 0xC1, 0xFD, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xF0,
  0xFC, 0xFE, 0x1F, 0x8F, 0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x9F, 0x87, 0xF0,
  0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x83, 0xF8, 0xE0, 0x7F, 0x04, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x20, 0x3F, 0x86,
  0x07, 0xF0, 0xFB, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F,
  0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3,
  0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x7F, 0x0F,
  0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC,
  0x7E, 0x0F, 0xE7, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xC7, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x87,
  0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0,
  0x7C, 0xFC, 0x07, 0xDF, 0xC0, 0x7D, 0xF8, 0x07, 0xDF, 0x80, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7E,
  0x0F, 0xC3, 0xFB, 0xF0, 0x7E, 0x1F, 0x9F, 0x87, 0xF0, 0xFC, 0xFC, 0x3F,
  0x8F, 0xC7, 0xE1, 0xFC, 0x7E, 0x3F, 0x1F, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F,
  0x0F, 0xCF, 0xF1, 0xF8, 0x7E, 0x7F, 0x9F, 0xC3, 0xF3, 0xFC, 0xFC, 0x1F,
  0xBF, 0xE7, 0xE0, 0xFD, 0xFF, 0x7E, 0x07, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF,
  0xDF, 0x81, 0xF7, 0xFF, 0xF8, 0x0F, 0xFD, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE,
  0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xE1,
  0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xE7, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xBF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3,
  0xF0, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F,
  0x80, 0xFE, 0x1F, 0xEF, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE7,
  0xF0, 0xFC, 0xFC, 0x1F, 0xBF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0x07, 0xFF, 0xE0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x40, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFB, 0xE0, 0xFC, 0xF8,
  0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xF3, 0xE0, 0x7D, 0xF8, 0x1F, 0xFC,
  0x07, 0xC0, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFE, 0x7E, 0x3F, 0x3F, 0x1F, 0x0F, 0x03, 0x80, 0x43, 0xF3, 0xE1, 0xFE,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xDF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0xFE, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xCF, 0xE3, 0xF3, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC3, 0xFB, 0xF0, 0x7C, 0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x78,
  0x0F, 0xBF, 0x07, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xDF, 0xC7,
  0xE7, 0xF3, 0xF1, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE1,
  0xF9, 0xF8, 0x7E, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE7, 0xF3, 0xFF, 0xF8,
  0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xBF, 0x83, 0xE7, 0xC0, 0x01, 0xF0, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x87, 0xF3, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x04, 0x7E, 0x10, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x1C, 0x7E, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0xF7, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F,
  0xC7, 0xF1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC7, 0xE1, 0xF9, 0xFC, 0x3F, 0x3F, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFB, 0xF0, 0x3E, 0x7C, 0x00, 0x00, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x3F, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x08, 0xFE, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x05, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x09, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xF0, 0x10, 0x3F, 0xBE, 0x07, 0xFB, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFD, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x7F, 0x3F,
  0x87, 0xF3, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x08, 0x0F, 0xE0, 0xE0,
  0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x78, 0x0F, 0xBF, 0x07, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF3, 0xF8, 0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x80, 0x40, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x00, 0x0E, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x9F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0x0F, 0xC7, 0xE1,
  0xF8, 0xFC, 0x1F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0xBF, 0x01, 0xF7, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFE, 0x0F, 0xC7,
  0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x00, 0x00, 0x1E, 0x0F, 0x03, 0xEF, 0xE7, 0xE1, 0xFF, 0xFB, 0xFC,
  0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xF9, 0xFC,
  0xFC, 0xFE, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF3, 0xF1,
  0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xE7,
  0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F,
  0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x00, 0x00,
  0x1E, 0x03, 0xEF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF,
  0xE1, 0xF9, 0xF8, 0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0xFE, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x3F, 0x3F, 0x7E,
  0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7E, 0xFC, 0x7E, 0xFC, 0x7E, 0xFC, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x3E, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xE7, 0xF0, 0xFE,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF9, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x20, 0xFE,
  0xF8, 0x3F, 0xDF, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x7F, 0x0F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F,
  0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x9F, 0xC7, 0xF3, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x1F, 0x7C,
  0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xE3, 0xFF, 0xC7, 0xE3, 0x0F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0xFE, 0x41, 0xFC, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x87,
  0xFE, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0xFD, 0xFF, 0xEF, 0xFE, 0x7F, 0xF1, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0x1F, 0x8F, 0xCF,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x7E, 0x3F, 0x3F, 0x8F, 0xCF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xF7, 0xC1, 0xF9, 0xE0, 0xFC, 0x3F, 0xFE, 0x1F, 0xBF, 0x0F,
  0xDF, 0x8F, 0xC7, 0xC7, 0xE3, 0xE7, 0xE1, 0xF3, 0xF0, 0xFB, 0xF0, 0x7D,
  0xF8, 0x3E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0xFC, 0x7F, 0x1F, 0xFE, 0x3F, 0x9F, 0xBF, 0x3F, 0xCF, 0xDF, 0x9F,
  0xE7, 0xEF, 0xDF, 0xF7, 0xE7, 0xEF, 0xFB, 0xF3, 0xF7, 0xFD, 0xF1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFE, 0xFC, 0x7D, 0xEF, 0x7C, 0x3F, 0xF7, 0xFE, 0x1F,
  0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x07, 0xFD, 0xFF, 0x83, 0xFC, 0xFF, 0x81,
  0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x3F, 0x3F, 0x81, 0xF9, 0xF8,
  0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xF7, 0xE0, 0x3F, 0xBF,
  0x01, 0xF9, 0xF8, 0x1F, 0x8F, 0xC1, 0xFC, 0x7F, 0x00, 0x0F, 0xC3, 0xF8,
  0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0x8F, 0xC0, 0x7C, 0x7E, 0x03, 0xE7,
  0xE0, 0x1F, 0x3F, 0x00, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0B, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3E, 0x01, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x00, 0x78, 0x00, 0x08, 0x00, 0xBF, 0xC0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFE, 0x03, 0xFC,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 12, 26, 10, 0, -26 },
  { 40, 16, 9, 17, 3, -26 },
  { 58, 21, 26, 20, 0, -26 },
  { 127, 18, 30, 18, 0, -28 },
  { 195, 27, 27, 29, 2, -27 },
  { 287, 22, 27, 22, 0, -27 },
  { 362, 8, 9, 9, 3, -26 },
  { 371, 14, 33, 10, 0, -27 },
  { 429, 13, 33, 10, -3, -27 },
  { 483, 16, 17, 16, 2, -28 },
  { 517, 16, 18, 19, 2, -22 },
  { 553, 9, 10, 10, -2, -5 },
  { 565, 11, 6, 11, 0, -13 },
  { 574, 7, 6, 10, 0, -6 },
  { 580, 20, 27, 15, -2, -27 },
  { 648, 17, 27, 18, 1, -27 },
  { 706, 15, 26, 18, 3, -26 },
  { 755, 18, 27, 18, -1, -27 },
  { 816, 18, 27, 18, 0, -27 },
  { 877, 18, 26, 18, 0, -26 },
  { 936, 17, 26, 18, 1, -26 },
  { 992, 18, 27, 18, 1, -27 },
  { 1053, 19, 26, 18, 1, -26 },
  { 1115, 18, 27, 18, 0, -27 },
  { 1176, 18, 27, 18, 0, -27 },
  { 1237, 10, 21, 10, 0, -21 },
  { 1264, 12, 26, 10, -2, -21 },
  { 1303, 17, 19, 19, 1, -23 },
  { 1344, 16, 14, 19, 2, -20 },
  { 1372, 16, 19, 19, 2, -23 },
  { 1410, 15, 27, 14, 1, -27 },
  { 1461, 25, 30, 26, 1, -27 },
  { 1555, 20, 27, 20, -2, -27 },
  { 1623, 20, 26, 19, 0, -26 },
  { 1688, 19, 27, 17, 1, -27 },
  { 1753, 20, 26, 20, 0, -26 },
  { 1818, 17, 26, 16, 0, -26 },
  { 1874, 17, 26, 15, 0, -26 },
  { 1930, 20, 27, 20, 1, -27 },
  { 1998, 22, 26, 21, 0, -26 },
  { 2070, 18, 26, 14, -1, -26 },
  { 2129, 18, 34, 10, -6, -26 },
  { 2206, 23, 26, 19, 0, -26 },
  { 2281, 13, 26, 15, 0, -26 },
  { 2324, 29, 26, 27, 0, -26 },
  { 2419, 24, 26, 22, 0, -26 },
  { 2497, 20, 27, 21, 1, -27 },
  { 2565, 19, 26, 18, 0, -26 },
  { 2627, 20, 33, 21, 1, -27 },
  { 2710, 19, 26, 19, 0, -26 },
  { 2772, 19, 27, 16, -1, -27 },
  { 2837, 16, 26, 16, 3, -26 },
  { 2889, 21, 26, 20, 1, -26 },
  { 2958, 20, 26, 19, 3, -26 },
  { 3023, 29, 26, 28, 2, -26 },
  { 3118, 23, 26, 19, -2, -26 },
  { 3193, 19, 26, 18, 3, -26 },
  { 3255, 20, 26, 16, -1, -26 },
  { 3320, 16, 33, 11, -2, -27 },
  { 3386, 8, 27, 15, 4, -27 },
  { 3413, 16, 33, 11, -3, -27 },
  { 3479, 18, 17, 17, -1, -26 },
  { 3518, 16, 5, 14, -4, 2 },
  { 3528, 8, 6, 12, 5, -28 },
  { 3534, 18, 21, 18, 1, -21 },
  { 3582, 18, 28, 18, 0, -28 },
  { 3645, 15, 21, 15, 1, -21 },
  { 3685, 19, 28, 18, 1, -28 },
  { 3752, 16, 21, 17, 1, -21 },
  { 3794, 20, 37, 11, -4, -28 },
  { 3887, 20, 30, 18, -1, -21 },
  { 3962, 18, 28, 18, 0, -28 },
  { 4025, 11, 29, 9, 0, -29 },
  { 4065, 16, 38, 9, -5, -29 },
  { 4141, 20, 28, 18, 0, -28 },
  { 4211, 11, 28, 9, 0, -28 },
  { 4250, 26, 21, 27, 0, -21 },
  { 4319, 18, 21, 18, 0, -21 },
  { 4367, 16, 21, 18, 1, -21 },
  { 4409, 20, 30, 18, -2, -21 },
  { 4484, 19, 30, 18, 0, -21 },
  { 4556, 15, 21, 13, 0, -21 },
  { 4596, 15, 21, 14, 0, -21 },
  { 4636, 13, 25, 13, 1, -25 },
  { 4677, 18, 20, 18, 1, -20 },
  { 4722, 17, 20, 17, 2, -20 },
  { 4765, 25, 20, 25, 2, -20 },
  { 4828, 21, 20, 17, -2, -20 },
  { 4881, 21, 29, 17, -2, -20 },
  { 4958, 18, 20, 14, -2, -20 },
  { 5003, 16, 32, 13, 0, -26 },
  { 5067, 5, 37, 15, 5, -29 },
  { 5091, 15, 32, 13, -2, -26 },
  { 5151, 17, 7, 19, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC37PT7B_H_
