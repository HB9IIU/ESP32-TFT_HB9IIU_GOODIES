#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC30PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F,
  0x0F, 0x87, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x3E, 0x1F, 0x0F,
  0x00, 0x7D, 0xF7, 0x9F, 0xF9, 0xEF, 0x9E, 0xFB, 0xEF, 0x3E, 0xF3, 0xC0,
  0x01, 0xEF, 0x00, 0xE7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x39, 0xE0, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFF, 0x07, 0x9C, 0x03, 0x9E, 0x01,
  0xCF, 0x07, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF0, 0x79, 0xC0, 0x3D, 0xE0,
  0x1C, 0xF0, 0x1E, 0x70, 0x0F, 0x78, 0x07, 0x3C, 0x00, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0xC0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0x44,
  0x1E, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xFC, 0x63, 0xF0, 0xE5, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x07, 0xE0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0xF8,
  0x1E, 0x0F, 0xE1, 0xE0, 0xFF, 0x0F, 0x07, 0x38, 0xF0, 0x79, 0xC7, 0x03,
  0xDE, 0x78, 0x1C, 0xF3, 0x80, 0xE7, 0xBC, 0x07, 0x3B, 0xCF, 0xBF, 0xDE,
  0xFF, 0xFD, 0xEF, 0xFF, 0xCF, 0x7F, 0x9C, 0xF7, 0x9C, 0x07, 0x3D, 0xE0,
  0x79, 0xCF, 0x03, 0x8E, 0x78, 0x3C, 0x73, 0x83, 0xC3, 0xBC, 0x1E, 0x1F,
  0xC1, 0xE0, 0xFE, 0x1E, 0x03, 0xE0, 0x00, 0x60, 0x00, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x7C, 0x7F, 0x9E, 0x3F, 0xFF, 0x9F,
  0xFF, 0xC7, 0xDF, 0xF3, 0xE7, 0xF8, 0xF8, 0xFE, 0x3E, 0x3F, 0x0F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xEF, 0xC0, 0x7D, 0xEF, 0xBE, 0xFB,
  0xCF, 0x00, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x3E,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x11, 0xE0, 0xEF, 0x17, 0xF7, 0x7F, 0xFB,
  0xFF, 0xC1, 0xFF, 0x1F, 0x83, 0xFE, 0x1F, 0xF0, 0x77, 0xC1, 0x1C, 0x08,
  0x80, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x1F, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0xF8, 0x7F, 0xBF,
  0xDF, 0xDF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0xFE, 0x3F,
  0xF1, 0xFF, 0x9F, 0x3C, 0xF9, 0xEF, 0x8F, 0x7C, 0xFB, 0xE7, 0xDF, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0xFB, 0xE7, 0xDF, 0x3E, 0xFB, 0xE7, 0xDF, 0x3F,
  0xF1, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xE3,
  0xFC, 0xFF, 0xBF, 0xF7, 0xBE, 0x6F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00,
  0x70, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0xC7, 0xC1, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0xE0, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x21, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x3F, 0xC0, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x4F, 0xC0, 0x1F, 0x80, 0x7E, 0x81, 0xF3, 0x0F,
  0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xFC, 0x0E,
  0xF8, 0x3D, 0xE0, 0xF7, 0xC1, 0xCF, 0x87, 0x9F, 0x1F, 0xFF, 0xBF, 0xFE,
  0x7F, 0xFC, 0xFF, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x87, 0xFF, 0x08, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x20, 0xF8, 0x87, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x00, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0xC3, 0xFF, 0x1F, 0xF8, 0x7C, 0x03,
  0xE0, 0x0F, 0x80, 0x7D, 0xE1, 0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0xFD, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xEF, 0xCF, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC0, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x07, 0xF0,
  0x1F, 0xF0, 0x7F, 0xE1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0xBE, 0x1F,
  0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x03, 0xFF, 0x07, 0xFF, 0x1F, 0x3E,
  0x3C, 0x7C, 0xF8, 0xF9, 0xF1, 0xE3, 0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x07,
  0xF0, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0x1F, 0xFC, 0x7D,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xEF, 0xCF, 0xFF, 0x3F,
  0xF8, 0x7F, 0xE0, 0xEF, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x8F, 0xFE, 0x3F,
  0xF0, 0xFF, 0x83, 0xF8, 0x00, 0x0E, 0x1F, 0x1F, 0x3F, 0x1E, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xF8, 0xF0, 0x03, 0x81,
  0xF0, 0x7C, 0x3F, 0x07, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0xF8,
  0x00, 0x00, 0x08, 0x01, 0xC0, 0x7E, 0x0F, 0xF1, 0xFF, 0x3F, 0xE3, 0xFC,
  0x1F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xF0, 0x07, 0x80, 0x0C,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x07, 0x80, 0x3F,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0x07, 0xF9, 0xFF,
  0x3F, 0xE1, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x07, 0x81, 0xFE,
  0x7F, 0xE3, 0xFF, 0x3F, 0xF2, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xFC,
  0x1F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0x7C, 0x3E, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x3C, 0x7F, 0x73,
  0x9F, 0xF7, 0x79, 0xFE, 0x77, 0x3C, 0xE7, 0x73, 0x9E, 0x7F, 0x79, 0xE7,
  0xE7, 0x1C, 0xFE, 0x71, 0xCE, 0xE7, 0x3C, 0xEE, 0x73, 0xDC, 0xE7, 0xFF,
  0xCE, 0x7D, 0xF8, 0xE1, 0x02, 0x0F, 0x00, 0x00, 0x78, 0x04, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xEF, 0x03, 0xEF, 0x03, 0xFF,
  0x03, 0xDF, 0x07, 0xDF, 0x07, 0xDF, 0x0F, 0x9F, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F,
  0xFC, 0x1F, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0x1F,
  0x1F, 0x3F, 0x1F, 0x3F, 0x1F, 0x3E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFC, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7D, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xF0, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xE1, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF8, 0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0x3F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x3F, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x7E, 0x7C, 0xFC, 0x7F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFE, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xF0,
  0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x21, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x82, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0xFE, 0x7C, 0xFE, 0xFC, 0xFE, 0xFD, 0xFC,
  0xF9, 0xFC, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0x7C, 0xFC, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xE0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0xFC, 0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3E, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x80,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x7E, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x1E, 0x00, 0x0F, 0x8F, 0xC3, 0xE3,
  0xE0, 0xF9, 0xF8, 0x3E, 0xFC, 0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x0F, 0x8F, 0x83, 0xE3, 0xF0, 0xF8, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0x7F, 0xEF,
  0xFC, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F,
  0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF3, 0xFE,
  0x3F, 0xE7, 0xFC, 0x7F, 0xDE, 0xF0, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xC3,
  0xDF, 0xEF, 0x8F, 0xBF, 0xDF, 0x1F, 0x7F, 0x7C, 0x3E, 0xFE, 0xF8, 0x7D,
  0xF9, 0xF0, 0xF3, 0xF3, 0xE3, 0xE7, 0xC7, 0x87, 0xCF, 0x9F, 0x0F, 0x9F,
  0x3E, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xF1, 0xF1,
  0xFE, 0x3C, 0x3F, 0xCF, 0x87, 0xF9, 0xF0, 0xFF, 0x3E, 0x3F, 0xF7, 0xC7,
  0xFE, 0xF0, 0xFF, 0xFE, 0x1F, 0x7F, 0xC3, 0xCF, 0xF8, 0xF9, 0xFE, 0x1F,
  0x3F, 0xC3, 0xE7, 0xF8, 0x7C, 0xFF, 0x0F, 0x0F, 0xE3, 0xE1, 0xF8, 0x7C,
  0x3F, 0x0F, 0x87, 0xE0, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E,
  0xF8, 0x7C, 0xFC, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7,
  0xCF, 0x8F, 0x9F, 0x3F, 0x7E, 0x7D, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF,
  0x0F, 0xF8, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F,
  0x7C, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E,
  0xF8, 0x7C, 0xFC, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x3F, 0x1F, 0x3F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x3F, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0,
  0x7D, 0xF0, 0x7D, 0xF0, 0x7D, 0xF0, 0x7D, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xFC, 0x00, 0x78, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE,
  0x0F, 0xFC, 0x0F, 0x8C, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x60, 0xF8, 0x7B, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0x80,
  0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x1F, 0x8F, 0x8F, 0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xC7, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xFD, 0xF8, 0x7F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0xF8, 0x3F, 0xF0, 0xFF,
  0xE1, 0xF7, 0xC7, 0xEF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7C, 0x7C, 0xF8, 0xFB,
  0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1E, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x7C, 0x7C, 0x3E, 0xF8, 0xF8, 0xF9, 0xE1, 0xF1, 0xF3, 0xC7, 0xE3, 0xE7,
  0x8F, 0xCF, 0x8F, 0x3F, 0x9F, 0x1E, 0x7F, 0x7C, 0x7C, 0xFE, 0xF8, 0xFB,
  0xFD, 0xF1, 0xF7, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xDF, 0x0F, 0xFF,
  0xFC, 0x1F, 0xEF, 0xF8, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFE, 0x7F,
  0x81, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0,
  0x00, 0x07, 0xC7, 0xE0, 0xFC, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x07, 0xEF, 0x80, 0xF8, 0xF8, 0x3F, 0x1F,
  0x0F, 0xC3, 0xE0, 0xF8, 0x7F, 0xE3, 0xEF, 0x8F, 0xBE, 0x7C, 0x79, 0xF1,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xF1, 0xE3, 0xC7, 0xCF, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF9, 0xF1,
  0xE3, 0xC0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFF, 0x07, 0xDE, 0x0F, 0x3C,
  0x3E, 0x78, 0xF8, 0xF1, 0xE1, 0xF7, 0xC1, 0xFF, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0xF1, 0xF1, 0xE0, 0x07, 0x9E, 0x1F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xE3, 0xEF, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E,
  0x7C, 0x78, 0xF9, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0xFE, 0x1F,
  0xFC, 0x3F, 0xF8, 0x3C, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF7, 0x07, 0xFE, 0x1F, 0xFC, 0xFF, 0xF3, 0xF7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF1, 0xF7, 0xC7, 0xDF, 0x1F, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0xBF, 0xFC, 0xFF, 0xF3, 0xDF, 0x8F, 0x7C, 0x00, 0x07, 0xC0,
  0xFF, 0x3F, 0xE3, 0xFE, 0x7E, 0x47, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x07, 0xBE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x3E, 0xFC, 0x3E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8,
  0xF9, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3C, 0xF0, 0x03, 0xC0,
  0x7F, 0x87, 0xFC, 0x7F, 0xF7, 0xCF, 0xBE, 0x7F, 0xE7, 0xDF, 0xFE, 0xFF,
  0xE7, 0xFC, 0x3C, 0x01, 0xE0, 0x0F, 0x04, 0x7F, 0xE3, 0xFF, 0x0F, 0xF8,
  0x3F, 0x80, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x03, 0xCF, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0x7E,
  0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x7C, 0x3C, 0x7C,
  0x7C, 0x7C, 0x7C, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1E, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x81, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x7F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xF7, 0x07, 0xBF, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0x9F, 0x3E,
  0x7C, 0xF1, 0xF7, 0xC7, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0xBE,
  0x3C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0x60, 0x00, 0x7C, 0x3E, 0x1F, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x06, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7C, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x1F,
  0x1F, 0x3E, 0x1F, 0x7E, 0x3E, 0x7C, 0x3E, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7D, 0xF0, 0x79, 0xF0,
  0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x1E, 0x78,
  0xF0, 0xF7, 0xEF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xEF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x9F, 0x7C, 0x78, 0xFB, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x9F, 0x7C, 0xF8, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x1E, 0x70, 0x7B, 0xF1, 0xFF,
  0xCF, 0xFF, 0x3F, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x1F, 0x7C, 0x79, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0xFB, 0xE3, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF0, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7F, 0xF7, 0xCF, 0xBE, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xBC, 0x7D, 0xE3, 0xEF, 0x3E, 0x7F, 0xF3,
  0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x07, 0x9C, 0x07, 0xBE, 0x07, 0xFF, 0x0F,
  0xFF, 0x0F, 0xDF, 0x0F, 0x9F, 0x0F, 0x9F, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3C, 0xF0, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0x9E, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF,
  0xE3, 0xEF, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x78, 0xF9, 0xF1,
  0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3D,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x1E, 0x71, 0xEF, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0xF2, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC1, 0xFF, 0x3F, 0xF3, 0xFE, 0x3E, 0x63,
  0xE0, 0x3F, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7C, 0x87, 0xCF,
  0xFC, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0x07, 0x03, 0xC0, 0xF0, 0x7F, 0x3F,
  0xDF, 0xF7, 0xFE, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F,
  0x83, 0xE0, 0xFF, 0x3F, 0xC7, 0xF1, 0xFC, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7,
  0xDF, 0x1F, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x3E, 0xF8, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xFB, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0x78, 0x79,
  0xE0, 0xF8, 0xFF, 0xC7, 0xFE, 0x7D, 0xF3, 0xEF, 0x9E, 0x7D, 0xF3, 0xEF,
  0x9F, 0xF8, 0xFF, 0xC7, 0xBC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0xFC, 0xFB, 0xE7, 0xE7, 0xDF, 0x7E,
  0x7C, 0xF3, 0xF3, 0xE7, 0x9F, 0x9E, 0x3D, 0xFD, 0xF1, 0xEF, 0xEF, 0x8F,
  0x7F, 0x78, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xDF, 0xE0, 0xFE, 0xFF,
  0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC,
  0x7E, 0x00, 0x0F, 0x8F, 0x87, 0xCF, 0xC1, 0xE7, 0xC0, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFB, 0xE0, 0xFC, 0xF8,
  0xFC, 0x7C, 0x00, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0,
  0xF9, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87,
  0xFE, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0,
  0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0x80, 0x7E, 0x03, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3F, 0x01,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x7F, 0x0F, 0xE0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F,
  0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 9, 21, 8, 0, -21 },
  { 25, 12, 7, 14, 3, -21 },
  { 36, 17, 21, 16, 0, -21 },
  { 81, 15, 25, 14, 0, -23 },
  { 128, 21, 22, 24, 2, -22 },
  { 186, 18, 22, 18, 0, -22 },
  { 236, 6, 7, 7, 3, -21 },
  { 242, 11, 27, 8, 0, -22 },
  { 280, 10, 27, 8, -2, -22 },
  { 314, 13, 14, 13, 2, -23 },
  { 337, 13, 15, 15, 1, -18 },
  { 362, 8, 8, 8, -2, -4 },
  { 370, 9, 4, 9, 0, -10 },
  { 375, 5, 5, 8, 0, -5 },
  { 379, 17, 22, 12, -2, -22 },
  { 426, 13, 22, 14, 1, -22 },
  { 462, 11, 21, 14, 3, -21 },
  { 491, 15, 22, 14, -1, -22 },
  { 533, 14, 22, 14, 0, -22 },
  { 572, 15, 21, 14, 0, -21 },
  { 612, 14, 21, 14, 1, -21 },
  { 649, 14, 22, 14, 1, -22 },
  { 688, 15, 21, 14, 1, -21 },
  { 728, 15, 22, 14, 0, -22 },
  { 770, 14, 22, 14, 0, -22 },
  { 809, 8, 17, 8, 0, -17 },
  { 826, 10, 21, 8, -2, -17 },
  { 853, 13, 15, 15, 1, -18 },
  { 878, 13, 11, 15, 1, -16 },
  { 896, 13, 15, 15, 1, -18 },
  { 921, 12, 22, 11, 1, -22 },
  { 954, 20, 24, 21, 1, -22 },
  { 1014, 16, 22, 16, -2, -22 },
  { 1058, 16, 21, 16, 0, -21 },
  { 1100, 15, 22, 14, 1, -22 },
  { 1142, 16, 21, 16, 0, -21 },
  { 1184, 14, 21, 13, 0, -21 },
  { 1221, 14, 21, 12, 0, -21 },
  { 1258, 16, 22, 16, 1, -22 },
  { 1302, 18, 21, 17, 0, -21 },
  { 1350, 14, 21, 11, -1, -21 },
  { 1387, 14, 28, 8, -5, -21 },
  { 1436, 18, 21, 15, 0, -21 },
  { 1484, 11, 21, 12, 0, -21 },
  { 1513, 23, 21, 22, 0, -21 },
  { 1574, 19, 21, 18, 0, -21 },
  { 1624, 16, 22, 17, 1, -22 },
  { 1668, 15, 21, 14, 0, -21 },
  { 1708, 16, 27, 17, 1, -22 },
  { 1762, 16, 21, 15, 0, -21 },
  { 1804, 16, 22, 13, -1, -22 },
  { 1848, 13, 21, 13, 2, -21 },
  { 1883, 17, 21, 16, 1, -21 },
  { 1928, 15, 21, 16, 3, -21 },
  { 1968, 23, 21, 22, 2, -21 },
  { 2029, 19, 21, 15, -2, -21 },
  { 2079, 14, 21, 15, 3, -21 },
  { 2116, 16, 21, 13, -1, -21 },
  { 2158, 13, 27, 9, -2, -22 },
  { 2202, 7, 22, 12, 3, -22 },
  { 2222, 12, 27, 9, -2, -22 },
  { 2263, 15, 14, 14, -1, -21 },
  { 2290, 12, 4, 12, -3, 2 },
  { 2296, 7, 5, 10, 4, -23 },
  { 2301, 15, 17, 15, 0, -17 },
  { 2333, 14, 23, 15, 0, -23 },
  { 2374, 12, 17, 12, 1, -17 },
  { 2400, 16, 23, 15, 0, -23 },
  { 2446, 13, 17, 14, 1, -17 },
  { 2474, 16, 30, 9, -3, -23 },
  { 2534, 16, 24, 15, -1, -17 },
  { 2582, 14, 23, 15, 0, -23 },
  { 2623, 9, 23, 8, 0, -23 },
  { 2649, 13, 30, 8, -4, -23 },
  { 2698, 16, 23, 15, 0, -23 },
  { 2744, 9, 23, 8, 0, -23 },
  { 2770, 21, 17, 22, 0, -17 },
  { 2815, 14, 17, 15, 0, -17 },
  { 2845, 13, 17, 14, 1, -17 },
  { 2873, 16, 24, 15, -2, -17 },
  { 2921, 15, 24, 15, 0, -17 },
  { 2966, 12, 17, 11, 0, -17 },
  { 2992, 12, 17, 12, 0, -17 },
  { 3018, 10, 20, 10, 1, -20 },
  { 3043, 14, 17, 15, 1, -17 },
  { 3073, 13, 17, 14, 2, -17 },
  { 3101, 21, 17, 20, 1, -17 },
  { 3146, 17, 17, 14, -2, -17 },
  { 3183, 17, 24, 14, -2, -17 },
  { 3234, 14, 17, 12, -1, -17 },
  { 3264, 13, 26, 10, 0, -21 },
  { 3307, 4, 30, 12, 4, -23 },
  { 3322, 12, 26, 10, -2, -21 },
  { 3361, 13, 5, 15, 1, -13 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic30pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC30PT7B_H_
