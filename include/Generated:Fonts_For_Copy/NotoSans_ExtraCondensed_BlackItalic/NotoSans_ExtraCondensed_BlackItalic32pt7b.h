#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC32PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x04, 0x07,
  0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x80, 0x7E, 0xFB, 0xE7, 0xDF, 0x7E, 0xFB,
  0xEF, 0x9F, 0x7C, 0xFB, 0xE7, 0x9F, 0x3C, 0x00, 0xF7, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x07, 0xBC, 0x03, 0xCF, 0x00, 0xF3, 0xC1, 0xFF, 0xFC, 0x7F,
  0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE0, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x38,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x0F, 0x3C, 0x03,
  0xCF, 0x00, 0xF3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0xBC, 0x00, 0x00,
  0x30, 0x00, 0x20, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0x5C, 0x1E, 0xC4, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0x78, 0x41, 0x78, 0x63, 0x78, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0x80, 0x06, 0x00, 0x04,
  0x00, 0x04, 0x00, 0x0F, 0x01, 0xF0, 0x7F, 0x03, 0xC0, 0xFF, 0x0F, 0x03,
  0xFE, 0x1E, 0x07, 0xBC, 0x78, 0x1E, 0x78, 0xF0, 0x3C, 0xF3, 0xC0, 0x79,
  0xEF, 0x00, 0xF3, 0x9E, 0x01, 0xEF, 0x78, 0xF3, 0xFE, 0xF7, 0xF7, 0xFB,
  0xDF, 0xEF, 0xE7, 0xBF, 0xEF, 0x9E, 0xF3, 0xC0, 0x3D, 0xE7, 0x80, 0xF3,
  0xCF, 0x03, 0xC7, 0x1C, 0x07, 0x9E, 0x78, 0x1E, 0x3C, 0xF0, 0x3C, 0x7F,
  0xC0, 0xF0, 0x7F, 0x81, 0xE0, 0xFE, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x79, 0xF0, 0x1F, 0x3E,
  0x03, 0xE7, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xCF,
  0x8F, 0xFB, 0xF3, 0xFF, 0x7C, 0x7F, 0xFF, 0x9F, 0x7F, 0xE3, 0xE7, 0xFC,
  0xFC, 0xFF, 0x1F, 0x9F, 0xC3, 0xF3, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xE7, 0xE0, 0x7E, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0x7C,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0x06, 0x00, 0x3E, 0x01, 0xF0, 0xCF, 0x07, 0x78, 0xBF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x0F, 0xF8, 0xFE, 0x0F, 0xF0, 0xFB, 0xC3, 0xDF, 0x0C, 0xF0, 0x42,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0x78,
  0xF8, 0x7F, 0xBF, 0xDF, 0xEF, 0xFF, 0xF8, 0x11, 0xFF, 0xFF, 0xFB, 0xE0,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1F,
  0xFC, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x7E, 0x7D, 0xF1, 0xF7, 0xC7, 0xDF,
  0x1F, 0xFC, 0xFF, 0xE3, 0xEF, 0x8F, 0xBE, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF,
  0xBE, 0x3F, 0xF8, 0x7F, 0xC1, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x3F,
  0x07, 0xF0, 0xFF, 0x1F, 0xE3, 0xFE, 0x7F, 0xEF, 0xFE, 0x7F, 0xC7, 0x7C,
  0x27, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xFE,
  0x07, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x07, 0x1F, 0x06, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x7F, 0xF0, 0xF7, 0xE1, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF9, 0x03, 0xF3, 0x8F, 0xE7, 0xFF, 0x8F, 0xFF, 0x1F, 0xF8, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0x7C, 0x0F, 0xFC, 0x1E, 0xF8,
  0x1C, 0xF8, 0x3C, 0xF8, 0x78, 0xF8, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF1, 0x07, 0xE3, 0x9F, 0xC7,
  0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x07, 0xFC,
  0x1F, 0xF8, 0x7F, 0xF0, 0xFC, 0x43, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E,
  0xF0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF, 0xEF, 0x9F, 0x9F, 0x3F, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xF3, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE,
  0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xBF,
  0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E, 0xF8, 0x7C, 0x7C, 0xFC, 0x7C,
  0xF8, 0xF8, 0xFC, 0xF8, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0,
  0x01, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xCF,
  0xCF, 0x9F, 0x9F, 0x3E, 0x3E, 0x7C, 0xFC, 0xF9, 0xF9, 0xFF, 0xF3, 0xFF,
  0xC7, 0xFF, 0x87, 0xDF, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE2, 0x1F, 0xC7,
  0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0x0F, 0x87, 0xE3,
  0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x03, 0xE3,
  0xF1, 0xF8, 0xF8, 0x7C, 0x00, 0x03, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8,
  0x3F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0x3F, 0xE0, 0xFE, 0x03, 0xC0, 0x0C,
  0x00, 0x00, 0x0F, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x90, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x1F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x78, 0x00, 0xE1, 0xC7, 0xFB, 0xCF,
  0x3F, 0xEF, 0x39, 0xFF, 0x3D, 0xE7, 0x1C, 0xF7, 0x3C, 0xF3, 0xBC, 0xE3,
  0xCE, 0xF7, 0x8E, 0x3B, 0x9E, 0x39, 0xEE, 0x79, 0xE7, 0x39, 0xE7, 0x9C,
  0xE7, 0xFF, 0xE3, 0x9F, 0xFF, 0x8E, 0x3E, 0xF8, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x18, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB,
  0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7E, 0x7C, 0x3F, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xC1, 0xF7, 0xE0, 0xFB, 0xF0, 0xFF,
  0xF0, 0x7E, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7C, 0xFC, 0x7E, 0x7E, 0x3E, 0x3F, 0x1F, 0x3F, 0x0F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xF3, 0xF0, 0xF8, 0xF8, 0xFC, 0x7C,
  0x7E, 0x7E, 0x3E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFC, 0x1F, 0x84, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x10, 0xFE, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7C, 0xFC, 0x7E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xCF, 0xC3,
  0xE7, 0xE3, 0xF3, 0xE1, 0xF9, 0xF0, 0xFC, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E,
  0x7E, 0x3E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0xFF, 0xE1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xFF, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x10, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xE0, 0x43, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xCF, 0xF1, 0xF3, 0xFC, 0xFC, 0xFF, 0x3F,
  0x3F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0xE7,
  0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xC3,
  0xE1, 0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x87, 0xE1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xF0, 0xF8,
  0x7E, 0x3F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xE1,
  0xF8, 0xFC, 0x3E, 0x1F, 0x80, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x01, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0xBF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xC3,
  0xF0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xFB,
  0xF0, 0x1F, 0xBE, 0x01, 0xF7, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xEF, 0x80, 0x7E, 0xFC, 0x07, 0xCF, 0xC0, 0x7C, 0xFC, 0x07, 0xCF, 0xC0,
  0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7E, 0x00, 0x07, 0xC0, 0xFC, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7F,
  0xF7, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0x87, 0xF8,
  0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F,
  0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F,
  0xF9, 0xFF, 0x0F, 0xFD, 0xFF, 0x87, 0xDE, 0xFF, 0xC3, 0xEF, 0xFF, 0xC1,
  0xF7, 0xFB, 0xE0, 0xFB, 0xFD, 0xF0, 0xF9, 0xFC, 0xF8, 0x7C, 0xFE, 0xFC,
  0x3E, 0x7F, 0x7C, 0x1F, 0x3F, 0x3E, 0x0F, 0x9F, 0x9F, 0x0F, 0x8F, 0x9F,
  0x87, 0xC7, 0xCF, 0x83, 0xE3, 0xC7, 0xC0, 0x07, 0xE0, 0xF8, 0x7F, 0x0F,
  0x83, 0xF8, 0x7C, 0x1F, 0xC3, 0xE0, 0xFE, 0x1F, 0x07, 0xF9, 0xF8, 0x7F,
  0xCF, 0x83, 0xFE, 0x7C, 0x1F, 0xF3, 0xE0, 0xFF, 0x9F, 0x0F, 0xBD, 0xF0,
  0x7D, 0xFF, 0x83, 0xEF, 0xFC, 0x1F, 0x7F, 0xE0, 0xFB, 0xFF, 0x0F, 0x8F,
  0xF0, 0x7C, 0x7F, 0x83, 0xE3, 0xFC, 0x1F, 0x1F, 0xE0, 0xF8, 0xFF, 0x0F,
  0x87, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0x7C, 0xFC, 0x3E, 0x7C,
  0x1F, 0x7E, 0x0F, 0xBF, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7D, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0x3F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x1F, 0x9F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0x3F, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F,
  0xF8, 0x3F, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFC, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F,
  0x7E, 0x0F, 0xBF, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7D, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x3F, 0x3F, 0xFF, 0x0F,
  0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0xFC, 0x7E, 0x7E, 0x3E, 0x3E,
  0x1F, 0x3F, 0x0F, 0x9F, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F, 0x0F,
  0x9F, 0x8F, 0xCF, 0xC7, 0xE3, 0xE3, 0xE1, 0xF8, 0x00, 0xFE, 0x01, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x7E, 0x30, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x40, 0xFC, 0x30, 0x7E, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x1F, 0xFC, 0x1F, 0xBE, 0x0F,
  0xDF, 0x0F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF9,
  0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x7E, 0x0F, 0xBE, 0x07, 0xDF, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x1E, 0x1F, 0xBE, 0x1F,
  0x0F, 0x9F, 0x0F, 0x87, 0xCF, 0x8F, 0xC7, 0xE7, 0xC7, 0xE3, 0xE3, 0xE7,
  0xF3, 0xF1, 0xF3, 0xF9, 0xF0, 0xF9, 0xFC, 0xF8, 0x7D, 0xFE, 0xFC, 0x3E,
  0xFF, 0x7C, 0x1F, 0xFF, 0xBE, 0x0F, 0x7F, 0xFE, 0x0F, 0xBF, 0xFF, 0x07,
  0xFF, 0xEF, 0x83, 0xFE, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xE0,
  0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8,
  0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x7E, 0x3F,
  0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x00, 0xFB, 0xE0, 0x1F, 0xBE, 0x03, 0xF3, 0xE0, 0x3E, 0x3F, 0x07,
  0xE3, 0xF0, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0xFC, 0x7E, 0xFC, 0x7C, 0xFC,
  0xFC, 0x7C, 0xF8, 0x7D, 0xF8, 0x7D, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xF8, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBE, 0x0F,
  0xBE, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x7C, 0x1F, 0xFC, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF9, 0xF9, 0xF3, 0xE3, 0xC3, 0xC0,
  0x07, 0x9F, 0x0F, 0xDF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0x7E, 0x3E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC,
  0xFC, 0xF8, 0xFD, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7E, 0xF8, 0x3C, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xDE, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xF9, 0xF3, 0xE3,
  0xE7, 0xC7, 0xCF, 0x8F, 0xBE, 0x3F, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xF3,
  0xE7, 0xCF, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC, 0x79, 0xF0, 0x07, 0xE0, 0x7F,
  0xC7, 0xFC, 0x7F, 0xE7, 0xF6, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x84, 0x7C, 0x63, 0xFF, 0x1F, 0xF8, 0x7F,
  0xC1, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x1E, 0x7C, 0x1F, 0xBE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x0F, 0xDF, 0x87, 0xCF, 0xC3, 0xE7, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x7C, 0x7C, 0x3E, 0x7E, 0x3F, 0x3E, 0x1F, 0xBF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0x79, 0xE0, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F,
  0xFE, 0x7E, 0x7D, 0xF1, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F,
  0xF0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x8F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01,
  0xE0, 0x00, 0x01, 0xEF, 0x83, 0xF7, 0xC3, 0xFF, 0xE1, 0xFF, 0xE1, 0xFB,
  0xF0, 0xF9, 0xF8, 0x7C, 0xFC, 0x7C, 0x7E, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x8F, 0x8F, 0xCF, 0xC7, 0xE7, 0xC3, 0xF7, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x08, 0x1F, 0x87, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xDE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF9, 0xF9, 0xF3, 0xE3, 0xE7, 0xC7,
  0xCF, 0x9F, 0x3F, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xF3, 0xE7, 0xCF,
  0x8F, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0xFC, 0x03, 0x81, 0xF0, 0xFC, 0x3E,
  0x0F, 0x81, 0x80, 0x00, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x01, 0x80, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x3F, 0x0F, 0xBF, 0x0F, 0xDF,
  0x07, 0xDF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0x7C, 0x0F, 0xBF, 0x0F, 0x9F, 0x87, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF8, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x1E, 0x7C,
  0x78, 0x3D, 0xFD, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xE7, 0xCF, 0xCF, 0x8F, 0x9F, 0x1F, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C,
  0xFC, 0xF8, 0xF9, 0xF1, 0xF3, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F, 0x8F,
  0x9F, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF3,
  0xE3, 0xE0, 0x1E, 0x78, 0x3D, 0xF8, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE7,
  0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7C, 0xFC, 0xF9, 0xF1, 0xF3, 0xE3,
  0xE7, 0xCF, 0xCF, 0x9F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xF0,
  0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7E, 0xFD, 0xF1, 0xF7, 0xC7,
  0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF9, 0xFB, 0xE7,
  0xCF, 0xFF, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x07, 0xCE, 0x03, 0xFF,
  0x81, 0xEF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F,
  0x1F, 0x0F, 0x8F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF3, 0xF0,
  0xF9, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0x7C, 0x1F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xDF, 0x0F, 0xDF, 0x1F, 0xFF, 0x1F, 0xFE,
  0x3F, 0x7E, 0x3E, 0x7E, 0x3E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0xFC, 0xFC, 0xFC, 0xF8, 0xFD, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x1E, 0x78, 0xF7, 0xC7,
  0xBC, 0x3F, 0xE3, 0xFF, 0x1F, 0xF0, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xE6, 0x1F, 0x00,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x3E, 0x63,
  0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0x81, 0xE0, 0x3C,
  0x0F, 0xF3, 0xFE, 0xFF, 0xDF, 0xF7, 0xFE, 0x3E, 0x07, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x9F, 0xE3, 0xFC, 0x3F, 0x87,
  0xF0, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xE7, 0xE7, 0xCF, 0x8F,
  0x9F, 0x1F, 0x3E, 0x7E, 0x7C, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF,
  0x9F, 0x9F, 0x7E, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFB, 0xE0, 0xF8,
  0x7F, 0xE1, 0xFF, 0x8F, 0xBE, 0x3E, 0xF9, 0xF3, 0xE7, 0xCF, 0xBF, 0x3E,
  0xF8, 0xFB, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0xFC, 0xFF, 0xCF, 0xE7,
  0xFE, 0x7E, 0x3F, 0xF3, 0xF3, 0xEF, 0xBF, 0x9F, 0x7D, 0xFD, 0xF3, 0xFF,
  0xEF, 0x9F, 0xFF, 0x7C, 0xF7, 0xFF, 0xC7, 0xFB, 0xFE, 0x3F, 0xDF, 0xE1,
  0xFE, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xC7, 0xF0, 0x00, 0x0F, 0xCF, 0xC3, 0xF3, 0xF0,
  0x7D, 0xF8, 0x1F, 0x7C, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8,
  0x07, 0xDF, 0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x7E, 0x7C, 0x3F, 0x1F, 0x80,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x78, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xC0,
  0xFE, 0x0F, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x01, 0xC0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 23, 8, 0, -23 },
  { 30, 13, 8, 14, 3, -23 },
  { 43, 18, 23, 17, 0, -23 },
  { 95, 16, 26, 15, 0, -24 },
  { 147, 23, 23, 25, 2, -23 },
  { 214, 19, 23, 19, 0, -23 },
  { 269, 7, 8, 8, 3, -23 },
  { 276, 12, 28, 9, 0, -23 },
  { 318, 12, 28, 9, -3, -23 },
  { 360, 13, 15, 14, 2, -25 },
  { 385, 14, 15, 16, 1, -19 },
  { 412, 8, 9, 8, -2, -5 },
  { 421, 9, 5, 10, 0, -11 },
  { 427, 6, 6, 8, 0, -6 },
  { 432, 18, 23, 13, -2, -23 },
  { 484, 14, 23, 15, 1, -23 },
  { 525, 12, 23, 15, 3, -23 },
  { 560, 16, 23, 15, -1, -23 },
  { 606, 15, 23, 15, 0, -23 },
  { 650, 16, 23, 15, 0, -23 },
  { 696, 15, 23, 15, 1, -23 },
  { 740, 15, 23, 15, 1, -23 },
  { 784, 16, 23, 15, 1, -23 },
  { 830, 16, 23, 15, 0, -23 },
  { 876, 15, 23, 15, 0, -23 },
  { 920, 9, 18, 9, 0, -18 },
  { 941, 11, 22, 9, -2, -18 },
  { 972, 14, 15, 16, 1, -19 },
  { 999, 14, 11, 16, 1, -17 },
  { 1019, 14, 15, 16, 1, -19 },
  { 1046, 13, 23, 12, 1, -23 },
  { 1084, 22, 25, 23, 1, -23 },
  { 1153, 17, 23, 17, -2, -23 },
  { 1202, 17, 23, 17, 0, -23 },
  { 1251, 16, 23, 15, 1, -23 },
  { 1297, 17, 23, 17, 0, -23 },
  { 1346, 15, 23, 13, 0, -23 },
  { 1390, 15, 23, 13, 0, -23 },
  { 1434, 18, 23, 18, 1, -23 },
  { 1486, 19, 23, 18, 0, -23 },
  { 1541, 15, 23, 12, -1, -23 },
  { 1585, 15, 30, 9, -5, -23 },
  { 1642, 20, 23, 16, 0, -23 },
  { 1700, 12, 23, 13, 0, -23 },
  { 1735, 25, 23, 24, 0, -23 },
  { 1807, 21, 23, 19, 0, -23 },
  { 1868, 17, 23, 18, 1, -23 },
  { 1917, 16, 23, 15, 0, -23 },
  { 1963, 17, 28, 18, 1, -23 },
  { 2023, 17, 23, 16, 0, -23 },
  { 2072, 17, 23, 14, -1, -23 },
  { 2121, 14, 23, 14, 2, -23 },
  { 2162, 18, 23, 17, 1, -23 },
  { 2214, 17, 23, 17, 3, -23 },
  { 2263, 25, 23, 24, 2, -23 },
  { 2335, 20, 23, 16, -2, -23 },
  { 2393, 16, 23, 16, 3, -23 },
  { 2439, 17, 23, 14, -1, -23 },
  { 2488, 14, 28, 9, -2, -23 },
  { 2537, 8, 23, 13, 3, -23 },
  { 2560, 14, 28, 9, -3, -23 },
  { 2609, 16, 15, 15, -1, -23 },
  { 2639, 13, 4, 12, -3, 2 },
  { 2646, 7, 6, 11, 5, -25 },
  { 2652, 16, 18, 16, 0, -18 },
  { 2688, 15, 24, 16, 0, -24 },
  { 2733, 13, 18, 13, 1, -18 },
  { 2763, 17, 24, 16, 0, -24 },
  { 2814, 14, 18, 15, 1, -18 },
  { 2846, 18, 32, 10, -4, -24 },
  { 2918, 17, 26, 16, -1, -18 },
  { 2974, 15, 24, 16, 0, -24 },
  { 3019, 10, 25, 8, 0, -25 },
  { 3051, 14, 33, 8, -4, -25 },
  { 3109, 17, 24, 15, 0, -24 },
  { 3160, 10, 24, 8, 0, -24 },
  { 3190, 23, 18, 23, 0, -18 },
  { 3242, 15, 18, 16, 0, -18 },
  { 3276, 14, 18, 15, 1, -18 },
  { 3308, 17, 26, 16, -2, -18 },
  { 3364, 16, 26, 16, 0, -18 },
  { 3416, 13, 18, 11, 0, -18 },
  { 3446, 13, 18, 12, 0, -18 },
  { 3476, 11, 21, 11, 1, -21 },
  { 3505, 15, 18, 16, 1, -18 },
  { 3539, 14, 18, 15, 2, -18 },
  { 3571, 21, 18, 22, 2, -18 },
  { 3619, 18, 18, 15, -2, -18 },
  { 3660, 18, 26, 15, -2, -18 },
  { 3719, 15, 18, 13, -1, -18 },
  { 3753, 13, 28, 11, 0, -23 },
  { 3799, 4, 32, 13, 4, -25 },
  { 3815, 13, 28, 11, -2, -23 },
  { 3861, 14, 6, 16, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC32PT7B_H_
