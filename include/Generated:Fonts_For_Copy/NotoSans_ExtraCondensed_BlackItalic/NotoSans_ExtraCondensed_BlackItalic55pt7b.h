#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC55PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x30, 0x00, 0x3F, 0xE7, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0x9F, 0xF1, 0xFE,
  0x3F, 0xE7, 0xFC, 0x7F, 0xCF, 0xF8, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xFC, 0x7F, 0x8F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0x8F, 0xF0, 0xFE, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xF3, 0x8E, 0x03, 0xFC, 0xC1,
  0x80, 0xFF, 0x70, 0x00, 0x3F, 0xDC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x6F, 0xF0, 0x40, 0x3B,
  0xFC, 0x18, 0x0E, 0xFF, 0x07, 0x03, 0xBF, 0xC1, 0xF0, 0xEF, 0xF0, 0x7F,
  0xBF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x0F,
  0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0xFE, 0x00, 0x3F, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x7E, 0x0F, 0xE0, 0x03,
  0xF0, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xF1,
  0xFC, 0x00, 0x3F, 0x8F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x8F, 0xE0, 0x00,
  0xFE, 0x7F, 0x3F, 0x87, 0xF1, 0xFC, 0xFE, 0x7F, 0x1F, 0xF3, 0xFB, 0xF9,
  0xFC, 0x7F, 0xF7, 0xFF, 0xF3, 0xF9, 0xFF, 0xF7, 0xFF, 0xCF, 0xE7, 0xFF,
  0xEF, 0xFF, 0x1F, 0x9F, 0xFF, 0xDF, 0xFC, 0x7F, 0x3F, 0x9F, 0x9F, 0xF1,
  0xFC, 0x7E, 0x3F, 0x0F, 0x83, 0xF9, 0xFC, 0x7E, 0x00, 0x0F, 0xE3, 0xF8,
  0xFC, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0xC3, 0xF0, 0x00,
  0xFE, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F, 0x1F, 0xC0, 0x07, 0xE0, 0xFE,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x7E, 0x00, 0x7F, 0x03, 0xF1, 0xFC, 0x00,
  0xFE, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x1F,
  0xFF, 0x80, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x3F, 0xE0, 0x3F, 0xFE, 0x3F, 0xF0, 0x3F, 0xFF, 0x1F, 0xF0,
  0x3F, 0xFF, 0xCF, 0xF8, 0x3F, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xEF, 0xFF, 0xFC, 0x1F, 0xF7, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0xFE,
  0x0F, 0xF8, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0x03, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xE7, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE,
  0xFF, 0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0xFF, 0x9F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x02, 0x07, 0xF0, 0x07, 0x0F, 0xE0, 0x1F, 0x9F, 0x81, 0x3F, 0xBF, 0x1E,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFF, 0x7F, 0x03, 0xFE, 0xFF, 0x03, 0xF9,
  0xFF, 0x03, 0xE1, 0xFC, 0x03, 0xC3, 0xF0, 0x03, 0x07, 0x80, 0x02, 0x06,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8,
  0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x06, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x9F, 0x81, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFD, 0xFF, 0x0F, 0xF8, 0xFF,
  0x0F, 0xF8, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xE1, 0xFF,
  0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0x83, 0xFE,
  0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFC,
  0xFF, 0x87, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0x0F, 0xF8,
  0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFD, 0xFF,
  0x07, 0x8F, 0xF8, 0x18, 0xFF, 0xC0, 0x47, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0xF0,
  0x07, 0xC3, 0xFF, 0x00, 0x78, 0x3F, 0xF0, 0x03, 0x03, 0xFF, 0x00, 0x20,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xF0, 0xFF, 0xC0, 0x30, 0x1F, 0xF0, 0x08, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x88, 0x00, 0x7F, 0xE3, 0x80, 0x3F, 0xF0, 0xFE, 0x7F, 0xFC, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFB, 0xFE, 0x00,
  0x7E, 0x7F, 0xC0, 0x1F, 0xCF, 0xF8, 0x07, 0xF1, 0xFF, 0x00, 0xFC, 0x7F,
  0xC0, 0x3F, 0x8F, 0xF8, 0x0F, 0xE1, 0xFF, 0x01, 0xF8, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0x83,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x20, 0x03, 0xFF, 0x0E, 0x01, 0xFF, 0x83, 0xF9, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x3E,
  0x00, 0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFE, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE1, 0xFF,
  0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x1F, 0xFB, 0xFF, 0x03, 0xFE,
  0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xF7, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF,
  0x87, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF, 0x87, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F,
  0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0xC3,
  0xFE, 0x7F, 0xE1, 0xFF, 0x3F, 0xF1, 0xFF, 0x9F, 0xF8, 0xFF, 0xCF, 0xFC,
  0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xF9, 0xFF, 0x00,
  0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x0C, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x0F, 0xF8,
  0xE0, 0x7F, 0xC4, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFB, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xFE, 0x3F, 0x07, 0xE1, 0xFF,
  0xFC, 0xFC, 0x3F, 0x8F, 0xFF, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0x8F, 0xC7,
  0xE1, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF3, 0xF1, 0xFC, 0x3F, 0x0F, 0xCF, 0xC7, 0xE0, 0xFC, 0x3E, 0x7E,
  0x1F, 0x87, 0xF1, 0xF9, 0xF8, 0xFE, 0x1F, 0x87, 0xE7, 0xE3, 0xF0, 0x7E,
  0x1F, 0x9F, 0x8F, 0xC1, 0xF8, 0x7C, 0x7C, 0x3F, 0x0F, 0xE3, 0xF3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xCF, 0xC7, 0xF0, 0xFC, 0x3E, 0x3F, 0x0F, 0xC7, 0xF1,
  0xF8, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC3,
  0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xFC, 0xFF, 0xC0, 0xFC, 0x0F, 0xE3, 0xFC,
  0x03, 0xF8, 0x0E, 0x03, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x20, 0x00, 0xFF, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0,
  0x07, 0xF9, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x1F,
  0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x87,
  0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0x03,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFC, 0x07, 0xFE,
  0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0x03, 0xFE, 0x1F, 0xF8,
  0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xC7, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x83,
  0xFE, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC,
  0x1F, 0xF0, 0xFF, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0x01, 0xFF, 0xC0, 0x40, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x04, 0x07, 0xFF, 0x03,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F,
  0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x87, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0x07,
  0xFE, 0x0F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x87, 0xFF,
  0x03, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xC3, 0xE0, 0x1F,
  0xFC, 0x03, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x8F, 0xFF, 0x87, 0xFE, 0x3F, 0xFE,
  0x1F, 0xF8, 0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xE3, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFC, 0x7F, 0xFC, 0x3F, 0xF1, 0xFF, 0xF0, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0x01, 0xFF, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0x7F, 0xE0,
  0x03, 0xFE, 0x3F, 0xF0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xE7, 0xFE,
  0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x3F,
  0xF0, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0x07, 0xFB, 0xF9, 0xFD,
  0xFF, 0x00, 0xFF, 0x7F, 0x7F, 0xBF, 0xE0, 0x3F, 0xEF, 0xEF, 0xFF, 0xF8,
  0x07, 0xFD, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xFF, 0xBF, 0xE0, 0x1F,
  0xE7, 0xFF, 0xE7, 0xFC, 0x03, 0xFC, 0xFF, 0xFC, 0xFF, 0x80, 0xFF, 0x9F,
  0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xF8,
  0xFF, 0x80, 0x7F, 0x8F, 0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0xE3, 0xFC,
  0x03, 0xFE, 0x3F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0x1F, 0xF0, 0x0F,
  0xF8, 0xFF, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFE, 0x03, 0xFC, 0x01,
  0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x7F,
  0xC0, 0x3F, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0xFF,
  0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0x8F, 0xF8, 0x07,
  0xFF, 0xF8, 0xFF, 0x00, 0x7F, 0xFF, 0x8F, 0xF0, 0x0F, 0xFF, 0xF9, 0xFF,
  0x00, 0xFF, 0xFF, 0x9F, 0xF0, 0x0F, 0xF7, 0xFD, 0xFF, 0x00, 0xFF, 0x3F,
  0xDF, 0xE0, 0x0F, 0xF3, 0xFD, 0xFE, 0x01, 0xFF, 0x3F, 0xDF, 0xE0, 0x1F,
  0xF3, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xE0, 0x1F, 0xE3, 0xFF, 0xFC,
  0x01, 0xFE, 0x1F, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0xFC, 0x03, 0xFE, 0x1F,
  0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0xF8, 0x03, 0xFC, 0x1F, 0xFF, 0x80, 0x3F,
  0xC1, 0xFF, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF8,
  0x07, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0x87, 0xFE, 0x03,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF,
  0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xE7,
  0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x1F, 0xFB, 0xFF,
  0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x1F,
  0xF8, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xE1,
  0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F, 0xFC,
  0x7F, 0xE0, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF,
  0x87, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3,
  0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x0F, 0xF9, 0xFF,
  0x80, 0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0,
  0x1F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x0F,
  0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE,
  0x3F, 0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x0F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xEF, 0xFE, 0x03, 0xFE, 0x3F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x03, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF,
  0x00, 0x7F, 0xCF, 0xF8, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00,
  0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE,
  0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x78, 0x03, 0xFE, 0x01, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x02, 0x00, 0x7F, 0xE0, 0x38, 0x07, 0xFE, 0x07, 0xE0, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x07,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xF9, 0xFF,
  0x80, 0xFF, 0xCF, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xE3, 0xFE, 0x03,
  0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x87, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC3, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x80, 0xFF, 0x8F,
  0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFB, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0xDF, 0xF0, 0x1F, 0xE0, 0x3F, 0xE7, 0xFC, 0x07, 0xF8,
  0x0F, 0xF9, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC7, 0xFC, 0x1F, 0xF8, 0x3F, 0xE1, 0xFF,
  0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0xFF,
  0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xFE, 0x3F,
  0xF0, 0x7F, 0x87, 0xFF, 0x8F, 0xF8, 0x1F, 0xE3, 0xFF, 0xE3, 0xFE, 0x07,
  0xF8, 0xFF, 0xF9, 0xFF, 0x03, 0xFE, 0x7F, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F,
  0xFF, 0x9F, 0xF0, 0x3F, 0xE7, 0xFF, 0xEF, 0xF8, 0x0F, 0xFB, 0xFF, 0xFB,
  0xFE, 0x03, 0xFE, 0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xF7, 0xFF, 0xF8, 0x03, 0xFF,
  0xFD, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x9F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x03, 0xFF, 0xF1, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x87, 0xFF, 0xC0, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC7,
  0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFF,
  0xBF, 0xE0, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x03,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF9, 0xFF, 0x03, 0xFE,
  0x3F, 0xE0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x3F, 0xF0, 0x7F, 0xC7, 0xFC, 0x07, 0xF9, 0xFF, 0x00,
  0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x1F, 0xF3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xE0, 0xFE, 0x07, 0xF8,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFE,
  0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x20, 0x3F, 0xE7, 0xF8,
  0x0F, 0xFC, 0xFF, 0x03, 0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x87,
  0xFE, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE, 0x0F, 0xF0, 0xFF,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFF, 0x07, 0xFC,
  0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFB, 0xFC, 0x07, 0xFF, 0x7F, 0x80, 0x7F, 0xCF, 0xE0, 0x07, 0xE1,
  0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x9F, 0x00, 0x1F, 0xEF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC,
  0x3F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0xE0,
  0xFF, 0xCF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFD, 0xFF, 0xC0, 0x7F, 0x3F, 0xF0, 0x1F,
  0xE3, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xF8, 0x20, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x08, 0x3F, 0xE0,
  0x60, 0x7F, 0xE3, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x7F, 0xC0, 0x1F,
  0xF3, 0xFC, 0x01, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE3, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0x87, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0x87, 0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x3F, 0xE7, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFE, 0xFF, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xF9, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF,
  0x7F, 0xC1, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x10,
  0xFF, 0x80, 0x60, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xCC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x04, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFF, 0x7F, 0x80, 0x1F,
  0xFD, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0,
  0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x1F,
  0xF8, 0x07, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0x20, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x30, 0x01,
  0xFF, 0x00, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x1F,
  0x00, 0x1F, 0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07,
  0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F,
  0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F,
  0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x10, 0x1F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1,
  0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x7F,
  0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0x7F, 0xBF, 0xF0, 0x00, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xF7, 0xFC, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x01, 0xFE,
  0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xFC, 0xFF, 0x87, 0xFC, 0x03,
  0xFD, 0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xF3, 0xFF, 0x07, 0xFC,
  0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF,
  0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x3F, 0x9F, 0xF0, 0x0F, 0xF7, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xF1, 0xFF,
  0x3F, 0xE1, 0xFF, 0x3F, 0xE0, 0xFF, 0x3F, 0xE0, 0xFF, 0x7F, 0xC1, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFE,
  0xFF, 0x87, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0xDF, 0xFC, 0x01, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x9F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xE0, 0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x8F,
  0xE0, 0x07, 0xFC, 0x10, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x20, 0x1F, 0xE3, 0xF8, 0x07, 0xFE, 0xFF, 0x01,
  0xFF, 0xDF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0xF0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE3, 0xFF, 0x07, 0xFC, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x07, 0xF7, 0xFC, 0x00, 0x20, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xF9, 0xFC,
  0x0F, 0xF7, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFE, 0x3C, 0x1F, 0xF0,
  0x20, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x88, 0x07, 0xFE, 0x3C, 0x3F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0x1F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x18, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x1F,
  0xF8, 0x3F, 0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xFC, 0x03, 0xFE, 0x7F,
  0x80, 0x3F, 0x8F, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0x9F, 0xE0, 0x7F, 0xCF, 0xF0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3,
  0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x8F, 0xF8,
  0x3F, 0xC7, 0xFC, 0x1F, 0xE7, 0xFC, 0x0F, 0xF3, 0xFE, 0x07, 0xF9, 0xFE,
  0x03, 0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFF, 0x0F, 0xFF, 0xFC,
  0x3F, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xC7, 0xFD, 0xFF, 0x1F, 0xFE, 0x3F,
  0xEF, 0xF8, 0xFF, 0xE1, 0xFE, 0x7F, 0xC7, 0xFF, 0x1F, 0xF3, 0xFE, 0x7F,
  0xF8, 0xFF, 0x9F, 0xF3, 0xFF, 0xC7, 0xF8, 0xFF, 0xBF, 0xFE, 0x7F, 0xC7,
  0xFD, 0xFF, 0xF3, 0xFC, 0x3F, 0xCF, 0xFF, 0x9F, 0xE1, 0xFE, 0xFF, 0xFD,
  0xFF, 0x0F, 0xF7, 0xFF, 0xEF, 0xF0, 0x7F, 0xBF, 0x7F, 0x7F, 0x83, 0xFF,
  0xFB, 0xFF, 0xF8, 0x1F, 0xFF, 0xDF, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xFE,
  0x07, 0xFF, 0xE7, 0xFF, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF, 0x01, 0xFF, 0xF1,
  0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x03,
  0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xE1, 0xFF,
  0xE0, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x01, 0xFF,
  0x83, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFE, 0x3F,
  0xE0, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0xC7, 0xFC, 0x01, 0xFF, 0x0F,
  0xF8, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F,
  0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0xFF, 0x7F, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x9F,
  0xF8, 0x00, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0x60, 0x07, 0xFF, 0x20, 0x00, 0x3C, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 17, 40, 14, 0, -39 },
  { 86, 23, 14, 25, 5, -39 },
  { 127, 31, 39, 29, 0, -39 },
  { 279, 26, 45, 26, 1, -42 },
  { 426, 39, 40, 44, 3, -40 },
  { 621, 33, 41, 33, 0, -40 },
  { 791, 11, 14, 13, 5, -39 },
  { 811, 19, 49, 16, 1, -40 },
  { 928, 19, 49, 16, -4, -40 },
  { 1045, 23, 25, 24, 4, -42 },
  { 1117, 24, 27, 28, 2, -33 },
  { 1198, 14, 16, 14, -3, -8 },
  { 1226, 16, 8, 17, 0, -19 },
  { 1242, 10, 11, 14, 0, -10 },
  { 1256, 30, 41, 22, -3, -40 },
  { 1410, 24, 41, 26, 2, -40 },
  { 1533, 21, 39, 26, 5, -39 },
  { 1636, 28, 40, 26, -2, -40 },
  { 1776, 26, 41, 26, 0, -40 },
  { 1910, 27, 39, 26, 0, -39 },
  { 2042, 26, 40, 26, 1, -39 },
  { 2172, 26, 41, 26, 2, -40 },
  { 2306, 28, 39, 26, 1, -39 },
  { 2443, 27, 41, 26, 0, -40 },
  { 2582, 25, 41, 26, 1, -40 },
  { 2711, 15, 32, 15, 0, -31 },
  { 2771, 18, 39, 15, -3, -31 },
  { 2859, 24, 28, 28, 2, -34 },
  { 2943, 24, 19, 28, 2, -29 },
  { 3000, 24, 28, 28, 2, -34 },
  { 3084, 21, 41, 21, 2, -40 },
  { 3192, 38, 44, 39, 1, -40 },
  { 3401, 29, 39, 29, -3, -39 },
  { 3543, 29, 39, 28, 0, -39 },
  { 3685, 27, 41, 26, 2, -40 },
  { 3824, 30, 39, 30, 0, -39 },
  { 3971, 26, 39, 23, 0, -39 },
  { 4098, 26, 39, 22, 0, -39 },
  { 4225, 30, 41, 30, 2, -40 },
  { 4379, 33, 39, 31, 0, -39 },
  { 4540, 27, 39, 21, -2, -39 },
  { 4672, 26, 51, 15, -9, -39 },
  { 4838, 34, 39, 28, 0, -39 },
  { 5004, 20, 39, 22, 0, -39 },
  { 5102, 43, 39, 41, 0, -39 },
  { 5312, 36, 39, 33, 0, -39 },
  { 5488, 30, 41, 32, 2, -40 },
  { 5642, 28, 39, 27, 0, -39 },
  { 5779, 30, 49, 32, 2, -40 },
  { 5963, 29, 39, 28, 0, -39 },
  { 6105, 28, 41, 24, -1, -40 },
  { 6249, 24, 39, 24, 4, -39 },
  { 6366, 30, 40, 30, 2, -39 },
  { 6516, 29, 39, 29, 5, -39 },
  { 6658, 42, 39, 41, 4, -39 },
  { 6863, 35, 39, 28, -3, -39 },
  { 7034, 27, 39, 27, 5, -39 },
  { 7166, 30, 39, 24, -2, -39 },
  { 7313, 23, 49, 16, -3, -40 },
  { 7454, 13, 41, 22, 5, -40 },
  { 7521, 23, 49, 16, -4, -40 },
  { 7662, 27, 26, 26, -1, -39 },
  { 7750, 22, 6, 21, -5, 4 },
  { 7767, 12, 9, 18, 8, -42 },
  { 7781, 27, 32, 27, 1, -31 },
  { 7889, 27, 43, 27, -1, -42 },
  { 8035, 23, 32, 22, 1, -31 },
  { 8127, 29, 43, 27, 1, -42 },
  { 8283, 24, 32, 25, 1, -31 },
  { 8379, 29, 55, 17, -6, -42 },
  { 8579, 30, 44, 27, -2, -31 },
  { 8744, 27, 42, 27, -1, -42 },
  { 8886, 18, 43, 14, -1, -43 },
  { 8983, 24, 56, 14, -7, -43 },
  { 9151, 31, 42, 27, -1, -42 },
  { 9314, 18, 42, 14, -1, -42 },
  { 9409, 40, 31, 40, -1, -31 },
  { 9564, 27, 31, 27, -1, -31 },
  { 9669, 24, 32, 26, 1, -31 },
  { 9765, 29, 44, 27, -3, -31 },
  { 9925, 27, 44, 27, 1, -31 },
  { 10074, 23, 31, 19, -1, -31 },
  { 10164, 22, 32, 21, 0, -31 },
  { 10252, 19, 38, 19, 2, -37 },
  { 10343, 27, 31, 27, 1, -30 },
  { 10448, 25, 30, 25, 3, -30 },
  { 10542, 37, 30, 37, 3, -30 },
  { 10681, 31, 30, 25, -3, -30 },
  { 10798, 31, 43, 25, -3, -30 },
  { 10965, 25, 30, 22, -2, -30 },
  { 11059, 23, 48, 19, 0, -39 },
  { 11197, 8, 55, 22, 7, -42 },
  { 11252, 22, 48, 19, -3, -39 },
  { 11384, 25, 11, 28, 2, -25 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC55PT7B_H_
