#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0x03,
  0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0x7E, 0xFD, 0xFB, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07,
  0x9E, 0x00, 0xF3, 0xC8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x03, 0xCE, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x00, 0x30, 0x00, 0x30,
  0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x44,
  0x1F, 0x40, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x41, 0x7C, 0x73, 0x7C, 0x7F, 0xF8,
  0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0x80, 0x06, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x07, 0x00, 0xF0, 0x3F, 0x01, 0xE0, 0xFF, 0x07, 0x83, 0xFE,
  0x1F, 0x07, 0xBC, 0x3C, 0x0F, 0x78, 0xF0, 0x3C, 0xF1, 0xE0, 0x79, 0xE7,
  0x80, 0xF3, 0xCF, 0x01, 0xE7, 0xBC, 0x23, 0xDE, 0x79, 0xF7, 0xFD, 0xEF,
  0xFF, 0xF7, 0xDF, 0xEF, 0xCF, 0x7B, 0xCF, 0x3C, 0xF3, 0x80, 0x7B, 0xCF,
  0x01, 0xE7, 0x9E, 0x03, 0xCF, 0x3C, 0x0F, 0x1E, 0x78, 0x3E, 0x3D, 0xE0,
  0x78, 0x7B, 0xC1, 0xE0, 0xFF, 0x03, 0xC0, 0xFE, 0x0F, 0x01, 0xF8, 0x00,
  0x78, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xDF, 0x00,
  0x7D, 0xF0, 0x0F, 0xDF, 0x00, 0xFD, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x3F, 0x1F, 0xF3, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC7, 0xDF, 0xFC, 0xFC, 0xFF, 0x8F, 0xCF, 0xF8, 0xFC, 0x7F, 0x0F, 0xEF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xF9, 0xFC, 0x7E,
  0xFD, 0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF8, 0x01, 0xF0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0x03,
  0xC0, 0x0F, 0x02, 0x3C, 0x1C, 0xF0, 0x7F, 0xBD, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0x0F, 0xC0, 0x7F, 0x07, 0xFE, 0x1F, 0x7C, 0x3D, 0xF0, 0x63, 0x80,
  0x88, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x1F, 0x3F, 0x3E,
  0x3E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x7F, 0xDF, 0xE7, 0xF9, 0xFE, 0xFF,
  0x80, 0x39, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xE3, 0xE7, 0xCF,
  0xCF, 0x9F, 0x1F, 0x3E, 0x7E, 0xFC, 0xFD, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7,
  0xDF, 0x8F, 0xBF, 0x3F, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xF3, 0xE7, 0xC7,
  0xFF, 0x8F, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xE0, 0xFF, 0x1F, 0xF9, 0xFF, 0x9F, 0xFC, 0xFB, 0xE3,
  0xBF, 0x09, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x00, 0x78, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x38,
  0xFC, 0x18, 0x7C, 0x04, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F,
  0xFF, 0x04, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x81, 0xFC, 0xF7, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0x7C, 0x0F,
  0x7C, 0x1E, 0xFC, 0x3C, 0xF8, 0x3C, 0xF8, 0x78, 0xF8, 0x7F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF,
  0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0xC3, 0xFF, 0x82, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF2, 0x0F, 0xC7, 0xBF, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x60, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xFC,
  0x7F, 0xFC, 0xFE, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8,
  0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x1F, 0x80,
  0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x20, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F,
  0x1F, 0x1F, 0x1F, 0xBF, 0x0F, 0xBE, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF0,
  0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C,
  0xFC, 0x7C, 0xFC, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0,
  0x00, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xBF,
  0x1F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0xC7, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00,
  0x02, 0x07, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC1, 0xF1, 0xF8, 0xFC, 0x7E, 0x3E, 0x00, 0x00, 0x80,
  0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x80, 0x00, 0x06, 0x00, 0x3C, 0x01,
  0xF8, 0x0F, 0xF0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0x1F, 0x80,
  0x3C, 0x00, 0x60, 0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0x7F, 0xF3, 0xFF,
  0x98, 0x7C, 0x83, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFC, 0x7E, 0x07, 0xC0, 0x7C, 0x3C, 0x00, 0xF1,
  0xE3, 0xF1, 0xCF, 0x1F, 0xE7, 0x3C, 0xFF, 0x9D, 0xE7, 0x9E, 0x77, 0x9E,
  0x79, 0xDC, 0xF1, 0xC7, 0xF3, 0xCF, 0x3F, 0xCE, 0x3C, 0xFF, 0x78, 0xF3,
  0xB9, 0xE7, 0x9E, 0xE7, 0x9E, 0x73, 0x9F, 0xFF, 0xCE, 0x3F, 0xFE, 0x38,
  0x79, 0xF0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x30, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x1F, 0xBE, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3,
  0xFF, 0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFF, 0xF0,
  0x3F, 0x07, 0xF0, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x7C, 0xFC, 0x3E, 0x3E, 0x3F, 0x3F, 0x1F, 0x9F, 0x8F, 0x9F, 0x87, 0xFF,
  0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xF0, 0xF8, 0xF8, 0x7C, 0x7E, 0x7E,
  0x3F, 0x3F, 0x1F, 0x1F, 0x9F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xE0, 0xFE, 0x20, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x04, 0x1F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xE7, 0xF0, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xF1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F,
  0x8F, 0xC7, 0xE3, 0xE1, 0xF8, 0xF8, 0x7E, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF,
  0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7F, 0xE1, 0xFF, 0xC3,
  0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xF0, 0xC1,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE7, 0xF9, 0xF9,
  0xFC, 0x7C, 0xFF, 0x3F, 0x3F, 0xCF, 0xCF, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E,
  0x3F, 0x0F, 0x8F, 0xC7, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C,
  0x1F, 0x87, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF8, 0x3E, 0x1F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF0, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xFC,
  0x3E, 0x0F, 0x87, 0xE0, 0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x07, 0xFE,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0xE0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x81, 0x7F, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0xC3, 0xF0, 0x7C, 0x3F, 0x0F, 0xC7, 0xE0, 0xFC,
  0xFC, 0x0F, 0x8F, 0xC0, 0xF9, 0xF8, 0x0F, 0xBF, 0x01, 0xFB, 0xF0, 0x1F,
  0xFE, 0x01, 0xF7, 0xC0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xC7, 0xC0, 0x7C, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E,
  0x0F, 0x87, 0xE0, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8,
  0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xEF, 0xFE, 0x07, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0xFF, 0xC1,
  0xFF, 0x3F, 0xF0, 0xFF, 0xDF, 0xF8, 0x3E, 0xF7, 0xFE, 0x0F, 0xBD, 0xEF,
  0x83, 0xEF, 0xFF, 0xE0, 0xFB, 0xFD, 0xF8, 0x7E, 0xFF, 0x7C, 0x1F, 0x3F,
  0x9F, 0x07, 0xCF, 0xE7, 0xC1, 0xF3, 0xF3, 0xF0, 0x7C, 0xFC, 0xFC, 0x3F,
  0x3F, 0x3E, 0x0F, 0x8F, 0x8F, 0x83, 0xE3, 0xE7, 0xE0, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xC3, 0xF8, 0x3E, 0x1F, 0xC3, 0xF0, 0xFF, 0x1F, 0x07, 0xF8,
  0xF8, 0x3F, 0xC7, 0xC3, 0xFE, 0x3E, 0x1F, 0xF3, 0xF0, 0xFF, 0xDF, 0x07,
  0xFE, 0xF8, 0x7D, 0xF7, 0xC3, 0xEF, 0xBE, 0x1F, 0x7D, 0xF0, 0xF9, 0xFF,
  0x07, 0xCF, 0xF8, 0x7E, 0x7F, 0xC3, 0xE3, 0xFE, 0x1F, 0x1F, 0xF0, 0xF8,
  0xFF, 0x07, 0xC3, 0xF8, 0x7E, 0x1F, 0xC3, 0xE0, 0xFE, 0x1F, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7,
  0xE3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0,
  0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E,
  0xFC, 0x3F, 0x3F, 0x0F, 0xCF, 0xC7, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0xFC, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F,
  0x9F, 0x8F, 0x8F, 0x87, 0xCF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0,
  0xFF, 0xE0, 0x7F, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0xC7, 0xE3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F,
  0xFC, 0x0F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0xC7, 0xE3, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x7C, 0xFC, 0x3E, 0x7E, 0x3F, 0x3F, 0x1F, 0x9F,
  0x8F, 0x8F, 0xC7, 0xCF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF,
  0xE0, 0x7D, 0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x9F, 0x87,
  0xCF, 0xC7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF0, 0xFC, 0x00, 0x7C, 0x00, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x70, 0x3F, 0x08, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x20, 0x7E, 0x1C, 0x3F,
  0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0x3F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC1, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x0F, 0x87, 0xC3, 0xE1,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0x00, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3,
  0xE7, 0xE3, 0xF3, 0xF1, 0xF9, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7C, 0x3F,
  0x7E, 0x1F, 0x3E, 0x0F, 0xBF, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x1F, 0x0F, 0xDF, 0x07, 0xC3, 0xE7,
  0xC3, 0xF1, 0xF9, 0xF0, 0xF8, 0x7C, 0x7C, 0x7E, 0x1F, 0x1F, 0x1F, 0x8F,
  0xC7, 0xC7, 0xE3, 0xE1, 0xF3, 0xF9, 0xF8, 0x7C, 0xFE, 0x7E, 0x1F, 0x7F,
  0x9F, 0x07, 0xDF, 0xEF, 0xC1, 0xF7, 0xFB, 0xE0, 0x7F, 0xFE, 0xF8, 0x1F,
  0xF7, 0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0,
  0x3F, 0xEF, 0xF8, 0x0F, 0xF3, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x07,
  0xE1, 0xF8, 0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7C,
  0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xEF,
  0x80, 0x3F, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F,
  0x83, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC,
  0x7C, 0xF8, 0x7D, 0xF8, 0x7D, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xF0, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x00, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F,
  0x1F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x07,
  0xFE, 0x07, 0xDF, 0x03, 0xE7, 0x83, 0xE3, 0xE1, 0xE1, 0xF1, 0xF0, 0xF9,
  0xF0, 0x3D, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0xF9, 0xF1, 0xF3, 0xE0, 0x01, 0x00, 0x83, 0xE7, 0x83, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x3E,
  0x3F, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7, 0xE7, 0xE3, 0xF3, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xBE, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x98, 0x1F,
  0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x7E, 0x7C, 0x7E, 0x7C,
  0x7C, 0x7E, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xF3, 0xE0, 0x01,
  0x80, 0x3F, 0xC7, 0xFE, 0x7F, 0xE3, 0xFF, 0x3F, 0x11, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x23, 0xF7, 0x1F,
  0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x11, 0xF8, 0x1F, 0x7C,
  0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFC, 0xFC, 0x3E, 0x3E, 0x1F,
  0x8F, 0x87, 0xE3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC3, 0xF3, 0xF0, 0xFD, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x3E, 0xF8, 0x00, 0x00, 0xC0, 0x1F, 0xC1, 0xFF, 0x87, 0xFF, 0x3F, 0xFD,
  0xF9, 0xF7, 0xC7, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x82, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7C,
  0x80, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x80, 0x40, 0xF9, 0xE0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x87, 0xE7, 0xE1, 0xF1, 0xF0, 0xFC, 0x7C, 0x3F, 0x1F,
  0x0F, 0x8F, 0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E, 0x1F, 0x9F, 0x87,
  0xEF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xF7, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x20, 0x7E, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x98, 0x1F, 0x7E, 0x1F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFF, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC,
  0xFC, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x01, 0x81, 0xF0, 0xFC, 0x3F,
  0x0F, 0x81, 0xC0, 0x00, 0x00, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3,
  0xE0, 0xF8, 0x3E, 0x00, 0x00, 0x18, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x04, 0x7E, 0x3E, 0x1F, 0x1F,
  0x07, 0xCF, 0xC1, 0xF7, 0xE0, 0xFD, 0xF0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xF7,
  0xE0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC,
  0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x00, 0x18, 0x10,
  0x3E, 0xFC, 0xF8, 0x7F, 0xFB, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7,
  0xF7, 0xE7, 0xCF, 0xCF, 0xCF, 0x9F, 0x1F, 0x1F, 0x3E, 0x3E, 0x7E, 0x7C,
  0xFC, 0xFD, 0xF9, 0xF9, 0xF3, 0xE3, 0xE3, 0xE7, 0xC7, 0xC7, 0xCF, 0x8F,
  0x9F, 0x9F, 0x3F, 0x3F, 0x7E, 0x7C, 0x7C, 0xF8, 0xF8, 0xF9, 0xF1, 0xF1,
  0xF3, 0xE7, 0xE7, 0xE0, 0x00, 0x18, 0x1F, 0x7E, 0x1F, 0xFE, 0x1F, 0xFF,
  0x1F, 0xFF, 0x3F, 0xBF, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xFC,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x01, 0x80, 0x1F, 0xC1, 0xFF, 0x87,
  0xFF, 0x3F, 0xFD, 0xF9, 0xF7, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x8F, 0xFE, 0x3F, 0xF8, 0xFB, 0xE7, 0xEF, 0x9F, 0x3F, 0xFC, 0xFF, 0xE1,
  0xFF, 0x03, 0xF8, 0x00, 0x00, 0x04, 0x01, 0xF7, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x07, 0xFF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F,
  0x83, 0xE3, 0xE1, 0xF8, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xC1,
  0xFB, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xEF, 0x81, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0x00, 0x83, 0xE7, 0x83, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF1, 0xF9, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E,
  0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE7, 0xE3, 0xF7,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xBE, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x18, 0xFB, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x1F,
  0xF8, 0xFE, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0x00,
  0x7F, 0x87, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0x08, 0xF8, 0x07, 0xE0, 0x3F,
  0xC0, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x7E, 0x41, 0xF3, 0x9F, 0x9F, 0xFC,
  0xFF, 0xC7, 0xFE, 0x3F, 0xC0, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0xBE, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x93, 0xFE, 0x7F, 0xC7, 0xF8, 0xFE, 0x00,
  0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF9, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFE, 0xF0, 0x7C, 0xF0,
  0xF8, 0x7F, 0xF0, 0xFB, 0xE3, 0xF7, 0xC7, 0xCF, 0x9F, 0x9F, 0x3E, 0x3E,
  0x7C, 0x7D, 0xF0, 0xFB, 0xE1, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0xFC,
  0x7F, 0xE7, 0xF3, 0xFF, 0x9F, 0xCF, 0xBE, 0x7F, 0x3E, 0xFB, 0xFD, 0xF3,
  0xEF, 0xF7, 0xCF, 0xBF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFB, 0xE3, 0xFF,
  0xFF, 0x0F, 0xF7, 0xFC, 0x3F, 0xDF, 0xE0, 0xFE, 0x7F, 0x83, 0xF9, 0xFE,
  0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xCF, 0xE0, 0xF9, 0xF8, 0x1F, 0x7E, 0x03, 0xEF, 0x80, 0x7F, 0xF0,
  0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xDF, 0x01,
  0xF3, 0xF0, 0x7E, 0x7E, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xE1, 0xF0, 0xF8,
  0x3E, 0x3F, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0x04, 0x03, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xFE,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x3E, 0x01, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x7F,
  0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x07,
  0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x00, 0x1C, 0x02, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xA0, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 10, 24, 9, 0, -24 },
  { 31, 14, 9, 15, 3, -24 },
  { 47, 19, 24, 17, 0, -24 },
  { 104, 16, 27, 16, 0, -25 },
  { 158, 23, 24, 26, 2, -24 },
  { 227, 20, 24, 20, 0, -24 },
  { 287, 7, 9, 8, 3, -24 },
  { 295, 12, 29, 9, 0, -24 },
  { 339, 12, 29, 9, -3, -24 },
  { 383, 14, 15, 15, 2, -25 },
  { 410, 15, 16, 17, 1, -20 },
  { 440, 8, 10, 9, -2, -5 },
  { 450, 10, 5, 10, 0, -11 },
  { 457, 6, 6, 9, 0, -6 },
  { 462, 18, 24, 13, -2, -24 },
  { 516, 15, 24, 16, 1, -24 },
  { 561, 13, 24, 16, 3, -24 },
  { 600, 17, 24, 16, -1, -24 },
  { 651, 16, 24, 16, 0, -24 },
  { 699, 16, 24, 16, 0, -24 },
  { 747, 15, 24, 16, 1, -24 },
  { 792, 16, 24, 16, 1, -24 },
  { 840, 16, 24, 16, 1, -24 },
  { 888, 16, 24, 16, 0, -24 },
  { 936, 16, 24, 16, 0, -24 },
  { 984, 9, 19, 9, 0, -19 },
  { 1006, 11, 24, 9, -2, -19 },
  { 1039, 15, 16, 17, 1, -20 },
  { 1069, 15, 11, 17, 1, -17 },
  { 1090, 15, 16, 17, 1, -20 },
  { 1120, 13, 24, 12, 1, -24 },
  { 1159, 22, 26, 23, 1, -24 },
  { 1231, 18, 24, 18, -2, -24 },
  { 1285, 17, 24, 17, 0, -24 },
  { 1336, 17, 24, 16, 1, -24 },
  { 1387, 18, 24, 18, 0, -24 },
  { 1441, 16, 24, 14, 0, -24 },
  { 1489, 15, 24, 13, 0, -24 },
  { 1534, 18, 24, 18, 1, -24 },
  { 1588, 20, 24, 19, 0, -24 },
  { 1648, 16, 24, 12, -1, -24 },
  { 1696, 15, 31, 9, -5, -24 },
  { 1755, 20, 24, 17, 0, -24 },
  { 1815, 12, 24, 13, 0, -24 },
  { 1851, 26, 24, 24, 0, -24 },
  { 1929, 21, 24, 20, 0, -24 },
  { 1992, 18, 24, 19, 1, -24 },
  { 2046, 17, 24, 16, 0, -24 },
  { 2097, 18, 30, 19, 1, -24 },
  { 2165, 17, 24, 17, 0, -24 },
  { 2216, 17, 24, 14, -1, -24 },
  { 2267, 15, 24, 14, 2, -24 },
  { 2312, 18, 24, 18, 1, -24 },
  { 2366, 17, 24, 17, 3, -24 },
  { 2417, 26, 24, 25, 2, -24 },
  { 2495, 21, 24, 17, -2, -24 },
  { 2558, 16, 24, 16, 3, -24 },
  { 2606, 18, 24, 14, -1, -24 },
  { 2660, 14, 30, 9, -2, -24 },
  { 2713, 8, 24, 13, 3, -24 },
  { 2737, 14, 30, 9, -3, -24 },
  { 2790, 17, 16, 15, -1, -24 },
  { 2824, 13, 4, 13, -3, 2 },
  { 2831, 7, 5, 11, 5, -25 },
  { 2836, 17, 19, 16, 0, -19 },
  { 2877, 16, 25, 16, 0, -25 },
  { 2927, 13, 19, 13, 1, -19 },
  { 2958, 18, 25, 16, 0, -25 },
  { 3015, 14, 19, 15, 1, -19 },
  { 3049, 18, 33, 10, -4, -25 },
  { 3124, 18, 27, 16, -1, -19 },
  { 3185, 16, 25, 16, 0, -25 },
  { 3235, 10, 26, 8, 0, -26 },
  { 3268, 14, 34, 8, -4, -26 },
  { 3328, 18, 25, 16, 0, -25 },
  { 3385, 10, 25, 8, 0, -25 },
  { 3417, 23, 19, 24, 0, -19 },
  { 3472, 16, 19, 16, 0, -19 },
  { 3510, 14, 19, 16, 1, -19 },
  { 3544, 18, 27, 16, -2, -19 },
  { 3605, 17, 27, 16, 0, -19 },
  { 3663, 13, 19, 12, 0, -19 },
  { 3694, 13, 19, 13, 0, -19 },
  { 3725, 11, 22, 11, 1, -22 },
  { 3756, 16, 18, 16, 1, -18 },
  { 3792, 15, 18, 15, 2, -18 },
  { 3826, 22, 18, 22, 2, -18 },
  { 3876, 19, 18, 15, -2, -18 },
  { 3919, 19, 26, 15, -2, -18 },
  { 3981, 15, 18, 13, -1, -18 },
  { 4015, 14, 29, 11, 0, -24 },
  { 4066, 5, 33, 13, 4, -25 },
  { 4087, 13, 29, 11, -2, -24 },
  { 4135, 15, 7, 17, 1, -15 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC33PT7B_H_
