#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC23PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF0, 0x00, 0x07,
  0x1E, 0x3C, 0x70, 0x7B, 0xDC, 0xE7, 0x7B, 0xDE, 0xE7, 0x39, 0xC0, 0x07,
  0x70, 0x3B, 0x81, 0x9C, 0x1C, 0xC3, 0xFF, 0x9F, 0xFC, 0xFF, 0xC3, 0xB8,
  0x1D, 0xC7, 0xFF, 0x3F, 0xF9, 0xFF, 0xC3, 0x30, 0x3B, 0x81, 0xDC, 0x1C,
  0xC0, 0x01, 0x00, 0xF8, 0x3F, 0x8F, 0xF3, 0xEC, 0x74, 0x0F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x23, 0xE6, 0x78, 0xFF, 0x3F, 0xC3, 0xF0, 0x08,
  0x03, 0x00, 0x0C, 0x02, 0x1F, 0x0E, 0x0F, 0xC6, 0x0E, 0xE7, 0x06, 0x77,
  0x07, 0x33, 0x83, 0xBB, 0x81, 0xDD, 0xDE, 0xFD, 0xDF, 0x3E, 0xFD, 0xCC,
  0xEE, 0xE0, 0x66, 0x70, 0x77, 0x30, 0x73, 0xB8, 0x39, 0xDC, 0x38, 0x7C,
  0x3C, 0x3C, 0x00, 0x01, 0x80, 0x1F, 0x80, 0xFE, 0x07, 0xB8, 0x1E, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x3C, 0xFF, 0xE7, 0xFF, 0xBD, 0xFC,
  0xF3, 0xE3, 0xCF, 0x8F, 0xFE, 0x1F, 0xFC, 0x7E, 0xF8, 0x7B, 0x9D, 0xEE,
  0x70, 0x07, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x0F, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xE0, 0x1A, 0x0E, 0x27, 0x1F, 0xBF,
  0xFF, 0xFC, 0xF0, 0xFC, 0xFF, 0x33, 0x89, 0x00, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x3B, 0xDC,
  0xEF, 0x70, 0x7E, 0xFF, 0xF7, 0xE0, 0x7F, 0xFE, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x07,
  0xE1, 0xFC, 0xFF, 0x7B, 0xDE, 0xF7, 0x3F, 0xCF, 0xF3, 0xFC, 0xEF, 0x7B,
  0x9E, 0xE7, 0x3B, 0xCF, 0xE3, 0xF8, 0x7C, 0x00, 0x07, 0x87, 0xCF, 0xCF,
  0xEF, 0xF3, 0x79, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x01, 0x80, 0x7E, 0x0F, 0xF1, 0xFF, 0x0C, 0xF0, 0x8F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7F,
  0xC7, 0xFC, 0xFF, 0x80, 0x07, 0x03, 0xF8, 0x7F, 0x8F, 0xF1, 0x1E, 0x03,
  0xC0, 0xF0, 0xFC, 0x1F, 0x03, 0xF0, 0x1F, 0x01, 0xE0, 0x3D, 0x0F, 0x3F,
  0xE7, 0xF8, 0xFE, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x3F,
  0x86, 0xF1, 0xDC, 0x73, 0x8C, 0xF3, 0xFF, 0x7F, 0xEF, 0xFC, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0xE3, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x7E, 0x0F, 0xE1,
  0xFE, 0x37, 0xC0, 0x78, 0x0F, 0x01, 0xEC, 0x79, 0xFF, 0x3F, 0xC7, 0xF0,
  0x01, 0xE1, 0xF8, 0x7F, 0x1F, 0xE3, 0xC0, 0xF0, 0x1F, 0xC3, 0xFC, 0xFF,
  0x9E, 0xF3, 0xDE, 0x7B, 0xCE, 0x79, 0xEF, 0x3F, 0xC7, 0xF0, 0x7C, 0x00,
  0x3F, 0xE7, 0xFD, 0xFF, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0x03, 0x81,
  0xF8, 0x7F, 0x8F, 0xF3, 0xCE, 0x7B, 0xC7, 0xF0, 0xFC, 0x1F, 0x07, 0xF1,
  0xEF, 0x39, 0xEF, 0x3D, 0xE7, 0xBF, 0xE3, 0xF8, 0x3E, 0x00, 0x03, 0x01,
  0xF8, 0x7F, 0x1F, 0xF3, 0xDE, 0x7B, 0xDE, 0x7B, 0xCF, 0x7F, 0xE7, 0xF8,
  0xFF, 0x09, 0xE0, 0x78, 0x1F, 0x3F, 0xC7, 0xF0, 0xFC, 0x00, 0x1C, 0xF3,
  0xCF, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x3C, 0xF0, 0x0E, 0x3C, 0x78, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0x00, 0x40,
  0x70, 0x7C, 0x7F, 0xFE, 0x3E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xF0, 0x0C,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x38,
  0x0F, 0x83, 0xF8, 0x1F, 0xC1, 0xF0, 0xFD, 0xFC, 0xFC, 0x3C, 0x0C, 0x00,
  0x0E, 0x1F, 0x9F, 0xEF, 0xF4, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C,
  0x00, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0x03, 0xFC,
  0x07, 0xFE, 0x0E, 0x07, 0x1C, 0x43, 0x39, 0xFB, 0x33, 0xFB, 0x77, 0x33,
  0x77, 0x73, 0x66, 0x77, 0x6E, 0x76, 0x6E, 0x66, 0xEF, 0xFC, 0x67, 0xFC,
  0x60, 0x00, 0x70, 0x10, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0x80, 0x03, 0xF0,
  0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0E, 0xF1, 0xEF, 0x1E, 0xF3,
  0xFF, 0x3F, 0xF3, 0xFF, 0x7F, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F, 0x1F, 0xE1,
  0xFF, 0x1F, 0xF1, 0xCF, 0x3C, 0xF3, 0xDF, 0x3F, 0xE3, 0xF8, 0x7F, 0xC7,
  0x9E, 0x79, 0xE7, 0x9E, 0x73, 0xEF, 0xFC, 0xFF, 0x8F, 0xF0, 0x03, 0x81,
  0xFC, 0x7F, 0x9F, 0xE3, 0xC4, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE2, 0x3F, 0xC3, 0xF8, 0x3F, 0x00, 0x1F, 0xE0,
  0xFF, 0x87, 0xFC, 0x39, 0xE3, 0xCF, 0x9E, 0x78, 0xF3, 0xC7, 0x9E, 0x78,
  0xF3, 0xC7, 0x9E, 0x78, 0xF3, 0xC7, 0x7C, 0x7F, 0xE3, 0xFE, 0x1F, 0xC0,
  0x1F, 0xE3, 0xF8, 0x7F, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0xE1, 0xFC, 0x7F,
  0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x01, 0xFE, 0x3F, 0xC7, 0xF0, 0x1F, 0xE3,
  0xF8, 0x7F, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0xE1, 0xFC, 0x7F, 0x8F, 0xE1,
  0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x01, 0xC0, 0xFF, 0x1F,
  0xF3, 0xFE, 0x3C, 0x27, 0x80, 0x78, 0x0F, 0xBE, 0xF3, 0xEF, 0x7E, 0xF7,
  0xEF, 0x1C, 0xF3, 0xCF, 0x3C, 0xFF, 0xC7, 0xFC, 0x3F, 0x80, 0x1E, 0x3C,
  0x78, 0xE1, 0xE7, 0x87, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0x0F, 0xFC,
  0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x70, 0x1F, 0xE3, 0xFC, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x3F, 0xC7, 0xF8,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC1, 0xF8, 0x3E, 0x0F, 0x80, 0x1E, 0x7C, 0x79, 0xE1, 0xEF, 0x07, 0x7C,
  0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xBC,
  0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF8, 0x1E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x70, 0xFF, 0xFF,
  0xFF, 0x1F, 0x0F, 0xC7, 0xC3, 0xF1, 0xF1, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F,
  0x8F, 0xCF, 0xE3, 0xFB, 0xF8, 0xFF, 0xDC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFE, 0xF1, 0xDF, 0xB8, 0x77, 0xCE, 0x3C, 0xF7, 0x8F, 0x39, 0xE3, 0xCE,
  0x78, 0x1F, 0x1E, 0x3E, 0x38, 0x7C, 0x70, 0xF9, 0xE3, 0xFB, 0xC7, 0xF7,
  0x8F, 0xEE, 0x1D, 0xDC, 0x7B, 0xF8, 0xF7, 0xF1, 0xEF, 0xE3, 0x9F, 0x87,
  0x3F, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x03, 0x80, 0xFE, 0x1F, 0xF3,
  0xFF, 0x3C, 0xF7, 0x8F, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF,
  0x1E, 0xF1, 0xEF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3E, 0x00, 0x1F, 0xE1, 0xFE,
  0x1F, 0xF1, 0xCF, 0x3C, 0xF3, 0xCF, 0x3D, 0xE3, 0xFE, 0x7F, 0xC7, 0xF8,
  0x7E, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0xFE,
  0x1F, 0xF3, 0xFF, 0x3C, 0xF7, 0x8F, 0x78, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF1, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0xFF, 0xC7, 0xF8, 0x3F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3D, 0xE3, 0xFE, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xB8, 0x73,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3E, 0x03, 0x81, 0xFC, 0x7F, 0x9F, 0xE3, 0xC4,
  0x78, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xC8, 0x79, 0xDF,
  0x3F, 0xE7, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xEF, 0xF8, 0xF0, 0x3C, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0x3C, 0xF9, 0xE7, 0x8F, 0x3C, 0xF1, 0xE7, 0x8E, 0x3C, 0xF1, 0xE7,
  0x8E, 0x3C, 0xF1, 0xE7, 0x8E, 0x3C, 0xF1, 0xE7, 0x8F, 0x7C, 0x7F, 0xC3,
  0xFC, 0x0F, 0xC0, 0xF0, 0xFF, 0x1E, 0xF1, 0xEF, 0x3C, 0xF3, 0xCF, 0x38,
  0xF7, 0x8F, 0x78, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0x80, 0xF1, 0xC7, 0xF9, 0xE3, 0xFC, 0xF3, 0xDE, 0x79, 0xEF,
  0x7C, 0xE7, 0xBE, 0xF3, 0xBF, 0x79, 0xDF, 0xF8, 0xEF, 0xFC, 0x7E, 0xFC,
  0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC7, 0xC1, 0xE3,
  0xC0, 0x1E, 0x3C, 0x3D, 0xE0, 0xF7, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xFC, 0x07, 0xF0, 0x3D, 0xC1,
  0xE7, 0x87, 0x9E, 0x3C, 0x78, 0xF1, 0xFE, 0x79, 0xCF, 0x3B, 0xC7, 0xF8,
  0xFE, 0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x3F, 0xE3, 0xFF, 0x1F, 0xF0, 0x0F, 0x87, 0xC3, 0xE1, 0xC1, 0xE0, 0xE0,
  0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x3F, 0x1F, 0x0F, 0x80, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x79,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0x07, 0xC3, 0xF0, 0xF8, 0x0E, 0x03,
  0x81, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1C, 0x07, 0x07, 0xC3, 0xF0, 0xF8, 0x00, 0x03, 0x80, 0xF0,
  0x1E, 0x07, 0xC1, 0xFC, 0x3B, 0x8E, 0x73, 0xCE, 0x71, 0xDE, 0x3C, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF3, 0xDE, 0x70, 0x0E, 0xF1, 0xFE, 0x3F, 0xE3, 0xDE,
  0x79, 0xE7, 0x9C, 0x71, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x87, 0xF8,
  0x7B, 0x80, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xDC, 0x7F, 0x8F, 0xF9,
  0xEF, 0x39, 0xEF, 0x3D, 0xE7, 0xBC, 0xE7, 0x3D, 0xE7, 0xBF, 0xE7, 0xFC,
  0xEF, 0x00, 0x0F, 0x87, 0xF3, 0xF8, 0xF2, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0xF0, 0x3C, 0x47, 0xF1, 0xFC, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0xEE, 0x0F, 0xF0, 0xFF, 0x87, 0xBC, 0x79, 0xE3, 0xCE, 0x1C,
  0x71, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xFE, 0x0F, 0xF0, 0x7B, 0x80, 0x07,
  0x87, 0xF3, 0xFC, 0xE7, 0x79, 0xDF, 0xF7, 0xFB, 0xF8, 0xF0, 0x3C, 0x27,
  0xF9, 0xFE, 0x3F, 0x00, 0x00, 0x60, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3C,
  0x01, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x04, 0x00, 0x07, 0x78, 0x7F, 0x87, 0xFC,
  0x3D, 0xE3, 0xCF, 0x1E, 0x70, 0xE3, 0x8F, 0x3C, 0x79, 0xE3, 0xDF, 0x1F,
  0xF0, 0x7F, 0x83, 0xFC, 0x01, 0xE2, 0x0E, 0x1F, 0xF0, 0xFF, 0x87, 0xF8,
  0x02, 0x00, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xDC, 0x7F, 0xCF, 0xF9,
  0xEF, 0x39, 0xEF, 0x3D, 0xE7, 0x3D, 0xE7, 0x3D, 0xE7, 0xBC, 0xE7, 0x9C,
  0xF7, 0x80, 0x0E, 0x3C, 0x78, 0xE0, 0x07, 0x8F, 0x1E, 0x38, 0x71, 0xE3,
  0xC7, 0x8E, 0x3C, 0x78, 0xF1, 0xE0, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x00,
  0x01, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0xFC, 0x3E, 0x0F, 0x81, 0x00,
  0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0xF3, 0xCE, 0x3D, 0xE3, 0xBC,
  0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xF8, 0x7F, 0x8F, 0x78, 0xF7, 0x8F, 0x3C,
  0xF3, 0xC0, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8F, 0x1C, 0x38, 0xF1, 0xE3,
  0xC7, 0x1E, 0x3C, 0x78, 0xF0, 0x39, 0xCE, 0x3B, 0xFF, 0x3F, 0xFF, 0x3D,
  0xEF, 0x39, 0xEF, 0x79, 0xCF, 0x79, 0xCF, 0x7B, 0xCE, 0x73, 0xCE, 0xF3,
  0xDE, 0xF3, 0x9E, 0xF7, 0x9E, 0xF7, 0x9C, 0x39, 0xC7, 0x7C, 0xFF, 0x9E,
  0xF3, 0x9E, 0xF3, 0xDE, 0x73, 0xDE, 0x73, 0xDE, 0x7B, 0xCE, 0x79, 0xCF,
  0x78, 0x07, 0x83, 0xF8, 0xFF, 0x1E, 0xF7, 0x9E, 0xF3, 0xDC, 0x77, 0x9E,
  0xF3, 0xDE, 0x79, 0xFE, 0x3F, 0x83, 0xE0, 0x1C, 0xE1, 0xDE, 0x1F, 0xF1,
  0xEF, 0x1C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCE, 0x39, 0xE7, 0x9E, 0x7F, 0xC7,
  0xFC, 0x77, 0x87, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x00,
  0x0E, 0xF1, 0xFE, 0x3F, 0xE3, 0xDE, 0x79, 0xE7, 0x9C, 0x71, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xFF, 0x87, 0xF8, 0x7F, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x39, 0x9D, 0xCF, 0xE7, 0xE3, 0xC3, 0xC1,
  0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x1F, 0x1F, 0xCF, 0xEF,
  0x27, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x47, 0xBF, 0xDF, 0xCF, 0xC0, 0x1C,
  0x1C, 0x3F, 0xFE, 0xFE, 0x78, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xFC,
  0xFC, 0x7C, 0x3C, 0xF3, 0xCE, 0x3D, 0xE3, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xC7, 0xBC, 0x73, 0xCF, 0x3C, 0xFF, 0x87, 0xF8, 0x7B, 0x80, 0xF1, 0xFE,
  0x79, 0xCF, 0x39, 0xC7, 0x78, 0xEE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0xF3, 0xCF, 0xF3, 0xCE, 0xF7, 0xDE, 0xF7, 0xDE,
  0xFF, 0xDC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFD, 0xF8, 0xFD, 0xF8, 0xF9, 0xF0,
  0xF9, 0xF0, 0xF9, 0xE0, 0xF3, 0xE0, 0x1E, 0xF8, 0xF7, 0x87, 0xF8, 0x3F,
  0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x1E, 0xF0,
  0xF7, 0x8F, 0x3C, 0x00, 0x3C, 0x79, 0xE7, 0x87, 0x3C, 0x39, 0xC1, 0xDE,
  0x0E, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80, 0x10, 0x00, 0x1F,
  0xE3, 0xF8, 0xFF, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xFE, 0x7F, 0xCF, 0xF0, 0x07, 0xC3, 0xE0, 0xF8, 0x38, 0x1E, 0x07,
  0x81, 0xE0, 0xF0, 0x7C, 0x3C, 0x0F, 0x81, 0xE0, 0x38, 0x0E, 0x07, 0x81,
  0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1E, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C,
  0x0F, 0x83, 0xC7, 0xC3, 0xC3, 0xC1, 0xE0, 0xF0, 0x70, 0xF8, 0x7C, 0x3C,
  0x18, 0x00, 0xFC, 0x7F, 0xFF, 0xFE, 0x1E,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 10, 6, 10, 2, -16 },
  { 23, 13, 16, 12, 0, -16 },
  { 49, 11, 18, 11, 0, -17 },
  { 74, 17, 17, 18, 1, -17 },
  { 111, 14, 17, 14, 0, -17 },
  { 141, 5, 6, 6, 2, -16 },
  { 145, 8, 21, 6, 0, -17 },
  { 166, 8, 21, 6, -2, -17 },
  { 187, 9, 11, 10, 2, -18 },
  { 200, 10, 11, 12, 1, -14 },
  { 214, 5, 6, 6, -1, -3 },
  { 218, 7, 4, 7, 0, -8 },
  { 222, 4, 4, 6, 0, -4 },
  { 224, 12, 17, 9, -1, -17 },
  { 250, 10, 17, 11, 1, -17 },
  { 272, 9, 16, 11, 2, -16 },
  { 290, 12, 17, 11, -1, -17 },
  { 316, 11, 17, 11, 0, -17 },
  { 340, 11, 16, 11, 0, -16 },
  { 362, 11, 16, 11, 0, -16 },
  { 384, 11, 17, 11, 1, -17 },
  { 408, 11, 16, 11, 1, -16 },
  { 430, 11, 17, 11, 0, -17 },
  { 454, 11, 17, 11, 0, -17 },
  { 478, 6, 13, 6, 0, -13 },
  { 488, 7, 16, 6, -1, -13 },
  { 502, 10, 11, 12, 1, -14 },
  { 516, 10, 8, 12, 1, -12 },
  { 526, 10, 11, 12, 1, -14 },
  { 540, 9, 17, 9, 1, -17 },
  { 560, 16, 19, 16, 0, -17 },
  { 598, 12, 16, 12, -1, -16 },
  { 622, 12, 16, 12, 0, -16 },
  { 646, 11, 17, 11, 1, -17 },
  { 670, 13, 16, 12, 0, -16 },
  { 696, 11, 16, 10, 0, -16 },
  { 718, 11, 16, 9, 0, -16 },
  { 740, 12, 17, 13, 1, -17 },
  { 766, 14, 16, 13, 0, -16 },
  { 794, 11, 16, 9, -1, -16 },
  { 816, 11, 21, 6, -4, -16 },
  { 845, 14, 16, 12, 0, -16 },
  { 873, 8, 16, 9, 0, -16 },
  { 889, 18, 16, 17, 0, -16 },
  { 925, 15, 16, 14, 0, -16 },
  { 955, 12, 17, 13, 1, -17 },
  { 981, 12, 16, 11, 0, -16 },
  { 1005, 12, 21, 13, 1, -17 },
  { 1037, 12, 16, 12, 0, -16 },
  { 1061, 11, 17, 10, 0, -17 },
  { 1085, 10, 16, 10, 2, -16 },
  { 1105, 13, 16, 13, 1, -16 },
  { 1131, 12, 16, 12, 2, -16 },
  { 1155, 17, 16, 17, 2, -16 },
  { 1189, 14, 16, 12, -1, -16 },
  { 1217, 11, 16, 11, 2, -16 },
  { 1239, 13, 16, 10, -1, -16 },
  { 1265, 9, 21, 7, -1, -17 },
  { 1289, 6, 17, 9, 2, -17 },
  { 1302, 10, 21, 7, -2, -17 },
  { 1329, 11, 10, 11, 0, -16 },
  { 1343, 9, 3, 9, -2, 1 },
  { 1347, 5, 4, 8, 3, -18 },
  { 1350, 12, 13, 11, 0, -13 },
  { 1370, 11, 17, 11, 0, -17 },
  { 1394, 10, 13, 9, 0, -13 },
  { 1411, 13, 17, 11, 0, -17 },
  { 1439, 10, 13, 11, 0, -13 },
  { 1456, 13, 24, 7, -3, -18 },
  { 1495, 13, 19, 11, -1, -13 },
  { 1526, 11, 17, 11, 0, -17 },
  { 1550, 7, 18, 6, 0, -18 },
  { 1566, 10, 24, 6, -3, -18 },
  { 1596, 12, 17, 11, 0, -17 },
  { 1622, 7, 17, 6, 0, -17 },
  { 1637, 16, 13, 17, 0, -13 },
  { 1663, 11, 13, 11, 0, -13 },
  { 1681, 11, 13, 11, 0, -13 },
  { 1699, 12, 19, 11, -1, -13 },
  { 1728, 12, 19, 11, 0, -13 },
  { 1757, 9, 13, 8, 0, -13 },
  { 1772, 9, 13, 9, 0, -13 },
  { 1787, 8, 15, 8, 1, -15 },
  { 1802, 12, 13, 11, 0, -13 },
  { 1822, 11, 13, 11, 1, -13 },
  { 1840, 16, 13, 16, 1, -13 },
  { 1866, 13, 13, 11, -1, -13 },
  { 1888, 13, 19, 11, -1, -13 },
  { 1919, 11, 13, 9, -1, -13 },
  { 1937, 10, 20, 8, 0, -16 },
  { 1962, 3, 23, 9, 3, -18 },
  { 1971, 9, 20, 8, -1, -16 },
  { 1994, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC23PT7B_H_
