#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0x0C, 0x00, 0x3F, 0x9F, 0xDF,
  0xE7, 0xF7, 0xF3, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0x8F, 0xE7, 0xE3,
  0xF1, 0xF8, 0xFC, 0xFE, 0x3F, 0x3F, 0x1F, 0xCF, 0xC7, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xCF, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF1, 0xF0, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0x1F, 0x9F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xE3, 0xE0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x3E, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xCF, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xF3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF,
  0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE,
  0xC6, 0x07, 0xE6, 0x10, 0x3F, 0x70, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x6F, 0xC1, 0x03, 0x7E, 0x0C,
  0x1B, 0xF0, 0x70, 0xDF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x10, 0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC,
  0x07, 0xC0, 0x1F, 0xFC, 0x0F, 0xC0, 0x3F, 0x7C, 0x1F, 0x80, 0x3E, 0x7E,
  0x1F, 0x00, 0x7E, 0x7C, 0x3F, 0x00, 0x7C, 0x7C, 0x3E, 0x00, 0x7C, 0x7C,
  0x7E, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x7C, 0xFC, 0xFC, 0x00, 0xFC, 0xFC,
  0xF8, 0x00, 0xFC, 0xF9, 0xF1, 0xFC, 0xFD, 0xFB, 0xF3, 0xFE, 0x7F, 0xF3,
  0xE7, 0xFE, 0x7F, 0xF7, 0xEF, 0xFF, 0x7F, 0xE7, 0xCF, 0xFF, 0x3F, 0xCF,
  0xDF, 0x9F, 0x1F, 0x0F, 0x9F, 0x1F, 0x00, 0x1F, 0x9F, 0x1F, 0x00, 0x3F,
  0x3F, 0x1F, 0x00, 0x3E, 0x3F, 0x3F, 0x00, 0x7E, 0x3E, 0x3E, 0x00, 0x7C,
  0x3E, 0x3E, 0x00, 0xFC, 0x3E, 0x7E, 0x00, 0xF8, 0x3E, 0x7C, 0x01, 0xF8,
  0x3F, 0xFC, 0x01, 0xF0, 0x3F, 0xF8, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xE0,
  0x1F, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xF8, 0x1F, 0xF8, 0xFE,
  0x0F, 0xFF, 0x3F, 0xC3, 0xFF, 0xF7, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xF3, 0xFF, 0xF0, 0xFE, 0x7F, 0xFC, 0x3F, 0xC7, 0xFF, 0x87,
  0xF8, 0xFF, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F, 0xE3, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x3F, 0xBF, 0xDF, 0xCF, 0xE7, 0xF3,
  0xF1, 0xF8, 0xFC, 0xFE, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xC4, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x31, 0xF8, 0x1E, 0x7C, 0x17, 0xFF, 0x3D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xFF, 0x0F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFD, 0xF8, 0x3F, 0x7F, 0x07, 0x8F, 0xC0,
  0xC3, 0xC0, 0x10, 0xE0, 0x00, 0x20, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE1, 0xFC,
  0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8,
  0x7F, 0x00, 0x3F, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xFB,
  0xFF, 0xC0, 0x0C, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x30, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE, 0x7F, 0x1F,
  0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3,
  0xF8, 0x7F, 0x3F, 0x8F, 0xF7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE,
  0x7F, 0x0F, 0xE7, 0xF1, 0xFE, 0x7F, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F,
  0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE7, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFF, 0x1F, 0xFF, 0x8F, 0xBF,
  0x83, 0x9F, 0xC0, 0x8F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xF8, 0xFF, 0x01, 0x83, 0xFC, 0x04, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x60, 0xFF, 0x02, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x80, 0x3F, 0xC7, 0x03, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x07, 0xDF, 0xC0, 0x7F, 0xFE, 0x03, 0xEF, 0xE0, 0x3E, 0x7F,
  0x03, 0xF3, 0xF8, 0x1F, 0x1F, 0xC1, 0xF1, 0xFE, 0x1F, 0x8F, 0xE0, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF6, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x10, 0x0F, 0xF0, 0xE0, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xF8, 0xC0,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x9E,
  0x03, 0xFB, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE3, 0xFE, 0xFF, 0x1F, 0xE7, 0xF8, 0xFE, 0x3F, 0xC7, 0xF1, 0xFE,
  0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFF, 0x3F, 0xC3, 0xF9,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC,
  0x0F, 0xEF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xBF, 0x83,
  0xF9, 0xFE, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0xFE, 0x0F,
  0xE7, 0xF0, 0xFE, 0x3F, 0xCF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF1, 0xFE, 0x7F, 0x1F, 0xC7, 0xF3, 0xFC, 0x7F, 0x3F, 0x87, 0xF3, 0xF8,
  0x7F, 0x3F, 0x8F, 0xF3, 0xF8, 0xFF, 0x3F, 0x9F, 0xF3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xDF, 0xC0,
  0x23, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x3F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xE0, 0x7C, 0x01, 0x00, 0x00, 0x38, 0x01, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC,
  0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x60, 0xFF, 0x10, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xCF,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F,
  0x0F, 0xC1, 0xF8, 0x7C, 0x3E, 0x1F, 0xFD, 0xF1, 0xF0, 0xFF, 0xE7, 0xC7,
  0xC7, 0xFF, 0x9F, 0x3E, 0x3F, 0x3E, 0x7C, 0xF9, 0xF8, 0xF9, 0xF3, 0xC7,
  0xC7, 0xC7, 0xDF, 0x1F, 0x1F, 0x1F, 0x7C, 0xF8, 0x7C, 0x7D, 0xE3, 0xE1,
  0xF1, 0xEF, 0x8F, 0x8F, 0x8F, 0xBE, 0x3E, 0x3E, 0x3E, 0xF9, 0xF8, 0xF8,
  0xF3, 0xE7, 0xE7, 0xE7, 0xCF, 0x9F, 0xBF, 0xBE, 0x3E, 0x3F, 0xFF, 0xF8,
  0xF8, 0xFF, 0x7F, 0xC3, 0xE1, 0xFD, 0xFE, 0x0F, 0x83, 0xC3, 0xE0, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x20, 0x03, 0xF8,
  0x07, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F,
  0x03, 0xFC, 0x7F, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFF,
  0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xFC, 0x3F,
  0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0x1F,
  0xE1, 0xFE, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE1, 0xFE,
  0x3F, 0xC7, 0xF8, 0x7F, 0x9F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFE, 0x08, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x81, 0xFE, 0x1C, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xF1,
  0xFF, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F, 0xE0,
  0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0xC1,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0x87, 0xF8, 0x3F, 0x87,
  0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xF8, 0x0C, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x9F, 0xC7, 0xFE, 0x7F, 0x8F, 0xFC, 0xFF, 0x1F, 0xF9, 0xFE, 0x7F,
  0xF3, 0xF8, 0xFF, 0xE7, 0xF1, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE1, 0xFF, 0x1F, 0xC3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0,
  0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x7F, 0x81,
  0xFE, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFE,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x1F, 0xE0,
  0x3F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x81,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x07, 0xF8, 0x0F,
  0xE1, 0xFE, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3, 0xFC,
  0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xF7, 0xF8, 0x01, 0xFE,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFC,
  0x00, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x7F, 0xFC, 0x0F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF,
  0xCF, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFD, 0xFB, 0xF8, 0x1F,
  0xFF, 0x7E, 0xFE, 0x07, 0xFF, 0xDF, 0xFF, 0x83, 0xFB, 0xFF, 0xDF, 0xC0,
  0xFE, 0xFF, 0xF7, 0xF0, 0x3F, 0xBF, 0xF9, 0xFC, 0x0F, 0xEF, 0xFE, 0x7F,
  0x03, 0xFB, 0xFF, 0x3F, 0xC1, 0xFC, 0xFF, 0xCF, 0xE0, 0x7F, 0x1F, 0xE3,
  0xF8, 0x1F, 0xC7, 0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x3F, 0x81, 0xF8, 0x7F,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC7, 0xF0, 0x3F, 0x87, 0xE1, 0xFC, 0x0F, 0xE1,
  0xF8, 0x7F, 0x00, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x03, 0xFE,
  0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x07, 0xFE, 0x0F, 0xE0, 0x7F, 0xF0, 0xFE,
  0x07, 0xFF, 0x0F, 0xE0, 0x7F, 0xF0, 0xFE, 0x07, 0xFF, 0x0F, 0xE0, 0xFF,
  0xF1, 0xFC, 0x0F, 0xFF, 0x9F, 0xC0, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF, 0x9F,
  0xC1, 0xFD, 0xF9, 0xFC, 0x1F, 0xDF, 0xBF, 0x81, 0xFD, 0xFB, 0xF8, 0x1F,
  0xDF, 0xFF, 0x81, 0xF9, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF, 0x03, 0xF8, 0xFF,
  0xF0, 0x3F, 0x8F, 0xFF, 0x03, 0xF8, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF, 0x07,
  0xF0, 0xFF, 0xE0, 0x7F, 0x0F, 0xFE, 0x07, 0xF0, 0x7F, 0xE0, 0x7F, 0x07,
  0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0xC0,
  0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x8F, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xFB,
  0xFC, 0x07, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFB, 0xFC, 0x0F, 0xF7, 0xF0,
  0x1F, 0xEF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFF, 0x3F, 0x81, 0xFE, 0x7F, 0x07,
  0xFC, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC, 0xFF, 0x83, 0xF8, 0xFF, 0x07,
  0xF1, 0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE,
  0x3F, 0xC3, 0xFC, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x8F, 0xF8, 0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x81, 0xFC, 0xFF,
  0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF8, 0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFB, 0xFC, 0x0F,
  0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0xDF, 0xC0, 0xFF, 0x3F, 0x81, 0xFE,
  0x7F, 0x07, 0xF8, 0xFF, 0x0F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFF, 0x07, 0xF1,
  0xFE, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x3F,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xFC, 0x07,
  0xF7, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xE0, 0xFE,
  0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0x7F, 0x0F, 0xF0, 0xFF, 0x1F, 0xC1,
  0xFE, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFC, 0x38, 0x07, 0xF0, 0x30, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x10,
  0x0F, 0xF0, 0x70, 0x3F, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0x83, 0xFC,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0,
  0xFE, 0x1F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x3F, 0xCF,
  0xF0, 0x7F, 0x9F, 0xE0, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x07, 0xF0, 0xFE,
  0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x07, 0xF1, 0xFE, 0x0F, 0xE3,
  0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0xFF,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x3F, 0xDF, 0xC0,
  0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0x07, 0xF9, 0xFC, 0x1F, 0xC1, 0xFC, 0x7F,
  0x0F, 0xF0, 0x7F, 0x1F, 0xC3, 0xFC, 0x3F, 0xC7, 0xF0, 0xFF, 0x0F, 0xE1,
  0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x1F, 0xF1, 0xFC, 0x1F, 0xCF, 0xFC, 0x7F,
  0x07, 0xF3, 0xFF, 0x3F, 0xC1, 0xFC, 0xFF, 0xCF, 0xE0, 0x7E, 0x7F, 0xF3,
  0xF8, 0x1F, 0x9F, 0xFD, 0xFE, 0x07, 0xEF, 0xFF, 0x7F, 0x03, 0xFB, 0xFF,
  0xDF, 0xC0, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF,
  0xBF, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x3F,
  0xFC, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x00,
  0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1,
  0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x80,
  0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x3F,
  0x80, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x07,
  0xF3, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x1F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFC, 0xFC, 0x07, 0xF3, 0xF0, 0x3F, 0x8F,
  0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFE, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE7,
  0xF0, 0x1F, 0xBF, 0x80, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xC7, 0xF8, 0xFE, 0x1F, 0x87,
  0xF0, 0xFC, 0x00, 0xE0, 0x00, 0x1F, 0x8F, 0xC1, 0xFE, 0xFE, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x7F, 0xC7, 0xF1, 0xFE, 0x7F,
  0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xE1, 0xFE,
  0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0xC7, 0xF1,
  0xFC, 0x3F, 0x9F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFE, 0xFC, 0x0F, 0xF7, 0xE0, 0x3E, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF9, 0xE0, 0x1F, 0xDF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xBF, 0xC3, 0xFC, 0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x3F,
  0xC7, 0xF0, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x8F,
  0xF1, 0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xFC, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xEF, 0xF8, 0x1F, 0xBF, 0xC0,
  0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x3F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xFE, 0x70, 0xFE, 0x08, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x81, 0x0F, 0xE0, 0xC3, 0xFF, 0xF0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x01,
  0xE3, 0xF8, 0x0F, 0xF7, 0xF0, 0x3F, 0xEF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xF7, 0xFC, 0x1F, 0xC7, 0xF8, 0x7F, 0x8F,
  0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F, 0xC1,
  0xFC, 0x7F, 0x03, 0xF9, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCF, 0xF3, 0xF9, 0xFC, 0x3F, 0x7F, 0x0F, 0xEF, 0xE3, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x08, 0x7F, 0x8F, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xE8, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFC, 0xFC, 0x07, 0xFB, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFD, 0xFF, 0x07, 0xF1,
  0xFE, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F,
  0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F,
  0xDF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x08, 0x07,
  0xF8, 0x1F, 0x1F, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF9, 0xE0, 0x1F,
  0xDF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0,
  0xFE, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC,
  0x7F, 0x0F, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF,
  0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC7, 0xF0, 0xFF, 0x1F, 0xC0, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x83, 0xF8, 0x7F, 0x81,
  0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x3F, 0xBF, 0xC0,
  0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xEF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x07, 0xE7, 0xF0, 0xFE, 0x07, 0xEF,
  0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0x0F, 0xE3,
  0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0xFF, 0x1F, 0xC3,
  0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFE, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F, 0x87, 0xF1, 0xFC, 0x3F, 0x8F,
  0xF1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0xFF, 0x1F, 0xC7, 0xF8, 0x00, 0x01, 0xC0, 0x1F, 0x9F, 0xC0,
  0x7E, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFC, 0xFF, 0x0F, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x7F, 0x0F,
  0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xF0,
  0xFF, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xF3, 0xF9, 0xFC, 0x7F, 0x7F, 0x8F,
  0xEF, 0xE1, 0xFD, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F,
  0xFF, 0x87, 0xFF, 0xF0, 0xFE, 0xFE, 0x1F, 0xDF, 0xC7, 0xFB, 0xF8, 0xFE,
  0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x01, 0xF9, 0xFC, 0x01, 0xFB, 0xFE,
  0x01, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0xFF,
  0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF,
  0x07, 0xF0, 0xFF, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE,
  0x0F, 0xF1, 0xFE, 0x0F, 0xE1, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xF3, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xCF, 0xC1, 0xFE, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x7F, 0xC7, 0xF1, 0xFE,
  0x7F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF9, 0xFE, 0x1F, 0xCF, 0xE0,
  0xFE, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x3F, 0xC7,
  0xF1, 0xFC, 0x3F, 0x9F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0xFC, 0xFC, 0x1F, 0xBF, 0x03, 0xF7, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xC1, 0xFC, 0x70, 0xFF, 0x08, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x20, 0x3F, 0x8C, 0x1F, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x23, 0xFF, 0x9F, 0xFF,
  0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE1, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0xFE, 0x1F, 0xC7,
  0xF0, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE, 0x1F,
  0xC7, 0xF1, 0xFE, 0x3F, 0x8F, 0xE3, 0xFC, 0x7F, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF1, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xEF, 0xC1, 0xFE, 0xFC, 0x07, 0xE7, 0xE0, 0xFE, 0x0F, 0xFF,
  0xE1, 0xFE, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8,
  0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7E, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x1F, 0xE1,
  0xFD, 0xFC, 0x7F, 0x87, 0xF7, 0xF3, 0xFE, 0x3F, 0x9F, 0x8F, 0xF8, 0xFE,
  0x7E, 0x3F, 0xE7, 0xF1, 0xF9, 0xFF, 0x9F, 0xC7, 0xE7, 0xFE, 0x7F, 0x1F,
  0x9F, 0xFB, 0xF8, 0x7E, 0xFF, 0xEF, 0xE1, 0xFB, 0xFF, 0xBF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFD, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0x83, 0xFF, 0xDF,
  0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE,
  0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x00,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F,
  0xC3, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFE, 0x03, 0xF9, 0xFE,
  0x03, 0xFB, 0xFC, 0x03, 0xFB, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0,
  0x1F, 0xDF, 0xC0, 0x3F, 0x9F, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0x0F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x1C, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFE, 0x80, 0x07, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 14, 32, 11, 0, -31 },
  { 57, 18, 11, 20, 4, -31 },
  { 82, 25, 31, 23, 0, -31 },
  { 179, 21, 36, 21, 1, -33 },
  { 274, 32, 32, 35, 2, -32 },
  { 402, 27, 32, 26, 0, -32 },
  { 510, 9, 11, 11, 4, -31 },
  { 523, 16, 39, 12, 0, -32 },
  { 601, 16, 39, 12, -4, -32 },
  { 679, 18, 21, 19, 3, -34 },
  { 727, 19, 21, 22, 2, -26 },
  { 777, 11, 12, 11, -3, -6 },
  { 794, 13, 7, 14, 0, -15 },
  { 806, 8, 9, 11, 0, -8 },
  { 815, 25, 32, 17, -3, -32 },
  { 915, 20, 32, 21, 1, -32 },
  { 995, 17, 31, 21, 4, -31 },
  { 1061, 22, 32, 21, -1, -32 },
  { 1149, 21, 32, 21, 0, -32 },
  { 1233, 21, 31, 21, 0, -31 },
  { 1315, 21, 31, 21, 1, -31 },
  { 1397, 21, 32, 21, 1, -32 },
  { 1481, 22, 31, 21, 1, -31 },
  { 1567, 21, 32, 21, 0, -32 },
  { 1651, 20, 32, 21, 1, -32 },
  { 1731, 12, 26, 12, 0, -25 },
  { 1770, 15, 31, 12, -3, -25 },
  { 1829, 19, 22, 22, 2, -27 },
  { 1882, 19, 15, 22, 2, -23 },
  { 1918, 19, 22, 22, 2, -27 },
  { 1971, 18, 33, 17, 1, -32 },
  { 2046, 30, 35, 31, 1, -32 },
  { 2178, 24, 32, 23, -3, -32 },
  { 2274, 23, 31, 23, 0, -31 },
  { 2364, 22, 32, 21, 1, -32 },
  { 2452, 24, 31, 24, 0, -31 },
  { 2545, 21, 31, 18, 0, -31 },
  { 2627, 21, 31, 18, 0, -31 },
  { 2709, 23, 32, 24, 2, -32 },
  { 2801, 27, 31, 25, 0, -31 },
  { 2906, 22, 31, 16, -2, -31 },
  { 2992, 21, 41, 12, -7, -31 },
  { 3100, 27, 31, 23, 0, -31 },
  { 3205, 16, 31, 18, 0, -31 },
  { 3267, 34, 31, 33, 0, -31 },
  { 3399, 28, 31, 27, 0, -31 },
  { 3508, 23, 32, 25, 2, -32 },
  { 3600, 23, 31, 21, 0, -31 },
  { 3690, 23, 39, 25, 2, -32 },
  { 3803, 23, 31, 22, 0, -31 },
  { 3893, 23, 32, 19, -1, -32 },
  { 3985, 19, 31, 19, 3, -31 },
  { 4059, 24, 31, 24, 2, -31 },
  { 4152, 23, 31, 23, 4, -31 },
  { 4242, 34, 31, 33, 3, -31 },
  { 4374, 28, 31, 22, -3, -31 },
  { 4483, 22, 31, 22, 4, -31 },
  { 4569, 24, 31, 19, -2, -31 },
  { 4662, 18, 39, 13, -2, -32 },
  { 4750, 11, 32, 17, 4, -32 },
  { 4794, 18, 39, 13, -3, -32 },
  { 4882, 22, 20, 20, -1, -31 },
  { 4937, 18, 5, 17, -4, 3 },
  { 4949, 10, 7, 15, 6, -34 },
  { 4958, 21, 25, 21, 1, -25 },
  { 5024, 22, 33, 21, -1, -33 },
  { 5115, 18, 25, 18, 1, -25 },
  { 5172, 23, 33, 21, 1, -33 },
  { 5267, 19, 25, 20, 1, -25 },
  { 5327, 24, 45, 14, -5, -34 },
  { 5462, 23, 36, 21, -1, -25 },
  { 5566, 22, 33, 22, -1, -33 },
  { 5657, 14, 34, 11, -1, -34 },
  { 5717, 19, 45, 11, -6, -34 },
  { 5824, 25, 33, 21, -1, -33 },
  { 5928, 15, 33, 11, -1, -33 },
  { 5990, 32, 25, 32, -1, -25 },
  { 6090, 22, 25, 22, -1, -25 },
  { 6159, 19, 25, 21, 1, -25 },
  { 6219, 24, 36, 21, -3, -25 },
  { 6327, 21, 36, 21, 1, -25 },
  { 6422, 19, 25, 15, -1, -25 },
  { 6482, 18, 25, 17, 0, -25 },
  { 6539, 15, 29, 15, 2, -29 },
  { 6594, 21, 24, 22, 1, -24 },
  { 6657, 20, 24, 20, 3, -24 },
  { 6717, 30, 24, 30, 2, -24 },
  { 6807, 24, 24, 20, -2, -24 },
  { 6879, 26, 35, 20, -3, -24 },
  { 6993, 21, 24, 17, -2, -24 },
  { 7056, 19, 38, 15, 0, -31 },
  { 7147, 7, 44, 17, 5, -34 },
  { 7186, 18, 38, 15, -3, -31 },
  { 7272, 19, 9, 22, 2, -20 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC44PT7B_H_
