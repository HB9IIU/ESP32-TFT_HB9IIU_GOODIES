#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x10, 0x00, 0x7F, 0xCF, 0xF7, 0xFC, 0xFF, 0x7F, 0x8F, 0xF7, 0xF9,
  0xFF, 0x7F, 0x9F, 0xE7, 0xF1, 0xFE, 0x7F, 0x1F, 0xEF, 0xF1, 0xFC, 0xFF,
  0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x3F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x80,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1,
  0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x0F, 0xF6, 0xF8, 0x0F, 0xEE, 0x38, 0x0F, 0xEE, 0x08, 0x0F, 0xEC, 0x00,
  0x0F, 0xEC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x77, 0xF0,
  0x40, 0x77, 0xF0, 0x70, 0x77, 0xF0, 0x7C, 0x6F, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xC0, 0x0F, 0xFE, 0x01, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0x80, 0x3F, 0xFE, 0x03, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0x00,
  0x7F, 0x3F, 0x07, 0xE0, 0x07, 0xE3, 0xF0, 0xFE, 0x00, 0x7E, 0x3F, 0x0F,
  0xC0, 0x0F, 0xE3, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x1F, 0x80, 0x0F, 0xC7,
  0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE7, 0xE0, 0x00,
  0xFC, 0xFC, 0x7E, 0x1F, 0x0F, 0xCF, 0xCF, 0xC7, 0xFC, 0xFD, 0xFD, 0xFC,
  0xFF, 0xCF, 0xFF, 0x9F, 0x9F, 0xFE, 0xFF, 0xF3, 0xFB, 0xFF, 0xE7, 0xFF,
  0x3F, 0x3F, 0xFE, 0x7F, 0xC7, 0xE7, 0xF3, 0xF1, 0xF8, 0x7E, 0x7E, 0x3F,
  0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC7, 0xE0, 0x07,
  0xE0, 0xFC, 0x7E, 0x00, 0x7E, 0x0F, 0xCF, 0xC0, 0x0F, 0xC0, 0xFC, 0xFC,
  0x00, 0xFC, 0x0F, 0xDF, 0x80, 0x1F, 0x80, 0xFF, 0xF8, 0x03, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFC, 0x7F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF, 0x1F, 0xF0, 0x7F,
  0xFC, 0x7F, 0x83, 0xFF, 0xFB, 0xFE, 0x1F, 0xFF, 0xEF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFD, 0xFF, 0xFE, 0x1F, 0xE7, 0xFF, 0xF8, 0x7F, 0x8F, 0xFF,
  0xC3, 0xFE, 0x3F, 0xFE, 0x0F, 0xF8, 0x7F, 0xF8, 0x3F, 0xE1, 0xFF, 0xC0,
  0xFF, 0x87, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xF7, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xDF,
  0xF7, 0xF9, 0xFE, 0x7F, 0x9F, 0xC7, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x02, 0x0F, 0xE0, 0x1C, 0x7F,
  0x00, 0xF3, 0xF8, 0x27, 0xFF, 0x8F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0x3F, 0xC0, 0xF1, 0xFC, 0x03, 0x87, 0x80, 0x08, 0x38, 0x00, 0x01, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xFE, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xCF, 0xFF, 0xBF, 0xFE, 0x00, 0x0E, 0x1F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC3, 0xFC, 0xFF, 0x1F, 0xF3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xCF,
  0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE1,
  0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE,
  0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0xC3, 0xFC, 0xFE,
  0x1F, 0xE3, 0xF8, 0x7F, 0x8F, 0xE3, 0xFE, 0x3F, 0x8F, 0xF0, 0xFF, 0x7F,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xF7, 0xF8, 0x3E, 0xFF,
  0x81, 0xCF, 0xF8, 0x08, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0x01, 0xF0, 0xFF, 0x00, 0x60, 0x7F,
  0x80, 0x20, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x83,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xE1, 0xFF, 0x01, 0x81,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x80, 0x1F, 0xF8, 0xE0, 0x3F,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xF7, 0xF8, 0x03, 0xF7,
  0xF8, 0x07, 0xE7, 0xF8, 0x0F, 0xC7, 0xF8, 0x0F, 0xCF, 0xF0, 0x1F, 0x8F,
  0xF0, 0x3F, 0x0F, 0xF0, 0x3F, 0x0F, 0xF0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x41,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC4, 0x01, 0xFF, 0x8E, 0x07, 0xFE,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x78, 0x07, 0xFB, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFE, 0x7F, 0x8F, 0xF8, 0xFF,
  0x1F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF1,
  0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F, 0xF3, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8,
  0xFF, 0x07, 0xF9, 0xFE, 0x07, 0xF9, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xE7,
  0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x07, 0xFD, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xCF,
  0xF0, 0xFF, 0x9F, 0xE3, 0xFE, 0x3F, 0xE7, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFD,
  0xFE, 0x03, 0xE7, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x03, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xC0, 0xFC, 0x01, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xF0, 0xFF, 0x0C,
  0x0F, 0xF0, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0xE1, 0xF0, 0xFC, 0x1F, 0xFE, 0x7C, 0x3F,
  0x1F, 0xFF, 0x9F, 0x1F, 0x87, 0xFF, 0xC7, 0xC7, 0xE3, 0xFF, 0xF1, 0xF3,
  0xF1, 0xF8, 0xFC, 0x7C, 0xFC, 0x7E, 0x3F, 0x1F, 0x3E, 0x3F, 0x0F, 0x87,
  0xDF, 0x8F, 0xC3, 0xE1, 0xF7, 0xE7, 0xE1, 0xF8, 0xFD, 0xF1, 0xF8, 0x7E,
  0x3E, 0x7C, 0x7E, 0x1F, 0x8F, 0xBF, 0x1F, 0x87, 0xC3, 0xEF, 0xC7, 0xC3,
  0xF1, 0xF3, 0xF1, 0xF0, 0xFC, 0x7C, 0xFC, 0x7C, 0x7F, 0x3F, 0x3E, 0x1F,
  0xBF, 0xDF, 0x8F, 0x87, 0xFF, 0xFF, 0xC3, 0xE1, 0xFF, 0xFF, 0xE0, 0xFC,
  0x3F, 0xCF, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xC0,
  0x03, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x1F, 0xC0,
  0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3,
  0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8, 0x0F, 0xF9, 0xFF,
  0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFC,
  0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F,
  0xE1, 0xFF, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFC, 0x78, 0x0F, 0xF8, 0x08, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x08, 0x0F, 0xFC, 0x1C,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0xE0, 0xFF, 0x87, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1, 0xFE, 0x07,
  0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xFC, 0x1F, 0xE3, 0xFF,
  0x07, 0xFD, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x40, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xF8, 0x78, 0x0F, 0xFC, 0x03, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xFC, 0x7F, 0xC7, 0xFF, 0x0F, 0xF0, 0xFF,
  0xE3, 0xFE, 0x3F, 0xFC, 0x7F, 0xC7, 0xFF, 0x8F, 0xF8, 0xFF, 0xF1, 0xFF,
  0x1F, 0xFC, 0x3F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFE, 0x0F, 0xFC,
  0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x43, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xF8, 0x01, 0xFE, 0x3F, 0xE0,
  0x03, 0xFC, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x07,
  0xFF, 0xF3, 0xFF, 0xF8, 0x0F, 0xFF, 0xE7, 0xEF, 0xF0, 0x1F, 0xDF, 0xDF,
  0xFF, 0xC0, 0x7F, 0xBF, 0xBF, 0xFF, 0x80, 0xFF, 0x7F, 0xFE, 0xFF, 0x01,
  0xFE, 0xFF, 0xFD, 0xFE, 0x03, 0xFD, 0xFF, 0xF7, 0xFC, 0x07, 0xF3, 0xFF,
  0xEF, 0xF0, 0x1F, 0xE7, 0xFF, 0x9F, 0xE0, 0x3F, 0xCF, 0xFF, 0x3F, 0xC0,
  0x7F, 0x9F, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xF9, 0xFF, 0x01, 0xFC, 0x7F,
  0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0xC7, 0xF8, 0x0F, 0xF1, 0xFF, 0x8F, 0xF0,
  0x1F, 0xE3, 0xFE, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x03, 0xFF,
  0x80, 0xFE, 0x03, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0xC1, 0xFE, 0x03, 0xFF,
  0xC1, 0xFE, 0x03, 0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0xC3, 0xFC, 0x07, 0xFF,
  0xC3, 0xFC, 0x07, 0xFF, 0xE3, 0xFC, 0x07, 0xFF, 0xE3, 0xFC, 0x0F, 0xFF,
  0xE3, 0xFC, 0x0F, 0xFF, 0xE7, 0xF8, 0x0F, 0xFF, 0xE7, 0xF8, 0x0F, 0xEF,
  0xE7, 0xF8, 0x0F, 0xEF, 0xF7, 0xF8, 0x1F, 0xEF, 0xF7, 0xF0, 0x1F, 0xE7,
  0xF7, 0xF0, 0x1F, 0xE7, 0xFF, 0xF0, 0x1F, 0xE7, 0xFF, 0xF0, 0x1F, 0xC7,
  0xFF, 0xF0, 0x3F, 0xC7, 0xFF, 0xE0, 0x3F, 0xC7, 0xFF, 0xE0, 0x3F, 0xC3,
  0xFF, 0xE0, 0x3F, 0xC3, 0xFF, 0xE0, 0x3F, 0x83, 0xFF, 0xE0, 0x7F, 0x83,
  0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0xC0, 0x7F, 0x81,
  0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE,
  0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFE,
  0x7F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xC0,
  0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xE7,
  0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F,
  0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0x8F, 0xF8,
  0x3F, 0xC7, 0xFC, 0x0F, 0xF3, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xE3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F,
  0xF3, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE,
  0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01, 0xFF,
  0x7F, 0xC0, 0x3F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x01, 0xFF, 0x3F, 0xE0,
  0x3F, 0xE7, 0xFC, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3,
  0xFE, 0x0F, 0xFC, 0x7F, 0xC3, 0xFF, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xF3, 0xFF, 0x03, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F,
  0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE,
  0x3F, 0xE0, 0xFF, 0x8F, 0xF8, 0x3F, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xCF,
  0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0x3F, 0xE0, 0x7F,
  0xCF, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0x0E, 0x01, 0xFF, 0x01, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x02, 0x00, 0xFF, 0x81, 0xE0, 0x3F, 0xE0, 0x7F, 0x3F, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F,
  0xF8, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x07, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xFC, 0x3F,
  0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x3F,
  0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0xFF,
  0x7F, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x03, 0xFE, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0xFF, 0x03, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x3F, 0xE7, 0xF8,
  0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0xFF, 0x83,
  0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFE, 0x1F, 0xF0, 0xFF,
  0x0F, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0xF1,
  0xFF, 0x07, 0xF8, 0xFF, 0xE3, 0xFC, 0x0F, 0xF3, 0xFF, 0xC7, 0xF8, 0x1F,
  0xE7, 0xFF, 0x9F, 0xE0, 0x3F, 0xCF, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xFE,
  0xFF, 0x80, 0xFF, 0x7F, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xFB, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xDF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xFE, 0x00,
  0x7F, 0xFC, 0xFF, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x01, 0xFF, 0xE3,
  0xFF, 0xE0, 0x03, 0xFF, 0xC7, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFF, 0x00,
  0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xC1, 0xFF, 0x80,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x00,
  0x7F, 0x87, 0xFC, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x0F,
  0xF1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFC, 0xFF,
  0x87, 0xFC, 0xFF, 0x8F, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0x9F, 0xF0, 0x7F,
  0x9F, 0xE0, 0x7F, 0xBF, 0xE0, 0x7F, 0xBF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xEF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE,
  0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xE3, 0xFC, 0x07,
  0xF1, 0xFC, 0x03, 0xF9, 0xFC, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8,
  0x3F, 0x00, 0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x07, 0xFE, 0xFF, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xE7,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F, 0x83,
  0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x87, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xEF, 0xE0, 0x7F, 0xCF, 0xC0, 0x3F, 0x8F,
  0xC0, 0x04, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x3F, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x7F,
  0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x7F, 0x87,
  0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x87, 0xF8, 0x7F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF,
  0x1F, 0xF0, 0xFF, 0x8F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xEF, 0xFC, 0x07, 0xF7, 0xFC, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFE, 0x0C, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x10, 0xFF, 0x83, 0x0F, 0xFD,
  0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0x8F, 0xF0, 0x0F, 0xFB, 0xFC, 0x07, 0xFE,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x83, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x83, 0xFE, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFF, 0x03,
  0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xCF, 0xC0, 0x0F, 0xE3, 0xF0, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0x3F, 0xCF, 0xF8, 0xFF,
  0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xE7, 0xF8, 0x7F, 0x9F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x43,
  0xFE, 0x0F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x02, 0x1F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x1F, 0xE7, 0xF0, 0x1F, 0xFB, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xE7,
  0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC7, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x01, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x02, 0x00, 0x7F, 0x80, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x00, 0x7F, 0xBF, 0xC0, 0x3F,
  0xBF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0xC3, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87,
  0xF8, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC0, 0x00, 0x1C, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0x1F, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x9F, 0xF0,
  0x07, 0xF9, 0xFE, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF,
  0x80, 0x3F, 0xCF, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0x87, 0xF8, 0x07,
  0xF8, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0xC0, 0x7F, 0x83,
  0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x03, 0xF8, 0xFC,
  0x0F, 0xC0, 0x3F, 0x9F, 0xE3, 0xFE, 0x03, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xCF, 0xFC, 0xFF, 0x0F, 0xF8, 0xFF,
  0x8F, 0xF0, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF8,
  0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0x7F, 0x83, 0xFC,
  0x3F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F,
  0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC,
  0x1F, 0xE1, 0xFE, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xF8, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0x0F, 0xF7, 0xF8,
  0x3F, 0xDF, 0xE0, 0xFF, 0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFE, 0xFF, 0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0xFF, 0xBF,
  0xC3, 0xFC, 0xFF, 0x1F, 0xF3, 0xFE, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFB,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7,
  0xFC, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x7F,
  0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xE1, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF,
  0x8F, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xE3,
  0xF0, 0x03, 0xFC, 0x10, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x01, 0xFE, 0x7F,
  0x07, 0xFE, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xE7, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC,
  0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x87, 0xF8, 0xFF, 0x87, 0xF8,
  0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xDF, 0xC0, 0x3F, 0xBF, 0xC0, 0x04, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0xF8, 0x1F, 0xCF, 0xC0,
  0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xF7, 0xC1, 0xFE, 0x0C, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x88, 0x07, 0xF8, 0xC0, 0xFF,
  0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE1, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x02, 0x00, 0x00, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3,
  0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3,
  0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87,
  0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F,
  0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xEF, 0xE0, 0x7F, 0xCF, 0xE0, 0x3F, 0x8F, 0xE0, 0x04, 0x00,
  0x00, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFB, 0xFC, 0x1F, 0xF7, 0xF8, 0x3F,
  0xCF, 0xF0, 0xFF, 0x9F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x8F, 0xF0,
  0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x07,
  0xF7, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x87,
  0xFC, 0x1F, 0xEF, 0xF0, 0xFF, 0x87, 0xF9, 0xFE, 0x3F, 0xF0, 0xFF, 0x3F,
  0xC7, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0xC7, 0xF8, 0xFF, 0x3F, 0xF8, 0xFF,
  0x1F, 0xE7, 0xFF, 0x3F, 0xC3, 0xFC, 0xFF, 0xE7, 0xF8, 0x7F, 0xBF, 0xFC,
  0xFE, 0x0F, 0xE7, 0xFF, 0xBF, 0xC1, 0xFD, 0xFF, 0xF7, 0xF8, 0x3F, 0xBF,
  0xFE, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0xC0, 0xFE, 0xFF, 0xF7, 0xF0, 0x1F,
  0xFF, 0x7E, 0xFE, 0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xF0,
  0x0F, 0xFF, 0x3F, 0xFE, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xF8, 0xFF,
  0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xF8,
  0x7F, 0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F,
  0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF7, 0xFC, 0x01, 0xFF, 0x3F,
  0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x07, 0xFC, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x80,
  0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x47,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x05, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0x80, 0x07, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 16, 37, 13, 0, -36 },
  { 75, 20, 13, 23, 5, -36 },
  { 108, 28, 36, 26, 0, -36 },
  { 234, 24, 41, 24, 1, -38 },
  { 357, 36, 36, 40, 3, -36 },
  { 519, 30, 37, 30, 0, -36 },
  { 658, 10, 13, 12, 5, -36 },
  { 675, 17, 45, 14, 1, -37 },
  { 771, 18, 45, 14, -4, -37 },
  { 873, 21, 24, 22, 3, -39 },
  { 936, 22, 24, 25, 2, -30 },
  { 1002, 13, 14, 13, -3, -7 },
  { 1025, 15, 7, 15, 0, -17 },
  { 1039, 9, 10, 13, 0, -9 },
  { 1051, 28, 37, 20, -3, -36 },
  { 1181, 22, 37, 24, 2, -36 },
  { 1283, 20, 36, 24, 4, -36 },
  { 1373, 25, 36, 24, -1, -36 },
  { 1486, 24, 37, 24, 0, -36 },
  { 1597, 24, 36, 24, 0, -36 },
  { 1705, 23, 37, 24, 1, -36 },
  { 1812, 23, 37, 24, 2, -36 },
  { 1919, 25, 36, 24, 1, -36 },
  { 2032, 24, 37, 24, 0, -36 },
  { 2143, 23, 37, 24, 1, -36 },
  { 2250, 13, 29, 13, 0, -28 },
  { 2298, 16, 35, 13, -3, -28 },
  { 2368, 22, 24, 25, 2, -30 },
  { 2434, 22, 17, 25, 2, -26 },
  { 2481, 22, 24, 25, 2, -30 },
  { 2547, 20, 37, 19, 1, -36 },
  { 2640, 34, 40, 35, 1, -36 },
  { 2810, 27, 36, 27, -3, -36 },
  { 2932, 27, 36, 26, 0, -36 },
  { 3054, 25, 37, 24, 2, -36 },
  { 3170, 27, 36, 27, 0, -36 },
  { 3292, 24, 36, 21, 0, -36 },
  { 3400, 23, 36, 20, 0, -36 },
  { 3504, 27, 37, 27, 2, -36 },
  { 3629, 30, 36, 28, 0, -36 },
  { 3764, 24, 36, 19, -2, -36 },
  { 3872, 24, 47, 14, -8, -36 },
  { 4013, 31, 36, 26, 0, -36 },
  { 4153, 18, 36, 20, 0, -36 },
  { 4234, 39, 36, 37, 0, -36 },
  { 4410, 32, 36, 30, 0, -36 },
  { 4554, 27, 37, 29, 2, -36 },
  { 4679, 26, 36, 24, 0, -36 },
  { 4796, 27, 45, 29, 2, -36 },
  { 4948, 26, 36, 25, 0, -36 },
  { 5065, 26, 37, 22, -1, -36 },
  { 5186, 21, 36, 21, 4, -36 },
  { 5281, 27, 37, 27, 2, -36 },
  { 5406, 26, 36, 26, 5, -36 },
  { 5523, 39, 36, 37, 3, -36 },
  { 5699, 32, 36, 25, -3, -36 },
  { 5843, 24, 36, 24, 5, -36 },
  { 5951, 27, 36, 22, -2, -36 },
  { 6073, 21, 45, 14, -3, -37 },
  { 6192, 12, 37, 20, 5, -36 },
  { 6248, 21, 45, 14, -4, -37 },
  { 6367, 25, 24, 23, -1, -36 },
  { 6442, 21, 6, 19, -5, 3 },
  { 6458, 11, 8, 17, 7, -38 },
  { 6469, 24, 29, 24, 1, -28 },
  { 6556, 25, 39, 24, -1, -38 },
  { 6678, 20, 29, 20, 1, -28 },
  { 6751, 26, 39, 24, 1, -38 },
  { 6878, 22, 29, 23, 1, -28 },
  { 6958, 27, 50, 15, -6, -38 },
  { 7127, 26, 40, 24, -1, -28 },
  { 7257, 25, 38, 25, -1, -38 },
  { 7376, 16, 39, 13, -1, -39 },
  { 7454, 21, 51, 13, -6, -39 },
  { 7588, 28, 38, 24, -1, -38 },
  { 7721, 16, 38, 13, -1, -38 },
  { 7797, 36, 28, 36, -1, -28 },
  { 7923, 25, 28, 25, -1, -28 },
  { 8011, 22, 29, 24, 1, -28 },
  { 8091, 27, 40, 24, -3, -28 },
  { 8226, 24, 40, 24, 1, -28 },
  { 8346, 21, 28, 18, -1, -28 },
  { 8420, 20, 29, 19, 0, -28 },
  { 8493, 17, 34, 17, 2, -33 },
  { 8566, 24, 29, 25, 1, -28 },
  { 8653, 23, 28, 23, 3, -28 },
  { 8734, 35, 28, 34, 2, -28 },
  { 8857, 28, 28, 23, -3, -28 },
  { 8955, 29, 40, 23, -3, -28 },
  { 9100, 23, 28, 20, -2, -28 },
  { 9181, 21, 44, 17, 0, -36 },
  { 9297, 7, 50, 20, 6, -39 },
  { 9341, 20, 44, 17, -3, -36 },
  { 9451, 22, 9, 25, 2, -22 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC50PT7B_H_
