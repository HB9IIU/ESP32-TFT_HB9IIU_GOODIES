#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC53PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0x60, 0x00,
  0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xF7, 0xFC, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F,
  0xF3, 0xFC, 0x3F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7F,
  0x1F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xE3,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x81, 0xFE, 0xE3, 0x80, 0xFE, 0x70, 0xC0, 0x7F, 0x38, 0x00, 0x3F, 0xD8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0E, 0xFE, 0x08, 0x07, 0x7F, 0x06, 0x03, 0x3F, 0x83, 0xC3, 0xBF, 0xC1,
  0xF9, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0x80,
  0x1F, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xFE, 0x07, 0xF0, 0x03, 0xF3, 0xF8,
  0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0xFE, 0x00, 0x7F, 0x3F, 0x87, 0xF0, 0x01,
  0xF8, 0xFE, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xC3,
  0xF0, 0x00, 0xFE, 0x3F, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x7E, 0x00, 0x0F,
  0xC7, 0xF3, 0xF8, 0x00, 0x3F, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0xFE, 0x7F,
  0x3F, 0xF3, 0xFF, 0xF3, 0xF9, 0xFF, 0xEF, 0xFF, 0xCF, 0xC7, 0xFF, 0xBF,
  0xFE, 0x7F, 0x3F, 0xFF, 0x7F, 0xF1, 0xF9, 0xFF, 0xFC, 0xFF, 0x8F, 0xE7,
  0xE3, 0xF1, 0xFC, 0x3F, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x3F, 0x00,
  0x0F, 0xE3, 0xF1, 0xFC, 0x00, 0x3F, 0x9F, 0xC7, 0xF0, 0x01, 0xFC, 0x7F,
  0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x7E, 0x00, 0x3F, 0x87, 0xE1, 0xF8, 0x00,
  0xFC, 0x1F, 0x8F, 0xE0, 0x07, 0xF0, 0x7E, 0x3F, 0x00, 0x1F, 0x81, 0xF9,
  0xFC, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0x1F,
  0x80, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFF,
  0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE,
  0x3F, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xE3, 0xFE, 0x07, 0xFF,
  0xF3, 0xFE, 0x0F, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xF8, 0x7F, 0xCF, 0xFF, 0xF0, 0x7F, 0xCF,
  0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x3F, 0xE7, 0xF9, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x20, 0xFE, 0x00,
  0xC3, 0xF8, 0x07, 0xCF, 0xE0, 0x1F, 0xBF, 0x0E, 0x7F, 0xFD, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xE7, 0xF0, 0x3F, 0x1F, 0xE0, 0x7C, 0x7F, 0x00, 0xE0,
  0xF8, 0x01, 0x83, 0x80, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x00, 0x3F,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xFC, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFB,
  0xFC, 0x7E, 0x06, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xF9, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xF8, 0xFF, 0x0F,
  0xF3, 0xFE, 0x1F, 0xE7, 0xFC, 0x3F, 0xCF, 0xF0, 0x7F, 0xBF, 0xE1, 0xFF,
  0x7F, 0xC3, 0xFE, 0xFF, 0x87, 0xFD, 0xFE, 0x0F, 0xFB, 0xFC, 0x1F, 0xEF,
  0xF8, 0x7F, 0xDF, 0xF0, 0xFF, 0xBF, 0xE1, 0xFF, 0x7F, 0x83, 0xFC, 0xFF,
  0x0F, 0xF9, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F, 0xC7, 0xF8, 0xFF, 0x8F, 0xF1,
  0xFF, 0x1F, 0xE7, 0xFC, 0x3F, 0xCF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xC7, 0xF7, 0xF8, 0x7E, 0xFF, 0x83, 0xCF, 0xF8, 0x18,
  0xFF, 0x81, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFB, 0xFF, 0x01, 0xF8, 0x7F, 0xC0,
  0x38, 0x1F, 0xF0, 0x0C, 0x07, 0xFC, 0x01, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xF3, 0xFF, 0x01,
  0xC0, 0xFF, 0x80, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x88, 0x00, 0xFF, 0xC6, 0x00, 0x7F, 0xE3, 0xE0, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x07, 0xEF, 0xF0, 0x03, 0xF3, 0xFC, 0x01, 0xFD, 0xFF, 0x00, 0x7E,
  0x7F, 0xC0, 0x3F, 0x1F, 0xF0, 0x1F, 0xC7, 0xF8, 0x07, 0xE1, 0xFE, 0x03,
  0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xBC, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x20, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x08, 0x01, 0xFF, 0x86, 0x00,
  0xFF, 0xC3, 0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFE, 0x04, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x3F, 0x00, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFE, 0xFF, 0xC7,
  0xFE, 0x3F, 0xE3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC,
  0x7F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0xFF,
  0x87, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF1, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFF,
  0x1F, 0xF0, 0x7F, 0xC7, 0xF8, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x00,
  0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F,
  0xE3, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8,
  0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xFD, 0xFF,
  0x0F, 0xF8, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF,
  0x1F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF, 0x3F, 0xE1, 0xFF,
  0x3F, 0xE3, 0xFF, 0x3F, 0xE7, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFC,
  0x07, 0xE7, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x80, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x07,
  0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFE, 0x07,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x03,
  0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x01,
  0xF8, 0x01, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xF1, 0xFF, 0x1C,
  0x0F, 0xF1, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0xFC, 0x7C, 0x1F, 0xC3, 0xFF, 0xF3,
  0xE0, 0xFC, 0x3F, 0xFF, 0x1F, 0x8F, 0xE3, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F,
  0x8F, 0xC7, 0xC3, 0xE1, 0xF8, 0x7E, 0x3E, 0x3F, 0x1F, 0x87, 0xE1, 0xF1,
  0xF8, 0xFC, 0x3F, 0x0F, 0x8F, 0x8F, 0xE1, 0xF8, 0xFC, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE7, 0xE3, 0xF0, 0xFC, 0x3F, 0x3F, 0x1F, 0x87, 0xE1, 0xF1, 0xF1,
  0xF8, 0x3F, 0x1F, 0x9F, 0x8F, 0xC3, 0xF8, 0xFC, 0xFC, 0x7E, 0x1F, 0x87,
  0xC7, 0xE3, 0xF0, 0xFC, 0x7E, 0x3F, 0x1F, 0xCF, 0xE7, 0xE1, 0xF8, 0xFF,
  0xFF, 0xFE, 0x0F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7E, 0x1F, 0xFB, 0xFF, 0x03,
  0xF0, 0x7F, 0x9F, 0xF0, 0x1F, 0x81, 0xF0, 0x7E, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x7F,
  0x00, 0x03, 0x80, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1,
  0xFF, 0x01, 0xFF, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0x01, 0xFF,
  0x3F, 0xF0, 0x1F, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x1F, 0xF7, 0xFE,
  0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xE7,
  0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC7, 0xFE, 0x07, 0xFC,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0x83, 0xFC, 0x3F, 0xF0, 0x7F, 0xCF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFE, 0xF8,
  0x0F, 0xFE, 0x06, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x18, 0x0F,
  0xFE, 0x3E, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFE,
  0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE,
  0x1F, 0xF8, 0x1F, 0xE3, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xF9, 0xF8, 0x07, 0xFE, 0x01, 0x80, 0x7F, 0xE0, 0x04, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0xC3, 0xFE,
  0x1F, 0xFE, 0x1F, 0xF1, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF, 0x8F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xC3, 0xFF, 0xC3, 0xFE, 0x1F, 0xFE, 0x1F, 0xF1, 0x1F, 0xF0,
  0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0x8F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x07,
  0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x21, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF0, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x07, 0xFC, 0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x87, 0xFF, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x07, 0xFF, 0xF9, 0xFF, 0xFE,
  0x03, 0xFF, 0xFD, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0xFE, 0xFF, 0x01, 0xFF,
  0xFF, 0x7F, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0, 0x7F, 0x9F, 0xFF,
  0xBF, 0xE0, 0x3F, 0xCF, 0xFF, 0x9F, 0xE0, 0x1F, 0xE7, 0xFF, 0xCF, 0xF0,
  0x1F, 0xF3, 0xFF, 0xEF, 0xF8, 0x0F, 0xF9, 0xFF, 0xE7, 0xFC, 0x07, 0xF8,
  0xFF, 0xF3, 0xFE, 0x03, 0xFC, 0x7F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xF8,
  0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xFC, 0x7F, 0xC0,
  0x7F, 0x87, 0xFC, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0x3F, 0xE1,
  0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x87,
  0xFC, 0x07, 0xF8, 0x3F, 0x83, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xC0,
  0x7F, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xF8, 0x1F, 0xE0, 0x3F, 0xFE, 0x07,
  0xF8, 0x0F, 0xFF, 0x83, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0xF8,
  0x3F, 0xC0, 0x3F, 0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xC7, 0xFC, 0x07, 0xFF,
  0xF1, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0x1F, 0xE0, 0x3F,
  0xFF, 0xC7, 0xF8, 0x0F, 0xF7, 0xFB, 0xFE, 0x03, 0xFD, 0xFE, 0xFF, 0x80,
  0xFF, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xEF, 0xF0, 0x1F, 0xF7, 0xFB, 0xFC,
  0x07, 0xF9, 0xFE, 0xFF, 0x01, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F, 0x8F, 0xFF,
  0xE0, 0x1F, 0xE3, 0xFF, 0xF8, 0x0F, 0xF8, 0xFF, 0xFE, 0x03, 0xFC, 0x3F,
  0xFF, 0x80, 0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xC1, 0xFF, 0xF0, 0x0F, 0xF0,
  0x7F, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xC0, 0x7F,
  0x81, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF,
  0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x1F, 0xF3, 0xFE,
  0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x1F,
  0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07,
  0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xCF,
  0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0xEF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x3F,
  0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF,
  0x81, 0xFF, 0x1F, 0xF8, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0xF0, 0x1F,
  0xF3, 0xFE, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xFE, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF,
  0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFC, 0xFF, 0x80,
  0xFF, 0xCF, 0xF8, 0x1F, 0xF8, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0,
  0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0x03,
  0xFC, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC3,
  0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0xFF, 0x87, 0xFC, 0x0F, 0xF9, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFE,
  0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x0F, 0x00, 0xFF, 0xC0, 0x60, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x10, 0x03, 0xFE, 0x03,
  0x00, 0x7F, 0xC0, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFC,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF,
  0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC3, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x7F,
  0xC0, 0x3F, 0xEF, 0xF8, 0x0F, 0xFD, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x7F,
  0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3,
  0xFE, 0x03, 0xFE, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFE, 0x01,
  0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0xFF, 0x9F, 0xE0, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0x1F, 0xF1,
  0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x7F, 0x83,
  0xFF, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0xC3,
  0xFE, 0x0F, 0xF0, 0xFF, 0xE1, 0xFE, 0x0F, 0xF8, 0xFF, 0xF1, 0xFF, 0x07,
  0xFC, 0x7F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F, 0xFC, 0x7F, 0x81, 0xFF, 0x3F,
  0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xFF, 0x3F, 0xE0, 0x7F, 0xDF, 0xFF, 0xBF,
  0xE0, 0x3F, 0xEF, 0xFF, 0xDF, 0xF0, 0x1F, 0xE7, 0xFF, 0xEF, 0xF0, 0x0F,
  0xF7, 0xFF, 0xEF, 0xF8, 0x07, 0xFB, 0xFF, 0xF7, 0xFC, 0x03, 0xFF, 0xFF,
  0xFB, 0xFC, 0x01, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x9F, 0xFF, 0x80, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x07, 0xFF, 0xC7,
  0xFF, 0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x01, 0xFF, 0xE1, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x1F, 0xF1, 0xFF,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF3,
  0xFE, 0x07, 0xFC, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x7F,
  0xC1, 0xFF, 0x1F, 0xF0, 0x7F, 0xCF, 0xF8, 0x1F, 0xF3, 0xFC, 0x07, 0xFD,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xF0, 0x0F,
  0xF3, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0xFF, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03,
  0xF9, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xF1, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F,
  0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0x40, 0x7F, 0x8F, 0xE0,
  0x3F, 0xF7, 0xF8, 0x1F, 0xFD, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xBF, 0xC0,
  0x3F, 0xCF, 0xF0, 0x07, 0xE3, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xC0, 0x0F, 0xFB,
  0xFC, 0x03, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xC7, 0xFC,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07,
  0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC7, 0xFC, 0x1F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE3, 0xFE, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xDF,
  0xFC, 0x07, 0xF3, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0x78, 0x3F, 0xF0,
  0x60, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x04,
  0x0F, 0xF8, 0x70, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x78, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFF, 0x7F, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x03, 0xFE, 0x1F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC,
  0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFC,
  0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF8,
  0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0xC3, 0xFC, 0xFF, 0x07, 0xFB, 0xFE, 0x3F,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x18, 0x7F, 0xE3, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x03, 0xF8, 0xFE,
  0x00, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF8, 0xFF,
  0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xF8, 0x1F,
  0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x03,
  0xFE, 0x1F, 0xF0, 0x3F, 0xC3, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE7,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFE,
  0x7F, 0x80, 0x01, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8,
  0x08, 0x00, 0xFF, 0x80, 0xC0, 0x1F, 0xF0, 0x0F, 0xC7, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xC0,
  0x0F, 0xFB, 0xFC, 0x03, 0xFD, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x40, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xC3, 0xFE, 0x00, 0xFF,
  0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0x7F, 0x9F,
  0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xF9,
  0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F,
  0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFE, 0x0F, 0xF8,
  0x07, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x07, 0xF1, 0xFE, 0x1F, 0xF0, 0x0F, 0xE7, 0xFE, 0x7F, 0xF0,
  0x1F, 0xDF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFC, 0x7F, 0xE7, 0xFC, 0x0F, 0xF8, 0xFF, 0x8F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xF8, 0x7F,
  0xC1, 0xFE, 0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF8,
  0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x1F,
  0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFE,
  0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x87,
  0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF,
  0x87, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE1,
  0xFF, 0x07, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xF8, 0x0F, 0xEF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFD,
  0xFF, 0x1F, 0xE1, 0xFE, 0x7F, 0xC3, 0xFC, 0xFF, 0x07, 0xFB, 0xFE, 0x0F,
  0xF7, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF7, 0xFC, 0x3F, 0xEF,
  0xF0, 0x7F, 0xDF, 0xF1, 0xFF, 0x3F, 0xE3, 0xFE, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0xE0, 0x0F, 0xEF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFD, 0xFF,
  0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xC1, 0xFF, 0x03, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x07,
  0xF8, 0x3F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87,
  0xFC, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xC0, 0x1F, 0xEF,
  0xF8, 0x03, 0xFE, 0x7F, 0x00, 0x3F, 0xE0, 0x80, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3F, 0x8F, 0xE0, 0x3F, 0xF7,
  0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xF3, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xF0, 0xFF,
  0x87, 0xF8, 0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x3F, 0xE0,
  0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xE3, 0xFE, 0x0F, 0xF9, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xE7, 0xF8, 0x00, 0x41, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x0F, 0xE3, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0xFF, 0x03, 0xFB,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFE, 0xC0, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFE, 0x3C, 0x1F, 0xF0, 0x40, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x40, 0x3F, 0xE3, 0x81, 0xFF, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFC,
  0x7F, 0xFF, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF,
  0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x10, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0x08, 0x00, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x8F,
  0xF8, 0x3F, 0xE7, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0x01, 0xFF, 0x9F, 0xC0,
  0x1F, 0xC7, 0xF0, 0x01, 0x80, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0x83,
  0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0x83, 0xFC, 0xFF, 0x87, 0xFC, 0x7F, 0x87,
  0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0x9F,
  0xF0, 0x7F, 0x9F, 0xE0, 0x7F, 0xBF, 0xE0, 0x7F, 0xBF, 0xC0, 0x7F, 0xBF,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x87,
  0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xE1, 0xFE, 0xFF, 0x8F, 0xFE, 0x3F, 0xEF,
  0xF0, 0xFF, 0xE3, 0xFC, 0xFF, 0x1F, 0xFE, 0x3F, 0xCF, 0xF1, 0xFF, 0xC7,
  0xFC, 0xFF, 0x1F, 0xFC, 0x7F, 0x8F, 0xF3, 0xFF, 0xC7, 0xF8, 0xFF, 0x3F,
  0xFC, 0xFF, 0x0F, 0xF3, 0xFF, 0xCF, 0xF0, 0xFF, 0x7F, 0xFD, 0xFF, 0x0F,
  0xF7, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFD, 0xFF, 0xFC, 0x0F, 0xFF, 0xDF, 0xFF, 0x80, 0xFF, 0xFD,
  0xFF, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xF0, 0x0F,
  0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0x1F, 0xFE,
  0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xE1,
  0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F,
  0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x0F,
  0xFC, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x03,
  0xFE, 0xFF, 0x80, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0x83,
  0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFE,
  0x00, 0x7F, 0x8F, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF9, 0xFF, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0x3F, 0xF0, 0x03, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFE, 0x80, 0x07, 0xF8,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 17, 39, 14, 0, -38 },
  { 84, 22, 14, 24, 5, -38 },
  { 123, 30, 38, 28, 0, -38 },
  { 266, 25, 43, 25, 1, -40 },
  { 401, 38, 38, 42, 3, -38 },
  { 582, 32, 39, 32, 0, -38 },
  { 738, 11, 14, 13, 5, -38 },
  { 758, 19, 47, 15, 1, -39 },
  { 870, 19, 47, 15, -4, -39 },
  { 982, 22, 25, 23, 4, -41 },
  { 1051, 23, 26, 27, 2, -32 },
  { 1126, 13, 15, 14, -3, -8 },
  { 1151, 16, 8, 16, 0, -18 },
  { 1167, 10, 10, 14, 0, -9 },
  { 1180, 29, 39, 21, -3, -38 },
  { 1322, 23, 39, 25, 2, -38 },
  { 1435, 20, 38, 25, 5, -38 },
  { 1530, 26, 38, 25, -1, -38 },
  { 1654, 25, 39, 25, 0, -38 },
  { 1776, 26, 38, 25, 0, -38 },
  { 1900, 25, 39, 25, 1, -38 },
  { 2022, 25, 39, 25, 2, -38 },
  { 2144, 27, 38, 25, 1, -38 },
  { 2273, 26, 39, 25, 0, -38 },
  { 2400, 24, 39, 25, 1, -38 },
  { 2517, 14, 31, 14, 0, -30 },
  { 2572, 17, 37, 14, -3, -30 },
  { 2651, 23, 26, 27, 2, -32 },
  { 2726, 23, 19, 27, 2, -28 },
  { 2781, 24, 26, 27, 2, -32 },
  { 2859, 20, 39, 20, 2, -38 },
  { 2957, 37, 42, 37, 1, -38 },
  { 3152, 28, 38, 28, -3, -38 },
  { 3285, 28, 38, 27, 0, -38 },
  { 3418, 26, 39, 25, 2, -38 },
  { 3545, 29, 38, 29, 0, -38 },
  { 3683, 25, 38, 22, 0, -38 },
  { 3802, 25, 38, 22, 0, -38 },
  { 3921, 29, 39, 29, 2, -38 },
  { 4063, 32, 38, 30, 0, -38 },
  { 4215, 26, 38, 20, -2, -38 },
  { 4339, 25, 50, 15, -8, -38 },
  { 4496, 33, 38, 27, 0, -38 },
  { 4653, 19, 38, 21, 0, -38 },
  { 4744, 41, 38, 39, 0, -38 },
  { 4939, 34, 38, 32, 0, -38 },
  { 5101, 28, 39, 30, 2, -38 },
  { 5238, 27, 38, 26, 0, -38 },
  { 5367, 28, 47, 30, 2, -38 },
  { 5532, 28, 38, 27, 0, -38 },
  { 5665, 27, 39, 23, -1, -38 },
  { 5797, 23, 38, 23, 4, -38 },
  { 5907, 29, 39, 29, 2, -38 },
  { 6049, 27, 38, 28, 5, -38 },
  { 6178, 41, 38, 39, 3, -38 },
  { 6373, 33, 38, 27, -3, -38 },
  { 6530, 26, 38, 26, 5, -38 },
  { 6654, 29, 38, 23, -2, -38 },
  { 6792, 23, 48, 15, -3, -39 },
  { 6930, 13, 39, 21, 5, -38 },
  { 6994, 22, 48, 15, -4, -39 },
  { 7126, 26, 25, 25, -1, -38 },
  { 7208, 22, 7, 20, -5, 3 },
  { 7228, 11, 9, 17, 8, -41 },
  { 7241, 26, 31, 26, 1, -30 },
  { 7342, 26, 41, 26, -1, -40 },
  { 7476, 22, 31, 21, 1, -30 },
  { 7562, 28, 41, 26, 1, -40 },
  { 7706, 23, 31, 24, 1, -30 },
  { 7796, 28, 54, 16, -6, -41 },
  { 7985, 28, 43, 26, -1, -30 },
  { 8136, 26, 40, 26, -1, -40 },
  { 8266, 17, 41, 13, -1, -41 },
  { 8354, 23, 54, 13, -7, -41 },
  { 8510, 30, 40, 26, -1, -40 },
  { 8660, 17, 40, 13, -1, -40 },
  { 8745, 39, 30, 38, -1, -30 },
  { 8892, 26, 30, 26, -1, -30 },
  { 8990, 23, 31, 25, 1, -30 },
  { 9080, 28, 43, 26, -3, -30 },
  { 9231, 26, 43, 26, 1, -30 },
  { 9371, 22, 30, 19, -1, -30 },
  { 9454, 21, 31, 21, 0, -30 },
  { 9536, 18, 36, 18, 2, -35 },
  { 9617, 26, 30, 26, 1, -29 },
  { 9715, 24, 29, 24, 3, -29 },
  { 9802, 36, 29, 36, 3, -29 },
  { 9933, 30, 29, 24, -3, -29 },
  { 10042, 30, 42, 24, -3, -29 },
  { 10200, 24, 29, 21, -2, -29 },
  { 10287, 22, 46, 18, 0, -38 },
  { 10414, 7, 53, 21, 7, -41 },
  { 10461, 21, 46, 18, -3, -38 },
  { 10582, 24, 10, 27, 2, -24 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC53PT7B_H_
