#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC31PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F,
  0xC3, 0xF0, 0xF8, 0x3C, 0x00, 0x7D, 0xFB, 0xEF, 0x9F, 0x7D, 0xF3, 0xEF,
  0x9E, 0x7C, 0xF3, 0xC7, 0x9E, 0x7C, 0x01, 0xE7, 0x80, 0xF3, 0x80, 0x73,
  0xC0, 0x79, 0xE0, 0x3C, 0xE0, 0x1C, 0xF0, 0x7F, 0xFE, 0x7F, 0xFF, 0x3F,
  0xFF, 0x83, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x00, 0xE7, 0x83, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFC, 0x3C, 0xF0, 0x1E, 0x70, 0x0E, 0x78, 0x0F, 0x3C,
  0x07, 0x9C, 0x03, 0x9E, 0x00, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x1F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x0F, 0x66, 0x1E, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x43,
  0x78, 0xC6, 0xF1, 0xEF, 0xE3, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x07, 0xE0,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x1F, 0x01, 0xE0, 0xFE, 0x0F, 0x07,
  0xF8, 0x38, 0x1E, 0xF1, 0xE0, 0xF3, 0xCF, 0x03, 0xCF, 0x3C, 0x0F, 0x39,
  0xE0, 0x3D, 0xE7, 0x80, 0xE7, 0xBC, 0x63, 0x9C, 0xF7, 0xEF, 0xF7, 0xBF,
  0xBF, 0x9C, 0xFF, 0x7C, 0xF7, 0xBC, 0x07, 0x9C, 0xF0, 0x1E, 0xF3, 0xC0,
  0xF3, 0xCF, 0x03, 0xCF, 0x38, 0x1E, 0x3D, 0xE0, 0x70, 0xF7, 0x83, 0xC3,
  0xFC, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x03, 0xEF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFE, 0x04, 0x3F, 0x9F, 0x0F, 0xFB, 0xE3,
  0xFF, 0xF8, 0xFB, 0xFF, 0x1F, 0x7F, 0xC7, 0xC7, 0xF8, 0xF8, 0xFE, 0x1F,
  0x9F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0x7F, 0x00,
  0x7D, 0xF7, 0xFE, 0xFB, 0xEF, 0x3C, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC0,
  0x7C, 0x0F, 0x80, 0x07, 0x40, 0x3C, 0x01, 0xE0, 0xCF, 0x07, 0xFB, 0xBF,
  0xFF, 0xFF, 0xE7, 0xFF, 0x1F, 0x81, 0xFE, 0x1F, 0xF0, 0xFB, 0xC3, 0x9F,
  0x08, 0xE0, 0x04, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x1F, 0x3E, 0x3E,
  0x3E, 0x7C, 0x7C, 0x78, 0xF8, 0x7F, 0xBF, 0xDF, 0xEF, 0xFF, 0xF0, 0x7B,
  0xFF, 0xFE, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0x1F, 0x7C, 0xF9,
  0xF3, 0xE7, 0xDF, 0x1F, 0x7C, 0x7D, 0xF3, 0xF7, 0xCF, 0xBE, 0x3E, 0xF8,
  0xFB, 0xE3, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xEF, 0x8F, 0xFC, 0x3F,
  0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x0F, 0xE1, 0xFE, 0x3F,
  0xE7, 0xFE, 0xFF, 0xCF, 0xFC, 0x77, 0xC2, 0x7C, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFF, 0x07, 0x3F,
  0x06, 0x3E, 0x04, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xC7, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x7C, 0x81, 0xF9, 0x87, 0xE3, 0xFF, 0xC7, 0xFF, 0x0F,
  0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xBC, 0x0F, 0xF8, 0x3D, 0xF0, 0x73,
  0xE1, 0xE7, 0xC7, 0x9F, 0x0F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xA0,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x83, 0xF3, 0x1F, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x70, 0x7D, 0xF0, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0xCF,
  0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0xFC, 0xF9, 0xF1, 0xF7, 0xE3, 0xFF,
  0x83, 0xFF, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F,
  0xF9, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF1, 0xF3, 0xE3, 0xE7,
  0xC7, 0xCF, 0x8F, 0xBE, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0xFF, 0x83,
  0xFF, 0x8F, 0xDF, 0x1F, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xF3, 0xFF,
  0xC3, 0xFF, 0x87, 0xFE, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xE1, 0xF3, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7E,
  0x7C, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC3, 0xFF, 0x03, 0x3E, 0x00,
  0x7C, 0x01, 0xF1, 0x0F, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0,
  0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xFC, 0xFC, 0xF8, 0xF8, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0x00, 0x04, 0x00,
  0x70, 0x07, 0xC0, 0x7F, 0x0F, 0xFC, 0xFF, 0xCF, 0xF8, 0x3F, 0x80, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x00, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03, 0x80,
  0x0F, 0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0x03,
  0xFC, 0x3F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20,
  0x00, 0x0F, 0xE3, 0xFF, 0x3F, 0xF3, 0xFF, 0x31, 0xF2, 0x1F, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0x00, 0x7F,
  0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0x01, 0xE0, 0xF0, 0x07, 0x8F,
  0x1F, 0x3C, 0xF3, 0xFC, 0xE7, 0x3F, 0xE7, 0x79, 0xEF, 0x3B, 0x9E, 0x79,
  0xDC, 0xE3, 0x9F, 0xEF, 0x1C, 0xEE, 0x79, 0xE7, 0x73, 0xCF, 0x3B, 0x9E,
  0x73, 0x9C, 0xFF, 0xFC, 0xE7, 0xFF, 0xC7, 0x1F, 0x7C, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x60, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x01, 0xE7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F,
  0xFF, 0x9F, 0xFF, 0xCF, 0x87, 0xEF, 0xC3, 0xF7, 0xC1, 0xFF, 0xE0, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0x9F, 0x1F, 0x9F,
  0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7D, 0xFC,
  0x7F, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0x8C, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x60, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFB, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x9F,
  0x8F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF1, 0xF9, 0xF8, 0xF8,
  0xF8, 0xFC, 0x7C, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xFF,
  0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0xE1,
  0xFC, 0x61, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x7F,
  0x9F, 0x3F, 0x9F, 0x9F, 0xCF, 0xCF, 0xE7, 0xE9, 0xF3, 0xF1, 0xF1, 0xF8,
  0xF8, 0xFC, 0x7C, 0x7F, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x00, 0x0F, 0xC7, 0xE1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x3F, 0x1F, 0x87, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0xFF, 0x87,
  0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7C, 0x3E, 0x1F,
  0x8F, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7E,
  0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xE1, 0xF1,
  0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0xC0, 0xFB, 0xF0, 0x3F, 0x7C, 0x07, 0xDF,
  0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xBE, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0x8F, 0xC1, 0xF0, 0xF8,
  0x00, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C,
  0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFE, 0x1F,
  0xE1, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xE7, 0xFC, 0x3F,
  0xE7, 0xFC, 0x3F, 0xF7, 0xFC, 0x3F, 0xFF, 0x7C, 0x3F, 0xFF, 0x7C, 0x3F,
  0xFE, 0xF8, 0x7D, 0xFE, 0xF8, 0x7D, 0xFE, 0xF8, 0x7D, 0xFC, 0xF8, 0x7D,
  0xFD, 0xF0, 0x79, 0xF9, 0xF0, 0xF9, 0xF9, 0xF0, 0xF9, 0xF1, 0xF0, 0xF9,
  0xF1, 0xF0, 0x0F, 0xC1, 0xF0, 0xFE, 0x1F, 0x0F, 0xE1, 0xE0, 0xFE, 0x3E,
  0x0F, 0xE3, 0xE1, 0xFE, 0x3E, 0x1F, 0xE3, 0xE1, 0xFF, 0x3C, 0x1F, 0xF7,
  0xC3, 0xFF, 0x7C, 0x3E, 0xF7, 0xC3, 0xEF, 0x7C, 0x3E, 0xFF, 0x83, 0xEF,
  0xF8, 0x7C, 0xFF, 0x87, 0xCF, 0xF8, 0x7C, 0x7F, 0x87, 0xC7, 0xF0, 0x78,
  0x7F, 0x0F, 0x87, 0xF0, 0xF8, 0x7F, 0x0F, 0x87, 0xE0, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF9, 0xF9, 0xF8, 0xFC, 0xF8, 0x7E,
  0xFC, 0x3F, 0x7E, 0x1F, 0xBE, 0x0F, 0xDF, 0x07, 0xFF, 0x83, 0xEF, 0xC1,
  0xF7, 0xE1, 0xFB, 0xF0, 0xF9, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x7E, 0x1F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xFE,
  0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xBF, 0x1F, 0x9F, 0x1F, 0x3F, 0x1F, 0x3F,
  0x1F, 0x3E, 0x3F, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE1, 0xF9, 0xF9, 0xF8, 0xFC, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F, 0xBE,
  0x0F, 0xDF, 0x07, 0xDF, 0x83, 0xEF, 0xC1, 0xF7, 0xE1, 0xFB, 0xF0, 0xF9,
  0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x7E, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xBF,
  0x1F, 0x9F, 0x1F, 0x1F, 0x1F, 0x3F, 0x1F, 0x3F, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7D, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xFC, 0xF8, 0xFC, 0xF8, 0xFC, 0x01, 0xFE,
  0x07, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0xDE, 0x0F, 0x84, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x60, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0x9F,
  0xFE, 0x8F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x8F, 0x8F,
  0x87, 0xC7, 0xC7, 0xE3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C,
  0x7C, 0x7E, 0x3E, 0x3E, 0x3F, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC7,
  0xE3, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0xFC, 0x7E, 0xFC, 0x3F,
  0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xF8, 0x3F, 0xF8, 0x3E,
  0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF8,
  0xF9, 0xF0, 0xF9, 0xF0, 0xFB, 0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x3C, 0x3F, 0x7C, 0x3C, 0x3E, 0x7C, 0x7C,
  0x3E, 0x7C, 0x7C, 0x7E, 0x7C, 0xFC, 0x7C, 0x7C, 0xFC, 0x7C, 0x7C, 0xFC,
  0xF8, 0x79, 0xFC, 0xF8, 0x79, 0xFC, 0xF8, 0x7B, 0xFD, 0xF0, 0xFB, 0xFD,
  0xF0, 0xFB, 0xFF, 0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0xBF, 0xE0, 0xFF, 0xBF,
  0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE3,
  0xF0, 0x7E, 0x7E, 0x03, 0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xF7, 0xE0, 0x3F, 0x3E, 0x03, 0xE3, 0xE0,
  0x7E, 0x3E, 0x0F, 0xC3, 0xF0, 0xF8, 0x7F, 0xF0, 0xFB, 0xE3, 0xF7, 0xE7,
  0xC7, 0xDF, 0x0F, 0xBE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0xF9, 0xF3, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x7C, 0xF9, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0x7C,
  0x78, 0xF1, 0xE3, 0xC0, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBC, 0x0F, 0xBC, 0x0F, 0x3C, 0x1F, 0x3E,
  0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0xF8, 0x1F, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFD, 0xFF, 0xE0, 0xFC, 0xF8, 0xF9, 0xF1, 0xE0, 0x07, 0x9F, 0x0F, 0xDE,
  0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x7E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0xFC, 0xF8, 0xFD, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF0, 0x7E, 0xF0, 0x3C, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xBC, 0x1F, 0xFC, 0x3F,
  0xF8, 0xFF, 0xF9, 0xFB, 0xF3, 0xE3, 0xE7, 0xCF, 0xCF, 0x1F, 0x3E, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF9, 0xF3, 0xE3, 0xE7, 0xCF, 0xFF, 0x9F, 0xFE, 0x3D,
  0xF8, 0x79, 0xE0, 0x0F, 0xF1, 0xFF, 0x3F, 0xE3, 0xFE, 0x7E, 0x27, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x8F, 0xF8,
  0xFF, 0x87, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFF, 0x0F, 0xFF, 0x87, 0xCF, 0xC3, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x7C, 0x3F, 0x3E, 0x1F, 0xBF, 0x07,
  0xFF, 0x83, 0xFF, 0x81, 0xFB, 0xC0, 0x79, 0xE0, 0x07, 0xE0, 0xFF, 0x8F,
  0xFE, 0x7D, 0xF7, 0xC7, 0xBE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC,
  0x3C, 0x01, 0xE0, 0x0F, 0x82, 0x7F, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0x80,
  0x00, 0x1C, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x03, 0xEF, 0x83, 0xF7, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xF3,
  0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1E, 0x1F,
  0x9F, 0x0F, 0xCF, 0x87, 0xEF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1E, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x10, 0x3E, 0x0F, 0xFF, 0x07, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xFC,
  0xFF, 0xF9, 0xFB, 0xF3, 0xE7, 0xE7, 0xCF, 0x8F, 0x9F, 0x3E, 0x3E, 0x7C,
  0x7C, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7C,
  0x7C, 0xF8, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x3E, 0x1F,
  0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x3F, 0x1F, 0x3E, 0x0F, 0xBF, 0x0F, 0x9F, 0x07, 0xDF, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x7C,
  0x0F, 0x3E, 0x0F, 0x9F, 0x87, 0xCF, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0x07,
  0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x1E, 0xFC, 0xF8, 0x7F, 0xF7, 0xF1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x7E, 0x7C, 0xF9, 0xF9, 0xF3, 0xE7, 0xC7,
  0xCF, 0x9F, 0x3E, 0x7C, 0x7C, 0xF9, 0xF1, 0xF3, 0xE7, 0xCF, 0x8F, 0x9F,
  0x3E, 0x3C, 0x7C, 0xF9, 0xF3, 0xE3, 0xE7, 0xCF, 0x9F, 0x1F, 0x3E, 0x7C,
  0x7C, 0xF9, 0xF3, 0xE0, 0x1E, 0xFC, 0x3F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF3,
  0xF7, 0xE7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF3,
  0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0xF8, 0xF9, 0xF0,
  0x0F, 0xE0, 0xFF, 0x8F, 0xFE, 0x7F, 0xF7, 0xCF, 0xBE, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x7F, 0xF3, 0xEF, 0x9F, 0x7F, 0xF3, 0xFF,
  0x8F, 0xF8, 0x3F, 0x00, 0x07, 0x9E, 0x03, 0xDF, 0x81, 0xFF, 0xC1, 0xFF,
  0xF0, 0xFD, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x3E, 0x1F, 0x1F, 0x0F,
  0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xE1, 0xF3, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF0, 0x3E, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xDF, 0x0F, 0xDE, 0x1F,
  0xFE, 0x3F, 0xFE, 0x3E, 0x7E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x78, 0xFC, 0xF8, 0xFC, 0xF8, 0xFD, 0xF8, 0xFF, 0xF8, 0x7F,
  0xF0, 0x7F, 0xF0, 0x3D, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x1E, 0x78, 0xF7, 0x87, 0xFC,
  0x7F, 0xC3, 0xFE, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x0F,
  0xF0, 0xFF, 0xCF, 0xFC, 0x7F, 0xC3, 0xE2, 0x1F, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xCC, 0x7E, 0x7F, 0xE3, 0xFF, 0x1F,
  0xF0, 0xFF, 0x00, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x83, 0xFE, 0xFF, 0x9F,
  0xF7, 0xFE, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07,
  0xC0, 0xF9, 0x1F, 0xE3, 0xFC, 0x3F, 0x87, 0xF0, 0x3E, 0x3E, 0x7C, 0xF8,
  0xF9, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0xF8,
  0xF9, 0xF1, 0xF3, 0xE7, 0xC7, 0xCF, 0x8F, 0xBF, 0x1F, 0xFE, 0x3F, 0xFC,
  0x7F, 0xF0, 0x7D, 0xE0, 0xF8, 0xFF, 0xE3, 0xEF, 0x8F, 0xBE, 0x7C, 0xF9,
  0xF3, 0xEF, 0x8F, 0xBE, 0x3E, 0xF0, 0xFF, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xF9, 0xF8,
  0xFF, 0xCF, 0xCF, 0xBE, 0xFE, 0x7D, 0xF7, 0xF7, 0xCF, 0xBF, 0xBE, 0x7F,
  0xFD, 0xE3, 0xDF, 0xFF, 0x1E, 0xEF, 0xF8, 0xFF, 0x77, 0x87, 0xFB, 0xFC,
  0x3F, 0x9F, 0xC1, 0xFD, 0xFE, 0x0F, 0xEF, 0xF0, 0x7E, 0x7F, 0x03, 0xF3,
  0xF8, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC3, 0xF7, 0xE0,
  0x7D, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0xFC, 0x7C, 0x00, 0x0F, 0x8F,
  0xC3, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xEF, 0x80,
  0xFB, 0xE0, 0x3E, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFE, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x3C, 0x03, 0xF0, 0x1F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x78, 0x1F, 0xC1, 0xFE,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x81, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFE, 0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 10, 22, 8, 0, -22 },
  { 29, 13, 8, 14, 3, -22 },
  { 42, 17, 22, 16, 0, -22 },
  { 89, 15, 26, 15, 0, -24 },
  { 138, 22, 22, 25, 2, -22 },
  { 199, 19, 22, 19, 0, -22 },
  { 252, 6, 8, 7, 3, -22 },
  { 258, 11, 28, 9, 0, -23 },
  { 297, 12, 28, 9, -3, -23 },
  { 339, 13, 15, 14, 2, -24 },
  { 364, 14, 16, 16, 1, -19 },
  { 392, 8, 9, 8, -2, -5 },
  { 401, 9, 5, 10, 0, -11 },
  { 407, 6, 5, 8, 0, -5 },
  { 411, 17, 22, 12, -2, -22 },
  { 458, 14, 22, 15, 1, -22 },
  { 497, 12, 22, 15, 3, -22 },
  { 530, 16, 22, 15, -1, -22 },
  { 574, 15, 22, 15, 0, -22 },
  { 616, 15, 22, 15, 0, -22 },
  { 658, 14, 22, 15, 1, -22 },
  { 697, 15, 22, 15, 1, -22 },
  { 739, 15, 22, 15, 1, -22 },
  { 781, 15, 22, 15, 0, -22 },
  { 823, 15, 22, 15, 0, -22 },
  { 865, 8, 17, 8, 0, -17 },
  { 882, 10, 21, 8, -2, -17 },
  { 909, 14, 16, 16, 1, -19 },
  { 937, 14, 11, 16, 1, -16 },
  { 957, 14, 16, 16, 1, -19 },
  { 985, 12, 22, 12, 1, -22 },
  { 1018, 21, 24, 22, 1, -22 },
  { 1081, 17, 22, 16, -2, -22 },
  { 1128, 16, 22, 16, 0, -22 },
  { 1172, 16, 22, 15, 1, -22 },
  { 1216, 17, 22, 17, 0, -22 },
  { 1263, 15, 22, 13, 0, -22 },
  { 1305, 15, 22, 13, 0, -22 },
  { 1347, 17, 22, 17, 1, -22 },
  { 1394, 19, 22, 17, 0, -22 },
  { 1447, 15, 22, 12, -1, -22 },
  { 1489, 15, 29, 9, -5, -22 },
  { 1544, 19, 22, 16, 0, -22 },
  { 1597, 11, 22, 12, 0, -22 },
  { 1628, 24, 22, 23, 0, -22 },
  { 1694, 20, 22, 19, 0, -22 },
  { 1749, 17, 22, 18, 1, -22 },
  { 1796, 16, 22, 15, 0, -22 },
  { 1840, 17, 27, 18, 1, -22 },
  { 1898, 16, 22, 16, 0, -22 },
  { 1942, 16, 22, 13, -1, -22 },
  { 1986, 14, 22, 13, 2, -22 },
  { 2025, 17, 22, 17, 1, -22 },
  { 2072, 16, 22, 16, 3, -22 },
  { 2116, 24, 22, 23, 2, -22 },
  { 2182, 20, 22, 16, -2, -22 },
  { 2237, 15, 22, 15, 3, -22 },
  { 2279, 17, 22, 14, -1, -22 },
  { 2326, 13, 28, 9, -2, -23 },
  { 2372, 7, 22, 12, 3, -22 },
  { 2392, 13, 28, 9, -2, -23 },
  { 2438, 16, 15, 14, -1, -22 },
  { 2468, 13, 4, 12, -3, 2 },
  { 2475, 7, 5, 10, 4, -24 },
  { 2480, 16, 17, 15, 0, -17 },
  { 2514, 15, 24, 15, 0, -24 },
  { 2559, 12, 17, 12, 1, -17 },
  { 2585, 17, 24, 15, 0, -24 },
  { 2636, 13, 17, 14, 1, -17 },
  { 2664, 16, 31, 10, -3, -24 },
  { 2726, 17, 24, 15, -1, -17 },
  { 2777, 15, 24, 15, 0, -24 },
  { 2822, 9, 24, 8, 0, -24 },
  { 2849, 13, 31, 8, -4, -24 },
  { 2900, 17, 24, 15, 0, -24 },
  { 2951, 10, 24, 8, 0, -24 },
  { 2981, 22, 17, 22, 0, -17 },
  { 3028, 15, 17, 15, 0, -17 },
  { 3060, 13, 17, 15, 1, -17 },
  { 3088, 17, 24, 15, -2, -17 },
  { 3139, 16, 24, 15, 0, -17 },
  { 3187, 13, 17, 11, 0, -17 },
  { 3215, 13, 17, 12, 0, -17 },
  { 3243, 11, 21, 11, 1, -21 },
  { 3272, 15, 17, 15, 1, -17 },
  { 3304, 14, 17, 14, 2, -17 },
  { 3334, 21, 17, 21, 2, -17 },
  { 3379, 18, 17, 14, -2, -17 },
  { 3418, 18, 24, 14, -2, -17 },
  { 3472, 14, 17, 12, -1, -17 },
  { 3502, 13, 27, 11, 0, -22 },
  { 3546, 4, 31, 12, 4, -24 },
  { 3562, 13, 27, 11, -2, -22 },
  { 3606, 14, 6, 16, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC31PT7B_H_
