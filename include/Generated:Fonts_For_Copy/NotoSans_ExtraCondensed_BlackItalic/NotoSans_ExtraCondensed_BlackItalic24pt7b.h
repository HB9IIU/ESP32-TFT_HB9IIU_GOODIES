#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78,
  0x00, 0x00, 0x70, 0xF0, 0xF0, 0xF0, 0x7B, 0xDE, 0xF7, 0x39, 0xCE, 0xF7,
  0xBD, 0xE0, 0x03, 0xB8, 0x39, 0xC1, 0xDC, 0x0E, 0xE3, 0xFF, 0x9F, 0xFC,
  0xFF, 0xE3, 0x9C, 0x1D, 0xC0, 0xEE, 0x3F, 0xFD, 0xFF, 0xE3, 0xB8, 0x19,
  0xC1, 0xCC, 0x0E, 0xE0, 0xE7, 0x00, 0x01, 0x80, 0x18, 0x0F, 0xF1, 0xFE,
  0x1F, 0xE3, 0xF4, 0x3E, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x7C,
  0x45, 0xC6, 0x7C, 0x7F, 0x8F, 0xF8, 0x7E, 0x00, 0x80, 0x18, 0x00, 0x1E,
  0x0E, 0x0F, 0xC7, 0x07, 0x71, 0xC1, 0xDC, 0xE0, 0x77, 0x38, 0x39, 0xDC,
  0x0E, 0x6E, 0x23, 0xBB, 0xBE, 0x7D, 0xDF, 0x9F, 0x77, 0x60, 0x3B, 0x9C,
  0x0E, 0xEE, 0x07, 0x3B, 0x81, 0xCE, 0xE0, 0xE3, 0xF0, 0x70, 0xFC, 0x1C,
  0x1E, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0x7F,
  0x81, 0xFC, 0x03, 0xEF, 0x3F, 0xBD, 0xFE, 0xF7, 0xFF, 0xBC, 0xFC, 0xF3,
  0xF3, 0xCF, 0x8F, 0xFF, 0x1F, 0xFC, 0x7E, 0xF8, 0x7B, 0xDC, 0xEF, 0x78,
  0x07, 0x83, 0x83, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x07,
  0x07, 0x80, 0x0E, 0x23, 0x8E, 0xC7, 0xFE, 0xFF, 0x8F, 0xF3, 0xE3, 0xFC,
  0x77, 0x89, 0x80, 0x40, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xFF,
  0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0xE7, 0x9E, 0x73, 0xCE, 0x00,
  0x7E, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0x87, 0xF3,
  0xFC, 0xF7, 0x79, 0xDE, 0x77, 0xBF, 0xCF, 0xF3, 0xFC, 0xFF, 0x3F, 0xDE,
  0xE7, 0xBF, 0xCF, 0xF3, 0xF8, 0x7C, 0x00, 0x07, 0x87, 0xC7, 0xE7, 0xF7,
  0xF7, 0xF9, 0xBC, 0x9E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF0,
  0x78, 0x3C, 0x00, 0x07, 0xE0, 0xFF, 0x1F, 0xF0, 0xEF, 0x08, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xFC,
  0x7F, 0xC7, 0xFC, 0xFF, 0xC0, 0x0F, 0xC1, 0xFE, 0x1F, 0xE1, 0x9F, 0x01,
  0xE0, 0x1E, 0x07, 0xC1, 0xF8, 0x1F, 0x81, 0xFC, 0x03, 0xC0, 0x3C, 0x03,
  0xCC, 0x7C, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x7E, 0x07, 0xE0, 0xFC, 0x1F, 0xC1, 0xBC, 0x3B, 0xC7, 0x3C, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFC, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x0F, 0xF0, 0xFE,
  0x1F, 0xE1, 0xE0, 0x1C, 0x01, 0xC0, 0x3F, 0x83, 0xFC, 0x3F, 0xC1, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xCC, 0x7C, 0xFF, 0x8F, 0xF0, 0xFE, 0x00, 0x07,
  0xE1, 0xFC, 0x7F, 0x9F, 0x03, 0xC0, 0xF0, 0x1F, 0xE7, 0xFC, 0xFF, 0xDE,
  0x7B, 0xCF, 0x79, 0xEF, 0x79, 0xEF, 0x3F, 0xC3, 0xF8, 0x7E, 0x00, 0x3F,
  0xF3, 0xFE, 0x3F, 0xE4, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0,
  0x00, 0x07, 0xE0, 0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0xE1, 0xDE, 0x1F, 0xC1,
  0xF8, 0x1F, 0x83, 0xFC, 0x7B, 0xC7, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0x87,
  0xF8, 0x3F, 0x00, 0x07, 0xC3, 0xFC, 0x7F, 0x9E, 0xF3, 0xCE, 0x7B, 0xDE,
  0x7B, 0xEF, 0x7F, 0xE7, 0xFC, 0xF7, 0x01, 0xE0, 0x7C, 0x1F, 0x3F, 0xC7,
  0xF0, 0xFC, 0x00, 0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x3C,
  0xF0, 0x0E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0xE3, 0xC7,
  0x8E, 0x3C, 0x70, 0x00, 0x40, 0x30, 0x3C, 0x3F, 0x3F, 0xBF, 0x8F, 0x83,
  0xF8, 0x3F, 0xC3, 0xF0, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x18, 0x03, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xF8, 0xFE, 0x7F, 0x1F, 0x83, 0xC0, 0x60, 0x00, 0x3F,
  0x3F, 0xDF, 0xEC, 0xF0, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x00,
  0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x1E,
  0x0E, 0x3C, 0x07, 0x39, 0xF7, 0x73, 0xF7, 0x67, 0x77, 0xEE, 0x77, 0xEE,
  0x77, 0xCE, 0x66, 0xCC, 0xE6, 0xCC, 0xEE, 0xCF, 0xFC, 0xCF, 0x78, 0xC0,
  0x00, 0xE0, 0x20, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x3F,
  0x03, 0xF0, 0x7F, 0x07, 0x70, 0x77, 0x0F, 0x70, 0xE7, 0x1E, 0xF1, 0xEF,
  0x3F, 0xF3, 0xFF, 0x3F, 0xF7, 0xFF, 0x78, 0xFF, 0x8F, 0xF0, 0xF0, 0x1F,
  0xE0, 0xFF, 0x87, 0xFE, 0x3D, 0xF1, 0xEF, 0x9E, 0x78, 0xF7, 0xC7, 0xFC,
  0x3F, 0xC3, 0xFF, 0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x3D, 0xF3, 0xFF, 0x1F,
  0xF8, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x1F, 0xE3, 0xE4, 0x7C, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x90,
  0xFF, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFF, 0x87, 0xFC, 0x3D, 0xF1,
  0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0xFB, 0xC7, 0xDE, 0x3C, 0xF3,
  0xE7, 0x9E, 0x3F, 0xF3, 0xFF, 0x1F, 0xF0, 0xFE, 0x00, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0x01, 0xE0, 0x78, 0x0F, 0xF1, 0xFC, 0x3F, 0x8F, 0xF1, 0xE0,
  0x3C, 0x07, 0x80, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC,
  0x7F, 0x8F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xFC, 0x3F, 0x8F, 0xF1, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xF8, 0x7F,
  0xC7, 0xFC, 0x7C, 0x67, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x7E, 0xF3, 0xF7,
  0x9F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x7C, 0xE3, 0xFF, 0x0F, 0xF8, 0x3F,
  0x80, 0x1F, 0x3E, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0xC7, 0x8F,
  0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x8F, 0x0F, 0x1E, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE0, 0x0F, 0xF1, 0xFE,
  0x0F, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0x0F, 0xF8, 0xFF, 0x00, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x1F, 0x3E, 0x3C, 0xF8,
  0x79, 0xE0, 0xF7, 0x81, 0xFF, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0xFF, 0x81, 0xFF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x3C, 0xF8,
  0x79, 0xF0, 0xF1, 0xE0, 0x1F, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0,
  0x78, 0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFD, 0xFE, 0xFF, 0x00,
  0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF9, 0xFC,
  0x7F, 0x3F, 0x8F, 0xEF, 0xE1, 0xFD, 0xFC, 0x3B, 0xBF, 0x8F, 0x7E, 0xF1,
  0xEF, 0xDE, 0x3D, 0xFF, 0x87, 0xBE, 0xF0, 0xE7, 0xDE, 0x3C, 0xF3, 0xC7,
  0x9E, 0x70, 0xF3, 0x9E, 0x00, 0x1F, 0x0F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F,
  0x9E, 0x1F, 0x9E, 0x3F, 0x9C, 0x3F, 0xBC, 0x3F, 0xBC, 0x3B, 0xFC, 0x7B,
  0xF8, 0x7B, 0xF8, 0x7B, 0xF8, 0x79, 0xF8, 0x71, 0xF8, 0xF1, 0xF0, 0xF1,
  0xF0, 0xF1, 0xF0, 0x07, 0xE0, 0xFF, 0x87, 0xFC, 0x7D, 0xF7, 0xC7, 0xBC,
  0x3D, 0xE3, 0xFF, 0x1F, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xE3, 0xEF, 0x1E,
  0x7D, 0xF3, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1,
  0xEF, 0x1E, 0xF3, 0xCF, 0x3C, 0xF3, 0xDF, 0x3F, 0xE7, 0xFC, 0x7F, 0x87,
  0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0xFF,
  0x87, 0xFC, 0x7D, 0xF7, 0xC7, 0xBC, 0x3D, 0xE3, 0xFF, 0x1F, 0xF0, 0xF7,
  0x87, 0xBC, 0x3D, 0xE3, 0xEF, 0x1E, 0x7D, 0xF3, 0xFF, 0x0F, 0xF0, 0x3F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0xE1, 0xFF, 0x1F,
  0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F,
  0x87, 0xBC, 0x7B, 0xC7, 0xBC, 0xF3, 0xCF, 0x3E, 0xF1, 0xE0, 0x0F, 0xE1,
  0xFF, 0x3F, 0xE3, 0xEE, 0x3C, 0x43, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x87, 0xCF, 0xF8, 0xFF, 0x8F, 0xF0, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x79,
  0xE3, 0xCF, 0x1E, 0x79, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x3C, 0x79,
  0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x3C, 0x7B, 0xE3, 0xFF, 0x0F, 0xF0,
  0x7F, 0x00, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xCF, 0x1E, 0x79, 0xE3,
  0xCF, 0x1E, 0xF0, 0xF7, 0x87, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0xF1, 0xE3, 0xFC, 0x79, 0xEF, 0x3E,
  0x7B, 0xCF, 0x9E, 0xF3, 0xEF, 0x3D, 0xFB, 0xCF, 0x7E, 0xF3, 0xFF, 0x78,
  0xFF, 0xDE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xF7, 0xF0, 0xFD, 0xF8, 0x3E,
  0x7E, 0x0F, 0x9F, 0x83, 0xE7, 0xC0, 0xF1, 0xF0, 0x00, 0x1F, 0x3E, 0x1E,
  0x78, 0x3D, 0xE0, 0x7B, 0xC0, 0xFF, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xBC, 0x1E,
  0x78, 0x3C, 0xF0, 0xF1, 0xF0, 0xF1, 0xFF, 0x9E, 0x7B, 0xC7, 0xBC, 0x7F,
  0x87, 0xF8, 0x7F, 0x07, 0xF0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x3F, 0xE1, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F,
  0xC3, 0xF0, 0xF8, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xF0,
  0xFC, 0x3E, 0x00, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x9E, 0x38, 0xE3, 0x8E,
  0x38, 0xF3, 0xCF, 0x1C, 0x07, 0xC3, 0xF0, 0xFC, 0x0F, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38,
  0x1E, 0x07, 0x81, 0xC1, 0xF0, 0xFC, 0x3F, 0x00, 0x03, 0x80, 0x70, 0x1E,
  0x07, 0xE0, 0xFC, 0x3F, 0x8F, 0x71, 0xCE, 0x79, 0xEE, 0x1F, 0xC3, 0x80,
  0xFF, 0xFF, 0xE0, 0xF9, 0xE3, 0xC0, 0x04, 0x01, 0xFF, 0x3F, 0xF3, 0xFE,
  0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFC,
  0x7F, 0xC7, 0xB8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC8, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3D, 0xEF, 0x3D, 0xE7, 0xBC, 0xF7, 0x9E, 0xF7, 0xFE, 0xF7,
  0xFE, 0xFF, 0x9D, 0xE0, 0x03, 0x03, 0xF1, 0xFC, 0xFE, 0x7C, 0x9E, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x91, 0xFC, 0x7F, 0x0F, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x4F, 0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x7D,
  0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xCF, 0x1C, 0x79, 0xE3, 0xCF, 0x1F, 0xF8,
  0x7F, 0xC3, 0xDC, 0x00, 0x0F, 0xC3, 0xFC, 0xFF, 0xBC, 0xF7, 0x9E, 0xFF,
  0x9F, 0xE7, 0xC0, 0xF0, 0x1E, 0x11, 0xFE, 0x3F, 0xC3, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x3C, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1E,
  0x00, 0x02, 0x00, 0x7F, 0xC3, 0xFE, 0x3F, 0xE3, 0xEF, 0x1E, 0x78, 0xF3,
  0xC7, 0x9E, 0x78, 0xE3, 0xCF, 0x1E, 0x78, 0xFF, 0xC3, 0xFE, 0x1F, 0xE0,
  0x0F, 0x00, 0x78, 0xEF, 0x87, 0xFC, 0x3F, 0xC0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC8, 0x7F, 0xCF, 0xF9, 0xFF, 0x3D, 0xEF, 0x3D,
  0xE7, 0xBC, 0xF7, 0x9E, 0xF7, 0xBC, 0xF7, 0x9E, 0xF3, 0xDE, 0xF0, 0x04,
  0x3C, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x8F, 0x1E,
  0x78, 0xF1, 0xE3, 0xC0, 0x00, 0x80, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x3F, 0x0F, 0xC3, 0xE0, 0xE0, 0x00,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x7C, 0xF7, 0xC7,
  0xBC, 0x3B, 0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xDF,
  0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x8F,
  0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x78, 0xF1, 0xE0, 0x00, 0x82,
  0x1F, 0xF7, 0x8F, 0xFF, 0xE7, 0xFF, 0xF3, 0xDF, 0x7B, 0xCF, 0x3D, 0xE7,
  0x9E, 0xF3, 0xDE, 0x79, 0xCF, 0x3D, 0xE7, 0xBC, 0xF3, 0xDE, 0x79, 0xEF,
  0x3D, 0xE7, 0xBC, 0xF0, 0x00, 0x87, 0xFC, 0xFF, 0x9F, 0xF3, 0xDE, 0xF3,
  0xDE, 0x7B, 0xCF, 0x79, 0xEF, 0x7B, 0xCF, 0x79, 0xEF, 0x3D, 0xEF, 0x00,
  0x02, 0x01, 0xF8, 0x7F, 0x9F, 0xF3, 0xDE, 0xF3, 0xDE, 0x7B, 0xCF, 0xF1,
  0xFE, 0x7B, 0xCF, 0x3F, 0xC7, 0xF8, 0x7C, 0x00, 0x00, 0x20, 0x7F, 0xC3,
  0xFE, 0x1F, 0xF0, 0xF7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF3,
  0xCF, 0xBC, 0x7F, 0xE3, 0xFE, 0x1F, 0xE0, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x04, 0x01, 0xFF, 0x1F, 0xF3, 0xFE, 0x7D,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0xF1, 0xCF, 0x3C, 0xF3, 0xCF, 0xFC, 0x7F,
  0xC7, 0xB8, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x00,
  0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x9F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x04, 0x07, 0xF3, 0xF9, 0xFE, 0x78, 0x9F,
  0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xC8, 0xF3, 0xFC, 0xFE, 0x3F, 0x00, 0x1C,
  0x1C, 0x3C, 0x7F, 0xFF, 0xFE, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0,
  0xFC, 0xFC, 0x7C, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x9E,
  0x79, 0xE7, 0x9E, 0x7B, 0xCF, 0xBC, 0xFF, 0xC7, 0xFC, 0x7B, 0x80, 0xF1,
  0xEE, 0x3D, 0xCF, 0x39, 0xE7, 0x78, 0xEF, 0x1D, 0xC3, 0xF8, 0x7E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF3, 0xEF, 0xF9, 0xF7, 0xBD, 0xFB, 0x9E,
  0xFB, 0xCF, 0x7D, 0xE7, 0xFE, 0xE3, 0xFF, 0xF1, 0xFB, 0xF0, 0xFD, 0xF8,
  0x7E, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9E, 0x00, 0x1E, 0xF8, 0xF7,
  0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0xC1,
  0xFE, 0x1E, 0xF0, 0xF7, 0x8F, 0x3E, 0x00, 0x3C, 0x78, 0xE3, 0xC7, 0x3C,
  0x39, 0xE1, 0xDE, 0x0E, 0xF0, 0x77, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0x80,
  0x38, 0x00, 0x1F, 0xE3, 0xFC, 0xFF, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x01, 0xFE, 0x7F, 0xCF, 0xF8, 0x03, 0xC1, 0xF0, 0xFC,
  0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x7E, 0x1F, 0x0F, 0x03, 0xE0, 0x3C,
  0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x1C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x0F, 0x87,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0F, 0x07, 0xC1, 0xE3, 0xF3, 0xE1,
  0xE0, 0xF0, 0x78, 0x38, 0x7C, 0x3E, 0x1E, 0x0E, 0x00, 0x30, 0x3F, 0xCF,
  0xFF, 0xEF, 0xF8, 0x38,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 8, 17, 6, 0, -17 },
  { 18, 10, 6, 11, 2, -17 },
  { 26, 13, 17, 13, 0, -17 },
  { 54, 12, 19, 11, 0, -18 },
  { 83, 18, 17, 19, 1, -17 },
  { 122, 14, 17, 14, 0, -17 },
  { 152, 5, 6, 6, 2, -17 },
  { 156, 9, 22, 7, 0, -18 },
  { 181, 9, 22, 7, -2, -18 },
  { 206, 10, 11, 11, 2, -18 },
  { 220, 10, 11, 12, 1, -14 },
  { 234, 6, 7, 6, -1, -4 },
  { 240, 7, 3, 7, 0, -8 },
  { 243, 4, 4, 6, 0, -4 },
  { 245, 13, 17, 10, -1, -17 },
  { 273, 10, 17, 11, 1, -17 },
  { 295, 9, 17, 11, 2, -17 },
  { 315, 12, 17, 11, -1, -17 },
  { 341, 12, 17, 11, 0, -17 },
  { 367, 12, 17, 11, 0, -17 },
  { 393, 12, 17, 11, 0, -17 },
  { 419, 11, 17, 11, 1, -17 },
  { 443, 12, 17, 11, 1, -17 },
  { 469, 12, 17, 11, 0, -17 },
  { 495, 11, 17, 11, 0, -17 },
  { 519, 6, 13, 6, 0, -13 },
  { 529, 7, 16, 6, -1, -13 },
  { 543, 10, 12, 12, 1, -15 },
  { 558, 10, 9, 12, 1, -13 },
  { 570, 11, 12, 12, 1, -15 },
  { 587, 9, 17, 9, 1, -17 },
  { 607, 16, 19, 17, 1, -17 },
  { 645, 12, 17, 13, -1, -17 },
  { 671, 13, 17, 12, 0, -17 },
  { 699, 12, 17, 11, 1, -17 },
  { 725, 13, 17, 13, 0, -17 },
  { 753, 11, 17, 10, 0, -17 },
  { 777, 11, 17, 10, 0, -17 },
  { 801, 13, 17, 13, 1, -17 },
  { 829, 15, 17, 14, 0, -17 },
  { 861, 12, 17, 9, -1, -17 },
  { 887, 12, 22, 7, -4, -17 },
  { 920, 15, 17, 12, 0, -17 },
  { 952, 9, 17, 10, 0, -17 },
  { 972, 19, 17, 18, 0, -17 },
  { 1013, 16, 17, 15, 0, -17 },
  { 1047, 13, 17, 14, 1, -17 },
  { 1075, 12, 17, 12, 0, -17 },
  { 1101, 13, 21, 14, 1, -17 },
  { 1136, 12, 17, 12, 0, -17 },
  { 1162, 12, 17, 10, 0, -17 },
  { 1188, 10, 17, 10, 2, -17 },
  { 1210, 13, 17, 13, 1, -17 },
  { 1238, 13, 17, 12, 2, -17 },
  { 1266, 18, 17, 18, 2, -17 },
  { 1305, 15, 17, 12, -1, -17 },
  { 1337, 12, 17, 12, 2, -17 },
  { 1363, 13, 17, 11, -1, -17 },
  { 1391, 10, 22, 7, -1, -18 },
  { 1419, 6, 17, 10, 2, -17 },
  { 1432, 10, 22, 7, -2, -18 },
  { 1460, 11, 11, 11, 0, -17 },
  { 1476, 10, 2, 9, -2, 2 },
  { 1479, 6, 3, 8, 3, -18 },
  { 1482, 12, 14, 12, 0, -14 },
  { 1503, 11, 18, 12, 0, -18 },
  { 1528, 10, 14, 10, 0, -14 },
  { 1546, 13, 18, 12, 0, -18 },
  { 1576, 11, 13, 11, 0, -13 },
  { 1594, 13, 24, 7, -3, -18 },
  { 1633, 13, 20, 12, -1, -14 },
  { 1666, 11, 18, 12, 0, -18 },
  { 1691, 7, 19, 6, 0, -19 },
  { 1708, 10, 25, 6, -3, -19 },
  { 1740, 13, 18, 12, 0, -18 },
  { 1770, 7, 18, 6, 0, -18 },
  { 1786, 17, 14, 17, 0, -14 },
  { 1816, 11, 14, 12, 0, -14 },
  { 1836, 11, 14, 12, 0, -14 },
  { 1856, 13, 20, 12, -2, -14 },
  { 1889, 12, 20, 12, 0, -14 },
  { 1919, 10, 14, 8, 0, -14 },
  { 1937, 10, 14, 9, 0, -14 },
  { 1955, 8, 16, 8, 1, -16 },
  { 1971, 12, 13, 12, 0, -13 },
  { 1991, 11, 13, 11, 1, -13 },
  { 2009, 17, 13, 16, 1, -13 },
  { 2037, 13, 13, 11, -1, -13 },
  { 2059, 13, 19, 11, -1, -13 },
  { 2090, 11, 13, 9, -1, -13 },
  { 2108, 10, 21, 8, 0, -17 },
  { 2135, 3, 25, 9, 3, -19 },
  { 2145, 9, 21, 8, -1, -17 },
  { 2169, 11, 5, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC24PT7B_H_
