#ifndef _NOTOSANS_EXTRACONDENSED_BLACKITALIC57PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BLACKITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-BlackItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_BlackItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x00,
  0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC,
  0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF8,
  0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE1, 0xF8,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0x80, 0x7F, 0xB8,
  0x70, 0x0F, 0xE7, 0x04, 0x03, 0xFC, 0xE0, 0x00, 0x7F, 0x9C, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xDF, 0xE0, 0x80, 0x3B, 0xFC, 0x1C, 0x0E,
  0x7F, 0x83, 0xC1, 0xCF, 0xF0, 0x7E, 0x3B, 0xFC, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xF8, 0x03,
  0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xFC, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x9F, 0xC1, 0xF8, 0x7F, 0x3F, 0x8F, 0xE3,
  0xFF, 0x3F, 0x9F, 0xCF, 0xE3, 0xFF, 0xDF, 0xFF, 0xC7, 0xF3, 0xFF, 0xE7,
  0xFF, 0xE7, 0xF3, 0xFF, 0xF3, 0xFF, 0xE7, 0xF9, 0xFF, 0xFD, 0xFF, 0xE3,
  0xF9, 0xFE, 0xFE, 0x7F, 0xE3, 0xF8, 0xFE, 0x7F, 0x0F, 0xE1, 0xFC, 0xFE,
  0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x0F, 0xE1, 0xF8, 0x00, 0x7F, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x83, 0xF8,
  0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0x1F, 0xC0, 0xFC, 0x7F, 0x00,
  0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0xFF, 0x80, 0x0F, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0xFF,
  0x8F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xC3,
  0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF,
  0xDF, 0xF8, 0x7F, 0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFB,
  0xFF, 0xFF, 0x87, 0xFE, 0x7F, 0xFF, 0xC1, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F,
  0xC3, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0x7F, 0xF0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F,
  0xC7, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x30,
  0x7F, 0x00, 0x3C, 0x7F, 0x00, 0x3E, 0x7F, 0x06, 0x7F, 0xFF, 0x3E, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xCF, 0xF0, 0x3F,
  0xCF, 0xF0, 0x1F, 0x8F, 0xF8, 0x0F, 0x07, 0xE0, 0x07, 0x07, 0x80, 0x02,
  0x07, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0x0F, 0x8F, 0xF7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x9F, 0xC3, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFC, 0xFF, 0x87, 0xFE, 0x7F, 0xC3, 0xFE, 0x3F, 0xE3, 0xFF,
  0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFC, 0xFF, 0xC3, 0xFE, 0x7F,
  0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0xBF, 0xF0, 0x7F, 0xDF, 0xF8, 0x7F, 0xEF,
  0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x0F, 0xFB, 0xFF, 0x07, 0xFD,
  0xFF, 0x07, 0xFE, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF,
  0x9F, 0xF0, 0xFF, 0x8F, 0xF8, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x3F,
  0xE1, 0xFF, 0x1F, 0xF0, 0xFF, 0x9F, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x87, 0xFB, 0xFE, 0x0F, 0xDF, 0xF8, 0x3E, 0x7F, 0xE0, 0x71,
  0xFF, 0x00, 0x87, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0x3F, 0xF8, 0x03, 0xE0, 0xFF, 0xC0, 0x1E, 0x07, 0xFE, 0x00, 0x60, 0x3F,
  0xF0, 0x02, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x00, 0xF0, 0x7F, 0xE0, 0x18, 0x0F, 0xFC, 0x02, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC4, 0x00, 0x3F, 0xF0, 0xF0, 0x0F,
  0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFD, 0xFF, 0x00, 0x1F, 0x9F, 0xF0, 0x03,
  0xF9, 0xFF, 0x00, 0x7F, 0x3F, 0xF0, 0x07, 0xE3, 0xFE, 0x00, 0xFE, 0x3F,
  0xE0, 0x1F, 0xC3, 0xFE, 0x01, 0xF8, 0x7F, 0xE0, 0x3F, 0x87, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xE7,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x20, 0x03, 0xFF, 0x86, 0x00, 0x7F, 0xE0, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFC, 0x01, 0xFF, 0x3F, 0xC0,
  0x3F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0xFF, 0xC7,
  0xFF, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x87, 0xFC, 0x7F, 0xE0, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xF3, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xF9, 0xFF, 0x01, 0xFF, 0x7F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0xFC, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF1, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0xC3, 0xFF, 0x1F, 0xF0, 0xFF,
  0x87, 0xFC, 0x7F, 0xE1, 0xFF, 0x1F, 0xF8, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1,
  0xFF, 0x07, 0xFC, 0x7F, 0xC3, 0xFF, 0x3F, 0xF0, 0xFF, 0xCF, 0xFC, 0x3F,
  0xF3, 0xFF, 0x1F, 0xFC, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0x7F, 0xC0, 0x7F, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x3C, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x03, 0xFC, 0x0F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x07, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x18, 0x00, 0x00, 0x0F, 0x00,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0x0F, 0xFC, 0x30, 0x1F, 0xF0, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xF8, 0x3F, 0x83, 0xFF, 0xE3, 0xF0, 0x7F, 0x0F, 0xFF, 0xE7,
  0xE1, 0xFC, 0x3F, 0xFF, 0x8F, 0xC3, 0xF0, 0xFF, 0xFF, 0x1F, 0x8F, 0xE3,
  0xFE, 0xFE, 0x3F, 0x1F, 0x87, 0xF1, 0xFC, 0x7E, 0x3F, 0x1F, 0xC3, 0xF8,
  0xFC, 0xFC, 0x3F, 0x07, 0xE1, 0xF9, 0xF8, 0xFE, 0x0F, 0xC3, 0xF3, 0xF1,
  0xFC, 0x3F, 0x87, 0xEF, 0xC3, 0xF0, 0x7F, 0x0F, 0x9F, 0x8F, 0xE0, 0xFC,
  0x3F, 0x3F, 0x1F, 0xC1, 0xF8, 0x7E, 0x7E, 0x3F, 0x87, 0xF0, 0xFC, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF3, 0xF8, 0xFE, 0x1F, 0x87, 0xE7, 0xF1, 0xFC, 0x7F,
  0x1F, 0x8F, 0xC3, 0xF9, 0xFE, 0x7F, 0x1F, 0x87, 0xFF, 0xFF, 0xFC, 0x3F,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0xFD, 0xFF, 0xE0, 0xFE, 0x1F, 0xF1,
  0xFF, 0x01, 0xFC, 0x1F, 0xC3, 0xFC, 0x01, 0xF8, 0x02, 0x00, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x02, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xF9,
  0xFF, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0x7F,
  0xC0, 0x1F, 0xF1, 0xFF, 0x00, 0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x80, 0xFF,
  0xCF, 0xFC, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xF7,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x1F, 0xFC, 0x0F, 0xFC, 0x3F,
  0xF0, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFC,
  0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1, 0xFF,
  0x81, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F,
  0xE1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0x87, 0x80, 0x7F, 0xF0, 0x10, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x01,
  0x00, 0xFF, 0xE0, 0x70, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0x3F, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x83, 0xFF,
  0x03, 0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x01,
  0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF8,
  0x1F, 0xF0, 0xFF, 0xE0, 0x3F, 0xEF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xC1, 0xF0, 0x0F, 0xFE, 0x00, 0x40, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE3, 0xFF, 0xF1, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0x87, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFC, 0x7F, 0xFE, 0x3F, 0xF0, 0xFF, 0xF8, 0x7F, 0xE1,
  0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0x88, 0xFF, 0xC3, 0xFF, 0x01,
  0xFF, 0x87, 0xFE, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8,
  0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x6F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0xC1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x1F,
  0xFC, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01,
  0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x80,
  0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0xC0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x0B, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x3F, 0xBF, 0xE0, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x07, 0xFF, 0xFD, 0xFE,
  0xFF, 0x80, 0x3F, 0xFF, 0xEF, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x7F, 0x7F,
  0xE0, 0x1F, 0xF7, 0xFF, 0xFB, 0xFE, 0x00, 0xFF, 0xBF, 0xFF, 0x9F, 0xF0,
  0x07, 0xFD, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xE7, 0xFF, 0xE7, 0xFC, 0x03,
  0xFE, 0x3F, 0xFE, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0xF3, 0xFE, 0x00, 0xFF,
  0x8F, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0x7F, 0xF8, 0xFF, 0x80, 0x3F, 0xC3,
  0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xFE,
  0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0x80, 0x3F, 0xFF, 0x87,
  0xFC, 0x01, 0xFF, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0xE1, 0xFF, 0x00, 0xFF,
  0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xE7, 0xFC,
  0x03, 0xFE, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xF9, 0xFF, 0x00, 0xFF, 0xBF,
  0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xFF, 0xFC, 0x03,
  0xFE, 0x3F, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0xFF, 0x00, 0xFF, 0x8F, 0xFF,
  0xF8, 0x07, 0xFC, 0x7F, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0xFC, 0x03, 0xFE,
  0x1F, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0xF0,
  0x07, 0xFC, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x07,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80,
  0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x03,
  0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F,
  0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF,
  0xBF, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9,
  0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x8F,
  0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFC,
  0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F,
  0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x83,
  0xFF, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x80,
  0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x03,
  0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F,
  0xF3, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF,
  0xBF, 0xF0, 0x07, 0xFF, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F, 0xF9,
  0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x8F,
  0xFC, 0x07, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0x3F, 0xF8, 0x0F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF, 0xC0, 0xFF,
  0x87, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE1,
  0xFF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0x1F, 0xF1, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0x7F, 0xE0, 0x07, 0xFD,
  0xFF, 0x80, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFE, 0x3F,
  0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC,
  0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xF0, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1E, 0x00, 0xFF, 0xC0, 0x20, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x10, 0x01, 0xFF, 0x80, 0xC0, 0x1F, 0xFC, 0x07, 0x80, 0xFF, 0xC0, 0x7F,
  0x9F, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFC,
  0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xCF, 0xFC, 0x07, 0xFE, 0x3F,
  0xF0, 0x1F, 0xF8, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0x81, 0xFF, 0x0F,
  0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC7, 0xFE,
  0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF, 0xC0, 0x1F, 0xF3, 0xFE, 0x00,
  0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F,
  0xEF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x01, 0xFE, 0xFF, 0x80, 0x07, 0xFB,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xF7, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xE7,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xFC, 0x3F,
  0xE0, 0x7F, 0xC3, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x7F, 0xFC, 0x7F, 0xE0,
  0x7F, 0xC7, 0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0xFF, 0xFC, 0xFF, 0xC0, 0x7F,
  0xCF, 0xFF, 0xCF, 0xFC, 0x07, 0xFC, 0xFF, 0xFC, 0xFF, 0x80, 0x7F, 0xDF,
  0xFF, 0xDF, 0xF8, 0x07, 0xF9, 0xFF, 0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xFF,
  0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xBF, 0xBF, 0xBF,
  0xE0, 0x0F, 0xFF, 0xFB, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x01, 0xFF,
  0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xE7, 0xFC, 0x0F, 0xFC,
  0x7F, 0xE0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x3F, 0xF0, 0x3F, 0xE3, 0xFE, 0x03, 0xFE, 0x7F, 0xE0, 0x3F, 0xE7, 0xFC,
  0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC2, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0,
  0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8,
  0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x7F,
  0x83, 0xFC, 0x0F, 0xF8, 0x3F, 0xC1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF,
  0x80, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xC1,
  0xFE, 0x07, 0xF8, 0x00, 0x7E, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFF,
  0x9F, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xF9, 0xFF, 0xC3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x7F, 0xE0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x7F, 0x80,
  0x3F, 0xE7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF3, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xEF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xF3, 0xFF, 0x07, 0xFE, 0x3F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F,
  0xF8, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF1,
  0xFF, 0x83, 0xFF, 0x9F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xBF, 0xFC, 0x07, 0xF1,
  0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xF8, 0x30, 0x7F,
  0xE0, 0x20, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xF0, 0x10, 0x7F, 0xE0, 0xE0, 0xFF, 0xE7, 0xC1, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0x8F, 0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFE, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x7F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x03,
  0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xF7, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x01, 0xFC, 0x7F,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0x7F, 0x9F, 0xF8, 0x3F,
  0xCF, 0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xE7, 0xFE, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x20, 0xFF, 0xC0, 0x70, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x20, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x02, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xFE, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0xFF, 0xCF, 0xF0, 0x03, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x3F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0xFF, 0xE0,
  0x1F, 0xFB, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0x41, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x0C, 0x00,
  0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xF0, 0x01, 0xFF, 0x7F, 0xC0,
  0x1F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xF3, 0xFF,
  0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC3, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x8F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF,
  0x0F, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFE,
  0x3F, 0xF0, 0x03, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0xC0, 0x07, 0xFC,
  0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFB,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x00, 0xFE,
  0x3F, 0xE1, 0xFF, 0x80, 0x7F, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xBF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0x3F, 0xF9, 0xFF, 0x83, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F, 0xE1,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0x83,
  0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87,
  0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x0F,
  0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFC, 0x3F,
  0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC7, 0xFC, 0x01, 0xFC, 0xFF, 0xE0,
  0x3F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x3F, 0xF0, 0x7F, 0xE3, 0xFF,
  0x07, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F,
  0xC1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFE, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xF8, 0xFF, 0x8F, 0xF8, 0x7F,
  0xCF, 0xFC, 0x3F, 0xE7, 0xFC, 0x1F, 0xF7, 0xFE, 0x0F, 0xFB, 0xFE, 0x07,
  0xFD, 0xFF, 0x03, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0xF7, 0xFC,
  0x1F, 0xF3, 0xFE, 0x0F, 0xF9, 0xFF, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x7F, 0x1F, 0xF0, 0x00, 0xFE, 0x7F,
  0xE0, 0x03, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xE7, 0xFE,
  0x01, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0x80,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F,
  0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFF,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0xFF,
  0xC0, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x0F, 0xF0, 0x0F, 0xF9, 0xFE, 0x01, 0xFF, 0x9F, 0xE0, 0x3F,
  0xFD, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xF9, 0xFF, 0xC1, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F,
  0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0,
  0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x01, 0xFC, 0xFF, 0x80, 0x02, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x7F, 0x01,
  0xFC, 0xFE, 0x03, 0xFD, 0xFE, 0x03, 0xFD, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFE, 0xFC, 0x1F, 0xF8, 0x30, 0x3F, 0xF0, 0x20, 0x7F, 0xE0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x20, 0x0F, 0xFC, 0x60,
  0x1F, 0xF0, 0xFC, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x87, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xFB, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xC0,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x7F,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0xC7, 0xFE, 0x0F, 0xFC, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xBF, 0xC0, 0x3F, 0xF3,
  0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xF0, 0x7F, 0xEF, 0xF8, 0x3F,
  0xE7, 0xFC, 0x1F, 0xF3, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0x8F,
  0xFC, 0x7F, 0xC7, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF3, 0xFE, 0x0F, 0xF9,
  0xFF, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x81, 0xFE, 0xFF, 0x80, 0xFF,
  0x7F, 0xC0, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC3, 0xFF, 0x83, 0xFE, 0xFF, 0x87, 0xFF, 0x0F, 0xF9, 0xFE,
  0x0F, 0xFE, 0x1F, 0xF3, 0xFC, 0x3F, 0xFC, 0x3F, 0xE7, 0xF8, 0x7F, 0xF8,
  0xFF, 0x8F, 0xF0, 0xFF, 0xE1, 0xFF, 0x3F, 0xE3, 0xFF, 0xC7, 0xFC, 0x7F,
  0xC7, 0xFF, 0x8F, 0xF8, 0xFF, 0x9F, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F, 0xFE,
  0x7F, 0xC3, 0xFE, 0x7F, 0xFC, 0xFF, 0x87, 0xFD, 0xFF, 0xF9, 0xFE, 0x0F,
  0xFB, 0xFF, 0xF7, 0xFC, 0x1F, 0xF7, 0xFF, 0xEF, 0xF8, 0x3F, 0xFF, 0xDF,
  0xDF, 0xE0, 0x7F, 0xBF, 0xBF, 0xFF, 0xC0, 0xFF, 0x7F, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0xFF, 0xFE, 0x03, 0xFF, 0xFB, 0xFF, 0xFC, 0x07, 0xFF, 0xE7,
  0xFF, 0xF0, 0x0F, 0xFF, 0xCF, 0xFF, 0xE0, 0x1F, 0xFF, 0x9F, 0xFF, 0x80,
  0x3F, 0xFE, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0xFF, 0xF8,
  0xFF, 0xF8, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x07, 0xFF, 0x87, 0xFF, 0x80, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x0F, 0xF9, 0xFF,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x80, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x0F,
  0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x1F,
  0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x3F,
  0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8F, 0xF8, 0x00,
  0x5F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xA0, 0x00, 0xFF, 0x80,
};

const GFXglyph NotoSans_ExtraCondensed_BlackItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 18, 42, 15, 0, -41 },
  { 96, 24, 15, 26, 5, -41 },
  { 141, 32, 41, 30, 0, -41 },
  { 305, 27, 46, 27, 1, -43 },
  { 461, 41, 41, 45, 3, -41 },
  { 672, 34, 42, 34, 0, -41 },
  { 851, 12, 15, 14, 5, -41 },
  { 874, 20, 51, 16, 1, -42 },
  { 1002, 21, 51, 16, -5, -42 },
  { 1136, 24, 27, 25, 4, -44 },
  { 1217, 24, 28, 29, 3, -34 },
  { 1301, 14, 16, 15, -3, -8 },
  { 1329, 16, 9, 18, 1, -20 },
  { 1347, 10, 11, 15, 0, -10 },
  { 1361, 31, 42, 23, -3, -41 },
  { 1524, 25, 42, 27, 2, -41 },
  { 1656, 22, 41, 27, 5, -41 },
  { 1769, 29, 41, 27, -2, -41 },
  { 1918, 27, 42, 27, 0, -41 },
  { 2060, 28, 41, 27, 0, -41 },
  { 2204, 27, 42, 27, 1, -41 },
  { 2346, 27, 42, 27, 2, -41 },
  { 2488, 28, 41, 27, 2, -41 },
  { 2632, 27, 42, 27, 1, -41 },
  { 2774, 26, 42, 27, 1, -41 },
  { 2911, 15, 33, 15, 0, -32 },
  { 2973, 18, 40, 15, -3, -32 },
  { 3063, 25, 29, 29, 2, -35 },
  { 3154, 24, 20, 29, 3, -30 },
  { 3214, 24, 29, 29, 3, -35 },
  { 3301, 22, 42, 21, 2, -41 },
  { 3417, 39, 45, 40, 1, -41 },
  { 3637, 30, 41, 30, -3, -41 },
  { 3791, 30, 41, 29, 0, -41 },
  { 3945, 28, 42, 27, 2, -41 },
  { 4092, 31, 41, 31, 0, -41 },
  { 4251, 27, 41, 24, 0, -41 },
  { 4390, 27, 41, 23, 0, -41 },
  { 4529, 31, 42, 31, 2, -41 },
  { 4692, 34, 41, 32, 0, -41 },
  { 4867, 28, 41, 21, -2, -41 },
  { 5011, 27, 54, 16, -9, -41 },
  { 5194, 35, 41, 29, 0, -41 },
  { 5374, 21, 41, 23, 0, -41 },
  { 5482, 45, 41, 42, 0, -41 },
  { 5713, 37, 41, 34, 0, -41 },
  { 5903, 31, 42, 33, 2, -41 },
  { 6066, 29, 41, 27, 0, -41 },
  { 6215, 31, 51, 33, 2, -41 },
  { 6413, 30, 41, 29, 0, -41 },
  { 6567, 29, 42, 25, -1, -41 },
  { 6720, 25, 41, 24, 4, -41 },
  { 6849, 32, 42, 31, 2, -41 },
  { 7017, 30, 41, 30, 5, -41 },
  { 7171, 44, 41, 42, 4, -41 },
  { 7397, 36, 41, 29, -3, -41 },
  { 7582, 28, 41, 28, 5, -41 },
  { 7726, 31, 41, 25, -2, -41 },
  { 7885, 24, 52, 16, -3, -42 },
  { 8041, 13, 42, 23, 6, -41 },
  { 8110, 23, 52, 16, -4, -42 },
  { 8260, 28, 27, 27, -1, -41 },
  { 8355, 24, 7, 22, -6, 4 },
  { 8376, 13, 9, 19, 8, -44 },
  { 8391, 28, 33, 28, 1, -32 },
  { 8507, 28, 44, 28, -1, -43 },
  { 8661, 23, 33, 23, 1, -32 },
  { 8756, 30, 44, 28, 1, -43 },
  { 8921, 25, 33, 26, 1, -32 },
  { 9025, 30, 58, 18, -6, -44 },
  { 9243, 31, 46, 28, -2, -32 },
  { 9422, 28, 43, 28, -1, -43 },
  { 9573, 18, 44, 14, -1, -44 },
  { 9672, 24, 58, 14, -7, -44 },
  { 9846, 32, 43, 28, -1, -43 },
  { 10018, 19, 43, 14, -1, -43 },
  { 10121, 41, 32, 41, -1, -32 },
  { 10285, 28, 32, 28, -1, -32 },
  { 10397, 25, 33, 27, 1, -32 },
  { 10501, 31, 46, 28, -4, -32 },
  { 10680, 28, 46, 28, 1, -32 },
  { 10841, 24, 32, 20, -1, -32 },
  { 10937, 23, 33, 22, 0, -32 },
  { 11032, 19, 39, 20, 2, -38 },
  { 11125, 28, 33, 28, 1, -32 },
  { 11241, 25, 32, 26, 4, -32 },
  { 11341, 39, 32, 39, 3, -32 },
  { 11497, 32, 32, 26, -3, -32 },
  { 11625, 32, 46, 26, -3, -32 },
  { 11809, 26, 32, 22, -2, -32 },
  { 11913, 24, 50, 20, 0, -41 },
  { 12063, 8, 57, 22, 7, -44 },
  { 12120, 22, 50, 20, -3, -41 },
  { 12258, 25, 11, 29, 2, -26 },
};

const GFXfont NotoSans_ExtraCondensed_BlackItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_BlackItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_BlackItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRACONDENSED_BLACKITALIC57PT7B_H_
