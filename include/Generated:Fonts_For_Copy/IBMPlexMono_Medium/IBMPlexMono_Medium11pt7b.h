#ifndef _IBMPLEXMONO_MEDIUM11PT7B_H_
#define _IBMPLEXMONO_MEDIUM11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x4F, 0xB6, 0x80, 0x2C, 0xA6, 0xCA, 0x2B, 0xB5, 0x14, 0x10,
  0xE5, 0x54, 0x70, 0x71, 0x55, 0xF8, 0x40, 0x66, 0x9B, 0x98, 0x0C, 0xD5,
  0x63, 0x31, 0x64, 0x09, 0x7A, 0x6C, 0x9D, 0xE0, 0x34, 0x48, 0x88, 0x84,
  0x43, 0xCC, 0x92, 0x49, 0x78, 0x12, 0x57, 0xCC, 0x69, 0x20, 0x21, 0x3E,
  0x42, 0x00, 0x7E, 0xE0, 0xF0, 0x18, 0x84, 0x42, 0x11, 0x08, 0xC4, 0x00,
  0x39, 0x34, 0x75, 0xD5, 0x14, 0xCE, 0x31, 0xCD, 0x04, 0x10, 0x41, 0x1F,
  0xF4, 0xC6, 0x23, 0x33, 0x1F, 0x79, 0x30, 0xCC, 0x0C, 0x14, 0xFE, 0x18,
  0x62, 0x92, 0x4B, 0xF0, 0x82, 0xFC, 0x21, 0xE9, 0x86, 0x7E, 0x32, 0x21,
  0xE8, 0xC6, 0x2E, 0xFC, 0xC4, 0x23, 0x11, 0x88, 0xF4, 0x62, 0xE8, 0xC6,
  0x3E, 0x74, 0xE3, 0x3E, 0x88, 0xCC, 0xF0, 0xF0, 0xF0, 0x7E, 0x09, 0xB1,
  0x83, 0x04, 0xF8, 0x3E, 0x83, 0x06, 0x36, 0x40, 0x74, 0xC6, 0xE6, 0x01,
  0x8C, 0x74, 0x6F, 0x9C, 0xE6, 0xF0, 0x70, 0x30, 0xE2, 0x9A, 0x49, 0xF4,
  0x71, 0xF4, 0xE7, 0xE8, 0xC6, 0x3E, 0x74, 0x61, 0x08, 0x42, 0x2E, 0xF4,
  0xE3, 0x18, 0xC6, 0x7E, 0xFC, 0x21, 0xF8, 0x42, 0x1F, 0xFC, 0x21, 0xF8,
  0x42, 0x10, 0x74, 0xE1, 0x0B, 0xC6, 0x6D, 0x8C, 0x63, 0xF8, 0xC6, 0x31,
  0xF9, 0x08, 0x42, 0x10, 0x9F, 0x71, 0x11, 0x11, 0x9F, 0x8C, 0xAD, 0xCE,
  0x4A, 0x71, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x9E, 0xF7, 0xDA, 0xE6, 0x31,
  0xCE, 0x73, 0x5A, 0xD6, 0x73, 0x39, 0x34, 0x71, 0xC5, 0x14, 0xCE, 0xF4,
  0x63, 0x1F, 0x42, 0x10, 0x39, 0x34, 0x71, 0xC5, 0x14, 0xCE, 0x10, 0x70,
  0xF4, 0x63, 0x1F, 0x5A, 0x51, 0x39, 0x14, 0x1C, 0x0C, 0x14, 0x7E, 0xFC,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x8C, 0x63, 0x18, 0xC6, 0x6E, 0xC5, 0x14,
  0xD2, 0x68, 0xA3, 0x8C, 0x86, 0x1D, 0x5D, 0x75, 0xB6, 0xDB, 0xC5, 0xA2,
  0x8C, 0x30, 0xA4, 0xF1, 0xC5, 0x36, 0x8A, 0x30, 0x41, 0x04, 0xF8, 0xC4,
  0x46, 0x22, 0x1F, 0xF8, 0x88, 0x88, 0x88, 0x8F, 0x86, 0x10, 0x82, 0x10,
  0x82, 0x10, 0xC0, 0xE4, 0x92, 0x49, 0x3C, 0x30, 0xA4, 0x91, 0x84, 0xF8,
  0x90, 0xF4, 0x85, 0xE9, 0x7C, 0x84, 0x2D, 0xB8, 0xC6, 0x7E, 0x74, 0xE1,
  0x08, 0xB8, 0x08, 0x7B, 0x38, 0xC6, 0x7D, 0x74, 0x7F, 0x08, 0xB8, 0x39,
  0x3E, 0x42, 0x10, 0x9F, 0x1B, 0xA7, 0x27, 0x41, 0xF1, 0xF8, 0x84, 0x2D,
  0xB8, 0xC6, 0x31, 0x21, 0x01, 0xC2, 0x10, 0x84, 0xF8, 0x33, 0x0F, 0x11,
  0x11, 0x11, 0xE0, 0x84, 0x27, 0x6E, 0x5A, 0x51, 0xE1, 0x08, 0x42, 0x10,
  0x9F, 0xFF, 0x5D, 0x75, 0xD7, 0x50, 0xB6, 0xE3, 0x18, 0xC4, 0x74, 0xE3,
  0x19, 0xB8, 0xB6, 0xE3, 0x19, 0xFA, 0x10, 0xEC, 0xE3, 0x19, 0xF4, 0x21,
  0xFB, 0x18, 0xC6, 0x7C, 0x74, 0xF8, 0x78, 0xF8, 0x20, 0x8F, 0xC8, 0x20,
  0x82, 0x0F, 0x9C, 0xE7, 0x39, 0xFC, 0x8C, 0xF4, 0xA5, 0x30, 0x96, 0xD7,
  0x5D, 0x6D, 0xB0, 0x4C, 0xA3, 0x0C, 0x2B, 0x30, 0xC5, 0x36, 0x8A, 0x30,
  0x43, 0x18, 0xF8, 0x88, 0xCC, 0x7C, 0x3A, 0x08, 0x4C, 0x10, 0x84, 0x41,
  0xC0, 0xFF, 0xC0, 0xE1, 0x08, 0x83, 0xA1, 0x04, 0x27, 0x00, 0x65, 0x59,
  0x80,
};

const GFXglyph IBMPlexMono_Medium11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 3, 3, 7, 2, -8 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 6, 10, 7, 0, -9 },
  { 19, 6, 8, 7, 0, -8 },
  { 25, 6, 8, 7, 0, -8 },
  { 31, 1, 3, 7, 3, -8 },
  { 32, 4, 10, 7, 2, -8 },
  { 37, 3, 10, 7, 1, -8 },
  { 41, 6, 6, 7, 0, -6 },
  { 46, 5, 5, 7, 1, -6 },
  { 50, 2, 4, 7, 2, -2 },
  { 51, 3, 1, 7, 2, -4 },
  { 52, 2, 2, 7, 2, -2 },
  { 53, 5, 10, 7, 1, -8 },
  { 60, 6, 8, 7, 0, -8 },
  { 66, 6, 8, 7, 0, -8 },
  { 72, 5, 8, 7, 1, -8 },
  { 77, 6, 8, 7, 0, -8 },
  { 83, 6, 8, 7, 0, -8 },
  { 89, 5, 8, 7, 1, -8 },
  { 94, 5, 8, 7, 1, -8 },
  { 99, 5, 8, 7, 1, -8 },
  { 104, 5, 8, 7, 1, -8 },
  { 109, 5, 8, 7, 1, -8 },
  { 114, 2, 6, 7, 2, -6 },
  { 116, 2, 8, 7, 2, -6 },
  { 118, 5, 6, 7, 1, -6 },
  { 122, 5, 3, 7, 1, -5 },
  { 124, 5, 6, 7, 1, -6 },
  { 128, 5, 8, 7, 1, -8 },
  { 133, 5, 9, 7, 1, -8 },
  { 139, 6, 8, 7, 0, -8 },
  { 145, 5, 8, 7, 1, -8 },
  { 150, 5, 8, 7, 1, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 5, 8, 7, 1, -8 },
  { 165, 5, 8, 7, 1, -8 },
  { 170, 5, 8, 7, 1, -8 },
  { 175, 5, 8, 7, 1, -8 },
  { 180, 5, 8, 7, 1, -8 },
  { 185, 4, 8, 7, 1, -8 },
  { 189, 5, 8, 7, 1, -8 },
  { 194, 5, 8, 7, 1, -8 },
  { 199, 5, 8, 7, 1, -8 },
  { 204, 5, 8, 7, 1, -8 },
  { 209, 6, 8, 7, 0, -8 },
  { 215, 5, 8, 7, 1, -8 },
  { 220, 6, 10, 7, 0, -8 },
  { 228, 5, 8, 7, 1, -8 },
  { 233, 6, 8, 7, 0, -8 },
  { 239, 6, 8, 7, 0, -8 },
  { 245, 5, 8, 7, 1, -8 },
  { 250, 6, 8, 7, 0, -8 },
  { 256, 6, 8, 7, 0, -8 },
  { 262, 6, 8, 7, 0, -8 },
  { 268, 6, 8, 7, 0, -8 },
  { 274, 5, 8, 7, 1, -8 },
  { 279, 4, 10, 7, 2, -8 },
  { 284, 5, 10, 7, 1, -8 },
  { 291, 3, 10, 7, 1, -8 },
  { 295, 6, 5, 7, 0, -8 },
  { 299, 5, 1, 7, 1, 1 },
  { 300, 2, 2, 7, 2, -9 },
  { 301, 5, 6, 7, 1, -6 },
  { 305, 5, 8, 7, 1, -8 },
  { 310, 5, 6, 7, 1, -6 },
  { 314, 5, 8, 7, 1, -8 },
  { 319, 5, 6, 7, 1, -6 },
  { 323, 5, 8, 7, 1, -8 },
  { 328, 5, 9, 7, 1, -7 },
  { 334, 5, 8, 7, 1, -8 },
  { 339, 5, 9, 7, 1, -9 },
  { 345, 4, 11, 7, 1, -9 },
  { 351, 5, 8, 7, 1, -8 },
  { 356, 5, 8, 7, 1, -8 },
  { 361, 6, 6, 7, 0, -6 },
  { 366, 5, 6, 7, 1, -6 },
  { 370, 5, 6, 7, 1, -6 },
  { 374, 5, 8, 7, 1, -6 },
  { 379, 5, 8, 7, 1, -6 },
  { 384, 5, 6, 7, 1, -6 },
  { 388, 5, 6, 7, 1, -6 },
  { 392, 6, 8, 7, 0, -8 },
  { 398, 5, 6, 7, 1, -6 },
  { 402, 5, 6, 7, 1, -6 },
  { 406, 6, 6, 7, 0, -6 },
  { 411, 6, 6, 7, 0, -6 },
  { 416, 6, 8, 7, 0, -6 },
  { 422, 5, 6, 7, 1, -6 },
  { 426, 5, 10, 7, 1, -8 },
  { 433, 1, 10, 7, 3, -8 },
  { 435, 5, 10, 7, 1, -8 },
  { 442, 6, 3, 7, 0, -5 },
};

const GFXfont IBMPlexMono_Medium11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_MEDIUM11PT7B_H_
