#ifndef _IBMPLEXMONO_MEDIUM71PT7B_H_
#define _IBMPLEXMONO_MEDIUM71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium71pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x3F, 0xE7, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0x7F, 0xF3, 0xFE, 0x1F, 0xC0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xF3, 0xF7, 0xFF, 0xC3, 0xFE, 0x1F, 0x87, 0xFC, 0x3F, 0xE0, 0xFC,
  0x0F, 0xC1, 0xFE, 0x07, 0xE0, 0x3C, 0x0F, 0xF0, 0x3F, 0x00, 0xC0, 0x7F,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0xC0,
  0xFC, 0x00, 0x01, 0xFF, 0x07, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0xFE, 0x00, 0x00,
  0x7E, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0x81, 0xFE,
  0x00, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0x01, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x86,
  0x00, 0x7E, 0x03, 0xF8, 0x78, 0x03, 0xF0, 0x1F, 0xC7, 0xE0, 0x1F, 0x81,
  0xFE, 0x7F, 0x80, 0xFC, 0x1F, 0xF7, 0xFF, 0x07, 0xE1, 0xFF, 0x1F, 0xFF,
  0x3F, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x83, 0xFF, 0xC0, 0x00, 0x1F, 0x83, 0xFF, 0xF0, 0x00, 0x1F, 0xC3,
  0xFF, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x3F,
  0x80, 0x07, 0xE1, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x7E,
  0x01, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x1F, 0x80, 0x0F, 0xF0, 0xFE,
  0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0x07, 0xE0,
  0x00, 0x3F, 0xFF, 0x04, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xF8, 0x3F, 0xFF,
  0xC0, 0x01, 0xFC, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x3F, 0x83, 0xF8, 0x00,
  0xFE, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x03,
  0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x07, 0xE1, 0xF8,
  0x00, 0x7F, 0x87, 0xF0, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x7E, 0x00, 0x01, 0xFF, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x03,
  0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xF7, 0xF8,
  0x0F, 0xFE, 0x1F, 0xE3, 0xFC, 0x0F, 0xFE, 0x3F, 0xC3, 0xFE, 0x0F, 0xC0,
  0x3F, 0x81, 0xFE, 0x0F, 0xC0, 0x7F, 0x80, 0xFF, 0x0F, 0xC0, 0x7F, 0x80,
  0x7F, 0x8F, 0xC0, 0x7F, 0x00, 0x3F, 0xCF, 0x80, 0x7F, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xBF, 0xE0, 0x3F, 0xF8,
  0x1F, 0x9F, 0xF0, 0x1F, 0xFF, 0xFF, 0x8F, 0xF8, 0x0F, 0xFF, 0xFF, 0x07,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1C, 0x00, 0x7F, 0x00, 0x18, 0xFC, 0x03, 0xF8, 0x07, 0xC7,
  0xFC, 0x1F, 0xC1, 0xFF, 0x7F, 0xFC, 0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xC7, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xE1, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xE0, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0xFF, 0xFF,
  0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x80,
  0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x00, 0x1C, 0x00, 0x7F,
  0x80, 0x00, 0x40, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x7F, 0xE0,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x00, 0x7F, 0xC7, 0xF0, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0x00, 0xFF,
  0x00, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xF8, 0x3E, 0x00,
  0x01, 0xFF, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x20, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x08, 0x00, 0x00, 0x7F,
  0xC3, 0x00, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xFC,
  0x03, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x03,
  0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0x1F, 0xFF, 0xF0, 0x0F, 0xE7, 0xFF, 0xFF,
  0x01, 0xFD, 0xFF, 0xFF, 0xF0, 0x3F, 0xBF, 0xFF, 0xFF, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x78,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x08, 0x00, 0x00, 0x7F, 0xC3, 0x80, 0x00, 0x0F, 0xF0, 0xF8,
  0x00, 0x03, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3,
  0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xFE, 0x00,
  0xFF, 0x1F, 0xFF, 0xF0, 0x1F, 0xE7, 0xFF, 0xFF, 0x03, 0xFD, 0xFF, 0xFF,
  0xF0, 0xFF, 0x7F, 0xFF, 0xFF, 0x1F, 0xEF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0xC7, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xFF,
  0x9F, 0xE0, 0xFF, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0x7F,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xC7, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xE1, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xE1, 0xFC, 0x07,
  0xF0, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x07, 0xFE,
  0x7F, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0x3E, 0x00, 0x01, 0xFF, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x03, 0xF7,
  0xE0, 0x03, 0xF0, 0xFD, 0xF8, 0x03, 0xFE, 0x3F, 0x7E, 0x01, 0xFF, 0xCF,
  0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0xFE,
  0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xC0, 0x0F, 0xFF, 0x03,
  0xF0, 0x03, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0x3F, 0xFC,
  0x1F, 0xC0, 0x0F, 0xFF, 0x07, 0xF0, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xC0, 0x0F, 0xFF, 0x03, 0xF0, 0x03,
  0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xE0,
  0x0F, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xC7, 0xFF, 0xF0, 0x1F,
  0xFF, 0xBF, 0x7E, 0x03, 0xFF, 0xEF, 0xDF, 0x80, 0xFF, 0xF3, 0xF7, 0xE0,
  0x1F, 0xFC, 0xFD, 0xF8, 0x03, 0xFE, 0x3F, 0x7F, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x0F, 0xE7,
  0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x07,
  0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x00,
  0x3F, 0xF8, 0xFF, 0x00, 0x07, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x3F, 0xC0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x01, 0xFF,
  0x8F, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0xBF, 0xC0,
  0x03, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x1F, 0xE0, 0x00,
  0x03, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x07, 0xF9, 0xFF,
  0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x00,
  0xFF, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xFE, 0x3F, 0xC0, 0x0F,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3E, 0x1F, 0xF0, 0x00, 0x06, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFB, 0xFC, 0x00, 0x00,
  0x7F, 0x7F, 0x80, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF,
  0x3F, 0xE0, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x01,
  0xFF, 0x87, 0xFC, 0x00, 0x77, 0xF0, 0xFF, 0xE0, 0x3E, 0xFE, 0x0F, 0xFF,
  0xFF, 0x9F, 0xC0, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0xFC, 0x7F, 0x00,
  0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xFF, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE1, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x80,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xE0, 0x00,
  0x07, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x03, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x07, 0xFC,
  0x0F, 0xE0, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xE0, 0x3F, 0xE0, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0xFF,
  0xC0, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xE1, 0xFF, 0x00, 0x00, 0xFE,
  0x3F, 0xE0, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x00, 0xFE, 0x7F, 0xF0, 0x00,
  0x0F, 0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x00,
  0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0xE0, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x01, 0xFF, 0x8F, 0xE0, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x00, 0x7F,
  0xCF, 0xE0, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x7E,
  0x03, 0xF7, 0xFF, 0xEF, 0xC0, 0x7E, 0xFF, 0xFD, 0xFC, 0x1F, 0x9F, 0xFF,
  0x9F, 0x83, 0xF3, 0xFF, 0xF3, 0xF8, 0x7E, 0x7F, 0xFE, 0x7F, 0x1F, 0x8F,
  0xFF, 0xC7, 0xE3, 0xF1, 0xFF, 0xF8, 0xFE, 0xFC, 0x3F, 0xFF, 0x0F, 0xDF,
  0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x7C,
  0x03, 0xFF, 0xF0, 0x0F, 0x00, 0x7F, 0xFE, 0x00, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1C, 0x01, 0xFF, 0xF8, 0x03, 0x00, 0x3F, 0xFF, 0x00, 0x20, 0x07, 0xFF,
  0xE0, 0x08, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFC, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0xFE, 0x00,
  0x3F, 0xFE, 0xFE, 0x00, 0x3F, 0xFE, 0xFE, 0x00, 0x3F, 0xFE, 0x7F, 0x00,
  0x3F, 0xFE, 0x7F, 0x00, 0x3F, 0xFE, 0x3F, 0x80, 0x3F, 0xFE, 0x3F, 0x80,
  0x3F, 0xFE, 0x3F, 0x80, 0x3F, 0xFE, 0x1F, 0xC0, 0x3F, 0xFE, 0x1F, 0xC0,
  0x3F, 0xFE, 0x1F, 0xC0, 0x3F, 0xFE, 0x0F, 0xE0, 0x3F, 0xFE, 0x0F, 0xE0,
  0x3F, 0xFE, 0x07, 0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x3F, 0xFE, 0x07, 0xF0,
  0x3F, 0xFE, 0x03, 0xF8, 0x3F, 0xFE, 0x03, 0xF8, 0x3F, 0xFE, 0x01, 0xF8,
  0x3F, 0xFE, 0x01, 0xFC, 0x3F, 0xFE, 0x01, 0xFC, 0x3F, 0xFE, 0x00, 0xFE,
  0x3F, 0xFE, 0x00, 0xFE, 0x3F, 0xFE, 0x00, 0xFE, 0x3F, 0xFE, 0x00, 0x7F,
  0x3F, 0xFE, 0x00, 0x7F, 0x3F, 0xFE, 0x00, 0x3F, 0x3F, 0xFE, 0x00, 0x3F,
  0xBF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x07, 0xFC, 0x3F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0x00, 0x01, 0xFF,
  0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFC, 0xFF,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x7F,
  0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x00,
  0x60, 0x3F, 0xC0, 0x00, 0x04, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0x00, 0xFF, 0x0C, 0x00,
  0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xC7, 0xFF, 0xC0, 0x3F,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x87, 0xFF,
  0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xE0,
  0x1F, 0xE0, 0x1F, 0xCF, 0xE0, 0x3F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0xC0,
  0x7F, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x7F, 0x01, 0xFF, 0x01, 0xFC, 0xFE,
  0x07, 0xFE, 0x03, 0xF9, 0xFC, 0x0F, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xFC,
  0x0F, 0xC7, 0xF0, 0x3F, 0xF8, 0x1F, 0x8F, 0xE0, 0x7D, 0xF0, 0x3F, 0x1F,
  0xC1, 0xFB, 0xE0, 0x7E, 0x3F, 0x83, 0xF7, 0xC0, 0xFC, 0x3F, 0x07, 0xCF,
  0xC1, 0xF8, 0x7E, 0x0F, 0x9F, 0x83, 0xF0, 0xFC, 0x1F, 0x1F, 0x0F, 0xE1,
  0xF8, 0x3E, 0x3E, 0x1F, 0xC3, 0xF0, 0xFC, 0x7C, 0x3F, 0x87, 0xF1, 0xF8,
  0xFC, 0x7F, 0x0F, 0xE3, 0xE1, 0xF8, 0xFE, 0x1F, 0xC7, 0xC3, 0xF1, 0xFC,
  0x3F, 0x8F, 0x83, 0xE3, 0xF8, 0x7F, 0x3F, 0x07, 0xC7, 0xE0, 0xFE, 0x7E,
  0x0F, 0xCF, 0xC1, 0xFC, 0xF8, 0x1F, 0x9F, 0x83, 0xF9, 0xF0, 0x3F, 0x3F,
  0x07, 0xF3, 0xE0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0xDF,
  0x80, 0xF9, 0xF8, 0x1F, 0xBF, 0x01, 0xFB, 0xF0, 0x3F, 0x7C, 0x03, 0xF7,
  0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xE0, 0x00,
  0x00, 0x3E, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x10, 0x00, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x02, 0x00, 0x78, 0x0F, 0xC1, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x03, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x03, 0xFC, 0x00,
  0xE0, 0x00, 0x1F, 0xE0, 0x04, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x07, 0xFE, 0x07, 0xFE, 0x03, 0xEF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0xC0,
  0x3F, 0x87, 0xFF, 0xF8, 0x1F, 0xC7, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFF,
  0x87, 0xF3, 0xFF, 0xFF, 0xE3, 0xFB, 0xC0, 0x7F, 0xF1, 0xFF, 0x80, 0x0F,
  0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9,
  0xFD, 0xE0, 0x3F, 0xF8, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0x3F, 0xFF, 0xFC,
  0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xC3, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x7C, 0x3F, 0xC0, 0x00,
  0x70, 0x7F, 0x80, 0x00, 0x40, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x20, 0x3F, 0xC0, 0x00, 0x38, 0x3F, 0xC0, 0x00,
  0x7E, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x07,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0x8F, 0xF0,
  0xFF, 0xFF, 0xE7, 0xF8, 0xFF, 0xFF, 0xFB, 0xFC, 0xFF, 0xF0, 0x3F, 0xFE,
  0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFC, 0xFF,
  0xC0, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0x87,
  0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF, 0x0F, 0xF0,
  0x1F, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x80, 0xFE, 0x00, 0x00, 0x30, 0x3F, 0xC0, 0x00, 0x1E, 0x07,
  0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0x00, 0x00, 0x0F, 0xF7, 0xE0,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x0F, 0xFF, 0x03, 0xFC, 0x7F, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0x8F, 0xF7,
  0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x7F, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFB, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x01, 0xFE,
  0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xFB, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x0F,
  0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x03, 0xFE, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x3F, 0x0F, 0xE3, 0xFC, 0x0F,
  0xFC, 0xFE, 0x7F, 0xE1, 0xFF, 0xCF, 0xEF, 0xFF, 0x3F, 0xFE, 0xFE, 0xFF,
  0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x0F, 0xFF,
  0xF0, 0x3F, 0xE0, 0x7F, 0xFE, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x0F, 0xFF, 0x03, 0xFC,
  0x7F, 0xFF, 0x07, 0xF9, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xFF, 0x1F, 0xEF,
  0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0xFF, 0x80,
  0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0xFE, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x03, 0xFF, 0xC0, 0x3F, 0x87,
  0xFF, 0xF8, 0x1F, 0xC7, 0xFF, 0xFE, 0x0F, 0xE7, 0xFF, 0xFF, 0x87, 0xF3,
  0xFF, 0xFF, 0xE3, 0xFB, 0xC0, 0x7F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC, 0xFF,
  0x80, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x1F, 0xF7, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x1F, 0xF9, 0xFD, 0xE0,
  0x3F, 0xF8, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0x3F, 0xFF, 0xFC, 0x3F, 0x8F,
  0xFF, 0xFC, 0x1F, 0xC3, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF,
  0x8F, 0xF0, 0xFF, 0xFF, 0xE7, 0xF8, 0xFF, 0xFF, 0xFB, 0xFC, 0xFF, 0xF0,
  0x3F, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xE0,
  0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF,
  0x7F, 0x87, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0xFF,
  0x0F, 0xF0, 0x1F, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0x0F, 0xF3, 0xFF, 0xF8, 0x01,
  0xFE, 0xF8, 0x00, 0x00, 0x3F, 0xDC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xE0, 0x0F, 0xFC, 0x3F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3C, 0x1F,
  0xE0, 0x00, 0x04, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE1, 0x80, 0x00, 0x07, 0xF1, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x1E, 0xFF,
  0x3F, 0xFF, 0xFD, 0xFE, 0x7F, 0xFF, 0xF3, 0xFC, 0x7F, 0xFF, 0xC7, 0xF8,
  0x7F, 0xFF, 0x0F, 0xF0, 0x3F, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x7E, 0x00, 0xFF,
  0x80, 0x3F, 0x7E, 0x00, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0x80, 0x7F,
  0x7F, 0x00, 0xFF, 0x80, 0x7E, 0x7F, 0x00, 0xFF, 0x80, 0x7E, 0x7F, 0x01,
  0xFF, 0xC0, 0x7E, 0x3F, 0x01, 0xF7, 0xC0, 0x7E, 0x3F, 0x01, 0xF7, 0xC0,
  0x7E, 0x3F, 0x01, 0xF7, 0xC0, 0x7E, 0x3F, 0x01, 0xE7, 0xC0, 0x7E, 0x3F,
  0x03, 0xE7, 0xC0, 0xFC, 0x3F, 0x83, 0xE3, 0xE0, 0xFC, 0x3F, 0x83, 0xE3,
  0xE0, 0xFC, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x1F, 0x83, 0xE3, 0xE0, 0xFC,
  0x1F, 0x83, 0xC3, 0xE0, 0xFC, 0x1F, 0x87, 0xC3, 0xE0, 0xFC, 0x1F, 0x87,
  0xC1, 0xF0, 0xFC, 0x1F, 0x87, 0xC1, 0xF1, 0xF8, 0x1F, 0x87, 0xC1, 0xF1,
  0xF8, 0x0F, 0xC7, 0xC1, 0xF1, 0xF8, 0x0F, 0xC7, 0x81, 0xF1, 0xF8, 0x0F,
  0xCF, 0x81, 0xF1, 0xF8, 0x0F, 0xCF, 0x80, 0xF9, 0xF8, 0x0F, 0xCF, 0x80,
  0xF9, 0xF8, 0x0F, 0xCF, 0x80, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0xF9, 0xF0,
  0x07, 0xDF, 0x00, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF1, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07,
  0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0x80,
  0x3F, 0xF0, 0x00, 0x3F, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0xFF, 0xFE, 0x00,
  0x3F, 0x0F, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xFF, 0x00, 0x7E, 0x3F, 0xC7,
  0xF8, 0x07, 0xE3, 0xF8, 0x3F, 0xC0, 0x7E, 0x3F, 0x01, 0xFE, 0x0F, 0xE7,
  0xF0, 0x0F, 0xF1, 0xFC, 0x7E, 0x00, 0xFF, 0xFF, 0xC7, 0xE0, 0x07, 0xFF,
  0xF8, 0x7E, 0x00, 0x3F, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0xF0, 0xFC, 0x00,
  0x0F, 0xFC, 0x01, 0xC0, 0x00, 0x3F, 0x00,
};

const GFXglyph IBMPlexMono_Medium71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 12, 51, 43, 15, -50 },
  { 78, 21, 21, 43, 11, -53 },
  { 134, 41, 50, 43, 1, -50 },
  { 391, 37, 65, 43, 3, -57 },
  { 692, 41, 51, 43, 1, -50 },
  { 954, 40, 51, 43, 1, -50 },
  { 1209, 7, 21, 43, 18, -53 },
  { 1228, 22, 64, 43, 14, -54 },
  { 1404, 23, 64, 43, 6, -54 },
  { 1588, 37, 36, 43, 3, -39 },
  { 1755, 34, 34, 43, 4, -39 },
  { 1900, 15, 21, 43, 13, -11 },
  { 1940, 21, 7, 43, 11, -25 },
  { 1959, 12, 12, 43, 15, -11 },
  { 1977, 31, 64, 43, 6, -54 },
  { 2225, 36, 51, 43, 3, -50 },
  { 2455, 37, 50, 43, 3, -50 },
  { 2687, 35, 50, 43, 4, -50 },
  { 2906, 35, 51, 43, 3, -50 },
  { 3130, 38, 50, 43, 2, -50 },
  { 3368, 35, 51, 43, 4, -50 },
  { 3592, 35, 51, 43, 4, -50 },
  { 3816, 34, 50, 43, 4, -50 },
  { 4029, 36, 51, 43, 3, -50 },
  { 4259, 35, 50, 43, 4, -50 },
  { 4478, 12, 38, 43, 15, -37 },
  { 4535, 15, 47, 43, 13, -37 },
  { 4624, 31, 42, 43, 6, -43 },
  { 4787, 34, 21, 43, 4, -32 },
  { 4877, 31, 42, 43, 6, -43 },
  { 5040, 32, 51, 43, 5, -50 },
  { 5244, 34, 58, 43, 4, -50 },
  { 5491, 40, 50, 43, 1, -50 },
  { 5741, 33, 50, 43, 6, -50 },
  { 5948, 35, 51, 43, 4, -50 },
  { 6172, 33, 50, 43, 6, -50 },
  { 6379, 31, 50, 43, 6, -50 },
  { 6573, 32, 50, 43, 6, -50 },
  { 6773, 35, 51, 43, 3, -50 },
  { 6997, 32, 50, 43, 5, -50 },
  { 7197, 31, 50, 43, 6, -50 },
  { 7391, 31, 51, 43, 4, -50 },
  { 7589, 36, 50, 43, 6, -50 },
  { 7814, 30, 50, 43, 8, -50 },
  { 8002, 35, 50, 43, 4, -50 },
  { 8221, 32, 50, 43, 5, -50 },
  { 8421, 36, 51, 43, 3, -50 },
  { 8651, 33, 50, 43, 6, -50 },
  { 8858, 36, 63, 43, 3, -50 },
  { 9142, 34, 50, 43, 6, -50 },
  { 9355, 36, 51, 43, 3, -50 },
  { 9585, 39, 50, 43, 2, -50 },
  { 9829, 33, 51, 43, 5, -50 },
  { 10040, 39, 50, 43, 2, -50 },
  { 10284, 39, 50, 43, 2, -50 },
  { 10528, 40, 50, 43, 1, -50 },
  { 10778, 41, 50, 43, 1, -50 },
  { 11035, 36, 50, 43, 3, -50 },
  { 11260, 21, 64, 43, 15, -54 },
  { 11428, 31, 64, 43, 6, -54 },
  { 11676, 21, 64, 43, 7, -54 },
  { 11844, 37, 31, 43, 3, -50 },
  { 11988, 34, 7, 43, 4, 6 },
  { 12018, 13, 15, 43, 12, -56 },
  { 12043, 36, 38, 43, 4, -37 },
  { 12214, 33, 54, 43, 6, -53 },
  { 12437, 32, 38, 43, 5, -37 },
  { 12589, 33, 54, 43, 4, -53 },
  { 12812, 34, 38, 43, 4, -37 },
  { 12974, 34, 53, 43, 5, -53 },
  { 13200, 36, 57, 43, 4, -42 },
  { 13457, 31, 53, 43, 6, -53 },
  { 13663, 32, 54, 43, 7, -54 },
  { 13879, 25, 68, 43, 7, -54 },
  { 14092, 35, 53, 43, 6, -53 },
  { 14324, 32, 53, 43, 5, -53 },
  { 14536, 36, 37, 43, 3, -37 },
  { 14703, 31, 37, 43, 6, -37 },
  { 14847, 35, 38, 43, 4, -37 },
  { 15014, 33, 51, 43, 6, -37 },
  { 15225, 33, 51, 43, 4, -37 },
  { 15436, 35, 37, 43, 5, -37 },
  { 15598, 33, 38, 43, 4, -37 },
  { 15755, 34, 50, 43, 3, -50 },
  { 15968, 31, 38, 43, 6, -37 },
  { 16116, 36, 37, 43, 3, -37 },
  { 16283, 40, 37, 43, 1, -37 },
  { 16468, 36, 37, 43, 3, -37 },
  { 16635, 37, 51, 43, 3, -37 },
  { 16871, 32, 37, 43, 5, -37 },
  { 17019, 29, 64, 43, 7, -54 },
  { 17251, 7, 64, 43, 18, -54 },
  { 17307, 29, 64, 43, 7, -54 },
  { 17539, 36, 16, 43, 3, -30 },
};

const GFXfont IBMPlexMono_Medium71pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium71pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium71pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _IBMPLEXMONO_MEDIUM71PT7B_H_
