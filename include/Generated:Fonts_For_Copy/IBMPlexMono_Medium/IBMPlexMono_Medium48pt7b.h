#ifndef _IBMPLEXMONO_MEDIUM48PT7B_H_
#define _IBMPLEXMONO_MEDIUM48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium48pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E,
  0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x01,
  0xFF, 0xC1, 0xFF, 0xBF, 0xF8, 0x3F, 0xF7, 0xFF, 0x07, 0xFE, 0xFF, 0xE1,
  0xFF, 0xC0, 0x7C, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x0F, 0xFC, 0x1F,
  0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x1F, 0xCF, 0x7F, 0x8F, 0xC7, 0x87, 0x87, 0xC3, 0xC1, 0x87, 0xC1,
  0xE0, 0x83, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7E,
  0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0xC7, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x3F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC3,
  0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x3C,
  0x1F, 0x10, 0x1E, 0x1F, 0x9C, 0x0F, 0x0F, 0x9F, 0x87, 0x8F, 0xDF, 0xF3,
  0xDF, 0xC7, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xE7, 0xFE, 0x00,
  0x7D, 0xFF, 0xE0, 0x0F, 0x3F, 0xFC, 0x03, 0xEF, 0x87, 0xC0, 0x79, 0xE0,
  0x78, 0x1F, 0x3C, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0xF8, 0xF0, 0x3C, 0x1E,
  0x1E, 0x07, 0x87, 0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x3E, 0x0F, 0x87,
  0xC7, 0x80, 0xFF, 0xF1, 0xF0, 0x1F, 0xFE, 0x3C, 0x01, 0xFF, 0x88, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0xF1,
  0xFF, 0xC0, 0x3E, 0x3F, 0xFC, 0x07, 0x8F, 0x87, 0x81, 0xF1, 0xE0, 0x78,
  0x3C, 0x3C, 0x0F, 0x0F, 0x87, 0x01, 0xE1, 0xE1, 0xE0, 0x3C, 0x7C, 0x3C,
  0x07, 0x8F, 0x03, 0x80, 0xF3, 0xE0, 0x78, 0x1E, 0x78, 0x0F, 0x03, 0xDF,
  0x01, 0xF0, 0xF3, 0xC0, 0x1F, 0xFE, 0xF8, 0x03, 0xFF, 0x9E, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x03,
  0xE0, 0x07, 0xC0, 0x30, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xF0, 0x1F, 0xC1, 0xFF, 0x03, 0xF8, 0x7F, 0xF0, 0x7F, 0x1F, 0x3E, 0x0F,
  0xE7, 0xC3, 0xE1, 0xE0, 0xF8, 0x7E, 0x3C, 0x3E, 0x07, 0xEF, 0x07, 0xC0,
  0x7D, 0xE0, 0xF8, 0x07, 0xFC, 0x1F, 0x00, 0x7F, 0x83, 0xE0, 0x0F, 0xE0,
  0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xFC, 0x1F, 0xC1,
  0xEF, 0xC1, 0xFF, 0xF8, 0xFC, 0x1F, 0xFE, 0x0F, 0xC1, 0xFF, 0x80, 0xFC,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x7C,
  0x0E, 0x7E, 0x3E, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3C, 0x01, 0xC0,
  0x04, 0x00, 0x40, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFC,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0,
  0x00, 0xFB, 0xF0, 0xF0, 0x7F, 0xF8, 0x7C, 0x3F, 0xFC, 0x7E, 0x1F, 0xFE,
  0x3F, 0x0F, 0xFF, 0x0F, 0x87, 0xFF, 0x87, 0x83, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xE1, 0xF8, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x7F, 0x0F, 0x80,
  0x7F, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x07, 0x01, 0xF0, 0x01, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF0, 0x7F, 0x9F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x38, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0x83, 0xFC,
  0x3E, 0x00, 0xFC, 0x1C, 0x00, 0x7E, 0x08, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x10, 0x00, 0x3F, 0x38, 0x00, 0x3E, 0x78, 0x00, 0x7E,
  0xFC, 0x00, 0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7C, 0xFC, 0x00,
  0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xE0, 0xFC,
  0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E,
  0x00, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x87,
  0xE0, 0x1F, 0x3F, 0xF8, 0x3E, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFE, 0x07,
  0xF9, 0xF8, 0x03, 0xF0, 0x60, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x40, 0x01, 0xF9, 0xC0, 0x03, 0xF7, 0x80, 0x0F, 0xDF, 0x80, 0x1F, 0x9F,
  0xC0, 0xFE, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x1F, 0x3F, 0xF8, 0x7E, 0xFF, 0xF8,
  0xFB, 0xFF, 0xF9, 0xF7, 0x07, 0xFB, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xC0,
  0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0x78, 0x00, 0x7E, 0xF0, 0x00, 0xF9, 0xE0, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x1F,
  0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0x83,
  0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF, 0x80, 0x03,
  0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0x81, 0xFC, 0x3F, 0x00, 0x7C, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x3F,
  0x81, 0xDF, 0x1F, 0xFF, 0xBF, 0x1F, 0xFF, 0xBF, 0x07, 0xFE, 0x3E, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xF9,
  0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x8F, 0xEF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0x1F, 0x00, 0x1F,
  0x0F, 0xE7, 0xF9, 0xFF, 0x7F, 0xDF, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0xFF,
  0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1E,
  0x0F, 0x83, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F,
  0x83, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x08, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0,
  0xFC, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x7C, 0x00, 0x1F, 0x78, 0x0F, 0x8F, 0x78, 0x1F, 0xCF, 0x78, 0x3F,
  0xEF, 0x78, 0x3F, 0xFF, 0x78, 0x7C, 0x3F, 0x78, 0x78, 0x1F, 0x78, 0x78,
  0x0F, 0xF8, 0x78, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0xF8,
  0x0F, 0x78, 0xF8, 0x0F, 0x78, 0x78, 0x0F, 0x78, 0x78, 0x0F, 0x78, 0x78,
  0x1F, 0x78, 0x7C, 0x1F, 0x78, 0x7F, 0xFF, 0x78, 0x3F, 0xEF, 0x78, 0x3F,
  0xCF, 0x3C, 0x1F, 0xCF, 0x3C, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07,
  0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F,
  0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0xFC, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFC, 0xF8, 0x07, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8,
  0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x7E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3E, 0x00, 0xFE, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFC, 0x1F, 0xC7, 0xE0, 0x1F, 0x8F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7C,
  0x00, 0x38, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0xE3, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7,
  0xE0, 0x1F, 0x87, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0x1F, 0x00, 0x7E, 0x3E, 0x00,
  0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xFB, 0xE0, 0x01,
  0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C,
  0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0,
  0x0F, 0xCF, 0x80, 0x3F, 0x1F, 0x01, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xC1, 0xFC, 0x1F, 0x80, 0xFE, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E,
  0x00, 0x3D, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x80, 0x7F, 0x1F, 0xC1, 0xDF, 0x0F, 0xFF, 0x9F, 0x0F,
  0xFF, 0x9F, 0x03, 0xFF, 0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC6, 0x00, 0x7F, 0xF0,
  0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x01, 0xF9, 0xFC, 0x1F, 0x87, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFE, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8,
  0x07, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8,
  0x3F, 0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0xFC, 0x00, 0xF9,
  0xF8, 0x00, 0xF9, 0xF8, 0x00, 0xFB, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFB, 0xC1, 0xFF, 0xF7, 0x83, 0xFF, 0xEF, 0x8F,
  0x7F, 0xCF, 0x1E, 0xFF, 0x9F, 0x3D, 0xFF, 0x1E, 0xF3, 0xFE, 0x3D, 0xE7,
  0xFC, 0x7F, 0x8F, 0xF8, 0x7F, 0x1F, 0xF0, 0xFE, 0x3F, 0xE0, 0xF8, 0x7F,
  0xC1, 0xF0, 0xFF, 0x83, 0xE1, 0xFF, 0x03, 0x83, 0xFE, 0x07, 0x07, 0xFC,
  0x0C, 0x0F, 0xF8, 0x08, 0x1F, 0xF0, 0x10, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFB, 0xE0, 0x3F, 0xEF,
  0x80, 0xFF, 0x9E, 0x03, 0xFE, 0x7C, 0x0F, 0xF9, 0xF0, 0x3F, 0xE3, 0xC0,
  0xFF, 0x8F, 0x83, 0xFE, 0x3E, 0x0F, 0xF8, 0x7C, 0x3F, 0xE1, 0xF0, 0xFF,
  0x83, 0xC3, 0xFE, 0x0F, 0x8F, 0xF8, 0x3E, 0x3F, 0xE0, 0x78, 0xFF, 0x81,
  0xF3, 0xFE, 0x07, 0xCF, 0xF8, 0x0F, 0xBF, 0xE0, 0x3E, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1,
  0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x01,
  0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3,
  0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0xF8, 0x03, 0xFB,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01,
  0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3,
  0xF0, 0x07, 0xC0, 0xFE, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0x80, 0x3F, 0x9F, 0x00,
  0x1F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x1F,
  0xBE, 0x00, 0x3F, 0x7C, 0x01, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x3F, 0xC0,
  0xFF, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x1C, 0x7E, 0x00, 0x08, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x30, 0x00, 0x3F, 0x78, 0x00,
  0x3F, 0xFE, 0x00, 0x7E, 0xFF, 0x81, 0xFE, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0xFD, 0xF8, 0x03,
  0xE3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1E, 0x78, 0x1F, 0x03, 0xCF, 0x03, 0xE0, 0xF9, 0xF0, 0xFE, 0x1F, 0x3E,
  0x1F, 0xC3, 0xE7, 0xC3, 0xF8, 0x7C, 0xF8, 0x7F, 0x0F, 0x9F, 0x0E, 0xE1,
  0xF3, 0xE3, 0xDE, 0x3E, 0x7C, 0x7B, 0xC7, 0x8F, 0x8F, 0x78, 0xF0, 0xF1,
  0xCF, 0x1E, 0x1E, 0x38, 0xE3, 0xC3, 0xCF, 0x1C, 0x78, 0x79, 0xE3, 0xCF,
  0x0F, 0x3C, 0x79, 0xE1, 0xE7, 0x8F, 0x3C, 0x3C, 0xE1, 0xE7, 0x87, 0x9C,
  0x1D, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7C, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x83,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xF0, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEE, 0x00, 0x01, 0xC1, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x18, 0x3E, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x81,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x7E, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x10, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFE, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF8, 0xFC, 0x03, 0xF8, 0xFE, 0x06, 0xFF, 0x7F, 0xFE, 0xFF, 0x3F, 0xFC,
  0x7F, 0x1F, 0xF8, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x0F, 0xC0, 0xF8, 0xFF, 0xC3, 0xE7, 0xFF, 0x8F, 0xBF, 0xFF,
  0x3F, 0xC1, 0xFE, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFF,
  0x07, 0xFB, 0xEF, 0xFF, 0xCF, 0x9F, 0xFE, 0x3E, 0x3F, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3,
  0xF8, 0x3F, 0x3F, 0x00, 0xFD, 0xF0, 0x03, 0x9F, 0x80, 0x10, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x10, 0xF8, 0x00, 0xE7, 0xE0, 0x0F, 0x9F, 0xC1, 0xFC, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0xC1, 0xF0, 0x7F, 0xE3, 0xE1,
  0xFF, 0xE7, 0xC7, 0xFF, 0xEF, 0x9F, 0xE0, 0xDF, 0x3F, 0x00, 0xFE, 0xFC,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x07,
  0xDF, 0x80, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x81, 0xBE, 0x3F, 0xFF, 0x7C,
  0x3F, 0xFC, 0xF8, 0x3F, 0xF1, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x87,
  0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x43, 0xF0, 0x01, 0xC3, 0xE0, 0x07, 0xC7, 0xF0, 0x3F,
  0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0xC0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0x03, 0xF8, 0x3E,
  0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x38,
  0x00, 0x3F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x7E,
  0x0F, 0x8F, 0xFC, 0x7C, 0xFF, 0xF3, 0xEF, 0xFF, 0xDF, 0x60, 0xFE, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF9, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xFF, 0x87, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0xFE, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07,
  0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0xFB, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0xFE, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF9, 0xF0, 0x7C, 0x7D, 0xFC, 0x7F, 0x3F, 0xFF, 0x7F,
  0xDF, 0xFF, 0xFF, 0xEF, 0xC7, 0xF1, 0xF7, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8,
  0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F,
  0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0,
  0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE,
  0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F,
  0xE0, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F, 0xF8, 0x3E, 0x0F, 0x80, 0xF8, 0x3F,
  0x07, 0xC7, 0xFE, 0x3E, 0x7F, 0xF9, 0xF7, 0xFF, 0xEF, 0xB0, 0x7F, 0x7E,
  0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x1F,
  0x7E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xE0, 0x0F, 0x87, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xF8, 0x3F, 0x03, 0xE3, 0xFF,
  0x0F, 0x9F, 0xFE, 0x3E, 0xFF, 0xFC, 0xFF, 0x07, 0xFB, 0xF0, 0x07, 0xEF,
  0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3E, 0xFC, 0x01, 0xFB, 0xFC, 0x1F, 0xEF, 0xBF, 0xFF, 0x3E, 0x7F,
  0xF8, 0xF8, 0xFF, 0xC3, 0xE0, 0xFC, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x3E, 0x0F,
  0xFC, 0x7C, 0x3F, 0xFC, 0xF8, 0xFF, 0xFD, 0xF3, 0xFC, 0x1B, 0xE7, 0xE0,
  0x1F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xF0, 0x37, 0xC7,
  0xFF, 0xEF, 0x87, 0xFF, 0x9F, 0x07, 0xFE, 0x3E, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F,
  0xF0, 0x3E, 0x60, 0x00, 0x7D, 0x80, 0x00, 0xFA, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x3F, 0x01, 0xF9, 0xF8, 0x01, 0xC7, 0xC0, 0x01, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF2, 0x00, 0x07, 0xCC, 0x00, 0x1F, 0x7C, 0x00, 0xFF, 0xFC,
  0x07, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xBF, 0x83,
  0x7D, 0xFF, 0xFB, 0xE7, 0xFF, 0x9F, 0x1F, 0xF8, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0x80, 0x07,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xFF, 0x03,
  0xE0, 0x7F, 0xE0, 0x7C, 0x0F, 0xFC, 0x1F, 0xC1, 0xE7, 0x83, 0xF8, 0x3C,
  0xF0, 0x7F, 0x07, 0x9E, 0x0E, 0xE0, 0xF3, 0xC1, 0xDC, 0x1E, 0x78, 0x7B,
  0xC3, 0xCF, 0x8F, 0x78, 0xF9, 0xF1, 0xCF, 0x1E, 0x1E, 0x38, 0xE3, 0xC3,
  0xC7, 0x1C, 0x78, 0x78, 0xE3, 0x8F, 0x0F, 0x3C, 0x79, 0xE1, 0xE7, 0x8F,
  0x3C, 0x3C, 0xE0, 0xE7, 0x87, 0x9C, 0x1C, 0xE0, 0x7B, 0x83, 0xBC, 0x0F,
  0x70, 0x77, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x1F,
  0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7,
  0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xF8,
  0x1F, 0x80, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xFC, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFE,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x06, 0x07, 0xF8, 0x07, 0xC7, 0xFE,
  0x03, 0xC7, 0xFF, 0x01, 0xE3, 0xC7, 0xC0, 0xF3, 0xE1, 0xF0, 0xF1, 0xE0,
  0x7C, 0x78, 0xF0, 0x3F, 0xFC, 0xF0, 0x0F, 0xFC, 0x78, 0x03, 0xFC, 0x0C,
  0x00, 0x78, 0x00,
};

const GFXglyph IBMPlexMono_Medium48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 34, 29, 10, -34 },
  { 35, 15, 14, 29, 7, -36 },
  { 62, 27, 34, 29, 1, -34 },
  { 177, 25, 45, 29, 2, -39 },
  { 318, 27, 35, 29, 1, -34 },
  { 437, 27, 35, 29, 1, -34 },
  { 556, 5, 14, 29, 12, -36 },
  { 565, 15, 43, 29, 9, -36 },
  { 646, 16, 43, 29, 4, -36 },
  { 732, 25, 24, 29, 2, -26 },
  { 807, 23, 24, 29, 3, -27 },
  { 876, 10, 14, 29, 9, -7 },
  { 894, 15, 5, 29, 7, -17 },
  { 904, 9, 8, 29, 10, -7 },
  { 913, 21, 43, 29, 4, -36 },
  { 1026, 25, 35, 29, 2, -34 },
  { 1136, 25, 34, 29, 2, -34 },
  { 1243, 23, 34, 29, 3, -34 },
  { 1341, 24, 35, 29, 2, -34 },
  { 1446, 26, 34, 29, 1, -34 },
  { 1557, 23, 35, 29, 3, -34 },
  { 1658, 23, 35, 29, 3, -34 },
  { 1759, 23, 34, 29, 3, -34 },
  { 1857, 25, 35, 29, 2, -34 },
  { 1967, 24, 34, 29, 2, -34 },
  { 2069, 9, 26, 29, 10, -25 },
  { 2099, 10, 32, 29, 9, -25 },
  { 2139, 21, 28, 29, 4, -29 },
  { 2213, 23, 14, 29, 3, -22 },
  { 2254, 21, 28, 29, 4, -29 },
  { 2328, 22, 34, 29, 3, -34 },
  { 2422, 24, 39, 29, 2, -34 },
  { 2539, 27, 34, 29, 1, -34 },
  { 2654, 22, 34, 29, 4, -34 },
  { 2748, 23, 35, 29, 3, -34 },
  { 2849, 23, 34, 29, 4, -34 },
  { 2947, 21, 34, 29, 4, -34 },
  { 3037, 22, 34, 29, 4, -34 },
  { 3131, 24, 35, 29, 2, -34 },
  { 3236, 22, 34, 29, 3, -34 },
  { 3330, 21, 34, 29, 4, -34 },
  { 3420, 21, 35, 29, 3, -34 },
  { 3512, 24, 34, 29, 4, -34 },
  { 3614, 21, 34, 29, 5, -34 },
  { 3704, 23, 34, 29, 3, -34 },
  { 3802, 22, 34, 29, 3, -34 },
  { 3896, 25, 35, 29, 2, -34 },
  { 4006, 22, 34, 29, 4, -34 },
  { 4100, 25, 42, 29, 2, -34 },
  { 4232, 23, 34, 29, 4, -34 },
  { 4330, 24, 35, 29, 2, -34 },
  { 4435, 27, 34, 29, 1, -34 },
  { 4550, 22, 35, 29, 3, -34 },
  { 4647, 27, 34, 29, 1, -34 },
  { 4762, 27, 34, 29, 1, -34 },
  { 4877, 27, 34, 29, 1, -34 },
  { 4992, 27, 34, 29, 1, -34 },
  { 5107, 25, 34, 29, 2, -34 },
  { 5214, 14, 43, 29, 10, -36 },
  { 5290, 21, 43, 29, 4, -36 },
  { 5403, 14, 43, 29, 5, -36 },
  { 5479, 25, 21, 29, 2, -34 },
  { 5545, 23, 4, 29, 3, 4 },
  { 5557, 9, 10, 29, 8, -38 },
  { 5569, 24, 26, 29, 3, -25 },
  { 5647, 22, 37, 29, 4, -36 },
  { 5749, 21, 26, 29, 4, -25 },
  { 5818, 23, 37, 29, 2, -36 },
  { 5925, 23, 26, 29, 3, -25 },
  { 6000, 23, 36, 29, 3, -36 },
  { 6104, 24, 39, 29, 3, -29 },
  { 6221, 21, 36, 29, 4, -36 },
  { 6316, 21, 37, 29, 5, -37 },
  { 6414, 18, 47, 29, 4, -37 },
  { 6520, 24, 36, 29, 4, -36 },
  { 6628, 21, 36, 29, 4, -36 },
  { 6723, 25, 25, 29, 2, -25 },
  { 6802, 21, 25, 29, 4, -25 },
  { 6868, 23, 26, 29, 3, -25 },
  { 6943, 22, 35, 29, 4, -25 },
  { 7040, 23, 35, 29, 2, -25 },
  { 7141, 23, 25, 29, 4, -25 },
  { 7213, 22, 26, 29, 3, -25 },
  { 7285, 23, 34, 29, 2, -34 },
  { 7383, 21, 26, 29, 4, -25 },
  { 7452, 25, 25, 29, 2, -25 },
  { 7531, 27, 25, 29, 1, -25 },
  { 7616, 25, 25, 29, 2, -25 },
  { 7695, 25, 35, 29, 2, -25 },
  { 7805, 21, 25, 29, 4, -25 },
  { 7871, 19, 43, 29, 5, -36 },
  { 7974, 5, 43, 29, 12, -36 },
  { 8001, 19, 43, 29, 5, -36 },
  { 8104, 25, 11, 29, 2, -20 },
};

const GFXfont IBMPlexMono_Medium48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_MEDIUM48PT7B_H_
