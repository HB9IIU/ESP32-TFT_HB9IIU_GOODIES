#ifndef _IBMPLEXMONO_MEDIUM32PT7B_H_
#define _IBMPLEXMONO_MEDIUM32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium32pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xCE, 0x73, 0x9C, 0x62, 0x10, 0x00, 0x03,
  0xBF, 0xFF, 0xBC, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xC0, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x07, 0x1C, 0x0F, 0xE3, 0xF9, 0xFC, 0x7F, 0x3F, 0x8F,
  0xE0, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC1, 0xFE, 0x3F,
  0xBF, 0x87, 0xF7, 0xF1, 0xFE, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0xF3, 0x3E, 0xF1,
  0x8C, 0x78, 0xC0, 0x3C, 0x60, 0x1E, 0x30, 0x07, 0x98, 0x03, 0xFE, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0xCF, 0x80, 0x63, 0xC0, 0x31,
  0xE4, 0x18, 0xF7, 0x0C, 0x7F, 0xE6, 0x79, 0xFF, 0xF8, 0x3F, 0xF8, 0x07,
  0xF0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1F, 0x00, 0xE7, 0xF0,
  0x39, 0xFF, 0x06, 0x38, 0xE1, 0xC6, 0x1C, 0x71, 0xC1, 0x8E, 0x18, 0x73,
  0x83, 0x8E, 0x70, 0x7F, 0xDC, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xF8, 0x0E, 0x7F, 0x81, 0x9C, 0x70, 0x73, 0x87, 0x1C, 0x70,
  0xE3, 0x8E, 0x1C, 0xE1, 0xC7, 0x1C, 0x1F, 0xE7, 0x03, 0xF9, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xF1, 0xE0, 0x38, 0x30,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x83, 0xE1,
  0xF0, 0xF9, 0xFE, 0x3E, 0x73, 0xCE, 0x3C, 0xFB, 0x8E, 0x1E, 0xC3, 0x83,
  0xF0, 0xE0, 0x7C, 0x38, 0x0F, 0x0F, 0x87, 0xE1, 0xFF, 0xBC, 0x3F, 0xC7,
  0x07, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC1, 0xC0, 0xE0, 0x78,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x70, 0x0F, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38,
  0x0E, 0x07, 0x03, 0x83, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x0C, 0x1C, 0x13, 0x8E, 0x3B, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0xF8,
  0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEF, 0x00, 0xE3, 0xC0, 0xF0, 0xE0, 0xF0,
  0x78, 0x10, 0x10, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x3E, 0x79, 0xF3, 0xC7,
  0x8F, 0x1C, 0x38, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF7,
  0x80, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0x83, 0xC7, 0x80,
  0xF3, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x0F, 0x70, 0x07, 0xF8, 0xE3, 0xFC,
  0x79, 0xFE, 0x3C, 0xFF, 0x1C, 0x7B, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x0E,
  0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x07, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0x80, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xDE, 0x03, 0xEF, 0x03,
  0xE7, 0x83, 0xE3, 0xC0, 0xE1, 0xE0, 0x20, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC3, 0xEF, 0x03, 0xDC, 0x03, 0xC8,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7C, 0x3E, 0x38, 0x0F, 0x10, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x20, 0x0F, 0x70, 0x0F, 0xF8, 0x1E, 0x7F, 0xFE, 0x1F, 0xFC,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3B, 0x80, 0x3D,
  0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x07, 0x03, 0x87, 0x81, 0xC3, 0x80, 0xE3, 0x80, 0x71, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x73, 0xE0, 0x77, 0xF8, 0x7F, 0xFC, 0x78,
  0x3E, 0x30, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x20, 0x0E, 0x70,
  0x1E, 0xF8, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x73, 0xF0, 0xF7, 0xF8, 0xFF, 0xFC, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0x78, 0x3E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xB8, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0x83, 0xE7, 0x80, 0xF3, 0xC0, 0x79,
  0xE0, 0x3C, 0x70, 0x1E, 0x3C, 0x1E, 0x0F, 0xFE, 0x01, 0xFC, 0x03, 0xFF,
  0x83, 0xC1, 0xF3, 0xC0, 0x79, 0xC0, 0x1F, 0xE0, 0x0F, 0x70, 0x07, 0xBC,
  0x07, 0x9F, 0x07, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x3C, 0xF0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F, 0xEE, 0x3F, 0xDE,
  0x1F, 0x9E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7F, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x78, 0x3C, 0xF9, 0xF3, 0xE3, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE7, 0x9F, 0x3C, 0x78, 0xF1, 0xC3, 0x8E, 0x1C,
  0x00, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x80, 0xF0, 0x07, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x02, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x06, 0x00, 0x3C, 0x01, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x03, 0xF0, 0x7E,
  0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0xF0, 0x06, 0x00, 0x20, 0x00, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xEF, 0x01, 0xCE, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xE7,
  0x00, 0xFC, 0x01, 0xF8, 0x7B, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF, 0x1F, 0x9C,
  0x3F, 0x38, 0x7E, 0x70, 0xFC, 0xE1, 0xF9, 0xC3, 0xF3, 0x87, 0xE7, 0xFF,
  0xC7, 0xFF, 0x87, 0xBF, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0x70, 0x01, 0xDE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x0E,
  0x3C, 0x07, 0x8F, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x3C, 0x1E, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x78, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0xB8, 0x00, 0xF0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF,
  0xE7, 0x03, 0xCE, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1C, 0xE0, 0x79,
  0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70,
  0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xF7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x78, 0x1E, 0x70,
  0x0F, 0xF0, 0x08, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x08, 0x70, 0x0F, 0x78,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0x81, 0xFF,
  0xC3, 0xFF, 0xC7, 0x07, 0xCE, 0x03, 0xDC, 0x07, 0xB8, 0x07, 0x70, 0x0E,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC0, 0x7B, 0x83, 0xE7, 0xFF, 0x8F, 0xFE,
  0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xEF,
  0xFF, 0xBF, 0xFE, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x3E, 0x1E, 0x38, 0x0F, 0x78, 0x0F, 0x78, 0x08, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0xFF, 0xF0, 0xFF, 0x70, 0xFF, 0x70,
  0x07, 0x70, 0x07, 0x78, 0x07, 0x78, 0x07, 0x78, 0x0F, 0x3E, 0x1F, 0x3F,
  0xF7, 0x1F, 0xE7, 0x07, 0xC7, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0xF7, 0x87, 0x9F,
  0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0x3C, 0x0F, 0x9E,
  0x07, 0x8F, 0x07, 0x87, 0x87, 0x83, 0xC7, 0x81, 0xE7, 0xC0, 0xF3, 0xC0,
  0x7B, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xE7, 0x83, 0xE3,
  0xC1, 0xE0, 0xF0, 0xF0, 0x7C, 0x78, 0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xCF,
  0x00, 0xF7, 0x80, 0x7C, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0xE1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFB, 0x9B, 0xF7, 0x77, 0xE7, 0xEF,
  0xCF, 0x9F, 0x9F, 0x3F, 0x1C, 0x7E, 0x38, 0xFC, 0x31, 0xF8, 0x43, 0xF0,
  0x87, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xC0, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFD, 0xC1,
  0xFB, 0x83, 0xF3, 0x87, 0xE7, 0x0F, 0xCF, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E,
  0x1C, 0xFC, 0x39, 0xF8, 0x7B, 0xF0, 0x77, 0xE0, 0xEF, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x87, 0x83, 0xC7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x1C, 0xE0, 0x0F,
  0x70, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7B, 0x80,
  0x3D, 0xC0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x8F, 0x07, 0x83,
  0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7,
  0x01, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0,
  0x7B, 0xFF, 0xF7, 0xFF, 0xCF, 0xFE, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x1C, 0xE0, 0x0F, 0x70, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F,
  0x3C, 0x07, 0x8F, 0x07, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x01, 0xEE, 0x01, 0xDC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B, 0xFF, 0xE7, 0xFF, 0xCF, 0xFC,
  0x1C, 0x78, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xE7,
  0x01, 0xEE, 0x03, 0xDC, 0x03, 0xC0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0xC7, 0x83, 0xE7, 0x80, 0x63, 0xC0, 0x21, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x20, 0x07, 0x38, 0x07, 0xBF, 0x07, 0xCF, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1E,
  0xE0, 0x3D, 0xE0, 0xF3, 0xFF, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0xF0, 0x03,
  0xF8, 0x03, 0xDC, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x78, 0xE0,
  0x3C, 0x78, 0x1C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x03, 0xC3, 0x81,
  0xE3, 0xC0, 0x71, 0xE0, 0x3C, 0xE0, 0x1E, 0x70, 0x07, 0x78, 0x03, 0xB8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0x1F, 0x87, 0x8F,
  0xC7, 0xC7, 0xE3, 0xE3, 0xF9, 0xB1, 0xDC, 0xD8, 0xEE, 0x6E, 0x77, 0x77,
  0x3B, 0xB9, 0x99, 0xDC, 0xDC, 0xEC, 0x6E, 0x76, 0x3F, 0x3B, 0x1F, 0x9F,
  0x8F, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xF8, 0xF0, 0x07, 0x9E, 0x01,
  0xC3, 0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x1E, 0x07, 0x8F, 0x00, 0xF3, 0x80,
  0x1D, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x01, 0xDE, 0x00, 0xF7, 0x80, 0x38, 0xF0, 0x1E, 0x3C, 0x0F, 0x07,
  0x83, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x07, 0xBC, 0x01, 0xF0, 0xF8, 0x01,
  0xEF, 0x00, 0x78, 0xF0, 0x0E, 0x1E, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x1E,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0xEE, 0x00, 0xF7, 0x80, 0x71, 0xC0, 0x78, 0xF0, 0x38, 0x38,
  0x3C, 0x1E, 0x1C, 0x07, 0x1E, 0x03, 0xCE, 0x00, 0xEF, 0x00, 0x39, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x11, 0xCF, 0x8E, 0x3C, 0x70,
  0x80, 0x0F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF8, 0xF0, 0x78, 0x20, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x1F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0xF0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x3C, 0xF0, 0x7C, 0xFF, 0xDF, 0x7F, 0xDF, 0x1F, 0x0F, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x71, 0xF0, 0xEF, 0xF1, 0xDF, 0xF3, 0xE1, 0xF7, 0x01, 0xEE, 0x01, 0xDC,
  0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0x77, 0x01,
  0xEF, 0x87, 0xDD, 0xFF, 0x3B, 0xFC, 0x71, 0xF0, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF1, 0xE1, 0xE7, 0x81, 0xEE, 0x02, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x47, 0x80, 0xC7, 0x87, 0xCF, 0xFF,
  0x0F, 0xFC, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x8F, 0x8F, 0x3F, 0xDE, 0xFF, 0xFD, 0xE0,
  0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x83, 0xEF, 0xFF, 0xCF, 0xF7, 0x8F,
  0xCF, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x8F, 0x03, 0x8F, 0xFF, 0x8F, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0x01,
  0xFF, 0x03, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x3C, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x78, 0x3C, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F,
  0xE0, 0x30, 0x00, 0x70, 0x00, 0x7F, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x20,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xFF, 0xFE, 0x7F, 0xFC, 0x1F,
  0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0xF8, 0xE7, 0xF3, 0xBF, 0xEF, 0x87, 0xBC, 0x0E, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0x03, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xEF, 0xFE, 0xFF, 0xCF,
  0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x3E, 0xE0, 0x78, 0xE0, 0xF0, 0xE1, 0xE0, 0xE3,
  0xC0, 0xE7, 0x80, 0xEF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFB, 0xC0, 0xF1,
  0xE0, 0xE0, 0xF0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0,
  0x1F, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x1E,
  0x77, 0xCF, 0xBB, 0xFF, 0xDE, 0x3C, 0xFE, 0x1C, 0x3F, 0x0E, 0x1F, 0x87,
  0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E,
  0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0x80, 0xE3,
  0xE3, 0x9F, 0xCE, 0xFF, 0xBE, 0x1E, 0xF0, 0x3B, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3C, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xF3, 0xC1,
  0xEF, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x01, 0xEF, 0x07, 0x8F, 0xFF, 0x0F, 0xFC, 0x07,
  0xE0, 0xE3, 0xE1, 0xDF, 0xE3, 0xBF, 0xE7, 0xC3, 0xEE, 0x03, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x00, 0xEE,
  0x03, 0xDF, 0x0F, 0xBB, 0xFE, 0x77, 0xF8, 0xE3, 0xE1, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x1F, 0x1E, 0x7F,
  0xBD, 0xFF, 0xFB, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xEF, 0x07, 0xDF,
  0xFF, 0x9F, 0xEF, 0x1F, 0x9E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0x07,
  0x60, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F, 0xF0, 0xFF, 0xFB, 0xC0, 0xE7, 0x00,
  0x8E, 0x00, 0x1F, 0x80, 0x3F, 0xF8, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0xF6, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFC, 0x0F, 0xE0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xDF, 0xEF, 0x1F,
  0x3C, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x1C, 0x78,
  0x3C, 0x38, 0x38, 0x3C, 0x38, 0x3C, 0x78, 0x1C, 0x70, 0x1C, 0x70, 0x0E,
  0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0xE1,
  0xC1, 0xF8, 0x78, 0x6E, 0x1E, 0x3B, 0x8F, 0x8E, 0xE3, 0x63, 0xB8, 0xD8,
  0xE6, 0x36, 0x39, 0x8D, 0xCE, 0x77, 0x33, 0x1D, 0xCC, 0xC7, 0x63, 0x71,
  0xD8, 0xDC, 0x76, 0x3F, 0x1D, 0x8F, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C,
  0x1E, 0x00, 0x78, 0x0F, 0x9E, 0x07, 0x0F, 0x07, 0x83, 0xC7, 0x80, 0xF3,
  0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xFC, 0x01, 0xEF, 0x00, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x1E,
  0xF8, 0x0F, 0x80, 0xF0, 0x07, 0xB8, 0x03, 0x9E, 0x03, 0xC7, 0x01, 0xE3,
  0xC0, 0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x3C, 0x38, 0x0E, 0x3C, 0x07, 0x1C,
  0x01, 0xCE, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x07, 0x8F, 0xF8, 0x7E, 0x03, 0xFE,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xFC,
  0x3F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0xFC, 0x1F, 0xE1, 0xC0, 0x1E,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x00, 0x0E, 0x03, 0x9F, 0x81, 0xCF,
  0xE0, 0xCE, 0x78, 0xE7, 0x1E, 0x73, 0x87, 0xF1, 0x81, 0xF9, 0xC0, 0x78,
};

const GFXglyph IBMPlexMono_Medium32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 22, 19, 7, -22 },
  { 15, 9, 10, 19, 5, -24 },
  { 27, 19, 22, 19, 0, -22 },
  { 80, 17, 28, 19, 1, -25 },
  { 140, 19, 22, 19, 0, -22 },
  { 193, 18, 22, 19, 1, -22 },
  { 243, 3, 10, 19, 8, -24 },
  { 247, 10, 28, 19, 6, -24 },
  { 282, 10, 28, 19, 3, -24 },
  { 317, 17, 16, 19, 1, -18 },
  { 351, 15, 15, 19, 2, -17 },
  { 380, 7, 10, 19, 6, -5 },
  { 389, 9, 3, 19, 5, -11 },
  { 393, 5, 5, 19, 7, -5 },
  { 397, 14, 28, 19, 3, -24 },
  { 446, 17, 22, 19, 1, -22 },
  { 493, 17, 22, 19, 1, -22 },
  { 540, 15, 22, 19, 2, -22 },
  { 582, 16, 22, 19, 1, -22 },
  { 626, 17, 22, 19, 1, -22 },
  { 673, 16, 22, 19, 2, -22 },
  { 717, 16, 22, 19, 2, -22 },
  { 761, 15, 22, 19, 2, -22 },
  { 803, 17, 22, 19, 1, -22 },
  { 850, 16, 22, 19, 2, -22 },
  { 894, 5, 17, 19, 7, -17 },
  { 905, 7, 22, 19, 6, -17 },
  { 925, 13, 19, 19, 3, -19 },
  { 956, 15, 10, 19, 2, -15 },
  { 975, 13, 19, 19, 3, -19 },
  { 1006, 15, 22, 19, 2, -22 },
  { 1048, 15, 26, 19, 2, -22 },
  { 1097, 18, 22, 19, 1, -22 },
  { 1147, 15, 22, 19, 3, -22 },
  { 1189, 16, 22, 19, 2, -22 },
  { 1233, 15, 22, 19, 3, -22 },
  { 1275, 14, 22, 19, 3, -22 },
  { 1314, 14, 22, 19, 3, -22 },
  { 1353, 16, 22, 19, 1, -22 },
  { 1397, 15, 22, 19, 2, -22 },
  { 1439, 14, 22, 19, 3, -22 },
  { 1478, 14, 22, 19, 2, -22 },
  { 1517, 17, 22, 19, 2, -22 },
  { 1564, 14, 22, 19, 3, -22 },
  { 1603, 15, 22, 19, 2, -22 },
  { 1645, 15, 22, 19, 2, -22 },
  { 1687, 17, 22, 19, 1, -22 },
  { 1734, 15, 22, 19, 3, -22 },
  { 1776, 17, 28, 19, 1, -22 },
  { 1836, 15, 22, 19, 3, -22 },
  { 1878, 17, 22, 19, 1, -22 },
  { 1925, 17, 22, 19, 1, -22 },
  { 1972, 15, 22, 19, 2, -22 },
  { 2014, 17, 22, 19, 1, -22 },
  { 2061, 17, 22, 19, 1, -22 },
  { 2108, 18, 22, 19, 1, -22 },
  { 2158, 19, 22, 19, 0, -22 },
  { 2211, 16, 22, 19, 2, -22 },
  { 2255, 9, 28, 19, 7, -24 },
  { 2287, 14, 28, 19, 3, -24 },
  { 2336, 10, 28, 19, 3, -24 },
  { 2371, 17, 14, 19, 1, -22 },
  { 2401, 15, 3, 19, 2, 3 },
  { 2407, 6, 7, 19, 5, -26 },
  { 2413, 16, 17, 19, 2, -17 },
  { 2447, 15, 24, 19, 3, -24 },
  { 2492, 15, 17, 19, 2, -17 },
  { 2524, 15, 24, 19, 2, -24 },
  { 2569, 15, 17, 19, 2, -17 },
  { 2601, 16, 24, 19, 2, -24 },
  { 2649, 16, 26, 19, 2, -20 },
  { 2701, 14, 24, 19, 3, -24 },
  { 2743, 15, 24, 19, 3, -24 },
  { 2788, 12, 30, 19, 3, -24 },
  { 2833, 16, 24, 19, 3, -24 },
  { 2881, 15, 24, 19, 2, -24 },
  { 2926, 17, 17, 19, 1, -17 },
  { 2963, 14, 17, 19, 3, -17 },
  { 2993, 15, 17, 19, 2, -17 },
  { 3025, 15, 23, 19, 3, -17 },
  { 3069, 15, 23, 19, 2, -17 },
  { 3113, 16, 17, 19, 2, -17 },
  { 3147, 15, 17, 19, 2, -17 },
  { 3179, 16, 22, 19, 1, -22 },
  { 3223, 14, 17, 19, 3, -17 },
  { 3253, 16, 17, 19, 2, -17 },
  { 3287, 18, 17, 19, 1, -17 },
  { 3326, 17, 17, 19, 1, -17 },
  { 3363, 17, 23, 19, 1, -17 },
  { 3412, 15, 17, 19, 2, -17 },
  { 3444, 13, 28, 19, 3, -24 },
  { 3490, 3, 28, 19, 8, -24 },
  { 3501, 13, 28, 19, 3, -24 },
  { 3547, 17, 8, 19, 1, -14 },
};

const GFXfont IBMPlexMono_Medium32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_MEDIUM32PT7B_H_
