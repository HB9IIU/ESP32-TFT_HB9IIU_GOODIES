#ifndef _IBMPLEXMONO_MEDIUM22PT7B_H_
#define _IBMPLEXMONO_MEDIUM22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xD2, 0x40, 0x7F, 0xF8, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0xF9, 0x80, 0x06, 0x60, 0x33, 0x03, 0x18, 0x19, 0x87, 0xCF, 0xBE, 0x7C,
  0x33, 0x01, 0x98, 0x19, 0xC7, 0xCF, 0xBE, 0x7C, 0x33, 0x01, 0x98, 0x18,
  0xC0, 0xCC, 0x00, 0x06, 0x00, 0xC0, 0x7E, 0x3F, 0xE7, 0x6F, 0xCC, 0xB9,
  0x83, 0x30, 0x7E, 0x07, 0xF8, 0x1F, 0x83, 0x30, 0x66, 0x8C, 0xF9, 0xBB,
  0xFE, 0x1F, 0x80, 0xC0, 0x18, 0x00, 0x38, 0x1B, 0xE1, 0xB1, 0x8D, 0x8C,
  0xCC, 0x6C, 0x63, 0x61, 0xF0, 0x07, 0x1C, 0x01, 0xF0, 0xF8, 0xC6, 0xC6,
  0x66, 0x33, 0x31, 0xB0, 0xFB, 0x83, 0x80, 0x0F, 0x01, 0xFC, 0x0C, 0x70,
  0x62, 0x03, 0x00, 0x1C, 0x00, 0x71, 0xE7, 0x8F, 0x76, 0x63, 0x3B, 0x38,
  0xF1, 0xC3, 0x87, 0x1E, 0x3F, 0xB8, 0x78, 0xE0, 0xFF, 0xFF, 0xF8, 0x0E,
  0x30, 0xE1, 0x86, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x18,
  0x30, 0x30, 0x70, 0x60, 0x70, 0xE0, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x06, 0x18, 0x30, 0xC7, 0x00, 0x06,
  0x00, 0xC0, 0x18, 0x63, 0x3F, 0xFE, 0x7F, 0x83, 0x80, 0xF8, 0x3B, 0x86,
  0x39, 0x82, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xC1,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x7B, 0x9C, 0xCE, 0x60, 0xFF, 0xFC, 0xEF,
  0xFE, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x00,
  0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x7E, 0x07, 0xC0, 0xFB, 0x9F, 0x73, 0xEE,
  0x7C, 0x0F, 0x81, 0xB0, 0x77, 0x1C, 0x7F, 0x07, 0xC0, 0x1F, 0x07, 0xE0,
  0xFC, 0x3B, 0x8E, 0x70, 0x8E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0xFF, 0xDF, 0xF8, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0x60,
  0x0C, 0x01, 0x80, 0x70, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0x0F, 0xFB, 0x87, 0x20, 0x60, 0x0C, 0x03, 0x87,
  0xE0, 0xFC, 0x01, 0xC0, 0x1C, 0x03, 0xA0, 0x7E, 0x1C, 0xFF, 0x8F, 0xC0,
  0x03, 0x80, 0xF0, 0x3E, 0x06, 0xC1, 0x98, 0x33, 0x0C, 0x63, 0x0C, 0x61,
  0x98, 0x33, 0xFF, 0xFF, 0xF0, 0x18, 0x03, 0x00, 0x60, 0x7F, 0xCF, 0xF9,
  0x80, 0x30, 0x06, 0x00, 0xDF, 0x1F, 0xF3, 0x8F, 0x00, 0xE0, 0x1C, 0x03,
  0xB0, 0x7F, 0x1C, 0xFF, 0x87, 0xC0, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0xDF, 0x1F, 0xF7, 0x8F, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x77, 0x1C,
  0x7F, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x6C, 0x1C, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00,
  0x1F, 0x8F, 0xF9, 0xC3, 0xB0, 0x7E, 0x0E, 0xE1, 0x8F, 0xE1, 0xFC, 0x60,
  0xFC, 0x1F, 0x81, 0xF0, 0x7E, 0x0E, 0xFF, 0x87, 0xC0, 0x1F, 0x07, 0xF9,
  0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x8F, 0x7F, 0xE7, 0xD8, 0x07,
  0x00, 0xC0, 0x30, 0x1C, 0x0F, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0xEF, 0xFE,
  0x73, 0xDE, 0xE0, 0x00, 0x00, 0x03, 0xDC, 0xE6, 0x73, 0x00, 0x00, 0x80,
  0xC1, 0xE3, 0xC7, 0x87, 0x83, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x30,
  0x08, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80,
  0x70, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x06, 0x07, 0x0F, 0x1E, 0x3C, 0x1C,
  0x08, 0x00, 0x3E, 0x3F, 0xF8, 0xF8, 0x30, 0x18, 0x1C, 0x7C, 0x30, 0x18,
  0x00, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x1F, 0x07, 0xF9, 0xC3, 0x30,
  0x3C, 0x77, 0x9F, 0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x8F, 0x31, 0xE7, 0xF4,
  0x76, 0xC0, 0x1C, 0x01, 0xFC, 0x0F, 0x80, 0x07, 0x00, 0x7C, 0x03, 0x60,
  0x1B, 0x00, 0xDC, 0x0E, 0x60, 0x63, 0x03, 0x1C, 0x38, 0xE1, 0xFF, 0x0F,
  0xF8, 0xE0, 0xE7, 0x07, 0x30, 0x1B, 0x80, 0xE0, 0xFF, 0x3F, 0xEC, 0x1B,
  0x07, 0xC1, 0xB0, 0x6F, 0xF3, 0xFE, 0xC1, 0xF0, 0x7C, 0x0F, 0x07, 0xC1,
  0xFF, 0xEF, 0xF0, 0x1F, 0x07, 0xF9, 0xC3, 0xB0, 0x76, 0x09, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0x82, 0x30, 0x77, 0x0E, 0x7F, 0x87, 0xC0,
  0xFE, 0x3F, 0xCC, 0x3B, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1F, 0x07, 0xC3, 0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0xFC, 0x03, 0x00,
  0xC0, 0x30, 0x0F, 0xFB, 0xFE, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFB, 0xFE,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0x07, 0xF1,
  0xC7, 0x30, 0x7E, 0x09, 0xC0, 0x38, 0x07, 0x3F, 0xE7, 0xFC, 0x1F, 0x83,
  0xB0, 0x77, 0x1E, 0x7F, 0xC7, 0xB8, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC7, 0xFF, 0xFE, 0x3F, 0xCF, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x87, 0x71, 0xDF, 0xE1,
  0xF0, 0xC0, 0xF8, 0x3B, 0x0E, 0x63, 0x8C, 0xE1, 0x98, 0x37, 0x07, 0xE0,
  0xFE, 0x1C, 0xE3, 0x0C, 0x61, 0xCC, 0x19, 0x83, 0xB0, 0x38, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xE0, 0xFE, 0x1F, 0xC7, 0xEC, 0xFD, 0xB7,
  0xB6, 0xF3, 0x9E, 0x73, 0xC6, 0x78, 0x8F, 0x11, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x18, 0xE1, 0xF8, 0x7F, 0x1F, 0xC7, 0xF9, 0xF6, 0x7D, 0x9F, 0x77,
  0xCD, 0xF3, 0x7C, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x3C, 0x1F, 0x07, 0xF1,
  0xC7, 0x30, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83,
  0xB0, 0x77, 0x1C, 0x7F, 0x07, 0xC0, 0xFF, 0x3F, 0xEC, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0xFE, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x83, 0xB0, 0x77, 0x1C, 0x7F, 0x87, 0xC0, 0x70, 0x06,
  0x00, 0xF8, 0x0F, 0x00, 0xFF, 0x3F, 0xEC, 0x1F, 0x07, 0xC0, 0xF0, 0x7C,
  0x1F, 0xFE, 0xFF, 0x31, 0x8C, 0x73, 0x0C, 0xC3, 0xB0, 0x6C, 0x1C, 0x1F,
  0x8F, 0xF9, 0xC3, 0xF0, 0x2E, 0x00, 0xC0, 0x1F, 0x81, 0xFE, 0x03, 0xE0,
  0x1C, 0x01, 0xA0, 0x7E, 0x0E, 0xFF, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x06, 0xE3, 0x9F,
  0xE3, 0xE0, 0xC0, 0x7E, 0x06, 0xE0, 0xE6, 0x0E, 0x60, 0xC7, 0x0C, 0x71,
  0xC3, 0x18, 0x31, 0x83, 0x98, 0x1B, 0x81, 0xB0, 0x1F, 0x01, 0xF0, 0x0E,
  0x00, 0xC0, 0x3C, 0x07, 0xC0, 0x6C, 0x06, 0xCE, 0x6C, 0xE6, 0xCE, 0x6C,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x96, 0xD1, 0xE7, 0x1E, 0x71, 0xE0,
  0x70, 0x39, 0x83, 0x8E, 0x38, 0x39, 0x81, 0xDC, 0x07, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x80, 0x6C, 0x07, 0x70, 0x31, 0xC3, 0x86, 0x38, 0x3B, 0x80,
  0xE0, 0xE0, 0x3B, 0x83, 0x8C, 0x1C, 0x71, 0xC1, 0x8E, 0x0E, 0xE0, 0x36,
  0x01, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0F, 0xFF, 0xC0, 0x70, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60,
  0x30, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x6C, 0x1D,
  0xC3, 0x18, 0xE3, 0x98, 0x37, 0x07, 0xC0, 0x60, 0xFF, 0xFF, 0xFC, 0x4C,
  0x66, 0x30, 0x1F, 0x0F, 0xF1, 0x87, 0x20, 0xE0, 0x1C, 0x7F, 0x9F, 0xF7,
  0x0E, 0xE1, 0xCF, 0xDC, 0xF3, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x33, 0xCD, 0xFB, 0x87, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF8, 0x7D,
  0xFB, 0x3C, 0x3E, 0x1F, 0xEE, 0x1B, 0x04, 0xC0, 0x30, 0x0C, 0x03, 0x04,
  0xE1, 0xDF, 0xE3, 0xE0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF, 0xB7,
  0xFD, 0xC7, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xDC, 0x77, 0xFC, 0xFB,
  0x1F, 0x07, 0xF9, 0xC3, 0x30, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0x04, 0x70,
  0xC7, 0xFC, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x38, 0x07, 0x00, 0xE1, 0xFF,
  0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x1F,
  0xFB, 0xFF, 0x00, 0xE0, 0x0E, 0x1F, 0x83, 0xFC, 0x71, 0xC6, 0x0C, 0x71,
  0xC7, 0xF8, 0x3F, 0x02, 0x00, 0x60, 0x07, 0xFC, 0x3F, 0xE4, 0x07, 0xE0,
  0x67, 0xFE, 0x3F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x7B, 0x7F,
  0xC7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x0E, 0x03,
  0x80, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0xFE, 0xFE, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x83, 0xB0, 0xE6,
  0x38, 0xCE, 0x1B, 0x83, 0xF8, 0x73, 0x0C, 0x71, 0x87, 0x30, 0x76, 0x07,
  0xFC, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0xDD, 0xDF, 0xBF, 0x39,
  0xE3, 0x3C, 0x67, 0x8C, 0xF1, 0x9E, 0x33, 0xC6, 0x78, 0xCF, 0x19, 0x80,
  0xCF, 0x6F, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x60, 0x1F, 0x07, 0xF9, 0xC7, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0x71, 0xC7, 0xF8, 0x7C, 0x00, 0xCF, 0x37, 0xEE, 0x1F, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x07, 0xE1, 0xF7, 0xEC, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x00,
  0x3E, 0xDF, 0xF7, 0x1F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0x71, 0xDF,
  0xF3, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0xF9, 0xFE, 0xF1, 0xC0, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x3F, 0xEF, 0xF8, 0x1F, 0x87, 0xF9,
  0xC3, 0x30, 0x07, 0xE0, 0x7F, 0x81, 0xF0, 0x07, 0x60, 0xDF, 0xF8, 0x7E,
  0x00, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x0F, 0xFF, 0xFF, 0xC7, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1F, 0xC3, 0xF8, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3, 0xFF, 0xCF, 0x60, 0xE0,
  0x6C, 0x1D, 0x83, 0x38, 0x63, 0x18, 0x63, 0x0E, 0x60, 0xD8, 0x1B, 0x01,
  0xE0, 0x38, 0x00, 0xE7, 0x1B, 0x38, 0xD9, 0xCC, 0xCA, 0x66, 0x5B, 0x36,
  0xD9, 0xB6, 0xC5, 0x96, 0x38, 0xB1, 0xC7, 0x0E, 0x38, 0xE0, 0xEE, 0x38,
  0xE6, 0x0D, 0x80, 0xF0, 0x1C, 0x07, 0xC0, 0xDC, 0x31, 0x8E, 0x3B, 0x83,
  0x80, 0xE0, 0x7C, 0x1D, 0x83, 0x38, 0x63, 0x18, 0x73, 0x06, 0xE0, 0xD8,
  0x1F, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0xF8, 0x1E, 0x00, 0xFF, 0xBF,
  0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0x8F, 0xC6, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x0E, 0x7E, 0x3F,
  0x01, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x07, 0xE1, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60,
  0x60, 0x18, 0x0F, 0xC7, 0xE3, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0C, 0x06,
  0x3F, 0x1F, 0x80, 0x38, 0x6F, 0x8D, 0xB9, 0xE3, 0xEC, 0x38,
};

const GFXglyph IBMPlexMono_Medium22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 7, 7, 13, 3, -16 },
  { 14, 13, 15, 13, 0, -15 },
  { 39, 11, 19, 13, 1, -17 },
  { 66, 13, 15, 13, 0, -15 },
  { 91, 13, 15, 13, 0, -15 },
  { 116, 3, 7, 13, 5, -16 },
  { 119, 7, 20, 13, 4, -17 },
  { 137, 7, 20, 13, 2, -17 },
  { 155, 11, 11, 13, 1, -12 },
  { 171, 11, 10, 13, 1, -12 },
  { 185, 5, 6, 13, 4, -3 },
  { 189, 7, 2, 13, 3, -8 },
  { 191, 4, 4, 13, 5, -4 },
  { 193, 9, 20, 13, 2, -17 },
  { 216, 11, 15, 13, 1, -15 },
  { 237, 11, 15, 13, 1, -15 },
  { 258, 11, 15, 13, 1, -15 },
  { 279, 11, 15, 13, 1, -15 },
  { 300, 11, 15, 13, 1, -15 },
  { 321, 11, 15, 13, 1, -15 },
  { 342, 11, 15, 13, 1, -15 },
  { 363, 11, 15, 13, 1, -15 },
  { 384, 11, 15, 13, 1, -15 },
  { 405, 11, 15, 13, 1, -15 },
  { 426, 4, 12, 13, 5, -12 },
  { 432, 5, 15, 13, 4, -12 },
  { 442, 9, 13, 13, 2, -13 },
  { 457, 11, 7, 13, 1, -10 },
  { 467, 9, 13, 13, 2, -13 },
  { 482, 9, 15, 13, 2, -15 },
  { 499, 11, 17, 13, 1, -15 },
  { 523, 13, 15, 13, 0, -15 },
  { 548, 10, 15, 13, 2, -15 },
  { 567, 11, 15, 13, 1, -15 },
  { 588, 10, 15, 13, 2, -15 },
  { 607, 10, 15, 13, 2, -15 },
  { 626, 10, 15, 13, 2, -15 },
  { 645, 11, 15, 13, 1, -15 },
  { 666, 10, 15, 13, 2, -15 },
  { 685, 9, 15, 13, 2, -15 },
  { 702, 10, 15, 13, 1, -15 },
  { 721, 11, 15, 13, 2, -15 },
  { 742, 10, 15, 13, 2, -15 },
  { 761, 11, 15, 13, 1, -15 },
  { 782, 10, 15, 13, 2, -15 },
  { 801, 11, 15, 13, 1, -15 },
  { 822, 10, 15, 13, 2, -15 },
  { 841, 11, 19, 13, 1, -15 },
  { 868, 10, 15, 13, 2, -15 },
  { 887, 11, 15, 13, 1, -15 },
  { 908, 12, 15, 13, 1, -15 },
  { 931, 10, 15, 13, 2, -15 },
  { 950, 12, 15, 13, 1, -15 },
  { 973, 12, 15, 13, 1, -15 },
  { 996, 13, 15, 13, 0, -15 },
  { 1021, 13, 15, 13, 0, -15 },
  { 1046, 11, 15, 13, 1, -15 },
  { 1067, 6, 20, 13, 5, -17 },
  { 1082, 9, 20, 13, 2, -17 },
  { 1105, 7, 20, 13, 2, -17 },
  { 1123, 11, 9, 13, 1, -15 },
  { 1136, 11, 2, 13, 1, 2 },
  { 1139, 4, 5, 13, 4, -18 },
  { 1142, 11, 11, 13, 1, -11 },
  { 1158, 10, 16, 13, 2, -16 },
  { 1178, 10, 11, 13, 2, -11 },
  { 1192, 10, 16, 13, 1, -16 },
  { 1212, 11, 11, 13, 1, -11 },
  { 1228, 11, 16, 13, 1, -16 },
  { 1250, 12, 17, 13, 1, -13 },
  { 1276, 9, 16, 13, 2, -16 },
  { 1294, 10, 16, 13, 2, -16 },
  { 1314, 8, 20, 13, 2, -16 },
  { 1334, 11, 16, 13, 2, -16 },
  { 1356, 10, 16, 13, 2, -16 },
  { 1376, 11, 11, 13, 1, -11 },
  { 1392, 9, 11, 13, 2, -11 },
  { 1405, 11, 11, 13, 1, -11 },
  { 1421, 10, 15, 13, 2, -11 },
  { 1440, 10, 15, 13, 1, -11 },
  { 1459, 10, 11, 13, 2, -11 },
  { 1473, 11, 11, 13, 1, -11 },
  { 1489, 11, 15, 13, 1, -15 },
  { 1510, 9, 11, 13, 2, -11 },
  { 1523, 11, 11, 13, 1, -11 },
  { 1539, 13, 11, 13, 0, -11 },
  { 1557, 11, 11, 13, 1, -11 },
  { 1573, 11, 15, 13, 1, -11 },
  { 1594, 10, 11, 13, 2, -11 },
  { 1608, 9, 20, 13, 2, -17 },
  { 1631, 2, 20, 13, 6, -17 },
  { 1636, 9, 20, 13, 2, -17 },
  { 1659, 11, 5, 13, 1, -9 },
};

const GFXfont IBMPlexMono_Medium22pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium22pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _IBMPLEXMONO_MEDIUM22PT7B_H_
