#ifndef _IBMPLEXMONO_MEDIUM30PT7B_H_
#define _IBMPLEXMONO_MEDIUM30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium30pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0x00,
  0x00, 0x79, 0xEF, 0xDE, 0x78, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x30, 0x03,
  0x9C, 0x00, 0xC7, 0x07, 0xF1, 0xFD, 0xFC, 0x7F, 0x7F, 0x1F, 0xC1, 0xC6,
  0x00, 0x73, 0x80, 0x18, 0xE0, 0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xE3, 0xF8,
  0x38, 0xC0, 0x0E, 0x70, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C,
  0x60, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFE, 0x79, 0x9E, 0x71, 0x84, 0x71, 0x80, 0x71, 0x80, 0x79, 0x80,
  0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x01, 0x9E, 0x01, 0x8F,
  0x01, 0x87, 0x21, 0x87, 0x71, 0x8F, 0xF9, 0x9E, 0x7F, 0xFE, 0x3F, 0xFC,
  0x0F, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x1E, 0x01, 0xCF, 0xC0,
  0xE7, 0xF8, 0x31, 0xCE, 0x1C, 0xE1, 0x86, 0x38, 0x73, 0x8E, 0x1C, 0xC1,
  0xCE, 0x70, 0x7F, 0x98, 0x0F, 0xC8, 0x01, 0xE1, 0xE0, 0x00, 0xFC, 0x07,
  0x7F, 0x83, 0x9C, 0xE0, 0xCE, 0x18, 0x73, 0x87, 0x18, 0xE1, 0x8E, 0x18,
  0xE3, 0x07, 0xF9, 0xC0, 0xFC, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x1F, 0xE0,
  0x3F, 0xF0, 0x38, 0x70, 0x78, 0x20, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1E, 0x1F, 0x3F, 0x1F, 0x7F, 0x9F, 0xF3, 0xDC, 0xE1, 0xDC,
  0xE1, 0xF8, 0xE0, 0xF8, 0xE0, 0x78, 0xF0, 0xFC, 0xFF, 0xDE, 0x7F, 0x8E,
  0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x87, 0x87, 0x03, 0x83,
  0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x1C, 0x07,
  0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xE0, 0x70, 0x30, 0x38, 0x38, 0x3C, 0x1C, 0x3C, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x41, 0x82, 0x79, 0x9E, 0xFF, 0xFF, 0x3F,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1C, 0x38, 0x3C,
  0x3C, 0x08, 0x10, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x7D, 0xE7, 0x9E, 0xF3, 0xCE, 0x38,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0,
  0x0E, 0xF1, 0x8F, 0xF3, 0xCF, 0xF3, 0xCF, 0xF1, 0x8F, 0xF0, 0x0F, 0xF0,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3E, 0xE0, 0x3C,
  0xE0, 0x78, 0xE0, 0xF0, 0xE0, 0x20, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xC0, 0xFF,
  0xC7, 0xFF, 0xBE, 0x1E, 0xE0, 0x3B, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xE3, 0x01, 0xE4, 0x03, 0xC0, 0x07, 0x00,
  0x1E, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x90, 0x0F, 0x70, 0x1F, 0xF0, 0x79, 0xFF, 0xF1, 0xFF, 0xC0,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xB8, 0x03, 0xB8,
  0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x38,
  0x30, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xF9, 0xFF, 0xE7,
  0xFF, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0xF8, 0x6F, 0xF1,
  0xBF, 0xE7, 0x87, 0xE8, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC8, 0x07,
  0x60, 0x3F, 0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x39, 0xF0,
  0xFF, 0xF1, 0xDF, 0xF3, 0xE1, 0xF7, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xB8,
  0x07, 0xF0, 0x0E, 0xF0, 0x3C, 0xF0, 0xF9, 0xFF, 0xE1, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xEE,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E,
  0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xE0,
  0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E,
  0x78, 0x1E, 0x7F, 0xFE, 0x1F, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xF3, 0xE1, 0xE7, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x07, 0x70,
  0x0E, 0xF0, 0x3D, 0xF0, 0xF9, 0xFF, 0x71, 0xFF, 0xE1, 0xF3, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x00,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x79, 0xE7, 0xBC,
  0xF3, 0x8E, 0x30, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x07, 0xC1, 0xF0,
  0x7E, 0x0F, 0x80, 0xE0, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x00, 0x30, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x0C, 0x00, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x00, 0x70, 0x07, 0x01, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x0F, 0x00,
  0xC0, 0x08, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x39,
  0x80, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x1F, 0x80, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x00, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x9E, 0x0E, 0x70,
  0x1F, 0x80, 0x7E, 0x1D, 0xF0, 0xFB, 0xC7, 0xFF, 0x1C, 0x7C, 0x60, 0xF1,
  0x83, 0xC6, 0x0F, 0x18, 0x3C, 0x71, 0xF1, 0xFB, 0xC7, 0xEF, 0x8F, 0x3E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x1C, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x3C, 0x38, 0x3C,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x70, 0x1E, 0x70, 0x0E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xFF, 0xCF, 0xFE, 0x3F,
  0xFE, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1F,
  0x70, 0x1F, 0xC0, 0x7F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x07, 0x70, 0x1D, 0xE1,
  0xF3, 0xFF, 0x87, 0xFC, 0x0F, 0xC0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7,
  0x83, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xBC, 0x07, 0x78, 0x1E,
  0xF0, 0x3D, 0xE0, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0,
  0xFF, 0xE1, 0xE1, 0xE7, 0x81, 0xEF, 0x01, 0xDC, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xEE, 0x01, 0xDC, 0x03,
  0xBC, 0x07, 0x78, 0x1E, 0x78, 0x7C, 0xFF, 0xB8, 0xFF, 0x70, 0xF8, 0xE0,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x87, 0x9F, 0xFC, 0x7F, 0xC1, 0xF8,
  0x00, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x38, 0xF0, 0x78, 0xF0, 0xF0, 0xF1,
  0xE0, 0xF3, 0xC0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFD,
  0xC0, 0xF9, 0xE0, 0xF0, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0xF0, 0x78, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x3F, 0xC0, 0xFF, 0x87, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF3, 0xFE, 0xCD, 0xFB, 0xF7, 0xEF, 0xDF, 0x9E, 0x7E,
  0x79, 0xF8, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x21, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFF, 0x07, 0xFC, 0x1F, 0xB8, 0x7E, 0xE1, 0xFB, 0x87, 0xE7, 0x1F, 0x9C,
  0x7E, 0x31, 0xF8, 0xE7, 0xE3, 0x9F, 0x87, 0x7E, 0x1D, 0xF8, 0x77, 0xE0,
  0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7C, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8,
  0x07, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80,
  0xEE, 0x03, 0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xEF, 0xFF, 0x3F, 0xFC, 0xFF,
  0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78,
  0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78,
  0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3B, 0x81,
  0xEF, 0xFF, 0x3F, 0xFC, 0xFF, 0xC3, 0x8E, 0x0E, 0x3C, 0x38, 0x78, 0xE0,
  0xE3, 0x83, 0xCE, 0x07, 0x38, 0x1E, 0xE0, 0x3C, 0x07, 0xF0, 0x3F, 0xF0,
  0xFF, 0xFB, 0xE0, 0xF7, 0x80, 0xCE, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x03,
  0x90, 0x07, 0x70, 0x0F, 0xF0, 0x7D, 0xFF, 0xF1, 0xFF, 0xC0, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x3D,
  0xE1, 0xE7, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0x70, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x3C,
  0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xE7, 0xE7, 0xE7, 0x66,
  0x66, 0x66, 0x66, 0x76, 0x66, 0x76, 0x6E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xF0, 0x0F, 0x78, 0x0E, 0x78,
  0x1E, 0x3C, 0x1C, 0x1C, 0x3C, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E,
  0x78, 0x1C, 0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0xF0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xE3, 0x80, 0x70, 0xF0, 0x3C, 0x1C, 0x0E,
  0x07, 0x87, 0x80, 0xE1, 0xC0, 0x3C, 0xF0, 0x07, 0x38, 0x01, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1C, 0x78, 0x1C, 0x38, 0x38,
  0x3C, 0x38, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0xE0, 0x07, 0x20, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x63, 0xC7, 0x0E, 0x18, 0x70, 0x0F, 0xC0,
  0x7F, 0xC1, 0xFF, 0xC7, 0x83, 0xC6, 0x07, 0x80, 0x07, 0x07, 0xFE, 0x3F,
  0xFC, 0xF0, 0x39, 0xC0, 0x73, 0x81, 0xE7, 0x87, 0xCF, 0xFB, 0xEF, 0xF7,
  0xCF, 0xC7, 0x80, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0xF8, 0xF7, 0xF3, 0xFF, 0xEF, 0x87, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x87,
  0xFF, 0xFE, 0xF7, 0xF3, 0xCF, 0x80, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E,
  0x1E, 0x70, 0x1F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x01, 0x9E, 0x0F, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC7, 0xCF, 0x3F,
  0xBD, 0xFF, 0xFF, 0x87, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0xDF, 0xFF, 0x3F, 0xBC, 0x7C, 0xF0,
  0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0F, 0x01, 0x1E, 0x0E, 0x7F, 0xFC, 0xFF,
  0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8,
  0x7F, 0x03, 0xFF, 0x0F, 0xFF, 0x1E, 0x1E, 0x38, 0x1C, 0x70, 0x38, 0xF0,
  0xF1, 0xFF, 0xC1, 0xFF, 0x81, 0xFC, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xF8,
  0x7F, 0xFC, 0x7F, 0xFD, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xDF,
  0xFF, 0x1F, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0xF8, 0xEF, 0xE7, 0xFF, 0xBC, 0x3D, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3C, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x7C, 0x0F, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xDF, 0xF8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xDF, 0xFB, 0xFE, 0x7F, 0x80, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x1F, 0xE0,
  0xF3, 0x87, 0x8E, 0x3C, 0x39, 0xE0, 0xEF, 0x03, 0xFC, 0x0F, 0xF8, 0x3C,
  0xE0, 0xE3, 0xC3, 0x87, 0x8E, 0x0F, 0x38, 0x1E, 0xE0, 0x7B, 0x80, 0xF0,
  0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE7, 0x1C, 0xEF, 0xBE, 0xFF, 0xFE, 0xF3, 0xCF, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE7, 0xC7, 0x7F,
  0x3F, 0xFD, 0xE1, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xE0, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xDE, 0x1E, 0x7F, 0xF8, 0xFF, 0xC0, 0xFC,
  0x00, 0xF3, 0xE3, 0xDF, 0xCF, 0xFF, 0xBE, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFE, 0x1F, 0xFF, 0xFB,
  0xDF, 0xCF, 0x3E, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x1F, 0x7F,
  0xFC, 0xFE, 0xF1, 0xF3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0xFF, 0x1F, 0xFE, 0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x0F, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0xFF, 0xE7,
  0xFF, 0xDC, 0x0E, 0x70, 0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8,
  0x00, 0xF4, 0x01, 0xDC, 0x0F, 0xFF, 0xF9, 0xFF, 0xC1, 0xFE, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xE0, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0E, 0xF0, 0xF7, 0xFF,
  0x9F, 0xDC, 0x7C, 0xE0, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C,
  0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0xC3, 0xC3,
  0xE3, 0xC3, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE7, 0x67, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x76, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x0E, 0x38, 0x1C, 0x3C, 0x3C, 0x1E, 0x78,
  0x0F, 0x70, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0E, 0x70, 0x1C, 0x78, 0x3C, 0x3C, 0x78, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F,
  0x70, 0x0E, 0x78, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x38,
  0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0x7C, 0x00, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x03, 0x80,
  0x78, 0xFF, 0x0F, 0xC0, 0xFF, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x0F, 0xF0, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x0F, 0xF0, 0x3F, 0x0F, 0xF1, 0xE0, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0x0F, 0xF0, 0xFE, 0x00,
  0x1E, 0x07, 0x3F, 0x06, 0x7F, 0x86, 0x73, 0xCE, 0x61, 0xFE, 0xE0, 0xFC,
  0xE0, 0x78,
};

const GFXglyph IBMPlexMono_Medium30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 6, 21, 18, 6, -21 },
  { 17, 8, 9, 18, 5, -22 },
  { 26, 18, 21, 18, 0, -21 },
  { 74, 16, 27, 18, 1, -24 },
  { 128, 18, 21, 18, 0, -21 },
  { 176, 16, 21, 18, 1, -21 },
  { 218, 4, 9, 18, 7, -22 },
  { 223, 9, 27, 18, 6, -23 },
  { 254, 9, 27, 18, 3, -23 },
  { 285, 16, 15, 18, 1, -16 },
  { 315, 14, 15, 18, 2, -17 },
  { 342, 6, 9, 18, 6, -5 },
  { 349, 10, 3, 18, 4, -11 },
  { 353, 6, 5, 18, 6, -5 },
  { 357, 14, 27, 18, 2, -23 },
  { 405, 16, 21, 18, 1, -21 },
  { 447, 16, 21, 18, 1, -21 },
  { 489, 14, 21, 18, 2, -21 },
  { 526, 15, 21, 18, 1, -21 },
  { 566, 16, 21, 18, 1, -21 },
  { 608, 14, 21, 18, 2, -21 },
  { 645, 15, 21, 18, 2, -21 },
  { 685, 14, 21, 18, 2, -21 },
  { 722, 16, 21, 18, 1, -21 },
  { 764, 15, 21, 18, 1, -21 },
  { 804, 6, 16, 18, 6, -16 },
  { 816, 6, 20, 18, 6, -16 },
  { 831, 12, 18, 18, 3, -18 },
  { 858, 14, 10, 18, 2, -14 },
  { 876, 12, 18, 18, 3, -18 },
  { 903, 14, 21, 18, 2, -21 },
  { 940, 14, 24, 18, 2, -21 },
  { 982, 16, 21, 18, 1, -21 },
  { 1024, 14, 21, 18, 2, -21 },
  { 1061, 14, 21, 18, 2, -21 },
  { 1098, 15, 21, 18, 2, -21 },
  { 1138, 13, 21, 18, 3, -21 },
  { 1173, 13, 21, 18, 3, -21 },
  { 1208, 15, 21, 18, 1, -21 },
  { 1248, 14, 21, 18, 2, -21 },
  { 1285, 14, 21, 18, 2, -21 },
  { 1322, 13, 21, 18, 2, -21 },
  { 1357, 16, 21, 18, 2, -21 },
  { 1399, 13, 21, 18, 3, -21 },
  { 1434, 14, 21, 18, 2, -21 },
  { 1471, 14, 21, 18, 2, -21 },
  { 1508, 16, 21, 18, 1, -21 },
  { 1550, 14, 21, 18, 3, -21 },
  { 1587, 16, 26, 18, 1, -21 },
  { 1639, 14, 21, 18, 3, -21 },
  { 1676, 15, 21, 18, 1, -21 },
  { 1716, 16, 21, 18, 1, -21 },
  { 1758, 14, 21, 18, 2, -21 },
  { 1795, 16, 21, 18, 1, -21 },
  { 1837, 16, 21, 18, 1, -21 },
  { 1879, 16, 21, 18, 1, -21 },
  { 1921, 18, 21, 18, 0, -21 },
  { 1969, 16, 21, 18, 1, -21 },
  { 2011, 9, 27, 18, 6, -23 },
  { 2042, 14, 27, 18, 2, -23 },
  { 2090, 9, 27, 18, 3, -23 },
  { 2121, 16, 13, 18, 1, -21 },
  { 2147, 14, 3, 18, 2, 2 },
  { 2153, 6, 6, 18, 5, -23 },
  { 2158, 15, 15, 18, 2, -15 },
  { 2187, 14, 22, 18, 2, -22 },
  { 2226, 14, 15, 18, 2, -15 },
  { 2253, 14, 22, 18, 2, -22 },
  { 2292, 14, 15, 18, 2, -15 },
  { 2319, 14, 22, 18, 2, -22 },
  { 2358, 15, 24, 18, 2, -18 },
  { 2403, 13, 22, 18, 3, -22 },
  { 2439, 14, 22, 18, 3, -22 },
  { 2478, 11, 28, 18, 3, -22 },
  { 2517, 14, 22, 18, 3, -22 },
  { 2556, 14, 22, 18, 2, -22 },
  { 2595, 16, 15, 18, 1, -15 },
  { 2625, 13, 15, 18, 3, -15 },
  { 2650, 14, 15, 18, 2, -15 },
  { 2677, 14, 21, 18, 2, -15 },
  { 2714, 14, 21, 18, 2, -15 },
  { 2751, 15, 15, 18, 2, -15 },
  { 2780, 14, 15, 18, 2, -15 },
  { 2807, 15, 21, 18, 1, -21 },
  { 2847, 13, 15, 18, 2, -15 },
  { 2872, 16, 15, 18, 1, -15 },
  { 2902, 16, 15, 18, 1, -15 },
  { 2932, 16, 15, 18, 1, -15 },
  { 2962, 16, 21, 18, 1, -15 },
  { 3004, 14, 15, 18, 2, -15 },
  { 3031, 12, 27, 18, 3, -23 },
  { 3072, 2, 27, 18, 8, -23 },
  { 3079, 12, 27, 18, 3, -23 },
  { 3120, 16, 7, 18, 1, -13 },
};

const GFXfont IBMPlexMono_Medium30pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium30pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium30pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _IBMPLEXMONO_MEDIUM30PT7B_H_
