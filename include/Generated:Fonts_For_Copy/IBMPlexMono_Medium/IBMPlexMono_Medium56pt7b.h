#ifndef _IBMPLEXMONO_MEDIUM56PT7B_H_
#define _IBMPLEXMONO_MEDIUM56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xBF, 0xEF, 0xFB, 0xFF, 0xFF, 0xBF,
  0xE7, 0xF8, 0xFC, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0xFE, 0x0F,
  0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC, 0x1F,
  0xFF, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF0, 0x7F, 0xFC, 0xFF, 0xF0, 0x7F,
  0xFC, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x3F, 0xCF, 0x3F, 0xF1, 0xF8, 0x78, 0x3F,
  0x1F, 0xC3, 0xC0, 0xF0, 0xFC, 0x1E, 0x03, 0x07, 0xE0, 0xF0, 0x00, 0x3F,
  0x07, 0x80, 0x01, 0xF8, 0x3C, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x7E, 0x0F,
  0x00, 0x03, 0xF8, 0x78, 0x00, 0x1F, 0xE3, 0xC0, 0x00, 0x7F, 0xDE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xCF, 0xF8, 0x00, 0x1E, 0x1F, 0xC0, 0x00, 0xF0, 0x7F, 0x00, 0x07, 0x81,
  0xF8, 0x00, 0x3C, 0x0F, 0xC0, 0x01, 0xE0, 0x7E, 0x00, 0x0F, 0x03, 0xF0,
  0x00, 0x78, 0x1F, 0x84, 0x03, 0xC0, 0xFC, 0x70, 0x1E, 0x07, 0xE7, 0xC0,
  0xF0, 0x7F, 0x7F, 0x87, 0x87, 0xF7, 0xFF, 0x3C, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x3F, 0xFC,
  0x00, 0x3E, 0x7F, 0xFE, 0x00, 0x3E, 0x7C, 0x3F, 0x00, 0x7C, 0xF8, 0x1F,
  0x00, 0x7C, 0xF8, 0x0F, 0x00, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0xF0, 0x0F,
  0x81, 0xF0, 0xF0, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x83, 0xE0, 0xF0, 0x0F,
  0x83, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x0F, 0xC0, 0xF8, 0x1F,
  0x0F, 0x80, 0x7C, 0x3F, 0x1F, 0x00, 0x7F, 0xFE, 0x1F, 0x00, 0x3F, 0xFC,
  0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xF8,
  0x7F, 0xF8, 0x00, 0xF8, 0xFF, 0xFC, 0x01, 0xF0, 0xF8, 0x7E, 0x01, 0xF1,
  0xF0, 0x3E, 0x03, 0xE1, 0xF0, 0x1E, 0x03, 0xE1, 0xE0, 0x1F, 0x07, 0xC1,
  0xE0, 0x1F, 0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x81, 0xE0, 0x1F, 0x1F, 0x81,
  0xE0, 0x1F, 0x1F, 0x01, 0xE0, 0x1F, 0x3F, 0x01, 0xF0, 0x1E, 0x3E, 0x01,
  0xF0, 0x3E, 0x7C, 0x00, 0xF8, 0x7E, 0x7C, 0x00, 0xFF, 0xFC, 0xF8, 0x00,
  0x7F, 0xF8, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x0F, 0x80, 0x10, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x1F, 0xFF,
  0x03, 0xFE, 0x3F, 0xBF, 0x83, 0xFE, 0x3F, 0x1F, 0xC3, 0xE0, 0x7E, 0x0F,
  0xC3, 0xE0, 0x7E, 0x07, 0xE3, 0xC0, 0x7C, 0x07, 0xF3, 0xC0, 0xFC, 0x03,
  0xFF, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0x80, 0xFC, 0x00,
  0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0xE0, 0x7F, 0xC1, 0xF7, 0xF0, 0x3F, 0xFF,
  0xE3, 0xF8, 0x1F, 0xFF, 0xE1, 0xFC, 0x0F, 0xFF, 0xC0, 0xFC, 0x07, 0xFF,
  0x80, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x70, 0x0F, 0x80, 0x73, 0xF0, 0x7C, 0x1F, 0xDF, 0xF3, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xE0, 0x03, 0xC0, 0x03,
  0x00, 0x08, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0,
  0x7C, 0x0F, 0xFF, 0x83, 0xF0, 0x7F, 0xFC, 0x3F, 0x83, 0xFF, 0xE1, 0xFC,
  0x1F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF8, 0x3F, 0x07, 0xEF, 0xC1, 0xF0, 0x3F,
  0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFB, 0xF0, 0x00,
  0x7F, 0x9F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8,
  0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0x80, 0x7E,
  0x00, 0x08, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0x00, 0x3F,
  0x87, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xC0, 0x01, 0xFC, 0x0C,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF0, 0x00, 0xFE,
  0x0E, 0x00, 0x0F, 0xE0, 0x40, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x80, 0x00, 0x7F,
  0x3C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xE7, 0xFC,
  0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0xFE, 0x00, 0x3E, 0x3F, 0xFC, 0x03, 0xE7,
  0xFF, 0xE0, 0x3E, 0xFF, 0xFF, 0x83, 0xEF, 0xFF, 0xF8, 0x3F, 0xC0, 0x7F,
  0xC3, 0xF8, 0x01, 0xFE, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x0C, 0x00, 0x07, 0xE1,
  0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFC, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x03,
  0xF1, 0xFF, 0xC0, 0x7E, 0x7F, 0xFF, 0x07, 0xEF, 0xFF, 0xF8, 0x7E, 0xFF,
  0xFF, 0x8F, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03,
  0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F,
  0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0x87,
  0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xE7, 0xFE, 0x07,
  0xFE, 0x3F, 0xFF, 0xF7, 0xE1, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xCF, 0xE0,
  0x7F, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x8F,
  0xC0, 0x1F, 0x87, 0xF9, 0xFF, 0x3F, 0xF7, 0xFE, 0xFF, 0xDF, 0xF1, 0xFE,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF9, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE3, 0xFE, 0x0F, 0xF9, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0x9E, 0x00, 0x1F, 0xC2, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0x07, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x01, 0xF1, 0xF7,
  0xC0, 0xFF, 0x3E, 0xF0, 0x3F, 0xF7, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xF8,
  0x7F, 0xF8, 0x3E, 0x03, 0xFF, 0x07, 0xC0, 0x7F, 0xE0, 0xF0, 0x0F, 0xFC,
  0x3E, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0xF8, 0x07, 0xFE, 0x1F, 0x00,
  0xFF, 0xC3, 0xE0, 0x1F, 0xF8, 0x7C, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xE1,
  0xF0, 0x0F, 0xFC, 0x3E, 0x01, 0xFF, 0x83, 0xE0, 0x3F, 0xF0, 0x7C, 0x07,
  0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xFE, 0xFF, 0x78, 0x1F, 0xFF, 0xEF, 0x81,
  0xFF, 0x7D, 0xF0, 0x1F, 0xCF, 0xBE, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0x00, 0x7F, 0x8F, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC,
  0x01, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xC0, 0x0F, 0xF3, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0x7F, 0x7F, 0x00, 0x03, 0x87, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0x83, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0xFF, 0x8F, 0xC0, 0x0F,
  0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00,
  0xFE, 0x3F, 0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x3F,
  0x00, 0x0F, 0xCF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x1C, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x3B, 0xF1, 0xFF, 0xFF,
  0x7E, 0x1F, 0xFF, 0xCF, 0xC1, 0xFF, 0xF1, 0xF8, 0x1F, 0xFC, 0x3F, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x20, 0x01, 0xFD, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xF0,
  0x7F, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xF8, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xF7, 0xF0,
  0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0x7F, 0xF7, 0xC3,
  0xEF, 0xFE, 0xF8, 0x7D, 0xFF, 0xDF, 0x9F, 0x3F, 0xF9, 0xF3, 0xE7, 0xFF,
  0x3E, 0x78, 0xFF, 0xE3, 0xFF, 0x1F, 0xFC, 0x7F, 0xE3, 0xFF, 0x8F, 0xF8,
  0x7F, 0xF0, 0xFF, 0x0F, 0xFE, 0x1F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8,
  0x3F, 0x07, 0xFF, 0x07, 0xC0, 0xFF, 0xE0, 0x78, 0x1F, 0xFC, 0x0F, 0x03,
  0xFF, 0x81, 0xC0, 0x7F, 0xF0, 0x18, 0x0F, 0xFE, 0x02, 0x01, 0xFF, 0xC0,
  0x40, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF8,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xDF, 0x00, 0xFF,
  0xF7, 0xE0, 0x3F, 0xFD, 0xF8, 0x0F, 0xFF, 0x3E, 0x03, 0xFF, 0xCF, 0xC0,
  0xFF, 0xF1, 0xF0, 0x3F, 0xFC, 0x7C, 0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0xC3,
  0xE0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFF, 0x07, 0xC3, 0xFF,
  0xC1, 0xF8, 0xFF, 0xF0, 0x3E, 0x3F, 0xFC, 0x0F, 0x8F, 0xFF, 0x03, 0xF3,
  0xFF, 0xC0, 0x7C, 0xFF, 0xF0, 0x1F, 0xBF, 0xFC, 0x07, 0xEF, 0xFF, 0x00,
  0xFB, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0xFE,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x3F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xEF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0xFE,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x3F, 0x00, 0x3F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03,
  0xF0, 0x7F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8,
  0x0F, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x78, 0x3F, 0x00, 0x00,
  0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0x00, 0x00, 0x7E,
  0x3C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0xBF, 0xE0, 0x03, 0xF8, 0xFF,
  0xC0, 0x7F, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xFC, 0x0F, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0,
  0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x0F,
  0xC0, 0xFD, 0xF8, 0x3F, 0x81, 0xF3, 0xF0, 0x7F, 0x03, 0xE7, 0xE0, 0xFF,
  0x07, 0xCF, 0xC1, 0xFE, 0x0F, 0x9F, 0x83, 0xFC, 0x1F, 0x1F, 0x07, 0xF8,
  0x3E, 0x3E, 0x1E, 0xF0, 0x7C, 0x7C, 0x3D, 0xF0, 0xF8, 0xF8, 0x7B, 0xE1,
  0xF1, 0xF0, 0xF3, 0xC3, 0xE3, 0xE1, 0xE7, 0x87, 0xC7, 0xC7, 0xCF, 0x0F,
  0x8F, 0x8F, 0x1F, 0x3F, 0x1F, 0x1E, 0x3E, 0x7E, 0x3E, 0x3C, 0x7C, 0xF8,
  0x7C, 0x78, 0x79, 0xF0, 0xFD, 0xF0, 0xF3, 0xE1, 0xFB, 0xE1, 0xE7, 0xC3,
  0xF7, 0x83, 0xEF, 0x83, 0xEF, 0x07, 0xDF, 0x07, 0xDE, 0x07, 0xBE, 0x0F,
  0xBC, 0x0F, 0x7C, 0x1F, 0xF8, 0x1E, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x46, 0x00, 0x00, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x08, 0x0F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0,
  0x7E, 0x0F, 0x83, 0xF0, 0x78, 0x08, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03,
  0xF8, 0x1F, 0xF0, 0x7E, 0x00, 0x7F, 0x01, 0xC0, 0x03, 0xF0, 0x08, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x87, 0xF8, 0x1F,
  0xFF, 0x7F, 0xFF, 0xDF, 0xF3, 0xFF, 0xFC, 0xFF, 0x1F, 0xFF, 0x8F, 0xF0,
  0xFF, 0xF0, 0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x0F,
  0xE3, 0xFF, 0x81, 0xFC, 0xFF, 0xF8, 0x3F, 0xBF, 0xFF, 0x87, 0xF7, 0xFF,
  0xF8, 0xFF, 0xC0, 0xFF, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03,
  0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xCF, 0xFC, 0x0F, 0xF9,
  0xFD, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0x87, 0xF3, 0xFF, 0xE0, 0xFE, 0x3F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0x7C, 0x7F, 0x00, 0x0C, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x02, 0x07, 0xF0, 0x00, 0xE0, 0xFC, 0x00, 0x3C, 0x3F,
  0x80, 0x1F, 0xC7, 0xF8, 0x1F, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x3F, 0x07, 0xFF, 0x0F, 0xC3, 0xFF, 0xE3, 0xF1, 0xFF, 0xFC, 0xFC, 0xFF,
  0xFF, 0xBF, 0x3F, 0xE0, 0xFF, 0xDF, 0xE0, 0x0F, 0xF7, 0xF0, 0x01, 0xFD,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0xFF, 0xCF, 0xFF,
  0xFB, 0xF1, 0xFF, 0xFC, 0xFC, 0x3F, 0xFE, 0x3F, 0x07, 0xFF, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0xC1, 0xF8, 0x00, 0x3C,
  0x3F, 0x80, 0x0F, 0xC3, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFD,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0x3F, 0x87, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0xFC, 0x7F, 0xF0, 0xFC, 0xFF, 0xF8,
  0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFF, 0x81, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFD, 0xF8, 0x00, 0xFF, 0x3F, 0x00, 0x3F,
  0xC7, 0xE0, 0x0F, 0xF0, 0xFC, 0x03, 0xFC, 0x1F, 0x80, 0xFF, 0x03, 0xF0,
  0x3F, 0xC0, 0x7E, 0x0F, 0xF0, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0xFE, 0x00,
  0x3F, 0x3F, 0x80, 0x07, 0xEF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xF1, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xF7, 0xE0, 0x00,
  0xFE, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7C, 0x0F, 0xC7, 0xE7, 0xF0, 0xFF, 0x3F, 0x7F, 0xCF,
  0xFD, 0xFB, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF1, 0xFF,
  0xF0, 0x3F, 0x07, 0xFF, 0x81, 0xF8, 0x1F, 0xFC, 0x0F, 0x80, 0xFF, 0xE0,
  0x7C, 0x07, 0xFF, 0x03, 0xE0, 0x3F, 0xF8, 0x1F, 0x01, 0xFF, 0xC0, 0xF8,
  0x0F, 0xFE, 0x07, 0xC0, 0x7F, 0xF0, 0x3E, 0x03, 0xFF, 0x81, 0xF0, 0x1F,
  0xFC, 0x0F, 0x80, 0xFF, 0xE0, 0x7C, 0x07, 0xFF, 0x03, 0xE0, 0x3F, 0xF8,
  0x1F, 0x01, 0xFF, 0xC0, 0xF8, 0x0F, 0xFE, 0x07, 0xC0, 0x7F, 0xF0, 0x3E,
  0x03, 0xFF, 0x81, 0xF0, 0x1F, 0xFC, 0x0F, 0x80, 0xFF, 0xE0, 0x7C, 0x07,
  0xFF, 0x03, 0xE0, 0x3F, 0xF8, 0x1F, 0x01, 0xFF, 0xC0, 0xF8, 0x0F, 0xFE,
  0x07, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0xFC, 0x7F, 0xF0, 0xFC, 0xFF, 0xF8,
  0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFF, 0x81, 0xFE, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF0, 0x01,
  0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x1F, 0xC7, 0xFF, 0x03, 0xF9, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0x0F,
  0xEF, 0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0x3F, 0xC0, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F,
  0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x9F, 0xF8,
  0x1F, 0xF3, 0xFB, 0xFF, 0xFC, 0x7F, 0x7F, 0xFF, 0x0F, 0xE7, 0xFF, 0xC1,
  0xFC, 0x7F, 0xF0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC3, 0xF0,
  0xFF, 0xF8, 0xFC, 0x7F, 0xFF, 0x3F, 0x3F, 0xFF, 0xEF, 0xCF, 0xF8, 0x3F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0x7F,
  0x80, 0x3F, 0xCF, 0xF8, 0x3F, 0xF3, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0x3F,
  0x0F, 0xFF, 0x8F, 0xC1, 0xFF, 0xC3, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFE,
  0x01, 0xFB, 0xC0, 0x00, 0x3F, 0x60, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x03, 0xC1, 0xF8, 0x00, 0x18,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC6,
  0x00, 0x01, 0xF9, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xDF, 0xF8, 0x07,
  0xF9, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0xFE,
  0x00, 0xFF, 0x7F, 0xC1, 0xDF, 0x9F, 0xFF, 0xEF, 0xC7, 0xFF, 0xE7, 0xE3,
  0xFF, 0xE3, 0xF0, 0x7F, 0xE1, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0x7F, 0xF0,
  0x3F, 0x80, 0xFB, 0xE0, 0x7F, 0x81, 0xF7, 0xC0, 0xFF, 0x03, 0xEF, 0x81,
  0xFE, 0x07, 0xDF, 0x03, 0xFC, 0x0F, 0xBE, 0x07, 0x78, 0x1E, 0x7C, 0x1E,
  0xF0, 0x7C, 0xF8, 0x3C, 0xF0, 0xF8, 0xF8, 0x79, 0xE1, 0xF1, 0xF0, 0xF3,
  0xC3, 0xE3, 0xE1, 0xE7, 0x87, 0xC7, 0xC3, 0x8F, 0x0F, 0x8F, 0x8F, 0x1E,
  0x1E, 0x1F, 0x1E, 0x1E, 0x3C, 0x3E, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x79,
  0xF0, 0x78, 0xF0, 0xF3, 0xE0, 0xFB, 0xC1, 0xE7, 0xC1, 0xF7, 0x83, 0xEF,
  0x83, 0xEF, 0x03, 0xDF, 0x07, 0xDE, 0x07, 0xBC, 0x0F, 0xBC, 0x0F, 0x78,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x1F, 0xC0,
  0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x0F, 0xC0,
  0x03, 0xF9, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x01, 0xC0, 0xFF, 0x80, 0x1F, 0x1F, 0xFC, 0x01, 0xF3, 0xFF,
  0xE0, 0x1F, 0x3F, 0xFE, 0x01, 0xE7, 0xE3, 0xF0, 0x3E, 0x7C, 0x1F, 0x83,
  0xEF, 0x81, 0xFC, 0x7C, 0xF8, 0x0F, 0xFF, 0xCF, 0x80, 0x7F, 0xF8, 0xF0,
  0x03, 0xFF, 0x8F, 0x00, 0x1F, 0xF0, 0x30, 0x00, 0x7C, 0x00,
};

const GFXglyph IBMPlexMono_Medium56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 10, 40, 34, 12, -39 },
  { 51, 16, 17, 34, 9, -41 },
  { 85, 32, 39, 34, 1, -39 },
  { 241, 29, 53, 34, 2, -46 },
  { 434, 32, 41, 34, 1, -40 },
  { 598, 32, 41, 34, 1, -40 },
  { 762, 6, 17, 34, 14, -41 },
  { 775, 18, 51, 34, 11, -43 },
  { 890, 18, 51, 34, 5, -43 },
  { 1005, 29, 28, 34, 2, -31 },
  { 1107, 27, 27, 34, 3, -31 },
  { 1199, 11, 17, 34, 11, -9 },
  { 1223, 17, 6, 34, 8, -20 },
  { 1236, 10, 9, 34, 12, -9 },
  { 1248, 24, 51, 34, 5, -43 },
  { 1401, 29, 41, 34, 2, -40 },
  { 1550, 29, 39, 34, 3, -39 },
  { 1692, 28, 40, 34, 3, -40 },
  { 1832, 28, 41, 34, 2, -40 },
  { 1976, 30, 39, 34, 2, -39 },
  { 2123, 28, 40, 34, 3, -39 },
  { 2263, 28, 40, 34, 3, -39 },
  { 2403, 27, 39, 34, 3, -39 },
  { 2535, 28, 41, 34, 3, -40 },
  { 2679, 28, 40, 34, 3, -40 },
  { 2819, 10, 30, 34, 12, -30 },
  { 2857, 11, 38, 34, 11, -30 },
  { 2910, 24, 33, 34, 5, -34 },
  { 3009, 27, 17, 34, 3, -26 },
  { 3067, 24, 33, 34, 5, -34 },
  { 3166, 25, 41, 34, 4, -40 },
  { 3295, 27, 46, 34, 3, -40 },
  { 3451, 32, 39, 34, 1, -39 },
  { 3607, 26, 39, 34, 5, -39 },
  { 3734, 28, 41, 34, 3, -40 },
  { 3878, 26, 39, 34, 5, -39 },
  { 4005, 24, 39, 34, 5, -39 },
  { 4122, 25, 39, 34, 5, -39 },
  { 4244, 27, 41, 34, 3, -40 },
  { 4383, 26, 39, 34, 4, -39 },
  { 4510, 25, 39, 34, 4, -39 },
  { 4632, 25, 40, 34, 3, -39 },
  { 4757, 29, 39, 34, 4, -39 },
  { 4899, 24, 39, 34, 6, -39 },
  { 5016, 27, 39, 34, 3, -39 },
  { 5148, 26, 39, 34, 4, -39 },
  { 5275, 29, 41, 34, 2, -40 },
  { 5424, 26, 39, 34, 5, -39 },
  { 5551, 29, 50, 34, 2, -40 },
  { 5733, 26, 39, 34, 5, -39 },
  { 5860, 29, 41, 34, 2, -40 },
  { 6009, 31, 39, 34, 1, -39 },
  { 6161, 26, 40, 34, 4, -39 },
  { 6291, 31, 39, 34, 1, -39 },
  { 6443, 31, 39, 34, 1, -39 },
  { 6595, 32, 39, 34, 1, -39 },
  { 6751, 32, 39, 34, 1, -39 },
  { 6907, 28, 39, 34, 3, -39 },
  { 7044, 16, 51, 34, 12, -43 },
  { 7146, 24, 51, 34, 5, -43 },
  { 7299, 17, 51, 34, 5, -43 },
  { 7408, 30, 24, 34, 2, -39 },
  { 7498, 27, 5, 34, 3, 5 },
  { 7515, 10, 12, 34, 10, -44 },
  { 7530, 28, 31, 34, 3, -30 },
  { 7639, 27, 42, 34, 4, -41 },
  { 7781, 26, 31, 34, 4, -30 },
  { 7882, 26, 42, 34, 3, -41 },
  { 8019, 27, 31, 34, 3, -30 },
  { 8124, 27, 41, 34, 4, -41 },
  { 8263, 29, 46, 34, 3, -34 },
  { 8430, 24, 41, 34, 5, -41 },
  { 8553, 25, 42, 34, 6, -42 },
  { 8685, 20, 53, 34, 5, -42 },
  { 8818, 27, 41, 34, 5, -41 },
  { 8957, 25, 41, 34, 4, -41 },
  { 9086, 29, 30, 34, 2, -30 },
  { 9195, 24, 30, 34, 5, -30 },
  { 9285, 28, 31, 34, 3, -30 },
  { 9394, 27, 41, 34, 4, -30 },
  { 9533, 26, 41, 34, 3, -30 },
  { 9667, 27, 29, 34, 4, -29 },
  { 9765, 27, 31, 34, 3, -30 },
  { 9870, 28, 39, 34, 2, -39 },
  { 10007, 25, 30, 34, 4, -29 },
  { 10101, 28, 29, 34, 3, -29 },
  { 10203, 31, 29, 34, 1, -29 },
  { 10316, 28, 29, 34, 3, -29 },
  { 10418, 29, 40, 34, 2, -29 },
  { 10563, 25, 29, 34, 4, -29 },
  { 10654, 22, 51, 34, 6, -43 },
  { 10795, 5, 51, 34, 14, -43 },
  { 10827, 22, 51, 34, 6, -43 },
  { 10968, 28, 13, 34, 3, -24 },
};

const GFXfont IBMPlexMono_Medium56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_MEDIUM56PT7B_H_
