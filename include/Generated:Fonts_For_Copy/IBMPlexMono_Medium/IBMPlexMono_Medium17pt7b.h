#ifndef _IBMPLEXMONO_MEDIUM17PT7B_H_
#define _IBMPLEXMONO_MEDIUM17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium17pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6C, 0x90, 0x1B, 0xE0, 0x9C, 0xE7, 0x39, 0x80, 0x09, 0x86,
  0x41, 0x91, 0xEF, 0x7B, 0xC4, 0xC1, 0x23, 0xCE, 0xF7, 0x8D, 0x82, 0x60,
  0x98, 0x08, 0x04, 0x0F, 0x8F, 0xEC, 0xB6, 0x43, 0xA0, 0xFC, 0x3F, 0x05,
  0xA2, 0x79, 0x6F, 0xF1, 0xF0, 0x20, 0x10, 0x70, 0xDE, 0x2C, 0x9B, 0x24,
  0x7B, 0x1C, 0x00, 0x38, 0x5F, 0x34, 0xC9, 0x36, 0x7F, 0x0E, 0x1C, 0x0F,
  0x86, 0x31, 0x80, 0x30, 0x0E, 0x77, 0xDD, 0x34, 0xC7, 0x38, 0xC7, 0xD8,
  0xE7, 0xFF, 0xC0, 0x1C, 0xC2, 0x18, 0x43, 0x0C, 0x30, 0xC3, 0x04, 0x18,
  0x20, 0xC1, 0xC0, 0xC3, 0x0C, 0x21, 0x0C, 0x63, 0x18, 0xC4, 0x23, 0x33,
  0x00, 0x18, 0x0C, 0x26, 0x5F, 0xE3, 0xC9, 0xE0, 0xD8, 0xCC, 0x44, 0x00,
  0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x76, 0x64, 0xC0, 0xFF,
  0xC0, 0xDF, 0x00, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x10, 0x30, 0x20, 0x60, 0x60, 0xC0, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0xDB,
  0xDB, 0xC3, 0xC3, 0xE3, 0x7E, 0x3C, 0x3C, 0x3E, 0x1B, 0x19, 0x8C, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x3F, 0xFF, 0xF0, 0x3C, 0x7E, 0xC7, 0x43,
  0x03, 0x06, 0x0E, 0x1C, 0x30, 0x60, 0xFF, 0xFF, 0x3C, 0x7E, 0xC7, 0x03,
  0x06, 0x3C, 0x3E, 0x03, 0x83, 0xC3, 0xFE, 0x3C, 0x0E, 0x07, 0x07, 0x86,
  0xC2, 0x63, 0x31, 0x19, 0x0C, 0xFF, 0xFF, 0xC1, 0x80, 0xC0, 0x7F, 0x7F,
  0x40, 0x40, 0x5E, 0xFF, 0xC3, 0x03, 0x83, 0xC3, 0x7E, 0x3C, 0x0E, 0x38,
  0x30, 0x60, 0xDE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C, 0xFF, 0xFF,
  0xC3, 0xC2, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x3C, 0x7F,
  0xC3, 0xC3, 0xC3, 0x7E, 0x7E, 0xC3, 0xC3, 0xC3, 0xFF, 0x3E, 0x3C, 0x7E,
  0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x3B, 0x06, 0x0E, 0x1C, 0x78, 0xDF, 0x00,
  0x37, 0xC0, 0x67, 0x60, 0x00, 0x76, 0x64, 0xC0, 0x01, 0x07, 0x1E, 0x38,
  0xE0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0xE0, 0x38, 0x1E, 0x07, 0x07, 0x1E, 0x38, 0xE0, 0x80, 0x3C, 0x7E,
  0xE3, 0x43, 0x06, 0x1C, 0x18, 0x00, 0x00, 0x18, 0x38, 0x18, 0x3C, 0x7E,
  0xC3, 0xCD, 0xDF, 0x91, 0x91, 0x91, 0x9F, 0xDD, 0xC0, 0x60, 0x7E, 0x3E,
  0x0E, 0x07, 0x81, 0xE0, 0x68, 0x13, 0x0C, 0xC3, 0x30, 0xFE, 0x7F, 0x98,
  0x66, 0x1B, 0x03, 0xFE, 0xFF, 0xC3, 0xC3, 0xC3, 0xFE, 0xFE, 0xC3, 0xC3,
  0xC3, 0xFF, 0xFE, 0x3C, 0x7E, 0x63, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3,
  0x63, 0x7E, 0x3C, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC7, 0xFE, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xE3, 0xC3, 0xC0, 0xCF, 0xCF, 0xC3, 0xC3,
  0xE3, 0x7F, 0x3B, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x7E, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x47, 0x8D,
  0xF9, 0xE0, 0xC3, 0xE1, 0xB1, 0x99, 0x8D, 0x87, 0xC3, 0xF1, 0xD8, 0xC6,
  0x63, 0xB0, 0xD8, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0xFF, 0xF0, 0xC3, 0xE3, 0xE7, 0xF5, 0xFD, 0xD9, 0xD9, 0xC9, 0xD1,
  0xC1, 0xC1, 0xC1, 0xE3, 0xE3, 0xF3, 0xF3, 0xD3, 0xDB, 0xDB, 0xCB, 0xCF,
  0xC7, 0xC7, 0xC7, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE3, 0x7E, 0x3C, 0xFE, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFE, 0xC0,
  0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xE3, 0x7E, 0x3C, 0x18, 0x1F, 0x0F, 0xFE, 0x7F, 0xB0, 0xD8, 0x6C, 0x36,
  0x1B, 0xFD, 0xFC, 0xCC, 0x63, 0x31, 0xD8, 0x70, 0x3C, 0x7F, 0xC3, 0xC0,
  0xE0, 0x7E, 0x3F, 0x03, 0x83, 0xC3, 0xFF, 0x3C, 0xFF, 0xFF, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7E, 0x3C, 0xE0,
  0xD8, 0x66, 0x19, 0x86, 0x31, 0x8C, 0xC3, 0x30, 0x4C, 0x1A, 0x07, 0x81,
  0xE0, 0x38, 0xC0, 0xD0, 0x34, 0x0D, 0x33, 0x4C, 0x93, 0xA4, 0xE9, 0xEA,
  0x72, 0x9C, 0xA7, 0x39, 0xCE, 0x61, 0xDC, 0x63, 0x30, 0x6C, 0x1E, 0x03,
  0x80, 0xE0, 0x78, 0x33, 0x0C, 0xC6, 0x1B, 0x87, 0xE0, 0xD8, 0x66, 0x18,
  0xCC, 0x33, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0xFF, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7F, 0xE0, 0xC0, 0x60, 0x60,
  0x20, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06, 0x02, 0x03,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF, 0xE0, 0x18, 0x1E,
  0x0D, 0x0C, 0xC6, 0x26, 0x1A, 0x06, 0xFF, 0xFF, 0x59, 0x90, 0x3C, 0x3F,
  0x31, 0x80, 0x47, 0xE6, 0x13, 0x19, 0xF7, 0x7B, 0x80, 0xC0, 0xC0, 0xC0,
  0xC0, 0xDE, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0xDE, 0x3C, 0x7E,
  0x63, 0xC0, 0xC0, 0xC0, 0x63, 0x7E, 0x3C, 0x03, 0x03, 0x03, 0x03, 0x7B,
  0x7F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x7B, 0x3C, 0x7E, 0xE3, 0xC3,
  0xFF, 0xC0, 0xE2, 0x7F, 0x3C, 0x0F, 0x1F, 0x18, 0x18, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x03, 0x01, 0x8F, 0x8F, 0xCC, 0x32,
  0x19, 0xF8, 0x78, 0x40, 0x3F, 0x9F, 0xF8, 0x3F, 0xF3, 0xF0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xDE, 0xDE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x38,
  0x70, 0x00, 0x0F, 0x9F, 0x06, 0x0C, 0x18, 0x30, 0x67, 0xFF, 0xE0, 0x1C,
  0x70, 0x00, 0xFB, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x2F, 0xBE, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x36, 0x33, 0x31, 0xB0, 0xFC, 0x76, 0x31, 0x98,
  0x6C, 0x38, 0xF8, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0xB7, 0xBF, 0xD9, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99,
  0xDE, 0xDE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C, 0x7E, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C, 0xDE, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3,
  0xE3, 0xFF, 0xDE, 0xC0, 0xC0, 0xC0, 0x7B, 0x7F, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x7F, 0x7B, 0x03, 0x03, 0x03, 0xF3, 0xFB, 0xC6, 0x03, 0x01, 0x00,
  0x80, 0x41, 0xFE, 0xFF, 0x00, 0x3E, 0x7F, 0x42, 0xF8, 0x7E, 0x0F, 0x43,
  0xFF, 0x3E, 0x30, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x3F, 0x1F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x7F, 0x3B, 0xC3,
  0xC3, 0x63, 0x66, 0x66, 0x24, 0x3C, 0x3C, 0x18, 0xCC, 0xD3, 0x34, 0xCD,
  0x3A, 0x5A, 0x9C, 0xA7, 0x29, 0xCA, 0x73, 0x80, 0xC3, 0x66, 0x34, 0x3C,
  0x18, 0x3C, 0x26, 0x66, 0xC3, 0xC3, 0xE1, 0x98, 0xCC, 0xC2, 0x61, 0xA0,
  0xF0, 0x30, 0x18, 0x0C, 0x3C, 0x1C, 0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xFF, 0xFF, 0x3E, 0x7C, 0x81, 0x01, 0x03, 0x3C, 0x78, 0x18,
  0x30, 0xC1, 0x02, 0x07, 0xCF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xE0,
  0x40, 0x82, 0x0C, 0x0F, 0x9F, 0x60, 0x40, 0xC0, 0x81, 0x1E, 0x3C, 0x00,
  0x71, 0xF9, 0xDF, 0x8E,
};

const GFXglyph IBMPlexMono_Medium17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 4, -12 },
  { 6, 5, 5, 10, 3, -13 },
  { 10, 10, 12, 10, 0, -12 },
  { 25, 9, 16, 10, 1, -14 },
  { 43, 10, 12, 10, 0, -12 },
  { 58, 10, 12, 10, 0, -12 },
  { 73, 2, 5, 10, 4, -13 },
  { 75, 6, 15, 10, 3, -13 },
  { 87, 5, 15, 10, 2, -13 },
  { 97, 9, 9, 10, 1, -9 },
  { 108, 8, 8, 10, 1, -9 },
  { 116, 4, 5, 10, 3, -3 },
  { 119, 5, 2, 10, 3, -6 },
  { 121, 3, 3, 10, 4, -3 },
  { 123, 8, 15, 10, 1, -13 },
  { 138, 8, 12, 10, 1, -12 },
  { 150, 9, 12, 10, 1, -12 },
  { 164, 8, 12, 10, 1, -12 },
  { 176, 8, 12, 10, 1, -12 },
  { 188, 9, 12, 10, 1, -12 },
  { 202, 8, 12, 10, 1, -12 },
  { 214, 8, 12, 10, 1, -12 },
  { 226, 8, 12, 10, 1, -12 },
  { 238, 8, 12, 10, 1, -12 },
  { 250, 8, 12, 10, 1, -12 },
  { 262, 3, 9, 10, 4, -9 },
  { 266, 4, 11, 10, 3, -9 },
  { 272, 8, 10, 10, 1, -10 },
  { 282, 8, 6, 10, 1, -8 },
  { 288, 8, 10, 10, 1, -10 },
  { 298, 8, 12, 10, 1, -12 },
  { 310, 8, 14, 10, 1, -12 },
  { 324, 10, 12, 10, 0, -12 },
  { 339, 8, 12, 10, 1, -12 },
  { 351, 8, 12, 10, 1, -12 },
  { 363, 8, 12, 10, 1, -12 },
  { 375, 8, 12, 10, 1, -12 },
  { 387, 8, 12, 10, 1, -12 },
  { 399, 8, 12, 10, 1, -12 },
  { 411, 8, 12, 10, 1, -12 },
  { 423, 8, 12, 10, 1, -12 },
  { 435, 7, 12, 10, 1, -12 },
  { 446, 9, 12, 10, 1, -12 },
  { 460, 7, 12, 10, 2, -12 },
  { 471, 8, 12, 10, 1, -12 },
  { 483, 8, 12, 10, 1, -12 },
  { 495, 8, 12, 10, 1, -12 },
  { 507, 8, 12, 10, 1, -12 },
  { 519, 8, 15, 10, 1, -12 },
  { 534, 9, 12, 10, 1, -12 },
  { 548, 8, 12, 10, 1, -12 },
  { 560, 10, 12, 10, 0, -12 },
  { 575, 8, 12, 10, 1, -12 },
  { 587, 10, 12, 10, 0, -12 },
  { 602, 10, 12, 10, 0, -12 },
  { 617, 10, 12, 10, 0, -12 },
  { 632, 10, 12, 10, 0, -12 },
  { 647, 8, 12, 10, 1, -12 },
  { 659, 5, 15, 10, 4, -13 },
  { 669, 8, 15, 10, 1, -13 },
  { 684, 5, 15, 10, 2, -13 },
  { 694, 9, 7, 10, 1, -12 },
  { 702, 8, 2, 10, 1, 1 },
  { 704, 3, 4, 10, 3, -14 },
  { 706, 9, 9, 10, 1, -9 },
  { 717, 8, 13, 10, 1, -13 },
  { 730, 8, 9, 10, 1, -9 },
  { 739, 8, 13, 10, 1, -13 },
  { 752, 8, 9, 10, 1, -9 },
  { 761, 8, 13, 10, 1, -13 },
  { 774, 9, 14, 10, 1, -11 },
  { 790, 8, 13, 10, 1, -13 },
  { 803, 7, 13, 10, 2, -13 },
  { 815, 6, 16, 10, 2, -13 },
  { 827, 9, 13, 10, 1, -13 },
  { 842, 8, 13, 10, 1, -13 },
  { 855, 8, 9, 10, 1, -9 },
  { 864, 8, 9, 10, 1, -9 },
  { 873, 8, 9, 10, 1, -9 },
  { 882, 8, 12, 10, 1, -9 },
  { 894, 8, 12, 10, 1, -9 },
  { 906, 9, 9, 10, 1, -9 },
  { 917, 8, 9, 10, 1, -9 },
  { 926, 8, 12, 10, 1, -12 },
  { 938, 8, 9, 10, 1, -9 },
  { 947, 8, 9, 10, 1, -9 },
  { 956, 10, 9, 10, 0, -9 },
  { 968, 8, 9, 10, 1, -9 },
  { 977, 9, 12, 10, 1, -9 },
  { 991, 8, 9, 10, 1, -9 },
  { 1000, 7, 15, 10, 2, -13 },
  { 1014, 2, 15, 10, 4, -13 },
  { 1018, 7, 15, 10, 2, -13 },
  { 1032, 8, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_Medium17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_MEDIUM17PT7B_H_
