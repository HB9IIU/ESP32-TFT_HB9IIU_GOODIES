#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &IBMPlexMono_Medium6pt7b, 6, "IBMPlexMono_Medium6pt7b" },
  { &IBMPlexMono_Medium7pt7b, 7, "IBMPlexMono_Medium7pt7b" },
  { &IBMPlexMono_Medium8pt7b, 8, "IBMPlexMono_Medium8pt7b" },
  { &IBMPlexMono_Medium9pt7b, 9, "IBMPlexMono_Medium9pt7b" },
  { &IBMPlexMono_Medium10pt7b, 10, "IBMPlexMono_Medium10pt7b" },
  { &IBMPlexMono_Medium11pt7b, 11, "IBMPlexMono_Medium11pt7b" },
  { &IBMPlexMono_Medium12pt7b, 12, "IBMPlexMono_Medium12pt7b" },
  { &IBMPlexMono_Medium13pt7b, 13, "IBMPlexMono_Medium13pt7b" },
  { &IBMPlexMono_Medium14pt7b, 14, "IBMPlexMono_Medium14pt7b" },
  { &IBMPlexMono_Medium15pt7b, 15, "IBMPlexMono_Medium15pt7b" },
  { &IBMPlexMono_Medium16pt7b, 16, "IBMPlexMono_Medium16pt7b" },
  { &IBMPlexMono_Medium17pt7b, 17, "IBMPlexMono_Medium17pt7b" },
  { &IBMPlexMono_Medium18pt7b, 18, "IBMPlexMono_Medium18pt7b" },
  { &IBMPlexMono_Medium19pt7b, 19, "IBMPlexMono_Medium19pt7b" },
  { &IBMPlexMono_Medium20pt7b, 20, "IBMPlexMono_Medium20pt7b" },
  { &IBMPlexMono_Medium21pt7b, 21, "IBMPlexMono_Medium21pt7b" },
  { &IBMPlexMono_Medium22pt7b, 22, "IBMPlexMono_Medium22pt7b" },
  { &IBMPlexMono_Medium23pt7b, 23, "IBMPlexMono_Medium23pt7b" },
  { &IBMPlexMono_Medium24pt7b, 24, "IBMPlexMono_Medium24pt7b" },
  { &IBMPlexMono_Medium25pt7b, 25, "IBMPlexMono_Medium25pt7b" },
  { &IBMPlexMono_Medium26pt7b, 26, "IBMPlexMono_Medium26pt7b" },
  { &IBMPlexMono_Medium27pt7b, 27, "IBMPlexMono_Medium27pt7b" },
  { &IBMPlexMono_Medium28pt7b, 28, "IBMPlexMono_Medium28pt7b" },
  { &IBMPlexMono_Medium29pt7b, 29, "IBMPlexMono_Medium29pt7b" },
  { &IBMPlexMono_Medium30pt7b, 30, "IBMPlexMono_Medium30pt7b" },
  { &IBMPlexMono_Medium31pt7b, 31, "IBMPlexMono_Medium31pt7b" },
  { &IBMPlexMono_Medium32pt7b, 32, "IBMPlexMono_Medium32pt7b" },
  { &IBMPlexMono_Medium33pt7b, 33, "IBMPlexMono_Medium33pt7b" },
  { &IBMPlexMono_Medium34pt7b, 34, "IBMPlexMono_Medium34pt7b" },
  { &IBMPlexMono_Medium35pt7b, 35, "IBMPlexMono_Medium35pt7b" },
  { &IBMPlexMono_Medium36pt7b, 36, "IBMPlexMono_Medium36pt7b" },
  { &IBMPlexMono_Medium37pt7b, 37, "IBMPlexMono_Medium37pt7b" },
  { &IBMPlexMono_Medium38pt7b, 38, "IBMPlexMono_Medium38pt7b" },
  { &IBMPlexMono_Medium39pt7b, 39, "IBMPlexMono_Medium39pt7b" },
  { &IBMPlexMono_Medium40pt7b, 40, "IBMPlexMono_Medium40pt7b" },
  { &IBMPlexMono_Medium41pt7b, 41, "IBMPlexMono_Medium41pt7b" },
  { &IBMPlexMono_Medium42pt7b, 42, "IBMPlexMono_Medium42pt7b" },
  { &IBMPlexMono_Medium43pt7b, 43, "IBMPlexMono_Medium43pt7b" },
  { &IBMPlexMono_Medium44pt7b, 44, "IBMPlexMono_Medium44pt7b" },
  { &IBMPlexMono_Medium45pt7b, 45, "IBMPlexMono_Medium45pt7b" },
  { &IBMPlexMono_Medium46pt7b, 46, "IBMPlexMono_Medium46pt7b" },
  { &IBMPlexMono_Medium47pt7b, 47, "IBMPlexMono_Medium47pt7b" },
  { &IBMPlexMono_Medium48pt7b, 48, "IBMPlexMono_Medium48pt7b" },
  { &IBMPlexMono_Medium49pt7b, 49, "IBMPlexMono_Medium49pt7b" },
  { &IBMPlexMono_Medium50pt7b, 50, "IBMPlexMono_Medium50pt7b" },
  { &IBMPlexMono_Medium51pt7b, 51, "IBMPlexMono_Medium51pt7b" },
  { &IBMPlexMono_Medium52pt7b, 52, "IBMPlexMono_Medium52pt7b" },
  { &IBMPlexMono_Medium53pt7b, 53, "IBMPlexMono_Medium53pt7b" },
  { &IBMPlexMono_Medium54pt7b, 54, "IBMPlexMono_Medium54pt7b" },
  { &IBMPlexMono_Medium55pt7b, 55, "IBMPlexMono_Medium55pt7b" },
  { &IBMPlexMono_Medium56pt7b, 56, "IBMPlexMono_Medium56pt7b" },
  { &IBMPlexMono_Medium57pt7b, 57, "IBMPlexMono_Medium57pt7b" },
  { &IBMPlexMono_Medium58pt7b, 58, "IBMPlexMono_Medium58pt7b" },
  { &IBMPlexMono_Medium59pt7b, 59, "IBMPlexMono_Medium59pt7b" },
  { &IBMPlexMono_Medium60pt7b, 60, "IBMPlexMono_Medium60pt7b" },
  { &IBMPlexMono_Medium61pt7b, 61, "IBMPlexMono_Medium61pt7b" },
  { &IBMPlexMono_Medium62pt7b, 62, "IBMPlexMono_Medium62pt7b" },
  { &IBMPlexMono_Medium63pt7b, 63, "IBMPlexMono_Medium63pt7b" },
  { &IBMPlexMono_Medium64pt7b, 64, "IBMPlexMono_Medium64pt7b" },
  { &IBMPlexMono_Medium65pt7b, 65, "IBMPlexMono_Medium65pt7b" },
  { &IBMPlexMono_Medium66pt7b, 66, "IBMPlexMono_Medium66pt7b" },
  { &IBMPlexMono_Medium67pt7b, 67, "IBMPlexMono_Medium67pt7b" },
  { &IBMPlexMono_Medium68pt7b, 68, "IBMPlexMono_Medium68pt7b" },
  { &IBMPlexMono_Medium69pt7b, 69, "IBMPlexMono_Medium69pt7b" },
  { &IBMPlexMono_Medium70pt7b, 70, "IBMPlexMono_Medium70pt7b" },
  { &IBMPlexMono_Medium71pt7b, 71, "IBMPlexMono_Medium71pt7b" },
  { &IBMPlexMono_Medium72pt7b, 72, "IBMPlexMono_Medium72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
