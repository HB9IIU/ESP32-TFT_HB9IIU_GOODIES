#ifndef _IBMPLEXMONO_MEDIUM41PT7B_H_
#define _IBMPLEXMONO_MEDIUM41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium41pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xC3,
  0x87, 0x0E, 0x1C, 0x30, 0x60, 0x00, 0x00, 0x00, 0x1F, 0x7E, 0xFF, 0xFF,
  0xFF, 0xE7, 0xC0, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF1, 0xE0, 0x7F, 0xC3, 0xFE, 0xFF,
  0x87, 0xFD, 0xFF, 0x0F, 0xFB, 0xFE, 0x1F, 0xF0, 0x3C, 0x38, 0x00, 0x70,
  0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x81, 0xFF, 0x0F,
  0xFB, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0xEF, 0xF0, 0xFF, 0xC1, 0xE1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x3C, 0x00,
  0x38, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x7E, 0x73, 0xFB, 0xE3, 0x87, 0x1E,
  0x1C, 0x10, 0xF0, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xF1, 0xC0,
  0x0F, 0xEE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x38, 0xF8, 0x01, 0xC3, 0xE0, 0x0E, 0x1F,
  0x00, 0x70, 0x79, 0x03, 0x87, 0xDC, 0x1C, 0x3F, 0xF0, 0xE1, 0xEF, 0xE7,
  0x3F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x80, 0x0F, 0x1F, 0xE0, 0x0E, 0x3F, 0xF0, 0x1E, 0x78, 0xF0, 0x1C, 0x70,
  0x78, 0x3C, 0x70, 0x38, 0x38, 0x70, 0x38, 0x78, 0x70, 0x38, 0xF0, 0x70,
  0x38, 0xF0, 0x70, 0x39, 0xE0, 0x70, 0x79, 0xE0, 0x78, 0xF3, 0xC0, 0x3F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFE, 0x01, 0xEF, 0x1E, 0x03, 0xCE, 0x0F, 0x03, 0x8E, 0x0F, 0x07,
  0x8E, 0x07, 0x0F, 0x0E, 0x07, 0x0F, 0x0E, 0x07, 0x1E, 0x0E, 0x0F, 0x1E,
  0x0E, 0x0F, 0x3C, 0x0F, 0x1E, 0x38, 0x07, 0xFE, 0x78, 0x03, 0xFC, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0xE0, 0x0F, 0x00, 0x80, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x0F, 0xC1, 0xF8, 0x1F, 0x87, 0xF8, 0x3F, 0x1F, 0xF8, 0x7E,
  0x7D, 0xF8, 0xE1, 0xF1, 0xF9, 0xC3, 0xE1, 0xF3, 0x87, 0x81, 0xFF, 0x0F,
  0x01, 0xFC, 0x1E, 0x01, 0xF8, 0x3C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xFC,
  0x0F, 0xE0, 0xFF, 0xFB, 0xE0, 0xFF, 0xE3, 0xE0, 0xFF, 0xC3, 0xE0, 0x7E,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x03, 0x83, 0xC1, 0xDF, 0x9E, 0x7E, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x87, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F,
  0x78, 0x01, 0xF3, 0xE0, 0x0F, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x80, 0xF0,
  0x18, 0x07, 0x00, 0x40, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x3E, 0x01, 0xF1, 0xF0,
  0x07, 0xCF, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x8F, 0x0F, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F,
  0x1F, 0xF8, 0xF0, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xEF,
  0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x3F, 0x07,
  0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFB,
  0xC0, 0x1F, 0x9E, 0x01, 0xF8, 0xF0, 0x1F, 0x87, 0x80, 0xF8, 0x3C, 0x03,
  0x81, 0xE0, 0x08, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7E, 0x0F, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xE3, 0x80,
  0x3E, 0x10, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x0F, 0xE7, 0x80, 0x3E, 0x10, 0x03, 0xE1,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xFC,
  0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF2, 0x00,
  0x1F, 0x70, 0x01, 0xFF, 0x80, 0x3E, 0xFE, 0x0F, 0xE7, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00,
  0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x3C, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x7E, 0x03, 0x9F, 0xF8, 0x3B, 0xFF, 0xC3,
  0xBF, 0xFE, 0x7F, 0x07, 0xE7, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF1, 0x00, 0x1F, 0x38, 0x01,
  0xF7, 0xC0, 0x3F, 0xFE, 0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x1F, 0x80, 0xFB, 0xFF, 0x07,
  0xBF, 0xFC, 0x3F, 0xFF, 0xF3, 0xFC, 0x1F, 0xDF, 0x80, 0x7E, 0xF8, 0x01,
  0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x07, 0xCF, 0x80, 0x7E, 0x3F, 0x07, 0xE1, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0x3E,
  0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xF3, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0x7C, 0x0F, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0x0F, 0xBE, 0x00, 0x3D,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x3E, 0x7E, 0x07, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7F, 0x07, 0xE7, 0xC0, 0x3E, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7,
  0xC0, 0x3F, 0x7F, 0x07, 0xF3, 0xFF, 0xEF, 0x3F, 0xFD, 0xF0, 0xFF, 0x9E,
  0x03, 0xF3, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80,
  0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8,
  0xF0, 0xF0, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x0F, 0xFE, 0x01, 0xFF,
  0x80, 0x7C, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x7E, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xC0, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x3C, 0xF7, 0x07, 0xEF, 0xF0, 0xFF, 0xFF, 0x0F, 0x1F, 0xF1, 0xE0,
  0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E,
  0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF0,
  0xFF, 0xF7, 0x0F, 0xFF, 0x70, 0x7E, 0xF7, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB,
  0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3E, 0x00, 0x78, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF8,
  0x07, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xF7, 0xC0,
  0x01, 0xEF, 0x80, 0x03, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0x80, 0xFD, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1E,
  0xF8, 0x03, 0xDF, 0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0xFF, 0xF1,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0xF8, 0x07, 0xDF, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xF8, 0x7E, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x80, 0x1F, 0x7C,
  0x00, 0x83, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x08, 0x3E, 0x00, 0x78,
  0xF0, 0x07, 0xE7, 0xC0, 0x3E, 0x1F, 0x87, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x1F, 0xCF, 0x80, 0x7C, 0xF8, 0x03,
  0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xEF,
  0x80, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0xF8, 0x1F, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xE0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1E,
  0x78, 0x01, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0xC0, 0x1F, 0x7C,
  0x01, 0xF7, 0xE0, 0x3F, 0x3F, 0x07, 0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0,
  0xFF, 0x8F, 0x03, 0xF0, 0xF0, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xCE, 0x00, 0xFF, 0x80, 0x7D,
  0xF0, 0x1F, 0x7E, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x03,
  0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xF9, 0xF0, 0x0F,
  0x8F, 0x80, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8,
  0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x7C, 0x07, 0xF3,
  0xE0, 0x3F, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x3E, 0x00,
  0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xF7, 0x0F, 0xFF, 0x78, 0xFF, 0xF7, 0x8E, 0xFF,
  0x3D, 0xEF, 0xF3, 0xDC, 0xFF, 0x1F, 0xCF, 0xF1, 0xFC, 0xFF, 0x1F, 0x8F,
  0xF0, 0xF8, 0xFF, 0x0F, 0x0F, 0xF0, 0x70, 0xFF, 0x07, 0x0F, 0xF0, 0x60,
  0xFF, 0x02, 0x0F, 0xF0, 0x20, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF0, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xBC, 0x0F, 0xF7, 0x81, 0xFE,
  0xF0, 0x3F, 0xCF, 0x07, 0xF9, 0xE0, 0xFF, 0x1E, 0x1F, 0xE3, 0xC3, 0xFC,
  0x78, 0x7F, 0x87, 0x8F, 0xF0, 0xF1, 0xFE, 0x1E, 0x3F, 0xC1, 0xE7, 0xF8,
  0x3C, 0xFF, 0x03, 0xDF, 0xE0, 0x7B, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E,
  0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0xC0,
  0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x7C, 0x3F, 0x07, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xCF,
  0x00, 0x3E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x0F,
  0x3C, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x3F, 0x07, 0xE1, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03,
  0xEF, 0x80, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0xF8, 0x7C, 0x0F, 0x83, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x07, 0xEF,
  0x80, 0x3E, 0xF8, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x7F, 0x03, 0xF7, 0xC0, 0x1E, 0x7C, 0x00, 0x47, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF2, 0x00, 0x0F,
  0x70, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xBE, 0x00,
  0xF7, 0xC0, 0x3E, 0x7E, 0x0F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0x80, 0x7F, 0x80, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8,
  0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x1E, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x38,
  0x3E, 0x1E, 0x78, 0x7C, 0x3C, 0xF0, 0xF8, 0x79, 0xE3, 0xF0, 0xF3, 0xC7,
  0xE1, 0xE7, 0x8E, 0xE3, 0xCF, 0x1D, 0xC7, 0x9E, 0x3B, 0x8F, 0x3C, 0xF7,
  0x1E, 0x79, 0xCE, 0x38, 0xF3, 0x9E, 0x71, 0xE7, 0x1C, 0xE3, 0xCE, 0x3B,
  0xC7, 0x9C, 0x77, 0x87, 0x78, 0xEF, 0x0E, 0xE1, 0xFE, 0x1D, 0xC3, 0xFC,
  0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3,
  0xF0, 0x3F, 0x80, 0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xEF,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0,
  0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x80,
  0x3E, 0x3C, 0x01, 0xE1, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0x80,
  0xF0, 0x78, 0x07, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xFB, 0xE0, 0x03, 0xDE,
  0x00, 0x1F, 0xF0, 0x00, 0x71, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x70, 0xF8, 0x78, 0x3C, 0x3C,
  0x1E, 0x0F, 0x0C, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x07, 0xE0, 0xFC, 0x1C, 0x03, 0xE0, 0x40, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xC0,
  0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x7C, 0x0F, 0xC3,
  0xFF, 0xDF, 0xCF, 0xFE, 0x7E, 0x7F, 0xE3, 0xF0, 0xFC, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0xF9, 0xFF, 0x0F, 0xBF, 0xF8, 0xFF, 0xFF, 0xCF, 0xE0, 0xFC, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80,
  0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0xE0, 0xFC, 0xFF, 0xFF, 0xCF, 0xBF, 0xF8, 0xF9, 0xFF, 0x0F,
  0x8F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xE0, 0xFC, 0xF8, 0x07, 0x9E, 0x00, 0xC7, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x63, 0xE0, 0x1E, 0x7E, 0x07, 0xE7, 0xFF, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0xFC, 0x3C, 0x7F, 0xE7, 0x9F, 0xFE, 0xF3, 0xFF, 0xDE, 0xFE,
  0x0F, 0xDF, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0x7C, 0x03, 0xEF, 0xE0, 0xFC, 0xFF, 0xF7, 0x9F, 0xFE, 0xF1, 0xFF,
  0x9E, 0x0F, 0xC3, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xFF, 0xFC, 0x3F, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0x80, 0x1F,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x87, 0xC0, 0x0C, 0x3F, 0x03, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x3E, 0x07, 0xC1,
  0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x1F, 0x03,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xFB, 0xC0, 0x07, 0xDC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xC0, 0x0F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC,
  0x07, 0xFF, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x3F, 0x0F, 0x9F, 0xF3, 0xEF, 0xFE, 0xFF, 0xFF, 0xBF, 0x83, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xDF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF,
  0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x7E, 0xF0, 0x0F, 0x8F, 0x01, 0xF0, 0xF0, 0x3E, 0x0F,
  0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0x7C,
  0x0F, 0x03, 0xE0, 0xF0, 0x3F, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F, 0x00,
  0x7C, 0xF0, 0x07, 0xEF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF3, 0xC3, 0xE7, 0xBF, 0x3F, 0xBF,
  0xFB, 0xFD, 0xFF, 0xFF, 0xEF, 0x8F, 0x8F, 0xF8, 0x78, 0x3F, 0xC3, 0xC1,
  0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1,
  0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x1E, 0x0F,
  0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xFF, 0x0F,
  0x07, 0x80, 0xF8, 0xFC, 0x3E, 0x7F, 0xCF, 0xBF, 0xFB, 0xFF, 0xFE, 0xFE,
  0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3F, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80,
  0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x3F, 0x07, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xF8, 0xFC, 0x0F, 0x9F, 0xF0,
  0xFB, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x0F, 0xCF, 0x80, 0x3E, 0xF8, 0x03,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80,
  0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xFE,
  0x0F, 0xCF, 0xFF, 0xFC, 0xFB, 0xFF, 0x8F, 0x9F, 0xF0, 0xF8, 0xFC, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE1, 0xE3, 0xFF,
  0x3C, 0xFF, 0xF7, 0x9F, 0xFE, 0xF7, 0xF0, 0x7E, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7B, 0xE0, 0x1F, 0x7F, 0x07,
  0xE7, 0xFF, 0xBC, 0xFF, 0xF7, 0x8F, 0xFC, 0xF0, 0x7E, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFD, 0xFF, 0x03, 0xD8, 0x00, 0x3D, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3E, 0x03, 0xC3, 0xC0,
  0x08, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF3,
  0x00, 0x1F, 0x7E, 0x03, 0xEF, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF0, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x1F, 0x7E, 0x0F, 0xDF, 0xFE, 0xF3, 0xFF, 0xBC, 0x7F,
  0xCF, 0x0F, 0xC3, 0xC0, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C,
  0xF8, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x03, 0xC0,
  0x78, 0x1E, 0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x1E, 0x00,
  0xF8, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x7C, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x77, 0x83, 0xE0, 0xEF,
  0x0F, 0xC1, 0xCE, 0x1D, 0xC7, 0x9C, 0x3B, 0x8F, 0x38, 0x77, 0x1E, 0x78,
  0xEE, 0x3C, 0xF1, 0x9C, 0x71, 0xE7, 0x38, 0xE3, 0xCE, 0x39, 0xC3, 0x9C,
  0x73, 0x87, 0x38, 0xE7, 0x0E, 0x61, 0xDE, 0x1D, 0xC3, 0xBC, 0x3F, 0x83,
  0x70, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F,
  0x00, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0x0F, 0x80, 0xF8, 0x3E, 0x0F, 0x81,
  0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x1E, 0x7C, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF0, 0x3E,
  0x0F, 0x00, 0xF8, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x80, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x1E, 0x01,
  0xF0, 0xF8, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xC0, 0x78, 0x3C, 0x03,
  0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x0F, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xF0, 0x7C,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x0F,
  0x00, 0x70, 0xFE, 0x03, 0xCF, 0xF8, 0x1C, 0xFF, 0xE0, 0xE7, 0x9F, 0x0F,
  0x38, 0x7C, 0x7B, 0xC1, 0xFF, 0x9E, 0x07, 0xFC, 0xE0, 0x1F, 0xC3, 0x00,
  0x78, 0x00,
};

const GFXglyph IBMPlexMono_Medium41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 29, 25, 9, -29 },
  { 27, 12, 12, 25, 6, -30 },
  { 45, 23, 29, 25, 1, -29 },
  { 129, 21, 37, 25, 2, -33 },
  { 227, 24, 29, 25, 0, -29 },
  { 314, 23, 29, 25, 1, -29 },
  { 398, 4, 12, 25, 10, -30 },
  { 404, 13, 37, 25, 8, -31 },
  { 465, 13, 37, 25, 4, -31 },
  { 526, 21, 21, 25, 2, -23 },
  { 582, 19, 20, 25, 3, -23 },
  { 630, 8, 12, 25, 8, -6 },
  { 642, 12, 4, 25, 6, -14 },
  { 648, 7, 7, 25, 9, -6 },
  { 655, 18, 37, 25, 3, -31 },
  { 739, 21, 29, 25, 2, -29 },
  { 816, 21, 29, 25, 2, -29 },
  { 893, 20, 29, 25, 2, -29 },
  { 966, 20, 29, 25, 2, -29 },
  { 1039, 22, 29, 25, 1, -29 },
  { 1119, 20, 29, 25, 2, -29 },
  { 1192, 21, 29, 25, 2, -29 },
  { 1269, 20, 29, 25, 2, -29 },
  { 1342, 21, 29, 25, 2, -29 },
  { 1419, 20, 29, 25, 2, -29 },
  { 1492, 7, 22, 25, 9, -21 },
  { 1512, 8, 27, 25, 8, -21 },
  { 1539, 18, 24, 25, 3, -24 },
  { 1593, 19, 13, 25, 3, -19 },
  { 1624, 18, 24, 25, 3, -24 },
  { 1678, 18, 29, 25, 3, -29 },
  { 1744, 20, 34, 25, 2, -29 },
  { 1829, 23, 29, 25, 1, -29 },
  { 1913, 19, 29, 25, 3, -29 },
  { 1982, 21, 29, 25, 2, -29 },
  { 2059, 20, 29, 25, 3, -29 },
  { 2132, 17, 29, 25, 4, -29 },
  { 2194, 18, 29, 25, 4, -29 },
  { 2260, 20, 29, 25, 2, -29 },
  { 2333, 19, 29, 25, 3, -29 },
  { 2402, 18, 29, 25, 3, -29 },
  { 2468, 18, 29, 25, 2, -29 },
  { 2534, 21, 29, 25, 3, -29 },
  { 2611, 18, 29, 25, 4, -29 },
  { 2677, 20, 29, 25, 2, -29 },
  { 2750, 19, 29, 25, 3, -29 },
  { 2819, 21, 29, 25, 2, -29 },
  { 2896, 20, 29, 25, 3, -29 },
  { 2969, 21, 36, 25, 2, -29 },
  { 3064, 20, 29, 25, 3, -29 },
  { 3137, 20, 29, 25, 2, -29 },
  { 3210, 23, 29, 25, 1, -29 },
  { 3294, 19, 29, 25, 3, -29 },
  { 3363, 23, 29, 25, 1, -29 },
  { 3447, 23, 29, 25, 1, -29 },
  { 3531, 23, 29, 25, 1, -29 },
  { 3615, 24, 29, 25, 0, -29 },
  { 3702, 21, 29, 25, 2, -29 },
  { 3779, 13, 37, 25, 8, -31 },
  { 3840, 18, 37, 25, 3, -31 },
  { 3924, 12, 37, 25, 4, -31 },
  { 3980, 21, 18, 25, 2, -29 },
  { 4028, 20, 4, 25, 2, 3 },
  { 4038, 8, 9, 25, 7, -33 },
  { 4047, 21, 21, 25, 2, -21 },
  { 4103, 20, 30, 25, 3, -30 },
  { 4178, 19, 21, 25, 3, -21 },
  { 4228, 19, 30, 25, 2, -30 },
  { 4300, 20, 21, 25, 2, -21 },
  { 4353, 20, 30, 25, 3, -30 },
  { 4428, 21, 33, 25, 2, -25 },
  { 4515, 18, 30, 25, 3, -30 },
  { 4583, 19, 31, 25, 4, -31 },
  { 4657, 15, 39, 25, 4, -31 },
  { 4731, 20, 30, 25, 4, -30 },
  { 4806, 19, 30, 25, 3, -30 },
  { 4878, 21, 21, 25, 2, -21 },
  { 4934, 18, 21, 25, 3, -21 },
  { 4982, 20, 21, 25, 2, -21 },
  { 5035, 20, 29, 25, 3, -21 },
  { 5108, 19, 29, 25, 2, -21 },
  { 5177, 20, 21, 25, 3, -21 },
  { 5230, 20, 21, 25, 2, -21 },
  { 5283, 20, 29, 25, 2, -29 },
  { 5356, 18, 21, 25, 3, -21 },
  { 5404, 21, 21, 25, 2, -21 },
  { 5460, 23, 21, 25, 1, -21 },
  { 5521, 21, 21, 25, 2, -21 },
  { 5577, 21, 29, 25, 2, -21 },
  { 5654, 18, 21, 25, 3, -21 },
  { 5702, 17, 37, 25, 4, -31 },
  { 5781, 4, 37, 25, 10, -31 },
  { 5800, 17, 37, 25, 4, -31 },
  { 5879, 21, 10, 25, 2, -17 },
};

const GFXfont IBMPlexMono_Medium41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_MEDIUM41PT7B_H_
