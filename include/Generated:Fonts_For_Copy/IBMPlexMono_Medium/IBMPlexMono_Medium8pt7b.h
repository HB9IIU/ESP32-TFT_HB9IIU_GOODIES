#ifndef _IBMPLEXMONO_MEDIUM8PT7B_H_
#define _IBMPLEXMONO_MEDIUM8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Medium.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Medium8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x72, 0xB6, 0xCF, 0x30, 0x7B, 0x63, 0x3F, 0x20, 0x4D,
  0xB4, 0x26, 0xDC, 0x65, 0x91, 0x7B, 0x7C, 0xC0, 0xEA, 0xAC, 0x95, 0x58,
  0x27, 0xD8, 0xA0, 0x2F, 0x22, 0xC0, 0xE0, 0x80, 0x25, 0x29, 0x20, 0x25,
  0x9B, 0x97, 0x23, 0x28, 0x42, 0x3C, 0x69, 0x12, 0x4F, 0x69, 0x13, 0x1F,
  0x11, 0x95, 0x2F, 0x88, 0x74, 0xA5, 0x1F, 0x34, 0x6D, 0x97, 0xF9, 0x12,
  0x26, 0x69, 0x57, 0x97, 0x69, 0x97, 0x16, 0x90, 0x98, 0x2A, 0x22, 0xF0,
  0xF0, 0x98, 0xA8, 0xD4, 0xA0, 0x80, 0x2D, 0xBD, 0xB8, 0x70, 0x23, 0x14,
  0xA7, 0x4C, 0xD6, 0xFB, 0xC0, 0x25, 0x88, 0x57, 0xD6, 0xDB, 0xC0, 0xF2,
  0x79, 0xC0, 0xF2, 0x79, 0x00, 0x25, 0x8B, 0x97, 0xB6, 0xFB, 0x40, 0xE9,
  0x25, 0xC0, 0x71, 0x11, 0x1F, 0x9A, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0xDD,
  0xFB, 0xD9, 0xB7, 0xFB, 0x40, 0x25, 0x99, 0x97, 0xD6, 0xF9, 0x00, 0x25,
  0x99, 0x97, 0x30, 0xD6, 0xFB, 0x40, 0x75, 0x43, 0x1F, 0xF9, 0x08, 0x42,
  0x10, 0xB6, 0xDB, 0xC0, 0x8C, 0x94, 0xA6, 0x10, 0x8C, 0x6D, 0xEF, 0x28,
  0x8A, 0x98, 0x45, 0x4C, 0x8A, 0x94, 0x42, 0x10, 0xF1, 0x22, 0x4F, 0xEA,
  0xAC, 0x92, 0x24, 0x48, 0xD5, 0x5C, 0x23, 0x15, 0x30, 0xF0, 0xC0, 0x71,
  0xF7, 0x93, 0xDB, 0xC0, 0xF2, 0x70, 0x11, 0x79, 0x97, 0x79, 0xE7, 0x6B,
  0xA5, 0xC0, 0x13, 0x94, 0xC7, 0x45, 0xC0, 0x93, 0xDB, 0x40, 0x43, 0x25,
  0xC0, 0x63, 0x24, 0x96, 0x88, 0xAC, 0xAB, 0xC9, 0x25, 0xC0, 0xFB, 0xBB,
  0xF6, 0xD0, 0x79, 0x97, 0xF6, 0xF9, 0x00, 0x79, 0x97, 0x11, 0xE9, 0x70,
  0x74, 0x3F, 0x44, 0xF4, 0x43, 0xB6, 0xF0, 0x95, 0x62, 0xAF, 0xBC, 0xA0,
  0xD2, 0x6D, 0x95, 0x62, 0x24, 0xEA, 0x70, 0x69, 0x44, 0x98, 0xFE, 0xCA,
  0x3C, 0xB0, 0xF2,
};

const GFXglyph IBMPlexMono_Medium8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 2, 5, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 7, 5, 0, -6 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 5, 2, -6 },
  { 20, 2, 7, 5, 2, -6 },
  { 22, 2, 7, 5, 1, -6 },
  { 24, 5, 4, 5, 0, -4 },
  { 27, 4, 4, 5, 0, -4 },
  { 29, 1, 2, 5, 2, -1 },
  { 30, 3, 1, 5, 1, -3 },
  { 31, 1, 1, 5, 2, -1 },
  { 32, 3, 7, 5, 1, -6 },
  { 35, 4, 6, 5, 0, -6 },
  { 38, 5, 6, 5, 0, -6 },
  { 42, 4, 6, 5, 0, -6 },
  { 45, 4, 6, 5, 0, -6 },
  { 48, 5, 6, 5, 0, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 4, 6, 5, 0, -6 },
  { 64, 4, 6, 5, 0, -6 },
  { 67, 1, 4, 5, 2, -4 },
  { 68, 1, 5, 5, 2, -4 },
  { 69, 3, 5, 5, 1, -5 },
  { 71, 4, 3, 5, 0, -4 },
  { 73, 3, 5, 5, 1, -5 },
  { 75, 3, 6, 5, 1, -6 },
  { 78, 4, 7, 5, 0, -6 },
  { 82, 5, 6, 5, 0, -6 },
  { 86, 3, 6, 5, 1, -6 },
  { 89, 4, 6, 5, 0, -6 },
  { 92, 3, 6, 5, 1, -6 },
  { 95, 3, 6, 5, 1, -6 },
  { 98, 3, 6, 5, 1, -6 },
  { 101, 4, 6, 5, 0, -6 },
  { 104, 3, 6, 5, 1, -6 },
  { 107, 3, 6, 5, 1, -6 },
  { 110, 4, 6, 5, 0, -6 },
  { 113, 4, 6, 5, 1, -6 },
  { 116, 3, 6, 5, 1, -6 },
  { 119, 4, 6, 5, 0, -6 },
  { 122, 3, 6, 5, 1, -6 },
  { 125, 4, 6, 5, 0, -6 },
  { 128, 3, 6, 5, 1, -6 },
  { 131, 4, 7, 5, 0, -6 },
  { 135, 3, 6, 5, 1, -6 },
  { 138, 4, 6, 5, 0, -6 },
  { 141, 5, 6, 5, 0, -6 },
  { 145, 3, 6, 5, 1, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 4, 6, 5, 0, -6 },
  { 167, 2, 7, 5, 2, -6 },
  { 169, 3, 7, 5, 1, -6 },
  { 172, 2, 7, 5, 1, -6 },
  { 174, 5, 4, 5, 0, -6 },
  { 177, 4, 1, 5, 0, 1 },
  { 178, 2, 1, 5, 1, -6 },
  { 179, 4, 4, 5, 0, -4 },
  { 181, 3, 6, 5, 1, -6 },
  { 184, 3, 4, 5, 1, -4 },
  { 186, 4, 6, 5, 0, -6 },
  { 189, 4, 4, 5, 0, -4 },
  { 191, 3, 6, 5, 1, -6 },
  { 194, 5, 7, 5, 0, -5 },
  { 199, 3, 6, 5, 1, -6 },
  { 202, 3, 6, 5, 1, -6 },
  { 205, 3, 8, 5, 1, -6 },
  { 208, 4, 6, 5, 1, -6 },
  { 211, 3, 6, 5, 1, -6 },
  { 214, 4, 4, 5, 0, -4 },
  { 216, 3, 4, 5, 1, -4 },
  { 218, 4, 4, 5, 0, -4 },
  { 220, 3, 6, 5, 1, -4 },
  { 223, 4, 6, 5, 0, -4 },
  { 226, 3, 4, 5, 1, -4 },
  { 228, 4, 4, 5, 0, -4 },
  { 230, 4, 6, 5, 0, -6 },
  { 233, 3, 4, 5, 1, -4 },
  { 235, 4, 4, 5, 0, -4 },
  { 237, 5, 4, 5, 0, -4 },
  { 240, 4, 4, 5, 0, -4 },
  { 242, 4, 6, 5, 0, -4 },
  { 245, 3, 4, 5, 1, -4 },
  { 247, 3, 7, 5, 1, -6 },
  { 250, 1, 7, 5, 2, -6 },
  { 251, 3, 7, 5, 1, -6 },
  { 254, 4, 2, 5, 0, -3 },
};

const GFXfont IBMPlexMono_Medium8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Medium8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Medium8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_MEDIUM8PT7B_H_
