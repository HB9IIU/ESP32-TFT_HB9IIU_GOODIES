#ifndef _NOTOSANS_CONDENSED_THIN14PT7B_H_
#define _NOTOSANS_CONDENSED_THIN14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x40, 0xFF, 0x24, 0x48, 0xA3, 0xF2, 0x85, 0x3F, 0x24, 0x48,
  0x90, 0x43, 0xB1, 0x8C, 0x21, 0xC9, 0x4A, 0x7C, 0x80, 0xE5, 0x52, 0xA5,
  0x4B, 0xFD, 0x4A, 0x95, 0x2A, 0x9C, 0xE2, 0x49, 0x18, 0x42, 0x8A, 0x66,
  0x8B, 0xD0, 0xF0, 0x6A, 0xAA, 0xA9, 0xA5, 0x55, 0x5A, 0x44, 0xF6, 0x90,
  0x21, 0x09, 0xF2, 0x10, 0xE0, 0xF0, 0x80, 0x11, 0x12, 0x22, 0x44, 0x48,
  0x74, 0xA3, 0x18, 0xC6, 0x31, 0x93, 0x80, 0x74, 0x92, 0x49, 0x24, 0xF1,
  0x11, 0x11, 0x24, 0x8F, 0xF1, 0x11, 0x61, 0x11, 0x1F, 0x08, 0x61, 0x8A,
  0x49, 0x28, 0x9F, 0x08, 0x20, 0xF4, 0x21, 0x0F, 0x04, 0x21, 0x0F, 0x80,
  0x74, 0x21, 0x0F, 0x46, 0x31, 0x8F, 0x80, 0xF1, 0x11, 0x22, 0x24, 0x44,
  0xF4, 0x63, 0x26, 0x4A, 0x31, 0x8F, 0x80, 0xF9, 0x99, 0x9F, 0x11, 0x1E,
  0x82, 0x83, 0x80, 0x1B, 0x21, 0x82, 0x0C, 0xF8, 0x01, 0xF0, 0x83, 0x06,
  0x26, 0x40, 0xF1, 0x11, 0x24, 0x44, 0x04, 0x3C, 0x42, 0x81, 0x9D, 0xA5,
  0xA5, 0xA5, 0xA9, 0x96, 0x80, 0x7C, 0x20, 0xC3, 0x0A, 0x49, 0xE4, 0xA1,
  0x86, 0x10, 0xF4, 0x63, 0x1F, 0x46, 0x31, 0x8F, 0x80, 0x7C, 0x21, 0x08,
  0x42, 0x10, 0x83, 0xC0, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x61, 0x8B, 0xC0,
  0xF8, 0x88, 0xF8, 0x88, 0x8F, 0xF8, 0x88, 0x8F, 0x88, 0x88, 0x7E, 0x08,
  0x20, 0x82, 0x78, 0x61, 0x85, 0xF0, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61,
  0x86, 0x10, 0xEA, 0xAA, 0xB0, 0x24, 0x92, 0x49, 0x24, 0xF0, 0x8C, 0xA9,
  0x4C, 0x52, 0x92, 0x8C, 0x40, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x81, 0x81,
  0xC3, 0xC3, 0xA5, 0xA5, 0xA5, 0x99, 0x99, 0x91, 0x86, 0x1C, 0x69, 0xA6,
  0x59, 0x63, 0x86, 0x10, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0,
  0xF4, 0x63, 0x18, 0xFA, 0x10, 0x84, 0x00, 0x7A, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x85, 0xA1, 0x02, 0xF4, 0x63, 0x19, 0x72, 0x52, 0x8C, 0x40, 0xF8,
  0x88, 0x43, 0x11, 0x1F, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x86, 0x18, 0x52, 0x49, 0x25,
  0x0C, 0x30, 0x80, 0x88, 0x62, 0x18, 0xC5, 0x32, 0x54, 0x94, 0xA5, 0x28,
  0xCC, 0x21, 0x08, 0x40, 0x8A, 0x54, 0x62, 0x11, 0x4A, 0x8C, 0x40, 0x8C,
  0x52, 0xA5, 0x10, 0x84, 0x21, 0x00, 0x78, 0x44, 0x22, 0x10, 0x88, 0x47,
  0xC0, 0xF2, 0x49, 0x24, 0x92, 0x70, 0x84, 0x44, 0x22, 0x21, 0x11, 0xE4,
  0x92, 0x49, 0x24, 0xF0, 0x10, 0xC4, 0x92, 0x84, 0xFC, 0xA4, 0xE1, 0x11,
  0xF9, 0x9F, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8C, 0x7C, 0x78, 0x88, 0x88,
  0x8F, 0x08, 0x42, 0xD9, 0xC6, 0x31, 0x8C, 0x7E, 0x69, 0x99, 0xE8, 0x8F,
  0x34, 0x4E, 0x44, 0x44, 0x44, 0x40, 0x64, 0xE3, 0x18, 0xC6, 0x3F, 0x08,
  0x7C, 0x88, 0x8E, 0x99, 0x99, 0x99, 0x90, 0x9F, 0xC0, 0x41, 0x55, 0x55,
  0xC0, 0x88, 0x89, 0xAA, 0xCA, 0xA9, 0x90, 0xFF, 0xE0, 0x66, 0x99, 0x91,
  0x91, 0x91, 0x91, 0x91, 0x91, 0x69, 0x99, 0x99, 0x99, 0x64, 0xA3, 0x18,
  0xC6, 0x3E, 0x74, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x20, 0x64, 0xE3, 0x18,
  0xC6, 0x3F, 0x08, 0x42, 0xF2, 0x49, 0x20, 0x72, 0x46, 0x4F, 0x5D, 0x24,
  0x92, 0x60, 0x99, 0x99, 0x99, 0xF0, 0x8C, 0x94, 0xA5, 0x30, 0x80, 0x91,
  0x99, 0x5A, 0x5A, 0x66, 0x24, 0x24, 0xCA, 0x88, 0x45, 0x2A, 0x20, 0x8C,
  0x54, 0xA5, 0x10, 0x84, 0x26, 0x00, 0x71, 0x22, 0x44, 0xF0, 0x69, 0x24,
  0xA2, 0x49, 0x30, 0xFF, 0xFC, 0x89, 0x24, 0x9A, 0x49, 0x60, 0xC5, 0xC0,
};

const GFXglyph NotoSans_Condensed_Thin14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 2, 4, 4, 1, -10 },
  { 4, 7, 10, 7, 0, -10 },
  { 13, 5, 12, 6, 1, -11 },
  { 21, 7, 10, 9, 1, -10 },
  { 30, 6, 10, 7, 1, -10 },
  { 38, 1, 4, 2, 1, -10 },
  { 39, 2, 12, 4, 1, -10 },
  { 42, 2, 12, 4, 1, -10 },
  { 45, 4, 5, 6, 1, -11 },
  { 48, 5, 6, 6, 1, -8 },
  { 52, 1, 3, 2, 1, -1 },
  { 53, 4, 1, 4, 0, -4 },
  { 54, 1, 1, 3, 1, -1 },
  { 55, 4, 10, 5, 0, -10 },
  { 60, 5, 10, 6, 1, -10 },
  { 67, 3, 10, 6, 1, -10 },
  { 71, 4, 10, 6, 1, -10 },
  { 76, 4, 10, 6, 1, -10 },
  { 81, 6, 10, 6, 0, -10 },
  { 89, 5, 10, 6, 1, -10 },
  { 96, 5, 10, 6, 1, -10 },
  { 103, 4, 10, 6, 1, -10 },
  { 108, 5, 10, 6, 1, -10 },
  { 115, 4, 10, 6, 1, -10 },
  { 120, 1, 7, 3, 1, -7 },
  { 121, 1, 9, 3, 1, -7 },
  { 123, 5, 6, 6, 1, -8 },
  { 127, 5, 4, 6, 1, -7 },
  { 130, 5, 6, 6, 1, -8 },
  { 134, 4, 10, 4, 0, -10 },
  { 139, 8, 11, 10, 1, -10 },
  { 150, 6, 10, 6, 0, -10 },
  { 158, 5, 10, 7, 1, -10 },
  { 165, 5, 10, 7, 1, -10 },
  { 172, 6, 10, 8, 1, -10 },
  { 180, 4, 10, 6, 1, -10 },
  { 185, 4, 10, 6, 1, -10 },
  { 190, 6, 10, 8, 1, -10 },
  { 198, 6, 10, 8, 1, -10 },
  { 206, 2, 10, 3, 1, -10 },
  { 209, 3, 12, 3, -1, -10 },
  { 214, 5, 10, 6, 1, -10 },
  { 221, 4, 10, 5, 1, -10 },
  { 226, 8, 10, 10, 1, -10 },
  { 236, 6, 10, 8, 1, -10 },
  { 244, 6, 10, 8, 1, -10 },
  { 252, 5, 10, 6, 1, -10 },
  { 259, 6, 12, 8, 1, -10 },
  { 268, 5, 10, 6, 1, -10 },
  { 275, 4, 10, 6, 1, -10 },
  { 280, 5, 10, 5, 0, -10 },
  { 287, 6, 10, 8, 1, -10 },
  { 295, 6, 10, 6, 0, -10 },
  { 303, 10, 10, 10, 0, -10 },
  { 316, 5, 10, 5, 0, -10 },
  { 323, 5, 10, 5, 0, -10 },
  { 330, 5, 10, 6, 0, -10 },
  { 337, 3, 12, 4, 1, -10 },
  { 342, 4, 10, 5, 0, -10 },
  { 347, 3, 12, 4, 0, -10 },
  { 352, 6, 5, 6, 0, -10 },
  { 356, 6, 1, 5, 0, 1 },
  { 357, 2, 3, 3, 1, -11 },
  { 358, 4, 8, 6, 1, -8 },
  { 362, 5, 11, 7, 1, -11 },
  { 369, 4, 8, 5, 1, -8 },
  { 373, 5, 11, 7, 1, -11 },
  { 380, 4, 8, 6, 1, -8 },
  { 384, 4, 11, 3, 0, -11 },
  { 390, 5, 11, 7, 1, -8 },
  { 397, 4, 11, 6, 1, -11 },
  { 403, 1, 10, 3, 1, -10 },
  { 405, 2, 13, 3, 0, -10 },
  { 409, 4, 11, 5, 1, -11 },
  { 415, 1, 11, 3, 1, -11 },
  { 417, 8, 8, 10, 1, -8 },
  { 425, 4, 8, 6, 1, -8 },
  { 429, 5, 8, 6, 1, -8 },
  { 434, 5, 11, 7, 1, -8 },
  { 441, 5, 11, 7, 1, -8 },
  { 448, 3, 7, 4, 1, -7 },
  { 451, 3, 8, 5, 1, -8 },
  { 454, 3, 9, 3, 0, -9 },
  { 458, 4, 7, 6, 1, -7 },
  { 462, 5, 7, 5, 0, -7 },
  { 467, 8, 7, 8, 0, -7 },
  { 474, 5, 7, 5, 0, -7 },
  { 479, 5, 10, 5, 0, -7 },
  { 486, 4, 7, 4, 0, -7 },
  { 490, 3, 12, 5, 1, -10 },
  { 495, 1, 14, 6, 2, -11 },
  { 497, 3, 12, 5, 1, -10 },
  { 502, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_Condensed_Thin14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_THIN14PT7B_H_
