#ifndef _NOTOSANS_CONDENSED_THIN13PT7B_H_
#define _NOTOSANS_CONDENSED_THIN13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFC, 0x28, 0xA7, 0xCA, 0x4B, 0xF4, 0x94, 0x50, 0x4F,
  0xCC, 0xC2, 0x55, 0x5E, 0x40, 0xE9, 0x52, 0xC5, 0xAA, 0xAD, 0x4C, 0xA5,
  0x4E, 0xE4, 0xA8, 0x8C, 0x56, 0x72, 0xE8, 0xE0, 0x6A, 0xAA, 0xA4, 0xC8,
  0x92, 0x49, 0x2B, 0x00, 0x4F, 0x4A, 0x21, 0x09, 0xF2, 0x10, 0x68, 0xE0,
  0x80, 0x11, 0x22, 0x24, 0x48, 0x80, 0xF9, 0x99, 0x99, 0x99, 0xE0, 0x75,
  0x55, 0x40, 0xF1, 0x11, 0x22, 0x48, 0xF0, 0xF1, 0x11, 0x61, 0x11, 0xF0,
  0x10, 0x42, 0x8A, 0x4A, 0x2F, 0xC2, 0x08, 0xF8, 0x8E, 0x11, 0x11, 0xE0,
  0x78, 0x8E, 0x99, 0x99, 0xF0, 0xF1, 0x12, 0x22, 0x44, 0x80, 0xF9, 0x9A,
  0x69, 0x99, 0xF0, 0xF9, 0x99, 0x97, 0x11, 0xE0, 0x82, 0x40, 0x06, 0x80,
  0x19, 0x30, 0x60, 0x80, 0xF8, 0x3E, 0xE0, 0x82, 0x6C, 0x00, 0xF1, 0x12,
  0x24, 0x40, 0x40, 0x7D, 0x06, 0x6D, 0x5A, 0xB9, 0x6A, 0xCA, 0x80, 0xF8,
  0x20, 0xC3, 0x14, 0x49, 0xE8, 0xA1, 0x84, 0xF4, 0x63, 0x2F, 0x46, 0x31,
  0xF0, 0x7C, 0x21, 0x08, 0x42, 0x10, 0x78, 0xF4, 0x63, 0x18, 0xC6, 0x31,
  0xF0, 0xF8, 0x88, 0xF8, 0x88, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0x80, 0x7E,
  0x08, 0x20, 0x9E, 0x18, 0x61, 0x7C, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88,
  0xEA, 0xAA, 0xC0, 0x24, 0x92, 0x49, 0x27, 0x80, 0x9C, 0xA9, 0x8C, 0x52,
  0x52, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x83, 0x07, 0x1E, 0x3A, 0x75,
  0x6A, 0xC9, 0x92, 0x8C, 0x73, 0x5A, 0xCE, 0x71, 0x88, 0xFA, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x78, 0xF9, 0x99, 0xF8, 0x88, 0x80, 0xFA, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x68, 0x40, 0x80, 0xF4, 0x63, 0x2E, 0x52, 0x52, 0x88,
  0xF8, 0x88, 0x61, 0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x20, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x78, 0x86, 0x28, 0x92, 0x49, 0x43, 0x08, 0x20,
  0x88, 0xC4, 0x62, 0x2A, 0x95, 0x52, 0xA9, 0x4C, 0x44, 0x22, 0x00, 0x8A,
  0x94, 0x42, 0x29, 0x51, 0x88, 0x8C, 0x94, 0xA2, 0x10, 0x84, 0x20, 0x78,
  0x84, 0x42, 0x11, 0x08, 0xF8, 0xF2, 0x49, 0x24, 0x93, 0x80, 0x84, 0x44,
  0x22, 0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x31, 0x92, 0x98, 0x80,
  0xF8, 0xB0, 0xE4, 0xBB, 0x78, 0x88, 0x8F, 0x99, 0x99, 0x9F, 0x72, 0x49,
  0x38, 0x11, 0x1F, 0x99, 0x99, 0x9F, 0xE9, 0x9E, 0x88, 0xF0, 0x69, 0x74,
  0x92, 0x48, 0xF9, 0x99, 0x99, 0xF1, 0x1F, 0x88, 0x8F, 0x99, 0x99, 0x99,
  0xBF, 0x80, 0x45, 0x55, 0x57, 0x88, 0x89, 0xAC, 0xCA, 0xA9, 0xFF, 0xC0,
  0xEF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0x80, 0xF9, 0x99, 0x99, 0x90, 0xF9,
  0x99, 0x99, 0xF0, 0xF9, 0x99, 0x99, 0xF8, 0x88, 0xF9, 0x99, 0x99, 0xF1,
  0x11, 0xF2, 0x49, 0x20, 0x78, 0x86, 0x11, 0xF0, 0x4B, 0xA4, 0x92, 0x60,
  0x99, 0x99, 0x99, 0xF0, 0x99, 0x95, 0x62, 0x40, 0x93, 0x26, 0x4B, 0x56,
  0xCC, 0x91, 0x00, 0x95, 0x62, 0x65, 0x90, 0x99, 0x55, 0x56, 0x22, 0x4C,
  0x71, 0x22, 0x44, 0xF0, 0x69, 0x25, 0x12, 0x49, 0x80, 0xFF, 0xF8, 0xC9,
  0x24, 0x52, 0x4A, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_Thin13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 3, 4, 1, -9 },
  { 4, 6, 9, 6, 0, -9 },
  { 11, 4, 11, 6, 1, -10 },
  { 17, 7, 9, 8, 1, -9 },
  { 25, 5, 9, 6, 1, -9 },
  { 31, 1, 3, 2, 1, -9 },
  { 32, 2, 11, 3, 1, -9 },
  { 35, 3, 11, 3, 0, -9 },
  { 40, 4, 4, 5, 1, -10 },
  { 42, 5, 6, 6, 0, -8 },
  { 46, 2, 3, 2, 0, -1 },
  { 47, 3, 1, 4, 0, -4 },
  { 48, 1, 1, 3, 1, -1 },
  { 49, 4, 9, 4, 0, -9 },
  { 54, 4, 9, 6, 1, -9 },
  { 59, 2, 9, 6, 1, -9 },
  { 62, 4, 9, 6, 1, -9 },
  { 67, 4, 9, 6, 1, -9 },
  { 72, 6, 9, 6, 0, -9 },
  { 79, 4, 9, 6, 1, -9 },
  { 84, 4, 9, 6, 1, -9 },
  { 89, 4, 9, 6, 1, -9 },
  { 94, 4, 9, 6, 1, -9 },
  { 99, 4, 9, 6, 1, -9 },
  { 104, 1, 7, 3, 1, -7 },
  { 105, 2, 9, 2, 0, -7 },
  { 108, 5, 5, 6, 0, -7 },
  { 112, 5, 3, 6, 0, -6 },
  { 114, 5, 5, 6, 0, -7 },
  { 118, 4, 9, 4, 0, -9 },
  { 123, 7, 10, 9, 1, -9 },
  { 132, 6, 9, 6, 0, -9 },
  { 139, 5, 9, 6, 1, -9 },
  { 145, 5, 9, 6, 1, -9 },
  { 151, 5, 9, 7, 1, -9 },
  { 157, 4, 9, 6, 1, -9 },
  { 162, 4, 9, 5, 1, -9 },
  { 167, 6, 9, 8, 1, -9 },
  { 174, 5, 9, 7, 1, -9 },
  { 180, 2, 9, 3, 1, -9 },
  { 183, 3, 11, 3, -1, -9 },
  { 188, 5, 9, 6, 1, -9 },
  { 194, 4, 9, 5, 1, -9 },
  { 199, 7, 9, 9, 1, -9 },
  { 207, 5, 9, 7, 1, -9 },
  { 213, 6, 9, 8, 1, -9 },
  { 220, 4, 9, 6, 1, -9 },
  { 225, 6, 11, 8, 1, -9 },
  { 234, 5, 9, 6, 1, -9 },
  { 240, 4, 9, 6, 1, -9 },
  { 245, 5, 9, 5, 0, -9 },
  { 251, 5, 9, 7, 1, -9 },
  { 257, 6, 9, 6, 0, -9 },
  { 264, 9, 9, 9, 0, -9 },
  { 275, 5, 9, 5, 0, -9 },
  { 281, 5, 9, 5, 0, -9 },
  { 287, 5, 9, 5, 0, -9 },
  { 293, 3, 11, 4, 1, -9 },
  { 298, 4, 9, 4, 0, -9 },
  { 303, 3, 11, 4, 0, -9 },
  { 308, 5, 5, 6, 0, -9 },
  { 312, 5, 1, 5, 0, 1 },
  { 313, 2, 2, 3, 1, -10 },
  { 314, 3, 7, 5, 1, -7 },
  { 317, 4, 10, 6, 1, -10 },
  { 322, 3, 7, 5, 1, -7 },
  { 325, 4, 10, 6, 1, -10 },
  { 330, 4, 7, 6, 1, -7 },
  { 334, 3, 10, 3, 0, -10 },
  { 338, 4, 10, 6, 1, -7 },
  { 343, 4, 10, 6, 1, -10 },
  { 348, 1, 9, 2, 1, -9 },
  { 350, 2, 12, 2, 0, -9 },
  { 353, 4, 10, 5, 1, -10 },
  { 358, 1, 10, 2, 1, -10 },
  { 360, 7, 7, 9, 1, -7 },
  { 367, 4, 7, 6, 1, -7 },
  { 371, 4, 7, 6, 1, -7 },
  { 375, 4, 10, 6, 1, -7 },
  { 380, 4, 10, 6, 1, -7 },
  { 385, 3, 7, 4, 1, -7 },
  { 388, 4, 7, 5, 0, -7 },
  { 392, 3, 9, 3, 0, -9 },
  { 396, 4, 7, 6, 1, -7 },
  { 400, 4, 7, 4, 0, -7 },
  { 404, 7, 7, 7, 0, -7 },
  { 411, 4, 7, 5, 0, -7 },
  { 415, 4, 10, 5, 0, -7 },
  { 420, 4, 7, 4, 0, -7 },
  { 424, 3, 11, 4, 1, -9 },
  { 429, 1, 13, 6, 2, -10 },
  { 431, 3, 11, 4, 1, -9 },
  { 436, 5, 1, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_Thin13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_THIN13PT7B_H_
