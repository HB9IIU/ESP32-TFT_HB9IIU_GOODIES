#ifndef _NOTOSANS_CONDENSED_THIN11PT7B_H_
#define _NOTOSANS_CONDENSED_THIN11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x29, 0x9E, 0xA5, 0x7D, 0x4A, 0x7A, 0xA4, 0x33, 0x3D,
  0x20, 0xD6, 0xB5, 0xFD, 0xAD, 0x6B, 0x72, 0x94, 0x46, 0x4E, 0x2F, 0xE0,
  0xFF, 0xC0, 0x95, 0x55, 0x60, 0x7A, 0x80, 0x21, 0x3E, 0x42, 0x00, 0xC0,
  0xE0, 0x80, 0x24, 0x94, 0xA4, 0xF6, 0xDB, 0x6F, 0x75, 0x55, 0x71, 0x11,
  0x12, 0x4F, 0xF1, 0x17, 0x11, 0x1F, 0x10, 0x8C, 0xA5, 0x7C, 0x42, 0xF2,
  0x62, 0x4F, 0x72, 0x7B, 0x6F, 0xE4, 0x94, 0x94, 0x79, 0x96, 0x59, 0x97,
  0x79, 0x99, 0x71, 0x17, 0x84, 0x86, 0x3A, 0x30, 0x70, 0xFF, 0xC0, 0xE0,
  0x87, 0xC0, 0xE4, 0x94, 0x82, 0x7A, 0x1B, 0x75, 0xD7, 0x5A, 0xA0, 0x78,
  0x23, 0x14, 0xA7, 0x4A, 0x31, 0xE9, 0x9E, 0x99, 0x9E, 0x78, 0x88, 0x88,
  0x87, 0xE9, 0x99, 0x99, 0x9E, 0xF2, 0x79, 0x27, 0xF2, 0x4F, 0x24, 0x7C,
  0x21, 0x09, 0xC6, 0x2F, 0x99, 0x9F, 0x99, 0x99, 0xD5, 0x57, 0x55, 0x55,
  0x70, 0x9A, 0xC8, 0xCA, 0xA9, 0x92, 0x49, 0x27, 0x86, 0x18, 0xF3, 0xCE,
  0xDB, 0x69, 0x99, 0x9D, 0xBB, 0x99, 0x74, 0x63, 0x18, 0xC6, 0x3E, 0xF6,
  0xDD, 0x24, 0x74, 0x63, 0x18, 0xC6, 0x3A, 0x20, 0x80, 0xE9, 0x99, 0xEA,
  0xA9, 0x78, 0x84, 0x31, 0x1F, 0xF2, 0x22, 0x22, 0x22, 0x99, 0x99, 0x99,
  0x9F, 0x8C, 0x64, 0xA5, 0x29, 0x84, 0x91, 0x91, 0x9A, 0x5A, 0x6A, 0x64,
  0x24, 0x44, 0x95, 0x62, 0x26, 0x99, 0x99, 0x56, 0x42, 0x22, 0x71, 0x22,
  0x44, 0x4F, 0xEA, 0xAA, 0xB0, 0x91, 0x24, 0x49, 0xD5, 0x55, 0x70, 0x22,
  0x95, 0x10, 0xF0, 0xC0, 0x71, 0x3D, 0x9F, 0x88, 0xE9, 0x99, 0x9E, 0xF2,
  0x49, 0xC0, 0x27, 0xDB, 0x6F, 0xF7, 0xC9, 0xC0, 0x6B, 0x24, 0x92, 0xF6,
  0xDB, 0xC9, 0xC0, 0x93, 0xDB, 0x6D, 0xBF, 0xBF, 0xE0, 0x92, 0xE9, 0xAD,
  0xFF, 0xFE, 0x9A, 0x69, 0xA6, 0x90, 0xF6, 0xDB, 0x40, 0xF6, 0xDB, 0xC0,
  0xE9, 0x99, 0x9E, 0x88, 0x80, 0xF6, 0xDB, 0xC9, 0x20, 0xEA, 0xA0, 0x78,
  0x42, 0x1F, 0xBA, 0xA4, 0xB6, 0xDB, 0xC0, 0x99, 0xA6, 0x44, 0x96, 0x5B,
  0x55, 0x49, 0x20, 0x96, 0x44, 0x69, 0x99, 0xA6, 0x64, 0x44, 0x80, 0x64,
  0xA5, 0xC0, 0x29, 0x2C, 0x92, 0x44, 0xFF, 0xE0, 0xC8, 0x92, 0x49, 0x58,
  0xF8,
};

const GFXglyph NotoSans_Condensed_Thin11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 2, 3, 3, 1, -8 },
  { 3, 5, 8, 5, 0, -8 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 5, 8, 7, 1, -8 },
  { 18, 5, 8, 5, 0, -8 },
  { 23, 1, 3, 2, 0, -8 },
  { 24, 1, 10, 3, 1, -8 },
  { 26, 2, 10, 3, 0, -8 },
  { 29, 3, 3, 4, 1, -8 },
  { 31, 5, 5, 5, 0, -6 },
  { 35, 1, 2, 2, 0, -1 },
  { 36, 3, 1, 3, 0, -3 },
  { 37, 1, 1, 2, 1, -1 },
  { 38, 3, 8, 4, 0, -8 },
  { 41, 3, 8, 5, 1, -8 },
  { 44, 2, 8, 5, 1, -8 },
  { 46, 4, 8, 5, 0, -8 },
  { 50, 4, 8, 5, 0, -8 },
  { 54, 5, 8, 5, 0, -8 },
  { 59, 3, 8, 5, 1, -8 },
  { 62, 3, 8, 5, 1, -8 },
  { 65, 3, 8, 5, 1, -8 },
  { 68, 4, 8, 5, 0, -8 },
  { 72, 4, 8, 5, 0, -8 },
  { 76, 1, 6, 2, 1, -6 },
  { 77, 1, 7, 2, 0, -6 },
  { 78, 5, 4, 5, 0, -6 },
  { 81, 5, 2, 5, 0, -5 },
  { 83, 5, 4, 5, 0, -6 },
  { 86, 3, 8, 3, 0, -8 },
  { 89, 6, 9, 8, 1, -8 },
  { 96, 5, 8, 5, 0, -8 },
  { 101, 4, 8, 5, 1, -8 },
  { 105, 4, 8, 5, 1, -8 },
  { 109, 4, 8, 6, 1, -8 },
  { 113, 3, 8, 5, 1, -8 },
  { 116, 3, 8, 4, 1, -8 },
  { 119, 5, 8, 6, 1, -8 },
  { 124, 4, 8, 6, 1, -8 },
  { 128, 2, 8, 3, 0, -8 },
  { 130, 2, 10, 2, -1, -8 },
  { 133, 4, 8, 5, 1, -8 },
  { 137, 3, 8, 4, 1, -8 },
  { 140, 6, 8, 8, 1, -8 },
  { 146, 4, 8, 6, 1, -8 },
  { 150, 5, 8, 6, 1, -8 },
  { 155, 3, 8, 5, 1, -8 },
  { 158, 5, 10, 6, 1, -8 },
  { 165, 4, 8, 5, 1, -8 },
  { 169, 4, 8, 5, 0, -8 },
  { 173, 4, 8, 4, 0, -8 },
  { 177, 4, 8, 6, 1, -8 },
  { 181, 5, 8, 5, 0, -8 },
  { 186, 8, 8, 8, 0, -8 },
  { 194, 4, 8, 4, 0, -8 },
  { 198, 4, 8, 4, 0, -8 },
  { 202, 4, 8, 4, 0, -8 },
  { 206, 2, 10, 3, 1, -8 },
  { 209, 3, 8, 4, 0, -8 },
  { 212, 2, 10, 3, 0, -8 },
  { 215, 5, 4, 5, 0, -8 },
  { 218, 4, 1, 4, 0, 1 },
  { 219, 2, 1, 3, 0, -8 },
  { 220, 4, 6, 5, 0, -6 },
  { 223, 4, 8, 5, 1, -8 },
  { 227, 3, 6, 4, 1, -6 },
  { 230, 3, 8, 5, 1, -8 },
  { 233, 3, 6, 5, 1, -6 },
  { 236, 3, 8, 3, 0, -8 },
  { 239, 3, 9, 5, 1, -6 },
  { 243, 3, 8, 5, 1, -8 },
  { 246, 1, 8, 2, 1, -8 },
  { 247, 1, 11, 2, 0, -8 },
  { 249, 3, 8, 4, 1, -8 },
  { 252, 1, 8, 2, 0, -8 },
  { 253, 6, 6, 7, 1, -6 },
  { 258, 3, 6, 5, 1, -6 },
  { 261, 3, 6, 5, 1, -6 },
  { 264, 4, 9, 5, 1, -6 },
  { 269, 3, 9, 5, 1, -6 },
  { 273, 2, 6, 3, 1, -6 },
  { 275, 4, 6, 4, 0, -6 },
  { 278, 2, 7, 3, 0, -7 },
  { 280, 3, 6, 5, 1, -6 },
  { 283, 4, 6, 4, 0, -6 },
  { 286, 6, 6, 6, 0, -6 },
  { 291, 4, 6, 4, 0, -6 },
  { 294, 4, 9, 4, 0, -6 },
  { 299, 3, 6, 3, 0, -6 },
  { 302, 3, 10, 4, 0, -8 },
  { 306, 1, 11, 5, 2, -8 },
  { 308, 3, 10, 4, 0, -8 },
  { 312, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_Thin11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_THIN11PT7B_H_
