#ifndef _NOTOSANS_CONDENSED_THIN52PT7B_H_
#define _NOTOSANS_CONDENSED_THIN52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin52pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x20,
  0x00, 0x03, 0x7C, 0xC0, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x05, 0x02, 0x81,
  0x40, 0xA0, 0x50, 0x28, 0x14, 0x08, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40,
  0x01, 0x00, 0x80, 0x06, 0x01, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x20, 0x10, 0x00, 0x40, 0x20, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x06,
  0x01, 0x01, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x40,
  0x20, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02, 0x01, 0x00, 0x0C, 0x02,
  0x00, 0x18, 0x0C, 0x00, 0x20, 0x18, 0x00, 0x40, 0x30, 0x00, 0x80, 0x40,
  0x01, 0x00, 0x80, 0xFF, 0xFF, 0xFC, 0x04, 0x02, 0x00, 0x18, 0x04, 0x00,
  0x30, 0x18, 0x00, 0x40, 0x30, 0x00, 0x80, 0x40, 0x01, 0x00, 0x80, 0x02,
  0x01, 0x00, 0x04, 0x02, 0x00, 0x18, 0x04, 0x00, 0x30, 0x18, 0x00, 0x40,
  0x30, 0x00, 0x80, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x31, 0x87, 0x0C, 0x30, 0x03, 0x06, 0x00,
  0x40, 0xC0, 0x18, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01,
  0x81, 0x80, 0x30, 0x30, 0x02, 0x06, 0x00, 0x60, 0xC0, 0x06, 0x18, 0x00,
  0x63, 0x00, 0x07, 0x60, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00,
  0x06, 0x70, 0x00, 0xC3, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00, 0x60, 0x20,
  0x0C, 0x04, 0x01, 0x80, 0x80, 0x30, 0x18, 0x06, 0x02, 0x00, 0xC0, 0x40,
  0x18, 0x08, 0x03, 0x03, 0x00, 0x60, 0xCC, 0x0C, 0x31, 0xF9, 0xBC, 0x03,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x04, 0x03, 0xF0, 0x00, 0x80, 0x61, 0x80, 0x08, 0x04, 0x0C,
  0x01, 0x80, 0x40, 0x40, 0x10, 0x0C, 0x04, 0x03, 0x00, 0x80, 0x40, 0x20,
  0x08, 0x06, 0x02, 0x00, 0x80, 0x60, 0x60, 0x08, 0x06, 0x04, 0x00, 0x80,
  0x20, 0xC0, 0x08, 0x02, 0x08, 0x00, 0x80, 0x20, 0x80, 0x08, 0x02, 0x18,
  0x00, 0x80, 0x61, 0x00, 0x08, 0x06, 0x30, 0xF0, 0x80, 0x62, 0x19, 0x88,
  0x04, 0x23, 0x0C, 0xC0, 0x46, 0x20, 0x44, 0x04, 0x46, 0x06, 0x40, 0xCC,
  0x40, 0x26, 0x18, 0x84, 0x02, 0x3F, 0x08, 0x40, 0x20, 0xC1, 0x8C, 0x02,
  0x00, 0x10, 0xC0, 0x30, 0x01, 0x0C, 0x03, 0x00, 0x20, 0xC0, 0x30, 0x02,
  0x0C, 0x03, 0x00, 0x60, 0xC0, 0x30, 0x04, 0x0C, 0x03, 0x00, 0x40, 0x40,
  0x20, 0x0C, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x01,
  0x00, 0x60, 0x60, 0x10, 0x02, 0x04, 0x03, 0x00, 0x30, 0xC0, 0x20, 0x01,
  0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x60, 0xC0, 0x03, 0x01, 0x00,
  0x08, 0x04, 0x00, 0x20, 0x18, 0x01, 0x80, 0x20, 0x06, 0x00, 0x80, 0x18,
  0x02, 0x00, 0x60, 0x18, 0x00, 0x80, 0x60, 0x02, 0x01, 0x00, 0x0C, 0x04,
  0x00, 0x10, 0x30, 0x00, 0x61, 0x80, 0x00, 0x8C, 0x00, 0x03, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xB0, 0x00, 0x08, 0x60, 0x00, 0x40,
  0x80, 0x02, 0x03, 0x00, 0x98, 0x06, 0x02, 0x40, 0x08, 0x09, 0x00, 0x30,
  0x2C, 0x00, 0x61, 0xB0, 0x00, 0x84, 0x80, 0x03, 0x12, 0x00, 0x06, 0x8C,
  0x00, 0x0A, 0x30, 0x00, 0x10, 0x40, 0x00, 0xE1, 0x00, 0x02, 0x86, 0x00,
  0x11, 0x0C, 0x01, 0x86, 0x18, 0x0C, 0x08, 0x3F, 0xE0, 0x10, 0x08, 0x00,
  0x00, 0x55, 0x55, 0x55, 0x40, 0x00, 0xC0, 0x40, 0x30, 0x18, 0x04, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x20, 0x08, 0x03,
  0x00, 0x40, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04,
  0x01, 0xC0, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06,
  0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01, 0x80, 0xC0, 0x60,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x18, 0x08,
  0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x18,
  0x08, 0x0C, 0x0C, 0x0C, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x18, 0x20, 0xCE, 0x4E, 0x03, 0xE0, 0x03, 0x80, 0x05, 0x00,
  0x11, 0x00, 0x41, 0x01, 0x83, 0x06, 0x02, 0x08, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x7F, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x13, 0x33, 0x22, 0x66, 0x44,
  0xC8, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0xC0, 0x01, 0xFE, 0x00, 0xC0, 0xC0, 0x60, 0x18,
  0x30, 0x02, 0x08, 0x00, 0xC6, 0x00, 0x11, 0x00, 0x04, 0x40, 0x01, 0x90,
  0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x01, 0x90, 0x00, 0x64, 0x00,
  0x11, 0x80, 0x04, 0x20, 0x03, 0x0C, 0x00, 0x83, 0x00, 0x60, 0x60, 0x10,
  0x0C, 0x18, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x70, 0x6C, 0x33, 0x18, 0xCC,
  0x3E, 0x0D, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0xFE, 0x03, 0x80, 0xE1, 0x80,
  0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0xFE, 0x03, 0x00,
  0xE3, 0x80, 0x0C, 0x40, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x7E,
  0x00, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x1A, 0x00, 0x0C, 0xE0, 0x0E, 0x0F, 0xFE, 0x00, 0x18, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x40, 0x00, 0x0D, 0x00,
  0x00, 0x24, 0x00, 0x01, 0x90, 0x00, 0x0C, 0x40, 0x00, 0x21, 0x00, 0x01,
  0x84, 0x00, 0x04, 0x10, 0x00, 0x30, 0x40, 0x00, 0x81, 0x00, 0x06, 0x04,
  0x00, 0x10, 0x10, 0x00, 0x80, 0x40, 0x06, 0x01, 0x00, 0x10, 0x04, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x01, 0x00, 0x40, 0x04, 0x03, 0x00,
  0x10, 0x18, 0x00, 0x40, 0x40, 0x01, 0x03, 0x00, 0x04, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x40, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x40, 0x00, 0x01, 0x00, 0x3F, 0xFF, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x7F, 0xC0, 0x78, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x88, 0x00, 0xE3, 0x80,
  0x60, 0x7F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x07, 0x80, 0x87, 0xFC, 0x26, 0x01, 0x89, 0x00, 0x32, 0x80,
  0x04, 0xE0, 0x01, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34,
  0x00, 0x09, 0x00, 0x02, 0x60, 0x01, 0x88, 0x00, 0x63, 0x00, 0x10, 0x40,
  0x08, 0x0C, 0x0E, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF,
  0x80, 0x30, 0x1C, 0x0C, 0x00, 0x83, 0x00, 0x18, 0x40, 0x01, 0x18, 0x00,
  0x33, 0x00, 0x06, 0x60, 0x00, 0x4C, 0x00, 0x19, 0x80, 0x03, 0x10, 0x00,
  0x63, 0x00, 0x08, 0x20, 0x03, 0x06, 0x00, 0xC0, 0x60, 0x30, 0x03, 0x1C,
  0x00, 0x3E, 0x00, 0x03, 0x80, 0x01, 0x8C, 0x00, 0x60, 0xC0, 0x30, 0x06,
  0x04, 0x00, 0x61, 0x80, 0x04, 0x60, 0x00, 0xC8, 0x00, 0x09, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00, 0x03,
  0x40, 0x00, 0x4C, 0x00, 0x18, 0x80, 0x02, 0x18, 0x00, 0xC1, 0xC0, 0x70,
  0x0F, 0xF8, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xC0, 0xC0,
  0x40, 0x08, 0x30, 0x03, 0x08, 0x00, 0x46, 0x00, 0x19, 0x00, 0x02, 0x40,
  0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x40, 0x00, 0xD0, 0x00, 0x36, 0x00, 0x0C,
  0x80, 0x05, 0x30, 0x03, 0x46, 0x01, 0x90, 0xFF, 0x84, 0x0F, 0x81, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40,
  0x00, 0x70, 0x00, 0x30, 0x0F, 0xF8, 0x00, 0x60, 0x00, 0xBF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x31, 0x8E, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x31, 0x8C, 0x42, 0x31, 0x88,
  0x46, 0x20, 0x00, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x02, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x07,
  0x01, 0xFF, 0x0C, 0x07, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x00, 0x60, 0x06, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x01, 0x80, 0x80, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x00, 0x62, 0x00, 0x0C, 0x01, 0x98,
  0x03, 0xFE, 0x02, 0x40, 0x18, 0x18, 0x09, 0x00, 0xC0, 0x60, 0x3C, 0x02,
  0x01, 0x80, 0xF0, 0x18, 0x06, 0x03, 0xC0, 0x40, 0x10, 0x06, 0x01, 0x00,
  0x40, 0x18, 0x0C, 0x01, 0x00, 0x60, 0x30, 0x04, 0x01, 0x80, 0xC0, 0x10,
  0x06, 0x03, 0x00, 0x40, 0x18, 0x0C, 0x01, 0x00, 0xE0, 0x30, 0x04, 0x03,
  0x80, 0xC0, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x28, 0x04, 0x03, 0x00, 0xB0,
  0x18, 0x1E, 0x06, 0xC0, 0x60, 0x48, 0x33, 0x00, 0xC6, 0x31, 0x84, 0x01,
  0xF0, 0x7C, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xE0, 0x02, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x50, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x08,
  0x80, 0x00, 0x11, 0x00, 0x00, 0x63, 0x00, 0x00, 0x86, 0x00, 0x01, 0x04,
  0x00, 0x02, 0x08, 0x00, 0x0C, 0x18, 0x00, 0x10, 0x10, 0x00, 0x20, 0x20,
  0x00, 0xC0, 0x40, 0x01, 0x00, 0xC0, 0x02, 0x00, 0x80, 0x04, 0x01, 0x00,
  0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x04, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x04, 0x00, 0x10, 0x08, 0x00, 0x20, 0x30, 0x00, 0x60, 0x40,
  0x00, 0xC0, 0x80, 0x00, 0x83, 0x00, 0x01, 0x06, 0x00, 0x03, 0x08, 0x00,
  0x06, 0x10, 0x00, 0x04, 0x60, 0x00, 0x08, 0x80, 0x00, 0x19, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x60, 0xFF, 0xF8, 0x18, 0x03, 0xC3,
  0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x09, 0x80, 0x01, 0xB0, 0x00, 0x16,
  0x00, 0x02, 0xC0, 0x00, 0x58, 0x00, 0x0B, 0x00, 0x01, 0x60, 0x00, 0x6C,
  0x00, 0x09, 0x80, 0x01, 0x30, 0x00, 0x66, 0x00, 0x18, 0xC0, 0x1C, 0x1F,
  0xFE, 0x03, 0x00, 0x38, 0x60, 0x01, 0x8C, 0x00, 0x09, 0x80, 0x01, 0xB0,
  0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x16, 0x00, 0x02, 0xC0,
  0x00, 0xD8, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x0F, 0x0F, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0xFE, 0x01, 0x80, 0x30, 0x70, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x02,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x30, 0x0F, 0xFE, 0x00, 0x06,
  0x00, 0xFF, 0xF0, 0x06, 0x01, 0xE0, 0x30, 0x01, 0xC1, 0x80, 0x03, 0x0C,
  0x00, 0x0C, 0x60, 0x00, 0x23, 0x00, 0x01, 0x98, 0x00, 0x04, 0xC0, 0x00,
  0x36, 0x00, 0x00, 0xB0, 0x00, 0x05, 0x80, 0x00, 0x2C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xB0, 0x00, 0x05,
  0x80, 0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x13, 0x00, 0x01, 0x98, 0x00,
  0x18, 0xC0, 0x00, 0x86, 0x00, 0x1C, 0x30, 0x01, 0x81, 0x80, 0xF8, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0xF8, 0x01, 0xC0, 0x0E, 0x03, 0x00, 0x02, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x40, 0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x20, 0x00,
  0x01, 0x20, 0x00, 0x01, 0x30, 0x00, 0x01, 0x18, 0x00, 0x01, 0x0C, 0x00,
  0x01, 0x06, 0x00, 0x01, 0x03, 0x00, 0x01, 0x01, 0xC0, 0x0F, 0x00, 0x7F,
  0xF8, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x10, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0xFF, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x40, 0x68, 0x67, 0xE0, 0xC0, 0x00, 0xD8, 0x00, 0x33, 0x00,
  0x0C, 0x60, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x02, 0x06, 0x00,
  0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x00, 0x60, 0x60, 0x0C, 0x18,
  0x01, 0x86, 0x00, 0x30, 0xC0, 0x06, 0x30, 0x00, 0xCE, 0x00, 0x19, 0x60,
  0x03, 0x6C, 0x00, 0x78, 0xC0, 0x0E, 0x08, 0x01, 0x81, 0x80, 0x30, 0x10,
  0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x03, 0x00, 0x60, 0x60, 0x04,
  0x0C, 0x00, 0xC1, 0x80, 0x08, 0x30, 0x01, 0x86, 0x00, 0x10, 0xC0, 0x03,
  0x18, 0x00, 0x33, 0x00, 0x02, 0x60, 0x00, 0x6C, 0x00, 0x06, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0F, 0xFF, 0xE0, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xD0, 0x00,
  0x00, 0x5D, 0x00, 0x00, 0x0D, 0xD8, 0x00, 0x00, 0xDC, 0x80, 0x00, 0x09,
  0xC8, 0x00, 0x01, 0x9C, 0xC0, 0x00, 0x11, 0xC4, 0x00, 0x01, 0x1C, 0x40,
  0x00, 0x31, 0xC6, 0x00, 0x02, 0x1C, 0x20, 0x00, 0x21, 0xC2, 0x00, 0x06,
  0x1C, 0x30, 0x00, 0x41, 0xC1, 0x00, 0x04, 0x1C, 0x10, 0x00, 0xC1, 0xC1,
  0x80, 0x08, 0x1C, 0x08, 0x00, 0x81, 0xC0, 0x80, 0x18, 0x1C, 0x0C, 0x01,
  0x01, 0xC0, 0x40, 0x10, 0x1C, 0x04, 0x03, 0x01, 0xC0, 0x60, 0x20, 0x1C,
  0x02, 0x02, 0x01, 0xC0, 0x20, 0x60, 0x1C, 0x03, 0x04, 0x01, 0xC0, 0x10,
  0x40, 0x1C, 0x01, 0x0C, 0x01, 0xC0, 0x18, 0x80, 0x1C, 0x00, 0x88, 0x01,
  0xC0, 0x09, 0x80, 0x1C, 0x00, 0xD0, 0x01, 0xC0, 0x05, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x10, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3D, 0x00, 0x01, 0xEC, 0x00, 0x0F, 0x20, 0x00,
  0x79, 0x80, 0x03, 0xC4, 0x00, 0x1E, 0x30, 0x00, 0xF0, 0x80, 0x07, 0x86,
  0x00, 0x3C, 0x10, 0x01, 0xE0, 0xC0, 0x0F, 0x02, 0x00, 0x78, 0x18, 0x03,
  0xC0, 0x40, 0x1E, 0x03, 0x00, 0xF0, 0x08, 0x07, 0x80, 0x60, 0x3C, 0x01,
  0x01, 0xE0, 0x0C, 0x0F, 0x00, 0x20, 0x78, 0x00, 0x83, 0xC0, 0x04, 0x1E,
  0x00, 0x10, 0xF0, 0x00, 0xC7, 0x80, 0x02, 0x3C, 0x00, 0x19, 0xE0, 0x00,
  0x4F, 0x00, 0x03, 0x78, 0x00, 0x0B, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0x00, 0xE0, 0x04, 0x00, 0x30, 0x08, 0x00, 0x18, 0x18,
  0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04, 0x20, 0x00, 0x06, 0x60,
  0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02, 0x60,
  0x00, 0x02, 0x20, 0x00, 0x06, 0x30, 0x00, 0x04, 0x10, 0x00, 0x0C, 0x18,
  0x00, 0x08, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x30, 0x03, 0x80, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xE0, 0x60, 0x1E, 0x30, 0x01, 0x98,
  0x00, 0x6C, 0x00, 0x16, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x02, 0xC0, 0x03, 0x60, 0x01, 0x30, 0x03, 0x98, 0x07, 0x0F,
  0xFE, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x03, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x08, 0x00, 0x18, 0x18, 0x00, 0x08, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x04,
  0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x02, 0x60, 0x00, 0x02, 0x20, 0x00, 0x06, 0x30, 0x00, 0x04,
  0x10, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x30,
  0x03, 0x00, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0xFF, 0xE0, 0x18,
  0x07, 0x83, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x11, 0x80, 0x03, 0x30,
  0x00, 0x26, 0x00, 0x04, 0xC0, 0x00, 0x98, 0x00, 0x13, 0x00, 0x02, 0x60,
  0x00, 0x4C, 0x00, 0x09, 0x80, 0x03, 0x30, 0x00, 0x46, 0x00, 0x08, 0xC0,
  0x02, 0x18, 0x00, 0xC3, 0x00, 0x60, 0x7F, 0xF0, 0x0C, 0x04, 0x01, 0x80,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x10, 0x18, 0x03, 0x03, 0x00,
  0x20, 0x60, 0x06, 0x0C, 0x00, 0x41, 0x80, 0x0C, 0x30, 0x00, 0x86, 0x00,
  0x18, 0xC0, 0x01, 0x18, 0x00, 0x33, 0x00, 0x02, 0x60, 0x00, 0x6C, 0x00,
  0x06, 0x00, 0x70, 0x01, 0xFF, 0xE0, 0xC0, 0x0C, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0xE0, 0x0E,
  0x1F, 0xFE, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0x60, 0x00, 0x09, 0x00, 0x00, 0x4C,
  0x00, 0x06, 0x60, 0x00, 0x21, 0x80, 0x03, 0x06, 0x00, 0x30, 0x1C, 0x07,
  0x00, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x34,
  0x00, 0x00, 0x90, 0x00, 0x02, 0x60, 0x00, 0x18, 0x80, 0x00, 0x62, 0x00,
  0x01, 0x08, 0x00, 0x04, 0x30, 0x00, 0x30, 0x40, 0x00, 0x81, 0x00, 0x02,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x20, 0x01, 0x00, 0x80, 0x04, 0x03,
  0x00, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80,
  0x60, 0x02, 0x01, 0x00, 0x08, 0x04, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0,
  0x01, 0x02, 0x00, 0x04, 0x08, 0x00, 0x18, 0x60, 0x00, 0x21, 0x00, 0x00,
  0x84, 0x00, 0x02, 0x10, 0x00, 0x0C, 0xC0, 0x00, 0x12, 0x00, 0x00, 0x48,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xA0, 0x00, 0x50, 0x00, 0x34, 0x00, 0x0A, 0x00, 0x04, 0x80, 0x01,
  0x40, 0x00, 0x98, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x06, 0x20,
  0x01, 0x10, 0x00, 0x84, 0x00, 0x22, 0x00, 0x10, 0xC0, 0x0C, 0x60, 0x06,
  0x18, 0x01, 0x8C, 0x00, 0xC1, 0x00, 0x20, 0x80, 0x10, 0x20, 0x04, 0x10,
  0x02, 0x04, 0x00, 0x82, 0x00, 0x40, 0xC0, 0x30, 0x60, 0x18, 0x08, 0x06,
  0x0C, 0x03, 0x01, 0x00, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x06,
  0x06, 0x02, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x08, 0x10, 0x0C, 0x08,
  0x01, 0x02, 0x00, 0x81, 0x00, 0x30, 0x40, 0x10, 0x60, 0x06, 0x18, 0x03,
  0x0C, 0x00, 0x43, 0x00, 0x61, 0x00, 0x08, 0x40, 0x04, 0x20, 0x01, 0x08,
  0x00, 0x84, 0x00, 0x31, 0x00, 0x11, 0x80, 0x02, 0x60, 0x03, 0x20, 0x00,
  0x48, 0x00, 0x24, 0x00, 0x09, 0x00, 0x04, 0x80, 0x01, 0xA0, 0x00, 0xB0,
  0x00, 0x3C, 0x00, 0x16, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x20, 0x00, 0x23, 0x00, 0x06, 0x10,
  0x00, 0x41, 0x80, 0x0C, 0x08, 0x00, 0x80, 0xC0, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x06, 0x02, 0x00, 0x20, 0x60, 0x03, 0x06, 0x00, 0x10, 0x40,
  0x01, 0x8C, 0x00, 0x08, 0x80, 0x00, 0xD8, 0x00, 0x05, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x05, 0x00, 0x00, 0xD0, 0x00, 0x09,
  0x80, 0x01, 0x88, 0x00, 0x10, 0xC0, 0x03, 0x04, 0x00, 0x20, 0x60, 0x06,
  0x02, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x10, 0x18, 0x01, 0x81,
  0x00, 0x08, 0x30, 0x00, 0xC2, 0x00, 0x04, 0x60, 0x00, 0x66, 0x00, 0x06,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0x28, 0x00, 0x0D, 0x00, 0x01, 0x30, 0x00,
  0x62, 0x00, 0x0C, 0x60, 0x01, 0x04, 0x00, 0x60, 0x80, 0x08, 0x18, 0x03,
  0x01, 0x00, 0x60, 0x30, 0x08, 0x02, 0x03, 0x00, 0x40, 0x40, 0x0C, 0x08,
  0x00, 0x83, 0x00, 0x18, 0x40, 0x01, 0x18, 0x00, 0x22, 0x00, 0x06, 0x40,
  0x00, 0x58, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x0F,
  0xFF, 0xF8, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xC0, 0xC0,
  0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0xFF, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x16, 0x00, 0x01, 0x90, 0x00, 0x08, 0xC0, 0x00, 0xC2, 0x00, 0x04, 0x18,
  0x00, 0x60, 0x40, 0x02, 0x03, 0x00, 0x30, 0x08, 0x01, 0x00, 0x60, 0x18,
  0x01, 0x00, 0x80, 0x0C, 0x0C, 0x00, 0x20, 0x40, 0x01, 0x86, 0x00, 0x04,
  0x20, 0x00, 0x33, 0x00, 0x00, 0xB0, 0x00, 0x06, 0xFF, 0xFF, 0xF0, 0xC0,
  0x60, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x07, 0xE0, 0x3E, 0xF0, 0xC0,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x01, 0xE0, 0x7F, 0xC3, 0x80, 0x9C,
  0x01, 0x60, 0x02, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x40, 0x0E, 0xC0, 0x14, 0xC0, 0xC8, 0xFF, 0x10,
  0x20, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x83, 0xF0, 0x23, 0xC7, 0x09, 0x80, 0x62,
  0x40, 0x0C, 0xA0, 0x01, 0x28, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0xC0,
  0x00, 0xB0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x2C, 0x00, 0x1A, 0x80, 0x04, 0xA0,
  0x03, 0x24, 0x01, 0x88, 0xC0, 0xC2, 0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x01,
  0xF8, 0x0F, 0x3C, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x08, 0x3F, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x03, 0xE0, 0xC3,
  0xCE, 0x31, 0x80, 0x4C, 0xC0, 0x0B, 0x20, 0x03, 0xD8, 0x00, 0x74, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x74, 0x00,
  0x1D, 0x80, 0x07, 0x60, 0x02, 0xCC, 0x01, 0xB1, 0x80, 0xCC, 0x3F, 0xE3,
  0x00, 0x80, 0x00, 0x03, 0xE0, 0x07, 0x3C, 0x06, 0x03, 0x06, 0x00, 0xC2,
  0x00, 0x23, 0x00, 0x19, 0x00, 0x05, 0x80, 0x02, 0xC0, 0x01, 0x40, 0x00,
  0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x83, 0x01,
  0xC0, 0xFF, 0x80, 0x0C, 0x00, 0x01, 0xF0, 0x1D, 0xC1, 0x80, 0x18, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x7F, 0xE0, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x03, 0xF0,
  0x07, 0x9E, 0x46, 0x01, 0xA6, 0x00, 0x56, 0x00, 0x1A, 0x00, 0x0D, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x06, 0xC0,
  0x03, 0x20, 0x02, 0x98, 0x03, 0x46, 0x03, 0x21, 0xFE, 0x10, 0x08, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x34, 0x00, 0x31, 0x80, 0x30, 0x7F, 0xF0, 0x01,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x83, 0xF0, 0x8F, 0x38, 0x98, 0x0C, 0x90, 0x06, 0xA0, 0x02,
  0xA0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xBF, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x0C, 0x18, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x0D, 0xF0, 0x80, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x50, 0x01, 0x20, 0x06, 0x40, 0x18, 0x80,
  0x21, 0x00, 0x82, 0x03, 0x04, 0x0C, 0x08, 0x10, 0x10, 0x60, 0x21, 0x80,
  0x42, 0x00, 0x8E, 0x01, 0x34, 0x02, 0x4C, 0x05, 0x08, 0x0E, 0x18, 0x18,
  0x10, 0x20, 0x30, 0x40, 0x20, 0x80, 0x61, 0x00, 0x42, 0x00, 0x44, 0x00,
  0x88, 0x01, 0x90, 0x01, 0x20, 0x01, 0x40, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x1F, 0x08, 0xE7, 0x07, 0x38, 0x98, 0x18, 0xC0, 0xCB,
  0x00, 0x98, 0x06, 0xA0, 0x0D, 0x00, 0x2C, 0x00, 0x60, 0x02, 0xC0, 0x06,
  0x00, 0x2C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x60, 0x03,
  0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00,
  0x60, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00,
  0x38, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80,
  0x06, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60,
  0x03, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x03, 0x80, 0x06, 0x00, 0x38,
  0x00, 0x60, 0x03, 0x03, 0xF0, 0x8E, 0x38, 0x98, 0x0C, 0x90, 0x06, 0xA0,
  0x02, 0xA0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x03,
  0xF0, 0x03, 0xCF, 0x01, 0x80, 0x60, 0xC0, 0x0C, 0x60, 0x01, 0x18, 0x00,
  0x64, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00,
  0x24, 0x00, 0x19, 0x80, 0x04, 0x20, 0x03, 0x0C, 0x00, 0x81, 0xC0, 0xC0,
  0x1F, 0xE0, 0x00, 0xC0, 0x00, 0x03, 0xF0, 0x21, 0xCF, 0x09, 0x80, 0x62,
  0x40, 0x0C, 0xB0, 0x01, 0x28, 0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0xC0,
  0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xB0, 0x00, 0x2E, 0x00, 0x1A, 0x80, 0x04, 0xB0,
  0x03, 0x26, 0x01, 0x88, 0xC0, 0xC2, 0x1F, 0xE0, 0x80, 0xC0, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0x9C, 0x46, 0x01, 0x26, 0x00, 0x52, 0x00, 0x3B, 0x00, 0x0D,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x0D, 0x00, 0x06,
  0xC0, 0x07, 0x20, 0x02, 0x98, 0x02, 0x46, 0x07, 0x21, 0xFE, 0x10, 0x18,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x03, 0xD1, 0xFE, 0x60, 0x48, 0x0A, 0x01, 0x40, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x00, 0x07, 0xF0, 0x3C, 0xF8, 0xC0, 0x13, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x00, 0x02,
  0x00, 0x0D, 0x00, 0x13, 0x80, 0xE3, 0xFF, 0x00, 0x30, 0x00, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x07, 0xFF, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x00, 0xFC, 0x04, 0x00, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x05, 0xC0, 0x05, 0x40, 0x0D, 0x60,
  0x19, 0x30, 0x31, 0x1F, 0xE1, 0x03, 0x00, 0xC0, 0x00, 0xA0, 0x00, 0xD0,
  0x00, 0x4C, 0x00, 0x22, 0x00, 0x31, 0x00, 0x18, 0xC0, 0x08, 0x60, 0x04,
  0x10, 0x06, 0x08, 0x02, 0x06, 0x01, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x40,
  0x40, 0x30, 0x20, 0x08, 0x30, 0x04, 0x10, 0x03, 0x08, 0x00, 0x8C, 0x00,
  0x46, 0x00, 0x22, 0x00, 0x19, 0x00, 0x05, 0x80, 0x02, 0x80, 0x01, 0x40,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x38, 0x00, 0x60, 0x02,
  0xC0, 0x0E, 0x00, 0x24, 0x00, 0xF0, 0x06, 0x40, 0x09, 0x00, 0x64, 0x00,
  0x90, 0x04, 0x60, 0x19, 0x00, 0x42, 0x01, 0x98, 0x04, 0x20, 0x11, 0x80,
  0xC2, 0x01, 0x08, 0x08, 0x30, 0x30, 0x80, 0x81, 0x03, 0x0C, 0x08, 0x10,
  0x20, 0xC1, 0x81, 0x02, 0x04, 0x10, 0x18, 0x60, 0x41, 0x01, 0x86, 0x06,
  0x10, 0x08, 0x40, 0x63, 0x00, 0x84, 0x02, 0x30, 0x0C, 0xC0, 0x22, 0x00,
  0xCC, 0x02, 0x20, 0x04, 0x80, 0x32, 0x00, 0x48, 0x01, 0x60, 0x07, 0x80,
  0x14, 0x00, 0x78, 0x01, 0x40, 0x03, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x10, 0x01, 0x0C, 0x01, 0x82, 0x00,
  0x81, 0x80, 0xC0, 0x40, 0x40, 0x30, 0x60, 0x08, 0x20, 0x06, 0x30, 0x01,
  0x10, 0x00, 0xD8, 0x00, 0x28, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x05, 0x00,
  0x06, 0xC0, 0x02, 0x20, 0x03, 0x18, 0x01, 0x04, 0x01, 0x83, 0x00, 0x80,
  0x80, 0xC0, 0x60, 0xC0, 0x10, 0x40, 0x0C, 0x60, 0x03, 0x20, 0x01, 0xB0,
  0x00, 0x60, 0x40, 0x00, 0xD8, 0x00, 0x22, 0x00, 0x08, 0x80, 0x06, 0x30,
  0x01, 0x04, 0x00, 0x41, 0x00, 0x30, 0x40, 0x0C, 0x18, 0x02, 0x02, 0x00,
  0x80, 0x80, 0x60, 0x30, 0x10, 0x04, 0x04, 0x01, 0x03, 0x00, 0x60, 0xC0,
  0x18, 0x20, 0x02, 0x08, 0x00, 0x86, 0x00, 0x31, 0x00, 0x04, 0x40, 0x01,
  0x30, 0x00, 0x48, 0x00, 0x1A, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x3F, 0xFE, 0x00, 0x78, 0x07, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x40, 0x0E, 0x03, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18,
  0x00, 0x40, 0x03, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x38, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x07, 0x03, 0x80, 0xC0, 0x1F,
  0xE8, 0x00, 0x70,
};

const GFXglyph NotoSans_Condensed_Thin52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 37, 11, 4, -37 },
  { 15, 9, 13, 16, 3, -37 },
  { 30, 23, 37, 26, 1, -37 },
  { 137, 19, 43, 23, 2, -40 },
  { 240, 28, 38, 33, 3, -38 },
  { 373, 22, 39, 25, 2, -38 },
  { 481, 2, 13, 9, 3, -37 },
  { 485, 10, 45, 14, 2, -37 },
  { 542, 9, 45, 14, 2, -37 },
  { 593, 15, 15, 21, 3, -39 },
  { 622, 19, 24, 23, 2, -30 },
  { 679, 4, 12, 9, 2, -5 },
  { 685, 11, 2, 15, 2, -15 },
  { 688, 2, 3, 10, 4, -3 },
  { 689, 15, 37, 17, 1, -37 },
  { 759, 18, 38, 23, 3, -38 },
  { 845, 10, 37, 23, 4, -37 },
  { 892, 18, 38, 23, 2, -38 },
  { 978, 18, 39, 23, 2, -38 },
  { 1066, 22, 37, 23, 1, -37 },
  { 1168, 18, 37, 23, 3, -37 },
  { 1252, 18, 39, 23, 3, -38 },
  { 1340, 18, 37, 23, 2, -37 },
  { 1424, 19, 39, 23, 2, -38 },
  { 1517, 18, 39, 23, 2, -38 },
  { 1605, 2, 28, 10, 4, -28 },
  { 1612, 5, 35, 10, 2, -28 },
  { 1634, 19, 21, 23, 2, -29 },
  { 1684, 19, 12, 23, 2, -24 },
  { 1713, 19, 21, 23, 2, -29 },
  { 1763, 14, 38, 16, 1, -38 },
  { 1830, 30, 42, 36, 3, -37 },
  { 1988, 23, 37, 23, 0, -37 },
  { 2095, 19, 37, 25, 4, -37 },
  { 2183, 20, 39, 25, 3, -38 },
  { 2281, 21, 37, 28, 4, -37 },
  { 2379, 16, 37, 22, 4, -37 },
  { 2453, 16, 37, 20, 4, -37 },
  { 2527, 24, 39, 30, 3, -38 },
  { 2644, 20, 37, 29, 4, -37 },
  { 2737, 8, 37, 12, 2, -37 },
  { 2774, 9, 46, 10, -3, -37 },
  { 2826, 19, 37, 23, 4, -37 },
  { 2914, 15, 37, 20, 4, -37 },
  { 2984, 28, 37, 37, 4, -37 },
  { 3114, 21, 37, 29, 4, -37 },
  { 3212, 24, 39, 30, 3, -38 },
  { 3329, 17, 37, 23, 4, -37 },
  { 3408, 24, 47, 30, 3, -38 },
  { 3549, 19, 37, 24, 4, -37 },
  { 3637, 18, 39, 23, 2, -38 },
  { 3725, 20, 37, 20, 0, -37 },
  { 3818, 21, 38, 29, 4, -37 },
  { 3918, 22, 37, 22, 0, -37 },
  { 4020, 35, 37, 37, 1, -37 },
  { 4182, 20, 37, 20, 0, -37 },
  { 4275, 19, 37, 19, 0, -37 },
  { 4363, 17, 37, 21, 2, -37 },
  { 4442, 10, 45, 16, 4, -37 },
  { 4499, 15, 37, 17, 1, -37 },
  { 4569, 10, 45, 16, 2, -37 },
  { 4626, 21, 19, 23, 1, -37 },
  { 4676, 20, 1, 20, 0, 5 },
  { 4679, 8, 8, 12, 2, -40 },
  { 4687, 15, 29, 21, 2, -28 },
  { 4742, 18, 41, 25, 4, -40 },
  { 4835, 15, 29, 19, 3, -28 },
  { 4890, 18, 41, 25, 3, -40 },
  { 4983, 17, 29, 22, 3, -28 },
  { 5045, 13, 40, 12, 1, -40 },
  { 5110, 17, 41, 24, 3, -28 },
  { 5198, 16, 40, 24, 4, -40 },
  { 5278, 2, 38, 10, 4, -38 },
  { 5288, 7, 51, 10, -1, -38 },
  { 5333, 15, 40, 19, 4, -40 },
  { 5408, 1, 40, 9, 4, -40 },
  { 5413, 28, 28, 35, 4, -28 },
  { 5511, 16, 28, 24, 4, -28 },
  { 5567, 18, 29, 24, 3, -28 },
  { 5633, 18, 40, 24, 4, -28 },
  { 5723, 17, 40, 24, 3, -28 },
  { 5808, 11, 28, 15, 4, -28 },
  { 5847, 15, 29, 19, 2, -28 },
  { 5902, 11, 35, 13, 1, -34 },
  { 5951, 16, 28, 24, 4, -27 },
  { 6007, 17, 27, 17, 0, -27 },
  { 6065, 28, 27, 29, 1, -27 },
  { 6160, 17, 27, 19, 1, -27 },
  { 6218, 18, 40, 18, 0, -27 },
  { 6308, 13, 27, 16, 2, -27 },
  { 6352, 13, 45, 18, 2, -37 },
  { 6426, 2, 53, 22, 10, -40 },
  { 6440, 14, 45, 18, 2, -37 },
  { 6519, 19, 5, 23, 2, -21 },
};

const GFXfont NotoSans_Condensed_Thin52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_THIN52PT7B_H_
