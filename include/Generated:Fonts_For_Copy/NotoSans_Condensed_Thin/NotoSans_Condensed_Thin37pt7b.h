#ifndef _NOTOSANS_CONDENSED_THIN37PT7B_H_
#define _NOTOSANS_CONDENSED_THIN37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin37pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0xF0, 0xC2, 0x85, 0x0A, 0x14,
  0x28, 0x50, 0xA1, 0x42, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08,
  0x04, 0x08, 0x04, 0x08, 0x04, 0x08, 0x04, 0x10, 0x7F, 0xFF, 0x04, 0x10,
  0x04, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20,
  0xFF, 0xFE, 0x08, 0x20, 0x08, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10, 0x20,
  0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x04, 0x00, 0x20, 0x07,
  0xF0, 0xC8, 0x44, 0x40, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x20,
  0x21, 0x01, 0x88, 0x06, 0x40, 0x0E, 0x00, 0x18, 0x00, 0xB0, 0x04, 0x40,
  0x21, 0x01, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x40, 0x82, 0x04,
  0x34, 0x23, 0x3F, 0xE0, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x01, 0x06,
  0x40, 0x20, 0x42, 0x02, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x40,
  0x81, 0x08, 0x08, 0x10, 0x80, 0x81, 0x10, 0x08, 0x11, 0x00, 0x81, 0x10,
  0x08, 0x12, 0x3C, 0x81, 0x24, 0x28, 0x24, 0x82, 0x42, 0x48, 0x26, 0x44,
  0x81, 0x38, 0x88, 0x10, 0x08, 0x81, 0x01, 0x08, 0x10, 0x10, 0x81, 0x01,
  0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08, 0x20,
  0x40, 0x42, 0x08, 0x03, 0xC0, 0x0E, 0x00, 0x23, 0x00, 0x82, 0x01, 0x02,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0xC0, 0x21, 0x00,
  0x44, 0x00, 0x58, 0x00, 0xC0, 0x03, 0x80, 0x08, 0x80, 0x21, 0x81, 0xC1,
  0x03, 0x01, 0x0A, 0x01, 0x14, 0x02, 0x28, 0x02, 0x90, 0x03, 0x20, 0x06,
  0x40, 0x0C, 0xC0, 0x24, 0x80, 0x88, 0xFE, 0x08, 0xD5, 0x55, 0x40, 0x0C,
  0x21, 0x04, 0x20, 0x84, 0x10, 0x42, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x04, 0x10, 0x41, 0x82, 0x08, 0x10, 0x60, 0x81, 0xC0,
  0x40, 0xC0, 0x81, 0x81, 0x02, 0x02, 0x04, 0x08, 0x10, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x81,
  0x04, 0x18, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x0E, 0x4E, 0x3E, 0x03,
  0x00, 0x50, 0x11, 0x04, 0x11, 0x02, 0x00, 0x01, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0xFF, 0xFC, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x24, 0x92, 0x92, 0x80, 0xFF, 0xE0, 0x00, 0x40, 0x10, 0x08, 0x02,
  0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10, 0x04, 0x01,
  0x00, 0x80, 0x20, 0x00, 0x07, 0x00, 0xC6, 0x08, 0x10, 0x40, 0x44, 0x02,
  0x20, 0x09, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x05, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xA0, 0x05, 0x00,
  0x28, 0x01, 0x20, 0x09, 0x00, 0x48, 0x04, 0x20, 0x20, 0x82, 0x03, 0xE0,
  0x06, 0x14, 0xCB, 0x18, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F,
  0x07, 0x0C, 0x80, 0x40, 0x02, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x00, 0xFF, 0xF0, 0x1E, 0x06, 0x0C, 0x80, 0x60, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x01, 0x81,
  0xF0, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x28, 0x04, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0x40, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x48, 0x01, 0x10,
  0x02, 0x20, 0x08, 0x40, 0x10, 0x80, 0x41, 0x00, 0x82, 0x02, 0x04, 0x08,
  0x08, 0x10, 0x10, 0x40, 0x20, 0x80, 0x42, 0x00, 0x87, 0xFF, 0xF0, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x7F, 0xE2, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x17, 0xC0, 0xC3, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x04, 0x80, 0x43, 0xFC, 0x00, 0x01, 0xE0, 0x70, 0x86, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x01, 0x1F, 0x8B, 0x06, 0x50, 0x1B, 0x00, 0x58, 0x02, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x02, 0x20, 0x31,
  0x81, 0x07, 0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x00, 0x0F, 0x01,
  0x86, 0x18, 0x08, 0x80, 0x2C, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x40,
  0x12, 0x01, 0x08, 0x18, 0x31, 0x00, 0x70, 0x07, 0x80, 0x43, 0x04, 0x0C,
  0x40, 0x34, 0x00, 0xA0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x02, 0x40, 0x13, 0x03, 0x07, 0xF0, 0x0F, 0x03, 0x08, 0x40, 0x44, 0x02,
  0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x03, 0x40, 0x53, 0x0D, 0x1F, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x7E, 0x00, 0xB8,
  0x00, 0x00, 0x00, 0x0E, 0x23, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x32, 0x22, 0x24, 0x44, 0x80, 0x00, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x00, 0x3C, 0x61, 0x80, 0x60, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x40, 0x60, 0x20, 0x20, 0x20, 0x10, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x01, 0xFF,
  0x00, 0x18, 0x06, 0x00, 0xC0, 0x04, 0x06, 0x00, 0x08, 0x10, 0x00, 0x30,
  0x80, 0x00, 0x46, 0x00, 0x01, 0x10, 0x0F, 0x02, 0x40, 0xC2, 0x09, 0x06,
  0x08, 0x28, 0x10, 0x20, 0xA0, 0xC0, 0x82, 0x82, 0x02, 0x0A, 0x08, 0x08,
  0x38, 0x20, 0x20, 0xA0, 0x81, 0x82, 0x82, 0x04, 0x0A, 0x08, 0x10, 0x28,
  0x20, 0x60, 0xA0, 0x42, 0x84, 0x81, 0x9B, 0x31, 0x03, 0x87, 0x84, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x40, 0x03, 0xFE, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40,
  0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20, 0x04, 0x20,
  0x04, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x08, 0x10, 0x08,
  0x1F, 0xF8, 0x10, 0x0C, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xC4,
  0x01, 0x20, 0x05, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x14, 0x00, 0xA0, 0x09, 0x03, 0x8F, 0xFC, 0x40, 0x12, 0x00, 0x50, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x02, 0x80, 0x67, 0xFC, 0x00, 0x00, 0xF0, 0x0E, 0x1C, 0x20, 0x00, 0x80,
  0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x04, 0x0F, 0xF0, 0xFF, 0xC1, 0x00, 0xC2,
  0x00, 0x44, 0x00, 0x48, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x28, 0x00, 0xD0,
  0x01, 0x20, 0x04, 0x40, 0x18, 0x80, 0xC1, 0xFE, 0x00, 0xFF, 0xF0, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0F, 0xFD, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFC, 0xFF, 0xF0, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0xFF, 0xE0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00, 0x00, 0xF8, 0x01,
  0x81, 0x83, 0x00, 0x23, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0xFF, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x50,
  0x00, 0x28, 0x00, 0x14, 0x00, 0x0B, 0x00, 0x04, 0x80, 0x02, 0x20, 0x01,
  0x18, 0x00, 0x86, 0x00, 0x40, 0xFF, 0xC0, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x10, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xFE, 0x80, 0x1C,
  0x01, 0x20, 0x19, 0x00, 0x88, 0x08, 0x40, 0x82, 0x0C, 0x10, 0x40, 0x84,
  0x04, 0x60, 0x22, 0x01, 0x30, 0x0A, 0x80, 0x52, 0x03, 0x18, 0x10, 0x40,
  0x81, 0x04, 0x08, 0x20, 0x21, 0x01, 0x08, 0x04, 0x40, 0x22, 0x00, 0x90,
  0x02, 0x80, 0x14, 0x00, 0x40, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x1F, 0xFC, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xA0, 0x00,
  0x3A, 0x00, 0x05, 0xA0, 0x00, 0x59, 0x00, 0x05, 0x90, 0x00, 0x99, 0x00,
  0x09, 0x88, 0x00, 0x98, 0x80, 0x11, 0x88, 0x01, 0x18, 0x40, 0x11, 0x84,
  0x02, 0x18, 0x40, 0x21, 0x82, 0x02, 0x18, 0x20, 0x41, 0x82, 0x04, 0x18,
  0x10, 0x41, 0x81, 0x08, 0x18, 0x10, 0x81, 0x80, 0x88, 0x18, 0x09, 0x01,
  0x80, 0x90, 0x18, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x03,
  0x80, 0x06, 0x80, 0x0D, 0x00, 0x19, 0x00, 0x32, 0x00, 0x62, 0x00, 0xC4,
  0x01, 0x84, 0x03, 0x08, 0x06, 0x08, 0x0C, 0x10, 0x18, 0x10, 0x30, 0x20,
  0x60, 0x20, 0xC0, 0x41, 0x80, 0x43, 0x00, 0x86, 0x00, 0x8C, 0x01, 0x18,
  0x01, 0x30, 0x02, 0x60, 0x02, 0xC0, 0x05, 0x80, 0x07, 0x00, 0x0C, 0x01,
  0xE0, 0x03, 0x86, 0x01, 0x80, 0x40, 0xC0, 0x08, 0x20, 0x01, 0x10, 0x00,
  0x44, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A,
  0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x18, 0x00, 0x0A, 0x00, 0x02, 0x80,
  0x00, 0xA0, 0x00, 0x28, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x90, 0x00,
  0x42, 0x00, 0x10, 0x80, 0x0C, 0x10, 0x02, 0x02, 0x03, 0x00, 0x7F, 0x80,
  0xFF, 0x88, 0x04, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x02, 0x80, 0x48, 0x18, 0xFC, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x01, 0xE0, 0x03, 0x86, 0x01, 0x80, 0x40, 0xC0, 0x08,
  0x20, 0x01, 0x18, 0x00, 0x44, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xA0,
  0x00, 0x28, 0x00, 0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x18, 0x00,
  0x0A, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x09, 0x00, 0x02,
  0x40, 0x00, 0x90, 0x00, 0x42, 0x00, 0x10, 0x80, 0x0C, 0x10, 0x02, 0x02,
  0x03, 0x00, 0x7F, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x06, 0x00, 0xFF, 0x84, 0x03, 0x20, 0x09, 0x00,
  0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14, 0x00, 0xA0, 0x09,
  0x00, 0x48, 0x0C, 0x7F, 0x82, 0x08, 0x10, 0x20, 0x81, 0x04, 0x04, 0x20,
  0x21, 0x00, 0x88, 0x04, 0x40, 0x12, 0x00, 0x90, 0x02, 0x80, 0x14, 0x00,
  0x40, 0x07, 0xC3, 0x83, 0x60, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x28, 0x04, 0xFF, 0x80, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x28, 0x00, 0x50, 0x00, 0x90, 0x01, 0x30,
  0x04, 0x30, 0x10, 0x3F, 0xC0, 0x80, 0x03, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08,
  0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x60, 0x04, 0x40, 0x02, 0x40, 0x02,
  0x40, 0x02, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x0C, 0x00,
  0x50, 0x03, 0x00, 0x24, 0x00, 0xC0, 0x09, 0x00, 0x30, 0x02, 0x20, 0x0A,
  0x00, 0x88, 0x04, 0x80, 0x62, 0x01, 0x20, 0x10, 0x80, 0x48, 0x04, 0x10,
  0x11, 0x01, 0x04, 0x08, 0x40, 0x41, 0x02, 0x10, 0x20, 0x40, 0x84, 0x08,
  0x10, 0x21, 0x02, 0x02, 0x08, 0x20, 0x80, 0x84, 0x08, 0x40, 0x21, 0x02,
  0x10, 0x08, 0x40, 0x84, 0x01, 0x10, 0x11, 0x00, 0x44, 0x04, 0x80, 0x12,
  0x01, 0x20, 0x04, 0x80, 0x48, 0x00, 0xA0, 0x12, 0x00, 0x28, 0x02, 0x80,
  0x0C, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0C,
  0x80, 0x22, 0x01, 0x04, 0x04, 0x10, 0x30, 0x20, 0x80, 0x82, 0x01, 0x10,
  0x04, 0x40, 0x0A, 0x00, 0x28, 0x00, 0xC0, 0x01, 0x00, 0x0E, 0x00, 0x28,
  0x01, 0x20, 0x04, 0x40, 0x21, 0x00, 0x82, 0x04, 0x08, 0x10, 0x10, 0x80,
  0x42, 0x01, 0x10, 0x02, 0x40, 0x0B, 0x00, 0x10, 0x80, 0x0D, 0x00, 0x24,
  0x00, 0x88, 0x04, 0x20, 0x10, 0x80, 0x81, 0x02, 0x04, 0x08, 0x08, 0x40,
  0x21, 0x00, 0x88, 0x01, 0x20, 0x04, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x7F, 0xF8, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x08, 0x00, 0x40, 0x04,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x07, 0xFF,
  0xC0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08,
  0x02, 0x00, 0x40, 0x10, 0x04, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x40,
  0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x02, 0x00,
  0x40, 0x10, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x01, 0x00, 0x05, 0x00, 0x0A, 0x00,
  0x22, 0x00, 0x44, 0x01, 0x04, 0x06, 0x08, 0x08, 0x08, 0x30, 0x10, 0x40,
  0x11, 0x80, 0x22, 0x00, 0x2C, 0x00, 0x60, 0xFF, 0xFE, 0xC0, 0x83, 0x06,
  0x08, 0x10, 0x1F, 0x18, 0x60, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x43, 0xF3, 0x05, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x3C, 0x15, 0xF9, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x8F, 0x84, 0x86, 0x28, 0x09, 0x80, 0x6C, 0x01,
  0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0xC0, 0x16, 0x01, 0x28, 0x11, 0x3F,
  0x00, 0x07, 0xE3, 0x08, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0F, 0xE0, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x0F, 0x08, 0x86, 0x48, 0x0A, 0x80,
  0x54, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x40, 0x1A, 0x01, 0x48,
  0x12, 0x3F, 0x10, 0x0F, 0x01, 0x0C, 0x20, 0x44, 0x02, 0x40, 0x28, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x04, 0x00, 0x40, 0x06, 0x00, 0x30, 0x21, 0xFE, 0x07, 0xC2, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x7F, 0x24, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x0F, 0x88, 0x82, 0x48,
  0x0A, 0x80, 0x34, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x40, 0x2A,
  0x01, 0x48, 0x12, 0x3F, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x08, 0x81, 0x81, 0xF0, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x8F, 0x12, 0x1A, 0x81, 0x60,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0xE1,
  0xFF, 0xFF, 0xE0, 0x08, 0x42, 0x00, 0x00, 0x01, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x45, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x60, 0x28, 0x12, 0x04, 0x82, 0x21, 0x08, 0xC2, 0x20, 0x98, 0x2A,
  0x0A, 0xC3, 0x10, 0x86, 0x20, 0x88, 0x12, 0x04, 0x80, 0xA0, 0x28, 0x06,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x8E, 0x07, 0x8B, 0x19, 0x84, 0xC0, 0x90,
  0x2C, 0x06, 0x02, 0x80, 0x60, 0x28, 0x04, 0x02, 0x80, 0x40, 0x18, 0x04,
  0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80,
  0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x80, 0x40, 0x18,
  0x04, 0x01, 0x80, 0x40, 0x18, 0x04, 0x01, 0x8F, 0x16, 0x1A, 0x81, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x0F,
  0x80, 0x82, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x0A, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x02, 0x40, 0x13, 0x01, 0x88, 0x18, 0x3F, 0x80, 0x8F, 0x84, 0x86, 0x28,
  0x09, 0x80, 0x6C, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00, 0x50, 0x02, 0xC0, 0x16,
  0x01, 0x28, 0x11, 0x3F, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x88, 0x86, 0x48,
  0x0A, 0x80, 0x54, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x40, 0x2A,
  0x01, 0x48, 0x12, 0x3F, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x8E, 0x91, 0xA0, 0xC0,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x0F, 0x86, 0x0D, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x20, 0x0A, 0x03, 0x3F, 0xC0, 0x20, 0x40, 0x81, 0x07,
  0xF4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x70, 0x0D, 0x02, 0x9F, 0x90, 0x80, 0x18, 0x01,
  0x40, 0x14, 0x02, 0x40, 0x22, 0x02, 0x20, 0x22, 0x04, 0x20, 0x41, 0x04,
  0x10, 0x81, 0x08, 0x10, 0x80, 0x88, 0x09, 0x00, 0x90, 0x05, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x80, 0x20, 0x14, 0x02, 0x01, 0x40, 0x30, 0x14, 0x05,
  0x01, 0x40, 0x50, 0x12, 0x05, 0x02, 0x20, 0x48, 0x22, 0x08, 0x82, 0x20,
  0x88, 0x21, 0x08, 0x84, 0x10, 0x84, 0x41, 0x10, 0x44, 0x11, 0x04, 0x40,
  0x90, 0x48, 0x09, 0x02, 0x80, 0xA0, 0x28, 0x0A, 0x02, 0x80, 0x60, 0x28,
  0x06, 0x01, 0x00, 0x40, 0x10, 0x80, 0x24, 0x02, 0x40, 0x42, 0x04, 0x20,
  0x81, 0x08, 0x11, 0x00, 0x90, 0x0A, 0x00, 0x60, 0x06, 0x00, 0xA0, 0x09,
  0x01, 0x10, 0x10, 0x82, 0x08, 0x20, 0x44, 0x04, 0x40, 0x28, 0x03, 0x40,
  0x0A, 0x00, 0x90, 0x04, 0x80, 0x22, 0x01, 0x10, 0x10, 0x80, 0x82, 0x04,
  0x10, 0x40, 0x82, 0x04, 0x10, 0x10, 0x80, 0x88, 0x04, 0x40, 0x12, 0x00,
  0xA0, 0x05, 0x00, 0x28, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x40, 0x02, 0x00, 0x20, 0x0E, 0x00, 0x00, 0x7F,
  0xC0, 0x30, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x04, 0x01, 0x00,
  0x80, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0xFF,
  0x07, 0x84, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0xC1, 0x80, 0x20, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x60, 0x10, 0x07, 0x06,
  0x02, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0xC1, 0x80, 0x18, 0x01, 0x9C, 0x18, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Thin37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 26, 8, 3, -26 },
  { 8, 7, 9, 11, 2, -26 },
  { 16, 16, 26, 18, 1, -26 },
  { 68, 13, 30, 17, 2, -28 },
  { 117, 20, 27, 24, 2, -27 },
  { 185, 15, 27, 18, 2, -27 },
  { 236, 2, 9, 6, 2, -26 },
  { 239, 6, 32, 10, 2, -26 },
  { 263, 7, 32, 10, 1, -26 },
  { 291, 11, 11, 15, 2, -28 },
  { 307, 14, 17, 17, 1, -22 },
  { 337, 3, 9, 7, 1, -4 },
  { 341, 8, 1, 10, 1, -11 },
  { 342, 2, 2, 7, 3, -2 },
  { 343, 10, 26, 12, 1, -26 },
  { 376, 13, 27, 17, 2, -27 },
  { 420, 7, 26, 17, 3, -26 },
  { 443, 12, 27, 17, 2, -27 },
  { 484, 12, 27, 17, 2, -27 },
  { 525, 15, 27, 17, 1, -27 },
  { 576, 13, 26, 17, 2, -26 },
  { 619, 13, 27, 17, 2, -27 },
  { 663, 13, 26, 17, 2, -26 },
  { 706, 13, 27, 17, 2, -27 },
  { 750, 12, 27, 17, 2, -27 },
  { 791, 2, 20, 7, 3, -20 },
  { 796, 4, 25, 7, 1, -20 },
  { 809, 14, 16, 17, 1, -21 },
  { 837, 14, 8, 17, 1, -17 },
  { 851, 14, 16, 17, 1, -21 },
  { 879, 9, 27, 11, 1, -27 },
  { 910, 22, 29, 25, 2, -26 },
  { 990, 16, 26, 16, 0, -26 },
  { 1042, 13, 26, 18, 3, -26 },
  { 1085, 15, 27, 18, 2, -27 },
  { 1136, 15, 26, 20, 3, -26 },
  { 1185, 11, 26, 16, 3, -26 },
  { 1221, 11, 26, 15, 3, -26 },
  { 1257, 17, 27, 21, 2, -27 },
  { 1315, 14, 26, 20, 3, -26 },
  { 1361, 5, 26, 9, 2, -26 },
  { 1378, 6, 32, 7, -2, -26 },
  { 1402, 13, 26, 16, 3, -26 },
  { 1445, 11, 26, 14, 3, -26 },
  { 1481, 20, 26, 26, 3, -26 },
  { 1546, 15, 26, 21, 3, -26 },
  { 1595, 18, 27, 22, 2, -27 },
  { 1656, 12, 26, 17, 3, -26 },
  { 1695, 18, 33, 22, 2, -27 },
  { 1770, 13, 26, 17, 3, -26 },
  { 1813, 12, 27, 16, 2, -27 },
  { 1854, 14, 26, 14, 0, -26 },
  { 1900, 15, 26, 21, 3, -26 },
  { 1949, 16, 26, 16, 0, -26 },
  { 2001, 26, 26, 26, 0, -26 },
  { 2086, 14, 26, 14, 0, -26 },
  { 2132, 14, 26, 14, 0, -26 },
  { 2178, 13, 26, 15, 1, -26 },
  { 2221, 7, 32, 11, 3, -26 },
  { 2249, 10, 26, 12, 1, -26 },
  { 2282, 7, 32, 11, 1, -26 },
  { 2310, 15, 13, 17, 1, -26 },
  { 2335, 15, 1, 15, 0, 3 },
  { 2337, 6, 6, 9, 1, -28 },
  { 2342, 10, 20, 15, 2, -20 },
  { 2367, 13, 28, 17, 3, -28 },
  { 2413, 11, 20, 13, 2, -20 },
  { 2441, 13, 28, 17, 2, -28 },
  { 2487, 12, 20, 16, 2, -20 },
  { 2517, 10, 28, 9, 0, -28 },
  { 2552, 13, 29, 17, 2, -20 },
  { 2600, 11, 28, 17, 3, -28 },
  { 2639, 1, 27, 7, 3, -27 },
  { 2643, 5, 36, 7, -1, -27 },
  { 2666, 10, 28, 13, 3, -28 },
  { 2701, 1, 28, 7, 3, -28 },
  { 2705, 20, 20, 25, 3, -20 },
  { 2755, 11, 20, 17, 3, -20 },
  { 2783, 13, 20, 17, 2, -20 },
  { 2816, 13, 29, 17, 3, -20 },
  { 2864, 13, 29, 17, 2, -20 },
  { 2912, 8, 20, 11, 3, -20 },
  { 2932, 11, 20, 13, 1, -20 },
  { 2960, 7, 24, 9, 1, -24 },
  { 2981, 11, 20, 17, 3, -20 },
  { 3009, 12, 20, 12, 0, -20 },
  { 3039, 20, 20, 21, 0, -20 },
  { 3089, 12, 20, 13, 1, -20 },
  { 3119, 13, 29, 13, 0, -20 },
  { 3167, 10, 20, 12, 1, -20 },
  { 3192, 9, 32, 13, 2, -26 },
  { 3228, 1, 37, 16, 7, -28 },
  { 3233, 9, 32, 13, 2, -26 },
  { 3269, 14, 3, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Thin37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin37pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_CONDENSED_THIN37PT7B_H_
