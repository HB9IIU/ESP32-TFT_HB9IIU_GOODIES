#ifndef _NOTOSANS_CONDENSED_THIN62PT7B_H_
#define _NOTOSANS_CONDENSED_THIN62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin62pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x64,
  0x92, 0x40, 0x00, 0x00, 0xDF, 0xF0, 0xC0, 0x78, 0x0B, 0x01, 0x60, 0x2C,
  0x05, 0x80, 0xB0, 0x16, 0x02, 0xC0, 0x58, 0x0B, 0x01, 0x60, 0x2C, 0x05,
  0x80, 0xB0, 0x16, 0x02, 0x00, 0x10, 0x02, 0x00, 0x01, 0x00, 0x60, 0x00,
  0x10, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x03, 0x00,
  0x40, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x20, 0x04, 0x00,
  0x02, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x80,
  0x00, 0x40, 0x08, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C,
  0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x08, 0x01, 0x00, 0x00, 0x80, 0x10,
  0x00, 0x08, 0x01, 0x00, 0x01, 0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x18, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x01, 0x00, 0x20, 0x00, 0x10, 0x02, 0x00, 0x03, 0x00, 0x60, 0x00,
  0x30, 0x06, 0x00, 0x03, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00,
  0x40, 0x00, 0x20, 0x04, 0x00, 0x02, 0x00, 0x40, 0x00, 0x60, 0x0C, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xF8,
  0x00, 0x7F, 0xFC, 0x0F, 0x30, 0xF8, 0xE1, 0x80, 0x8C, 0x0C, 0x00, 0x60,
  0x60, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x00, 0xC0, 0x08, 0x06, 0x00,
  0x40, 0x30, 0x02, 0x01, 0x80, 0x10, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x03,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0E, 0x30, 0x00,
  0x1D, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1B,
  0xC0, 0x00, 0xC7, 0x00, 0x06, 0x0E, 0x00, 0x30, 0x38, 0x01, 0x80, 0xC0,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x30, 0x03, 0x01, 0xA0, 0x18, 0x39, 0xE0, 0xC7, 0x87, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x30,
  0x03, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0xC0, 0x02, 0x00, 0x60, 0x10, 0x01,
  0x80, 0x18, 0x06, 0x00, 0x40, 0x04, 0x01, 0x80, 0x30, 0x01, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x08, 0x02, 0x00, 0x30, 0x02, 0x01, 0x80, 0x0C, 0x00,
  0x80, 0x40, 0x03, 0x00, 0x20, 0x30, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0x30,
  0x03, 0x02, 0x00, 0x0C, 0x00, 0xC1, 0x80, 0x03, 0x00, 0x30, 0x60, 0x00,
  0xC0, 0x08, 0x30, 0x00, 0x30, 0x02, 0x0C, 0x00, 0x0C, 0x00, 0x82, 0x0F,
  0x83, 0x00, 0x21, 0x86, 0x38, 0x40, 0x18, 0x63, 0x02, 0x10, 0x06, 0x10,
  0x80, 0xC6, 0x01, 0x8C, 0x60, 0x11, 0x80, 0x42, 0x18, 0x06, 0x30, 0x31,
  0x84, 0x01, 0x8C, 0x18, 0x63, 0x00, 0x61, 0xFC, 0x10, 0xC0, 0x08, 0x1E,
  0x0C, 0x30, 0x02, 0x00, 0x02, 0x0C, 0x00, 0x80, 0x01, 0x83, 0x00, 0x20,
  0x00, 0x60, 0xC0, 0x08, 0x00, 0x10, 0x30, 0x03, 0x00, 0x0C, 0x0C, 0x00,
  0xC0, 0x02, 0x03, 0x00, 0x20, 0x01, 0x80, 0xC0, 0x08, 0x00, 0x60, 0x30,
  0x02, 0x00, 0x10, 0x0C, 0x00, 0x80, 0x0C, 0x03, 0x00, 0x60, 0x02, 0x00,
  0x40, 0x18, 0x01, 0x80, 0x10, 0x06, 0x00, 0x60, 0x06, 0x01, 0x00, 0x10,
  0x00, 0x80, 0xC0, 0x0C, 0x00, 0x30, 0x30, 0x02, 0x00, 0x06, 0x18, 0x01,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x60, 0x60, 0x00, 0x10, 0x0C, 0x00, 0x0C, 0x01, 0x00,
  0x02, 0x00, 0x60, 0x00, 0x80, 0x18, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00,
  0x80, 0x06, 0x00, 0x20, 0x01, 0x80, 0x18, 0x00, 0x20, 0x06, 0x00, 0x08,
  0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30, 0x00, 0x10, 0x0C, 0x00,
  0x06, 0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x76, 0x00, 0x00, 0x38,
  0x80, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x19,
  0x80, 0x30, 0x06, 0x40, 0x06, 0x01, 0xB0, 0x00, 0xC0, 0x4C, 0x00, 0x30,
  0x12, 0x00, 0x06, 0x0C, 0x80, 0x00, 0xC3, 0x20, 0x00, 0x10, 0x88, 0x00,
  0x06, 0x62, 0x00, 0x00, 0xD0, 0x80, 0x00, 0x1C, 0x20, 0x00, 0x06, 0x0C,
  0x00, 0x01, 0xC3, 0x00, 0x00, 0xD0, 0x60, 0x00, 0x66, 0x18, 0x00, 0x30,
  0xC3, 0x00, 0x18, 0x10, 0x70, 0x1C, 0x06, 0x07, 0xFC, 0x00, 0xC0, 0x38,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF5, 0x00, 0xE0, 0x10, 0x06, 0x01, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xE0, 0x06, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x30, 0x10, 0x13, 0x82, 0x1F, 0x0E, 0x4E, 0x00, 0x3E, 0x00,
  0x03, 0x80, 0x00, 0x50, 0x00, 0x11, 0x00, 0x06, 0x30, 0x01, 0x83, 0x00,
  0x60, 0x20, 0x08, 0x02, 0x03, 0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x08, 0x71, 0x86, 0x18, 0x61,
  0x0C, 0x30, 0xC2, 0x18, 0x61, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x6E,
  0xF6, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0xC0, 0xE0,
  0x18, 0x01, 0x80, 0xC0, 0x0C, 0x0C, 0x00, 0x30, 0x40, 0x01, 0x86, 0x00,
  0x06, 0x30, 0x00, 0x31, 0x00, 0x00, 0x98, 0x00, 0x04, 0xC0, 0x00, 0x36,
  0x00, 0x01, 0xA0, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x05, 0x00,
  0x00, 0x68, 0x00, 0x03, 0x60, 0x00, 0x1B, 0x00, 0x00, 0xD8, 0x00, 0x04,
  0xC0, 0x00, 0x22, 0x00, 0x03, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x60, 0x06, 0x01, 0x80, 0x60, 0x07, 0x0E, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x60, 0x1C, 0x06, 0x83, 0x90, 0xE2, 0x38, 0x4C,
  0x0F, 0x01, 0x40, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x0E, 0x00, 0xE0,
  0xC0, 0x03, 0x04, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x10,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xF0, 0x0E, 0x00, 0xE1, 0xC0,
  0x01, 0x8C, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x20, 0x00, 0x71, 0xE0, 0x0F, 0x03, 0xFF,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xB0, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x13, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x18, 0x30, 0x00, 0x04,
  0x0C, 0x00, 0x03, 0x03, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x30, 0x00,
  0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x0C, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x03, 0x00, 0x60, 0x00, 0xC0, 0x30,
  0x00, 0x30, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x00, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xFF, 0xE0, 0x40, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0xFF, 0xE0, 0x1F,
  0x81, 0xE0, 0x20, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC3,
  0x00, 0x06, 0x0F, 0x80, 0x70, 0x0F, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0x1E, 0x01, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x0F, 0xE0, 0x10, 0xFB, 0xE0, 0x46, 0x00, 0xC3, 0x30, 0x01, 0x8D,
  0x80, 0x03, 0x3C, 0x00, 0x04, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00,
  0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00,
  0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0xD8,
  0x00, 0x02, 0x60, 0x00, 0x08, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00,
  0x04, 0x18, 0x00, 0x30, 0x60, 0x01, 0x80, 0xC0, 0x0E, 0x01, 0xC0, 0x70,
  0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xE0, 0x1C, 0x06, 0x00,
  0x38, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC6, 0x00, 0x01, 0x18, 0x00, 0x04,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x30, 0x03, 0x00, 0x60, 0x38, 0x00, 0xE1, 0xC0, 0x00, 0xFC, 0x00,
  0x01, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0xE1, 0xC0, 0x0E, 0x03, 0x80, 0x70,
  0x03, 0x03, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x31, 0x00, 0x00,
  0x6C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x30, 0xC0, 0x01, 0xC1, 0x80, 0x0E,
  0x03, 0x80, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xF0, 0x03, 0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x0C, 0x10, 0x00,
  0x31, 0x80, 0x01, 0x88, 0x00, 0x04, 0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0,
  0x00, 0x05, 0x80, 0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xB0, 0x00, 0x1D, 0x80, 0x01, 0xE6, 0x00, 0x0B,
  0x30, 0x00, 0xD8, 0xE0, 0x1C, 0xC3, 0xFF, 0x86, 0x07, 0xF8, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x40, 0x78, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x6F, 0xF6,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0xEF, 0x60, 0x18, 0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x87,
  0x18, 0x61, 0x86, 0x10, 0xC3, 0x0C, 0x21, 0x86, 0x10, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xF8, 0xE0, 0x1C, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x03, 0x00, 0x00, 0x03, 0x00, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x00, 0x80, 0xC0, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x41,
  0x80, 0x00, 0x00, 0x06, 0x30, 0x00, 0x1C, 0x00, 0x63, 0x00, 0x0F, 0xF8,
  0x02, 0x30, 0x03, 0x80, 0x80, 0x36, 0x00, 0x70, 0x08, 0x03, 0x60, 0x06,
  0x01, 0x80, 0x36, 0x00, 0xC0, 0x18, 0x03, 0x60, 0x08, 0x01, 0x80, 0x34,
  0x01, 0x80, 0x18, 0x01, 0x40, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x00, 0x18,
  0x01, 0xC0, 0x10, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x30,
  0x01, 0x80, 0x1C, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x30, 0x01, 0x80, 0x1C,
  0x03, 0x00, 0x18, 0x03, 0xC0, 0x30, 0x01, 0x80, 0x3C, 0x03, 0x00, 0x38,
  0x03, 0xC0, 0x10, 0x03, 0x80, 0x24, 0x01, 0x80, 0x28, 0x06, 0x40, 0x18,
  0x06, 0x80, 0x66, 0x00, 0x80, 0x48, 0x0C, 0x60, 0x0C, 0x0C, 0xC0, 0xC6,
  0x00, 0x7F, 0x87, 0x78, 0x20, 0x03, 0xF0, 0x3E, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x40, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x05, 0x80, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x04, 0x60, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x04, 0x10, 0x00, 0x00, 0x83, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x06, 0x04, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x30, 0x18, 0x00, 0x06, 0x01,
  0x00, 0x00, 0x80, 0x20, 0x00, 0x10, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x08, 0x00, 0x10, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x02, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x00, 0x80, 0x40, 0x00, 0x18, 0x18, 0x00, 0x03, 0x03, 0x00,
  0x00, 0x60, 0x40, 0x00, 0x04, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18,
  0x60, 0x00, 0x01, 0x08, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0xC8, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30,
  0xFF, 0xFE, 0x03, 0x00, 0x3F, 0x0C, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0xC0,
  0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00,
  0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x04, 0xC0, 0x00, 0x33, 0x00,
  0x01, 0x8C, 0x00, 0x0C, 0x30, 0x01, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0C, 0x00, 0x0E, 0x30, 0x00, 0x1C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x2C, 0x00, 0x01, 0xB0,
  0x00, 0x0C, 0xC0, 0x00, 0x63, 0x00, 0x07, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xE0, 0x07, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0x80, 0x01, 0x00, 0xF0,
  0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xC0, 0xFF, 0xFC, 0x00, 0x60, 0x0F,
  0xC0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x06, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00, 0x06, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x00, 0x98, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x05, 0x80, 0x00, 0x02, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x02, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x01, 0x8C,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xE1, 0x80, 0x00, 0xE0,
  0xC0, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xB0, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x03, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x30,
  0xC0, 0x00, 0x03, 0x06, 0x00, 0x00, 0x30, 0x30, 0x00, 0x03, 0x01, 0xC0,
  0x00, 0x30, 0x0F, 0x80, 0x3F, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x1F, 0xF0, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x68, 0x1D, 0xFF, 0x1F, 0x80, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0xCC,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0xC0, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x0C, 0x01, 0xC0,
  0x30, 0x06, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00, 0x30,
  0x30, 0x00, 0xC1, 0x80, 0x03, 0x0E, 0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0,
  0x00, 0xCD, 0x80, 0x03, 0x36, 0x00, 0x0D, 0x8C, 0x00, 0x3C, 0x30, 0x00,
  0xE0, 0x60, 0x03, 0x80, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x30, 0x00, 0x60, 0xC0, 0x00, 0xC3,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xD0, 0x00, 0x00, 0x06, 0xF6, 0x00, 0x00, 0x01, 0xBD,
  0x80, 0x00, 0x00, 0x6F, 0x20, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00, 0x0C,
  0xF3, 0x00, 0x00, 0x03, 0x3C, 0x40, 0x00, 0x01, 0x8F, 0x18, 0x00, 0x00,
  0x63, 0xC6, 0x00, 0x00, 0x18, 0xF0, 0x80, 0x00, 0x0C, 0x3C, 0x30, 0x00,
  0x03, 0x0F, 0x0C, 0x00, 0x00, 0xC3, 0xC1, 0x00, 0x00, 0x60, 0xF0, 0x60,
  0x00, 0x18, 0x3C, 0x18, 0x00, 0x06, 0x0F, 0x02, 0x00, 0x03, 0x03, 0xC0,
  0xC0, 0x00, 0xC0, 0xF0, 0x30, 0x00, 0x30, 0x3C, 0x04, 0x00, 0x18, 0x0F,
  0x01, 0x80, 0x06, 0x03, 0xC0, 0x60, 0x01, 0x80, 0xF0, 0x08, 0x00, 0xC0,
  0x3C, 0x03, 0x00, 0x30, 0x0F, 0x00, 0xC0, 0x08, 0x03, 0xC0, 0x10, 0x06,
  0x00, 0xF0, 0x06, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x40, 0x0F, 0x00, 0x20,
  0x30, 0x03, 0xC0, 0x0C, 0x0C, 0x00, 0xF0, 0x03, 0x02, 0x00, 0x3C, 0x00,
  0x41, 0x80, 0x0F, 0x00, 0x18, 0x60, 0x03, 0xC0, 0x06, 0x10, 0x00, 0xF0,
  0x00, 0x8C, 0x00, 0x3C, 0x00, 0x33, 0x00, 0x0F, 0x00, 0x0C, 0x80, 0x03,
  0xC0, 0x01, 0x60, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x0F,
  0x20, 0x00, 0x07, 0x98, 0x00, 0x03, 0xC6, 0x00, 0x01, 0xE3, 0x00, 0x00,
  0xF0, 0xC0, 0x00, 0x78, 0x60, 0x00, 0x3C, 0x18, 0x00, 0x1E, 0x0C, 0x00,
  0x0F, 0x03, 0x00, 0x07, 0x81, 0x80, 0x03, 0xC0, 0x60, 0x01, 0xE0, 0x30,
  0x00, 0xF0, 0x0C, 0x00, 0x78, 0x06, 0x00, 0x3C, 0x01, 0x80, 0x1E, 0x00,
  0xC0, 0x0F, 0x00, 0x30, 0x07, 0x80, 0x18, 0x03, 0xC0, 0x06, 0x01, 0xE0,
  0x03, 0x00, 0xF0, 0x00, 0xC0, 0x78, 0x00, 0x60, 0x3C, 0x00, 0x18, 0x1E,
  0x00, 0x0C, 0x0F, 0x00, 0x03, 0x07, 0x80, 0x00, 0x83, 0xC0, 0x00, 0x61,
  0xE0, 0x00, 0x10, 0xF0, 0x00, 0x0C, 0x78, 0x00, 0x02, 0x3C, 0x00, 0x01,
  0x9E, 0x00, 0x00, 0x4F, 0x00, 0x00, 0x37, 0x80, 0x00, 0x0B, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06,
  0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x41, 0x00, 0x00, 0x03, 0x18,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x44, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x14, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x05, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xC2, 0x00, 0x00,
  0x06, 0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x70, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF8,
  0x0C, 0x03, 0xF0, 0xC0, 0x03, 0x8C, 0x00, 0x0C, 0xC0, 0x00, 0x6C, 0x00,
  0x06, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0xCC, 0x00, 0x18, 0xC0, 0x07, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x70, 0x07, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x41, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0x44, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x02, 0xC0, 0x00,
  0x00, 0x14, 0x00, 0x00, 0x00, 0xA0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x28, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00,
  0x0B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0xC2, 0x00,
  0x00, 0x06, 0x18, 0x00, 0x00, 0x60, 0x40, 0x00, 0x03, 0x03, 0x00, 0x00,
  0x30, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0xFF,
  0xF8, 0x03, 0x00, 0xFC, 0x0C, 0x00, 0x38, 0x30, 0x00, 0x30, 0xC0, 0x00,
  0x63, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x13,
  0x00, 0x00, 0x4C, 0x00, 0x01, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00,
  0x00, 0x4C, 0x00, 0x03, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00,
  0x8C, 0x00, 0x06, 0x30, 0x00, 0x30, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0x80, 0x1C, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x20, 0x00, 0x71, 0xE0, 0x0F, 0x07, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x07, 0x00, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x34, 0x00,
  0x00, 0x0D, 0x80, 0x00, 0x02, 0x60, 0x00, 0x01, 0x88, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x10, 0xC0, 0x00, 0x04, 0x30, 0x00, 0x03, 0x04, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x20, 0x60, 0x00, 0x18, 0x08, 0x00, 0x06, 0x02, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x40, 0x30, 0x00, 0x30, 0x04, 0x00, 0x0C, 0x01,
  0x00, 0x02, 0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x02, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0xC0, 0x01, 0x00,
  0x20, 0x00, 0x60, 0x08, 0x00, 0x18, 0x06, 0x00, 0x02, 0x01, 0x80, 0x00,
  0x80, 0x40, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x0C, 0x00, 0x01, 0x03, 0x00,
  0x00, 0x60, 0x80, 0x00, 0x18, 0x60, 0x00, 0x02, 0x18, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x31, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x30, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x60, 0x00, 0x1E, 0x00, 0x00, 0x98, 0x00, 0x07, 0x80, 0x00, 0x66, 0x00,
  0x01, 0x20, 0x00, 0x18, 0x80, 0x00, 0xCC, 0x00, 0x06, 0x30, 0x00, 0x33,
  0x00, 0x01, 0x0C, 0x00, 0x0C, 0xC0, 0x00, 0xC3, 0x00, 0x03, 0x30, 0x00,
  0x30, 0x40, 0x00, 0x84, 0x00, 0x0C, 0x10, 0x00, 0x61, 0x80, 0x02, 0x06,
  0x00, 0x18, 0x60, 0x01, 0x81, 0x80, 0x06, 0x18, 0x00, 0x60, 0x60, 0x01,
  0x02, 0x00, 0x18, 0x08, 0x00, 0x40, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x30,
  0x01, 0x00, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x30, 0x03, 0x03, 0x00, 0x30,
  0x04, 0x00, 0x80, 0x40, 0x0C, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x18, 0x06, 0x01, 0x80, 0x60, 0x02, 0x01, 0x00,
  0x20, 0x18, 0x00, 0x80, 0x40, 0x0C, 0x04, 0x00, 0x30, 0x30, 0x03, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x30, 0x30, 0x00,
  0x40, 0x80, 0x04, 0x08, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00, 0x06, 0x18,
  0x00, 0x61, 0x80, 0x01, 0x86, 0x00, 0x18, 0x60, 0x00, 0x21, 0x00, 0x02,
  0x10, 0x00, 0x0C, 0x40, 0x00, 0xC4, 0x00, 0x03, 0x30, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x0C, 0xC0, 0x00, 0x13, 0x00, 0x03, 0x30, 0x00, 0x04,
  0x80, 0x00, 0x48, 0x00, 0x01, 0xA0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x06, 0x20, 0x00, 0x08,
  0x60, 0x00, 0x30, 0x40, 0x00, 0x40, 0xC0, 0x01, 0x81, 0x80, 0x02, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x04,
  0x03, 0x00, 0x0C, 0x06, 0x00, 0x08, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x40, 0x00, 0x31, 0x80, 0x00, 0x62, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x26, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x0C, 0x00,
  0x06, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x30, 0x01,
  0x80, 0x60, 0x03, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x60,
  0x01, 0x80, 0xC0, 0x03, 0x03, 0x00, 0x03, 0x06, 0x00, 0x06, 0x18, 0x00,
  0x04, 0x30, 0x00, 0x0C, 0x40, 0x00, 0x09, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x06, 0x80, 0x00, 0x09, 0x80, 0x00, 0x33, 0x00, 0x00,
  0x63, 0x00, 0x01, 0x86, 0x00, 0x03, 0x04, 0x00, 0x04, 0x0C, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x20, 0x02, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x00, 0xC0, 0x20, 0x01, 0x80, 0xC0, 0x01,
  0x01, 0x00, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x10, 0x00, 0x0C,
  0x60, 0x00, 0x08, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00, 0x28,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x34, 0x00, 0x00, 0x26,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x43, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x81,
  0x80, 0x01, 0x81, 0x80, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x07, 0xFC, 0x07, 0xC3, 0x83, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x7C, 0x07,
  0xFF, 0x07, 0x80, 0xC7, 0x00, 0x33, 0x00, 0x0D, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xD0, 0x00, 0xB6, 0x00, 0x6C, 0xE0,
  0x73, 0x1F, 0xF0, 0x40, 0x70, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x07, 0xF8, 0x10, 0xF0, 0xE0,
  0x8C, 0x01, 0xC4, 0xC0, 0x06, 0x2C, 0x00, 0x19, 0x40, 0x00, 0x4A, 0x00,
  0x03, 0x70, 0x00, 0x1B, 0x00, 0x00, 0x58, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x58, 0x00, 0x06, 0xE0, 0x00, 0x35, 0x00, 0x03, 0x2C, 0x00, 0x19, 0x20,
  0x01, 0x89, 0x80, 0x18, 0x47, 0x03, 0x82, 0x0F, 0xF8, 0x00, 0x0E, 0x00,
  0x00, 0xFF, 0x80, 0xF8, 0x70, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0x01, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x1F, 0xE0, 0xC1, 0xE1,
  0xE3, 0x0E, 0x01, 0xCC, 0x70, 0x01, 0x31, 0x80, 0x06, 0xCC, 0x00, 0x0F,
  0x30, 0x00, 0x1D, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x40,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1C, 0xC0, 0x00,
  0xF3, 0x00, 0x02, 0xC6, 0x00, 0x1B, 0x1C, 0x00, 0xCC, 0x3C, 0x0E, 0x30,
  0x3F, 0xE0, 0xC0, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x78, 0xF0, 0x0E, 0x01,
  0x81, 0xC0, 0x0C, 0x18, 0x00, 0x43, 0x00, 0x06, 0x30, 0x00, 0x26, 0x00,
  0x03, 0x60, 0x00, 0x36, 0x00, 0x03, 0x40, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x40, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x20, 0x70,
  0x0E, 0x01, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0xFF, 0x01, 0x82, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x01, 0xFE, 0x08, 0x3E, 0x3C, 0x43, 0x80, 0x32,
  0x30, 0x00, 0xD1, 0x80, 0x02, 0x98, 0x00, 0x1C, 0x80, 0x00, 0x6C, 0x00,
  0x03, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x68, 0x00, 0x03, 0x40, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x0E, 0x60, 0x00, 0x53, 0x00, 0x06, 0x8C, 0x00, 0x24, 0x30,
  0x03, 0x20, 0xE0, 0x71, 0x03, 0xFE, 0x08, 0x03, 0x80, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xC4,
  0x00, 0x0E, 0x38, 0x00, 0xE0, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0xFF, 0x04, 0x3C, 0x78,
  0x8C, 0x03, 0x93, 0x00, 0x32, 0xC0, 0x03, 0x50, 0x00, 0x6E, 0x00, 0x05,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x7F, 0xB0, 0x00, 0x00, 0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x03, 0x07, 0x07, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x02, 0x02, 0x06, 0x06, 0xFC, 0xF8, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x0D, 0x00, 0x06, 0x80, 0x06, 0x40, 0x06, 0x20, 0x02, 0x10,
  0x03, 0x08, 0x03, 0x04, 0x03, 0x02, 0x01, 0x81, 0x01, 0x80, 0x81, 0x80,
  0x40, 0x80, 0x20, 0xC0, 0x10, 0xE0, 0x08, 0x70, 0x04, 0x6C, 0x02, 0x66,
  0x01, 0x61, 0x80, 0xA0, 0xC0, 0x70, 0x30, 0x30, 0x18, 0x10, 0x06, 0x08,
  0x03, 0x04, 0x00, 0xC2, 0x00, 0x61, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x03,
  0x20, 0x01, 0x90, 0x00, 0x68, 0x00, 0x34, 0x00, 0x0E, 0x00, 0x06, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x83, 0xF8, 0x07, 0xF8, 0x47, 0x0E, 0x07,
  0x0E, 0x26, 0x01, 0x86, 0x01, 0x92, 0x00, 0x66, 0x00, 0xCB, 0x00, 0x36,
  0x00, 0x35, 0x00, 0x0A, 0x00, 0x1B, 0x00, 0x07, 0x00, 0x05, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x83, 0xFC,
  0x10, 0xE0, 0xE2, 0x30, 0x0E, 0x4C, 0x00, 0xCB, 0x00, 0x0D, 0x40, 0x01,
  0xB8, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x01, 0xFE, 0x00, 0x1E, 0x1E, 0x00, 0xE0,
  0x0C, 0x06, 0x00, 0x18, 0x10, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x01,
  0x98, 0x00, 0x06, 0x60, 0x00, 0x09, 0x00, 0x00, 0x24, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x60,
  0x00, 0x09, 0x80, 0x00, 0x62, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x30, 0x00,
  0x30, 0x60, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0xC0, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x81, 0xFE, 0x04, 0x3C, 0x38, 0x23, 0x00, 0x61, 0x30,
  0x01, 0x89, 0x00, 0x06, 0x58, 0x00, 0x12, 0x80, 0x00, 0xDC, 0x00, 0x06,
  0xC0, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xA8,
  0x00, 0x0D, 0x40, 0x00, 0x4B, 0x00, 0x06, 0x4C, 0x00, 0x62, 0x70, 0x06,
  0x11, 0xE0, 0xE0, 0x83, 0xFE, 0x04, 0x03, 0x00, 0x20, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x08, 0x3C, 0x3C,
  0x43, 0x80, 0x72, 0x38, 0x00, 0x91, 0x80, 0x06, 0x98, 0x00, 0x14, 0xC0,
  0x00, 0x6C, 0x00, 0x03, 0x60, 0x00, 0x1A, 0x00, 0x00, 0xD0, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x28, 0x00, 0x03, 0x40, 0x00,
  0x1B, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0x60, 0x00, 0x53, 0x00, 0x06, 0x8C,
  0x00, 0x24, 0x30, 0x06, 0x20, 0xE0, 0x71, 0x03, 0xFE, 0x08, 0x03, 0x80,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x83,
  0xFC, 0x39, 0xA3, 0x01, 0x30, 0x09, 0x00, 0x58, 0x02, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x03, 0xC3, 0xE1, 0x80, 0x08,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x6C, 0x00, 0x33, 0xE0, 0x38, 0x3F, 0xFC, 0x00, 0xF0, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x7F,
  0xFF, 0xFF, 0xC2, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x00, 0xC1, 0x03, 0xF8, 0x06, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x16, 0xC0, 0x06, 0xDC, 0x01, 0x99, 0xC0, 0xE3, 0x1F,
  0xF8, 0x60, 0x30, 0x00, 0xC0, 0x00, 0x1A, 0x00, 0x01, 0x98, 0x00, 0x0C,
  0xC0, 0x00, 0x66, 0x00, 0x02, 0x10, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00,
  0x08, 0x10, 0x00, 0x40, 0x80, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x00,
  0x80, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04, 0x03,
  0x00, 0x30, 0x18, 0x01, 0x80, 0x80, 0x04, 0x0C, 0x00, 0x30, 0x60, 0x01,
  0x82, 0x00, 0x0C, 0x10, 0x00, 0x21, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x40,
  0x00, 0x26, 0x00, 0x01, 0x30, 0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x68, 0x00, 0x38, 0x00, 0x24,
  0x00, 0x16, 0x00, 0x13, 0x00, 0x0B, 0x00, 0x19, 0x80, 0x0C, 0x80, 0x0C,
  0xC0, 0x06, 0x40, 0x06, 0x20, 0x03, 0x30, 0x02, 0x18, 0x01, 0x18, 0x01,
  0x0C, 0x01, 0x84, 0x01, 0x86, 0x00, 0xC2, 0x00, 0xC1, 0x00, 0x61, 0x80,
  0x40, 0xC0, 0x20, 0xC0, 0x20, 0x60, 0x30, 0x20, 0x30, 0x30, 0x18, 0x10,
  0x18, 0x08, 0x0C, 0x0C, 0x08, 0x06, 0x04, 0x06, 0x04, 0x03, 0x06, 0x01,
  0x06, 0x01, 0x83, 0x00, 0x83, 0x00, 0x41, 0x80, 0x61, 0x80, 0x30, 0x80,
  0x30, 0x80, 0x18, 0xC0, 0x18, 0x40, 0x0C, 0x60, 0x04, 0x60, 0x02, 0x30,
  0x03, 0x30, 0x01, 0x10, 0x01, 0x90, 0x00, 0xD8, 0x00, 0xC8, 0x00, 0x6C,
  0x00, 0x2C, 0x00, 0x16, 0x00, 0x16, 0x00, 0x0A, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x36, 0x00, 0x06, 0x30, 0x00, 0x63, 0x00, 0x0C, 0x18, 0x00,
  0xC0, 0x80, 0x18, 0x0C, 0x01, 0x80, 0x40, 0x30, 0x06, 0x02, 0x00, 0x20,
  0x60, 0x03, 0x04, 0x00, 0x18, 0xC0, 0x01, 0x98, 0x00, 0x0D, 0x80, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xD8, 0x00,
  0x19, 0x80, 0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x06, 0x00, 0x60, 0x60,
  0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x81, 0x80, 0x08, 0x10, 0x00,
  0xC3, 0x00, 0x04, 0x20, 0x00, 0x66, 0x00, 0x02, 0xC0, 0x00, 0x30, 0x60,
  0x00, 0x0B, 0x00, 0x00, 0xC8, 0x00, 0x06, 0x60, 0x00, 0x23, 0x00, 0x03,
  0x18, 0x00, 0x18, 0x40, 0x00, 0x83, 0x00, 0x04, 0x18, 0x00, 0x60, 0x40,
  0x03, 0x03, 0x00, 0x10, 0x18, 0x01, 0x80, 0x40, 0x0C, 0x02, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC0, 0x30, 0x02, 0x01, 0x80, 0x18, 0x08, 0x00, 0xC0,
  0xC0, 0x02, 0x06, 0x00, 0x10, 0x20, 0x00, 0xC3, 0x00, 0x06, 0x18, 0x00,
  0x10, 0xC0, 0x00, 0xC4, 0x00, 0x06, 0x60, 0x00, 0x13, 0x00, 0x00, 0x90,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0xF0, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x38, 0x03,
  0xC0, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x78,
  0x01, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x70, 0x0F, 0xC0,
  0x1C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x70, 0x78, 0x03,
  0xC0, 0x1E, 0x0E, 0x80, 0x07, 0xFC, 0x00, 0x00, 0xE0,
};

const GFXglyph NotoSans_Condensed_Thin62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 44, 13, 5, -44 },
  { 18, 11, 16, 19, 4, -44 },
  { 40, 28, 44, 30, 1, -44 },
  { 194, 21, 51, 28, 3, -47 },
  { 328, 34, 46, 40, 3, -45 },
  { 524, 26, 46, 30, 3, -45 },
  { 674, 2, 16, 10, 4, -44 },
  { 678, 11, 54, 16, 3, -44 },
  { 753, 11, 54, 16, 2, -44 },
  { 828, 19, 18, 25, 3, -47 },
  { 871, 24, 28, 28, 2, -36 },
  { 955, 6, 15, 11, 2, -7 },
  { 967, 14, 2, 17, 2, -18 },
  { 971, 4, 4, 12, 4, -4 },
  { 973, 18, 44, 20, 1, -44 },
  { 1072, 21, 45, 28, 3, -45 },
  { 1191, 11, 44, 28, 5, -44 },
  { 1252, 21, 45, 28, 3, -45 },
  { 1371, 21, 46, 28, 3, -45 },
  { 1492, 26, 45, 28, 1, -45 },
  { 1639, 22, 45, 28, 3, -44 },
  { 1763, 22, 46, 28, 3, -45 },
  { 1890, 21, 44, 28, 3, -44 },
  { 2006, 22, 46, 28, 3, -45 },
  { 2133, 21, 46, 28, 3, -45 },
  { 2254, 4, 33, 12, 4, -33 },
  { 2271, 6, 41, 12, 2, -33 },
  { 2302, 24, 26, 28, 2, -35 },
  { 2380, 24, 14, 28, 2, -29 },
  { 2422, 24, 26, 28, 2, -35 },
  { 2500, 16, 45, 19, 1, -45 },
  { 2590, 36, 50, 42, 3, -44 },
  { 2815, 27, 44, 27, 0, -44 },
  { 2964, 22, 44, 30, 5, -44 },
  { 3085, 24, 46, 29, 4, -45 },
  { 3223, 25, 44, 33, 5, -44 },
  { 3361, 19, 44, 27, 5, -44 },
  { 3466, 19, 44, 24, 5, -44 },
  { 3571, 28, 46, 36, 4, -45 },
  { 3732, 24, 44, 34, 5, -44 },
  { 3864, 9, 44, 15, 3, -44 },
  { 3914, 11, 55, 12, -4, -44 },
  { 3990, 22, 44, 27, 5, -44 },
  { 4111, 18, 44, 24, 5, -44 },
  { 4210, 34, 44, 44, 5, -44 },
  { 4397, 25, 44, 35, 5, -44 },
  { 4535, 29, 46, 36, 4, -45 },
  { 4702, 20, 44, 28, 5, -44 },
  { 4812, 29, 56, 36, 4, -45 },
  { 5015, 22, 44, 28, 5, -44 },
  { 5136, 21, 46, 27, 3, -45 },
  { 5257, 24, 44, 24, 0, -44 },
  { 5389, 24, 45, 34, 5, -44 },
  { 5524, 26, 44, 26, 0, -44 },
  { 5667, 42, 44, 44, 1, -44 },
  { 5898, 23, 44, 24, 0, -44 },
  { 6025, 23, 44, 23, 0, -44 },
  { 6152, 21, 44, 25, 2, -44 },
  { 6268, 12, 54, 19, 5, -44 },
  { 6349, 18, 44, 20, 1, -44 },
  { 6448, 12, 54, 19, 2, -44 },
  { 6529, 24, 23, 28, 2, -44 },
  { 6598, 24, 1, 24, 0, 6 },
  { 6601, 10, 9, 14, 2, -47 },
  { 6613, 18, 34, 25, 3, -33 },
  { 6690, 21, 48, 29, 5, -47 },
  { 6816, 18, 34, 22, 3, -33 },
  { 6893, 22, 48, 29, 3, -47 },
  { 7025, 20, 34, 27, 3, -33 },
  { 7110, 16, 47, 14, 1, -47 },
  { 7204, 21, 48, 29, 3, -33 },
  { 7330, 19, 47, 28, 5, -47 },
  { 7442, 3, 45, 12, 4, -45 },
  { 7459, 8, 60, 12, -1, -45 },
  { 7519, 17, 47, 23, 5, -47 },
  { 7619, 1, 47, 11, 5, -47 },
  { 7625, 33, 33, 42, 5, -33 },
  { 7762, 19, 33, 28, 5, -33 },
  { 7841, 22, 34, 28, 3, -33 },
  { 7935, 21, 47, 29, 5, -33 },
  { 8059, 21, 47, 29, 3, -33 },
  { 8183, 13, 33, 18, 5, -33 },
  { 8237, 18, 34, 22, 2, -33 },
  { 8314, 13, 42, 15, 1, -41 },
  { 8383, 19, 34, 28, 5, -33 },
  { 8464, 21, 33, 21, 0, -33 },
  { 8551, 33, 33, 35, 1, -33 },
  { 8688, 20, 33, 23, 1, -33 },
  { 8771, 21, 48, 22, 0, -33 },
  { 8897, 16, 33, 20, 2, -33 },
  { 8963, 15, 54, 21, 3, -44 },
  { 9065, 2, 62, 26, 12, -47 },
  { 9081, 15, 54, 21, 3, -44 },
  { 9183, 24, 6, 28, 2, -25 },
};

const GFXfont NotoSans_Condensed_Thin62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_THIN62PT7B_H_
