#ifndef _NOTOSANS_CONDENSED_THIN43PT7B_H_
#define _NOTOSANS_CONDENSED_THIN43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin43pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x55, 0x00, 0x7C, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x08, 0x01, 0x01, 0x00, 0x20, 0x20,
  0x04, 0x08, 0x00, 0x81, 0x00, 0x10, 0x20, 0x02, 0x04, 0x00, 0x80, 0x80,
  0x10, 0x10, 0x02, 0x02, 0x00, 0x40, 0x41, 0xFF, 0xFF, 0x81, 0x02, 0x00,
  0x20, 0x40, 0x0C, 0x08, 0x01, 0x01, 0x00, 0x20, 0x20, 0x04, 0x04, 0x00,
  0x81, 0x80, 0x10, 0x20, 0x02, 0x04, 0x0F, 0xFF, 0xFC, 0x10, 0x10, 0x02,
  0x02, 0x00, 0x40, 0x40, 0x08, 0x08, 0x01, 0x02, 0x00, 0x20, 0x40, 0x04,
  0x08, 0x01, 0x01, 0x00, 0x20, 0x20, 0x04, 0x04, 0x00, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0xFF, 0x83, 0x10, 0xCC, 0x20, 0x30, 0x40, 0x40, 0x80,
  0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x08, 0x20, 0x18,
  0x40, 0x0C, 0x80, 0x0D, 0x00, 0x07, 0x00, 0x07, 0x80, 0x09, 0x80, 0x10,
  0x80, 0x20, 0x80, 0x41, 0x80, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x30, 0x10, 0x40, 0x21, 0xB0, 0x4C, 0x1F, 0xF0, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x1E, 0x00, 0x40, 0x46, 0x00, 0x81, 0x04,
  0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x41, 0x80, 0x80, 0x82, 0x01, 0x01, 0x04, 0x02, 0x02, 0x10,
  0x04, 0x04, 0x20, 0x08, 0x08, 0xC7, 0x10, 0x11, 0x11, 0x90, 0x22, 0x41,
  0x20, 0x48, 0x83, 0x41, 0x13, 0x02, 0x46, 0x64, 0x04, 0x78, 0x88, 0x08,
  0x01, 0x10, 0x10, 0x04, 0x20, 0x20, 0x08, 0x40, 0x40, 0x30, 0x80, 0x80,
  0x41, 0x01, 0x00, 0x82, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x18,
  0x08, 0x10, 0x20, 0x10, 0x40, 0x40, 0x30, 0x81, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x02, 0x18, 0x01, 0x02, 0x00, 0x40, 0x40, 0x30, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x40, 0x40, 0x10, 0x10, 0x04, 0x08, 0x01, 0x82, 0x00,
  0x21, 0x00, 0x0C, 0xC0, 0x01, 0x40, 0x00, 0x60, 0x00, 0x2C, 0x00, 0x11,
  0x00, 0x08, 0x20, 0x04, 0x0C, 0x0B, 0x01, 0x02, 0x80, 0x20, 0xA0, 0x0C,
  0x28, 0x01, 0x12, 0x00, 0x24, 0x80, 0x07, 0x20, 0x01, 0x88, 0x00, 0x63,
  0x00, 0x34, 0x40, 0x19, 0x8C, 0x0C, 0x21, 0xFC, 0x04, 0xFF, 0xE0, 0x03,
  0x06, 0x04, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40,
  0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0,
  0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x04, 0x06,
  0x03, 0x80, 0x81, 0x81, 0x03, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20,
  0x60, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x10, 0x00, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x71, 0x1C, 0x7F, 0x00, 0x40,
  0x05, 0x00, 0x64, 0x02, 0x10, 0x20, 0x82, 0x02, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x24, 0xB4, 0x96, 0x92, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x10, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x00, 0x07, 0xC0, 0x10, 0x60,
  0x40, 0x61, 0x80, 0x42, 0x00, 0xCC, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40,
  0x04, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x28,
  0x00, 0xD0, 0x01, 0xA0, 0x02, 0x40, 0x04, 0xC0, 0x08, 0x80, 0x31, 0x80,
  0x41, 0x01, 0x81, 0x06, 0x01, 0xF8, 0x00, 0x02, 0x0C, 0x28, 0x96, 0x38,
  0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x80, 0x0F,
  0xC0, 0xE0, 0x61, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xC0,
  0xE0, 0x63, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0xF0, 0x0F, 0xE0, 0x00, 0x30, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x98, 0x06, 0x1F, 0xF8, 0x00, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x12, 0x00, 0x04,
  0x80, 0x02, 0x20, 0x01, 0x88, 0x00, 0x42, 0x00, 0x30, 0x80, 0x08, 0x20,
  0x04, 0x08, 0x01, 0x02, 0x00, 0x80, 0x80, 0x60, 0x20, 0x10, 0x08, 0x0C,
  0x02, 0x02, 0x00, 0x81, 0x80, 0x20, 0x40, 0x08, 0x20, 0x02, 0x0F, 0xFF,
  0xFC, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x3F, 0xF8, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0F, 0xFC, 0x18, 0x0C, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60,
  0x01, 0x98, 0x06, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x0E, 0x08, 0x30, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x3C, 0x19, 0x86, 0x34, 0x02, 0x70, 0x02,
  0xE0, 0x05, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x80, 0x11, 0x00, 0x23, 0x00,
  0xC3, 0x03, 0x03, 0xFC, 0x00, 0x80, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x30, 0x60, 0x80, 0x23, 0x00,
  0x24, 0x00, 0x48, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x04, 0x80, 0x08,
  0x80, 0x31, 0x80, 0xC1, 0x83, 0x00, 0xC8, 0x00, 0xE0, 0x03, 0x60, 0x08,
  0x20, 0x60, 0x31, 0x80, 0x32, 0x00, 0x2C, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0A, 0x00, 0x26, 0x00, 0xC6,
  0x03, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x30, 0x40, 0x80, 0x42, 0x00, 0x44,
  0x00, 0x98, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xD0, 0x01, 0xA0, 0x05, 0x20, 0x1A,
  0x60, 0x6C, 0x3F, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x6D, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x92, 0xDA, 0x5A, 0x48, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x3F, 0x18, 0x30, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x03, 0x00,
  0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x04, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x30, 0x06, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x01, 0x00,
  0xC0, 0x00, 0x40, 0x40, 0x00, 0x30, 0x40, 0x00, 0x08, 0x60, 0x00, 0x02,
  0x20, 0x00, 0x01, 0x10, 0x07, 0xC0, 0x98, 0x0C, 0x30, 0x28, 0x0C, 0x18,
  0x14, 0x04, 0x0C, 0x0A, 0x04, 0x04, 0x07, 0x02, 0x02, 0x03, 0x83, 0x01,
  0x01, 0xC1, 0x80, 0x80, 0xC0, 0x80, 0x40, 0x60, 0x40, 0x20, 0x30, 0x20,
  0x10, 0x18, 0x10, 0x08, 0x0E, 0x0C, 0x0C, 0x07, 0x02, 0x06, 0x04, 0x81,
  0x02, 0x82, 0x40, 0x42, 0x42, 0x20, 0x1E, 0x1E, 0x18, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x06, 0x00, 0x20, 0x01, 0xC0, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x40, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0A,
  0x00, 0x02, 0x20, 0x00, 0x44, 0x00, 0x08, 0x80, 0x02, 0x18, 0x00, 0x41,
  0x00, 0x08, 0x20, 0x01, 0x04, 0x00, 0x40, 0xC0, 0x08, 0x08, 0x01, 0x01,
  0x00, 0x60, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x3F, 0xF8, 0x08, 0x01,
  0x81, 0x00, 0x10, 0x20, 0x02, 0x0C, 0x00, 0x41, 0x00, 0x04, 0x20, 0x00,
  0x84, 0x00, 0x11, 0x00, 0x03, 0x20, 0x00, 0x24, 0x00, 0x05, 0x80, 0x00,
  0xA0, 0x00, 0x18, 0xFF, 0x01, 0x03, 0xE2, 0x00, 0x64, 0x00, 0x48, 0x00,
  0x50, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x14,
  0x00, 0x48, 0x01, 0x90, 0x06, 0x3F, 0xF0, 0x40, 0x70, 0x80, 0x19, 0x00,
  0x1A, 0x00, 0x14, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x14, 0x00, 0x68, 0x01, 0x90, 0x0E, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x01, 0xC0, 0xC1, 0x80, 0x01, 0x00, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x04, 0x07, 0xFE, 0xFE, 0x00, 0x41, 0xF0,
  0x20, 0x0C, 0x10, 0x01, 0x08, 0x00, 0x44, 0x00, 0x32, 0x00, 0x09, 0x00,
  0x06, 0x80, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x28, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x05, 0x00, 0x06, 0x80,
  0x02, 0x40, 0x03, 0x20, 0x01, 0x10, 0x01, 0x08, 0x01, 0x04, 0x07, 0x03,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF,
  0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x18, 0x07, 0x06, 0x00, 0x10, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x40, 0x00, 0x12, 0x00, 0x01,
  0x20, 0x00, 0x13, 0x00, 0x01, 0x10, 0x00, 0x10, 0x80, 0x01, 0x04, 0x00,
  0x10, 0x30, 0x03, 0x00, 0xFF, 0xC0, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFC, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x4F, 0xC0, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0xFC, 0x10, 0x80,
  0x05, 0x00, 0x12, 0x00, 0x64, 0x00, 0x88, 0x02, 0x10, 0x0C, 0x20, 0x30,
  0x40, 0x40, 0x81, 0x01, 0x06, 0x02, 0x18, 0x04, 0x20, 0x08, 0xC0, 0x13,
  0x00, 0x26, 0x00, 0x52, 0x00, 0xC4, 0x01, 0x84, 0x02, 0x0C, 0x04, 0x08,
  0x08, 0x18, 0x10, 0x10, 0x20, 0x10, 0x40, 0x20, 0x80, 0x21, 0x00, 0x62,
  0x00, 0x44, 0x00, 0xC8, 0x00, 0x90, 0x00, 0xA0, 0x01, 0x80, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x2E, 0x00, 0x00, 0x5A, 0x00, 0x00, 0xB4,
  0x00, 0x02, 0x68, 0x00, 0x04, 0xC8, 0x00, 0x09, 0x90, 0x00, 0x23, 0x20,
  0x00, 0x46, 0x20, 0x00, 0x8C, 0x40, 0x02, 0x18, 0x80, 0x04, 0x30, 0x80,
  0x08, 0x61, 0x00, 0x20, 0xC2, 0x00, 0x41, 0x82, 0x00, 0x83, 0x04, 0x02,
  0x06, 0x08, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x20, 0x30, 0x20, 0x40,
  0x60, 0x20, 0x80, 0xC0, 0x42, 0x01, 0x80, 0x84, 0x03, 0x00, 0x88, 0x06,
  0x01, 0x20, 0x0C, 0x02, 0x40, 0x18, 0x02, 0x80, 0x30, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0x80, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3A,
  0x00, 0x1D, 0x80, 0x0E, 0x40, 0x07, 0x30, 0x03, 0x88, 0x01, 0xC6, 0x00,
  0xE1, 0x00, 0x70, 0xC0, 0x38, 0x20, 0x1C, 0x18, 0x0E, 0x04, 0x07, 0x03,
  0x03, 0x80, 0x81, 0xC0, 0x60, 0xE0, 0x10, 0x70, 0x0C, 0x38, 0x02, 0x1C,
  0x01, 0x8E, 0x00, 0x47, 0x00, 0x13, 0x80, 0x09, 0xC0, 0x02, 0xE0, 0x01,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x01, 0xFC, 0x00,
  0x38, 0x18, 0x03, 0x00, 0x60, 0x30, 0x01, 0x81, 0x00, 0x04, 0x10, 0x00,
  0x10, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40, 0x00, 0x12, 0x00, 0x00, 0x90,
  0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80,
  0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09, 0x00, 0x00, 0x4C, 0x00, 0x02,
  0x20, 0x00, 0x21, 0x00, 0x01, 0x04, 0x00, 0x18, 0x30, 0x00, 0x80, 0xC0,
  0x08, 0x03, 0x01, 0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x02, 0x0F, 0x08, 0x03,
  0x20, 0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x68, 0x01, 0x20, 0x0C, 0x81,
  0xC3, 0xF8, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x38, 0x18, 0x03, 0x00, 0x60, 0x30, 0x01,
  0x81, 0x00, 0x04, 0x10, 0x00, 0x10, 0x80, 0x00, 0x8C, 0x00, 0x06, 0x40,
  0x00, 0x12, 0x00, 0x00, 0x90, 0x00, 0x04, 0x80, 0x00, 0x24, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x24, 0x00, 0x01, 0x20, 0x00, 0x09,
  0x00, 0x00, 0x4C, 0x00, 0x02, 0x20, 0x00, 0x21, 0x00, 0x01, 0x04, 0x00,
  0x18, 0x30, 0x00, 0x80, 0xC0, 0x08, 0x03, 0x01, 0x80, 0x0F, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0xFE, 0x01, 0x07, 0x82, 0x00, 0xC4,
  0x00, 0xC8, 0x00, 0x90, 0x01, 0x20, 0x02, 0x40, 0x06, 0x80, 0x0D, 0x00,
  0x1A, 0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x02, 0x20, 0x0C, 0x40, 0x30,
  0xFF, 0x81, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x08, 0x20,
  0x10, 0x40, 0x10, 0x80, 0x21, 0x00, 0x22, 0x00, 0x44, 0x00, 0x48, 0x00,
  0x90, 0x00, 0xA0, 0x01, 0x80, 0x07, 0xF0, 0x30, 0x18, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x90,
  0x06, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x40, 0x00, 0xA0,
  0x00, 0x50, 0x00, 0x64, 0x00, 0x23, 0x00, 0x30, 0xC0, 0x30, 0x1F, 0xE0,
  0x80, 0x00, 0x60, 0x00, 0x14, 0x00, 0x0D, 0x00, 0x02, 0x40, 0x00, 0x98,
  0x00, 0x22, 0x00, 0x18, 0x80, 0x04, 0x20, 0x01, 0x04, 0x00, 0x41, 0x00,
  0x20, 0x40, 0x08, 0x10, 0x02, 0x02, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10,
  0x0C, 0x04, 0x01, 0x03, 0x00, 0x40, 0x80, 0x10, 0x20, 0x02, 0x08, 0x00,
  0x84, 0x00, 0x21, 0x00, 0x08, 0x40, 0x01, 0x30, 0x00, 0x48, 0x00, 0x12,
  0x00, 0x06, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x24, 0x00, 0x50, 0x01, 0x20, 0x02, 0x80, 0x09, 0x00, 0x34, 0x00, 0xC8,
  0x01, 0x20, 0x04, 0x60, 0x09, 0x80, 0x21, 0x00, 0x44, 0x01, 0x08, 0x06,
  0x20, 0x08, 0x40, 0x21, 0x00, 0xC3, 0x01, 0x0C, 0x04, 0x08, 0x08, 0x20,
  0x20, 0x40, 0x41, 0x01, 0x02, 0x06, 0x08, 0x18, 0x10, 0x20, 0x40, 0x80,
  0x41, 0x03, 0x04, 0x02, 0x08, 0x08, 0x20, 0x10, 0xC0, 0x43, 0x00, 0x84,
  0x02, 0x10, 0x06, 0x20, 0x18, 0x80, 0x11, 0x00, 0x44, 0x00, 0x88, 0x02,
  0x60, 0x04, 0xC0, 0x12, 0x00, 0x34, 0x00, 0x90, 0x00, 0xA0, 0x06, 0x80,
  0x05, 0x00, 0x14, 0x00, 0x28, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x20, 0x02, 0x30, 0x02, 0x10, 0x06, 0x10,
  0x04, 0x08, 0x0C, 0x08, 0x08, 0x04, 0x18, 0x04, 0x10, 0x06, 0x10, 0x02,
  0x20, 0x03, 0x20, 0x01, 0x40, 0x01, 0x40, 0x00, 0x80, 0x00, 0x80, 0x01,
  0x40, 0x01, 0x40, 0x02, 0x20, 0x02, 0x20, 0x06, 0x30, 0x04, 0x10, 0x0C,
  0x18, 0x08, 0x08, 0x18, 0x08, 0x10, 0x04, 0x30, 0x04, 0x20, 0x06, 0x60,
  0x02, 0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40, 0x02, 0x40,
  0x02, 0x20, 0x04, 0x20, 0x04, 0x30, 0x0C, 0x10, 0x08, 0x10, 0x08, 0x08,
  0x10, 0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x04, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFE, 0x00, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80,
  0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x0C, 0x00, 0x40,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0xFF, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x0F, 0xFC, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x58, 0x00, 0x24, 0x00, 0x23,
  0x00, 0x10, 0x80, 0x10, 0x40, 0x08, 0x10, 0x08, 0x08, 0x04, 0x02, 0x04,
  0x01, 0x02, 0x00, 0x42, 0x00, 0x21, 0x00, 0x09, 0x00, 0x05, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x83, 0x06, 0x0C, 0x10, 0x20, 0x40, 0x1F, 0xC7, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x01, 0xF1, 0xE1, 0x30, 0x14, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x03, 0xC0, 0x34, 0x05, 0x3F, 0x90, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x1F, 0x84, 0xC1, 0x89, 0x00, 0x94, 0x01, 0xA8, 0x01,
  0x60, 0x02, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x2C, 0x00, 0x54, 0x01, 0xA8, 0x02, 0x4C, 0x08, 0x8F, 0xE0, 0x03, 0xF8,
  0x60, 0x84, 0x00, 0x60, 0x02, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x04, 0x3F, 0xC0,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x1F, 0x88, 0xC1, 0x93, 0x00,
  0xA4, 0x01, 0x58, 0x01, 0xA0, 0x03, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x05, 0x00, 0x0A, 0x00, 0x34, 0x00, 0x6C, 0x01, 0x48, 0x02, 0x88, 0x09,
  0x0F, 0xE2, 0x07, 0xC0, 0x60, 0xC3, 0x01, 0x08, 0x02, 0x60, 0x09, 0x00,
  0x14, 0x00, 0x50, 0x01, 0xC0, 0x06, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x20, 0xFF, 0x80, 0x03, 0xE0, 0xC4, 0x10, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x03, 0xFE, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x00, 0x07, 0xE2, 0x30, 0x64, 0xC0, 0x29, 0x00,
  0x34, 0x00, 0x68, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x40,
  0x06, 0x80, 0x0D, 0x00, 0x1B, 0x00, 0x52, 0x00, 0xA2, 0x02, 0x43, 0xF8,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40,
  0x00, 0x80, 0x02, 0x30, 0x0C, 0x3F, 0xE0, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x7C, 0x26, 0x0C, 0x90, 0x12, 0x80, 0x2A, 0x00, 0xB0, 0x02, 0xC0,
  0x0B, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0xF4, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0C, 0x30, 0x40, 0x00, 0x00, 0x00, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x20, 0x82, 0xF0, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x38, 0x02, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x10, 0x82, 0x08, 0x60, 0x84,
  0x08, 0xC0, 0x9C, 0x09, 0x60, 0xA2, 0x0C, 0x30, 0xC1, 0x08, 0x18, 0x80,
  0x88, 0x04, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x8F, 0x81, 0xF1, 0x30, 0xC4, 0x1A, 0xC0, 0x90, 0x15,
  0x00, 0xC0, 0x3C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x04, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x80, 0x87, 0xE2,
  0x60, 0xC9, 0x01, 0xA8, 0x02, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xB0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0xE0, 0x30, 0x60, 0xC0, 0x21, 0x00, 0x26, 0x00,
  0x48, 0x00, 0xD0, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x40, 0x02, 0x80,
  0x05, 0x00, 0x11, 0x00, 0x23, 0x00, 0x83, 0x03, 0x03, 0xF8, 0x00, 0x87,
  0xE1, 0x18, 0x62, 0x40, 0x25, 0x00, 0x6A, 0x00, 0x58, 0x00, 0xB0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0B, 0x00, 0x15, 0x00,
  0x6B, 0x00, 0x93, 0x02, 0x23, 0xF8, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x00, 0x07, 0xE2, 0x30, 0x64, 0xC0, 0x29, 0x00, 0x56, 0x00, 0x68, 0x00,
  0xD0, 0x01, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x06, 0x80, 0x0D, 0x00,
  0x1B, 0x00, 0x52, 0x00, 0xA3, 0x06, 0x43, 0xF8, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x87, 0xCC, 0x64, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x1F, 0xC3, 0x06, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x30, 0x02, 0x00,
  0x28, 0x04, 0xFF, 0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x07, 0xFC, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x08, 0x04, 0x03, 0xF0,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x06, 0x80, 0x34, 0x02, 0x90, 0x34,
  0x7E, 0x20, 0x80, 0x07, 0x00, 0x14, 0x00, 0xD0, 0x02, 0x40, 0x08, 0x80,
  0x22, 0x01, 0x08, 0x04, 0x30, 0x10, 0x40, 0xC1, 0x02, 0x04, 0x08, 0x08,
  0x20, 0x21, 0x00, 0x84, 0x03, 0x10, 0x04, 0xC0, 0x12, 0x00, 0x48, 0x00,
  0xA0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x10, 0x03, 0x00, 0x60,
  0x0A, 0x00, 0xC0, 0x14, 0x01, 0x40, 0x24, 0x02, 0x80, 0x48, 0x0D, 0x01,
  0x90, 0x12, 0x02, 0x20, 0x22, 0x04, 0x60, 0x44, 0x08, 0x41, 0x88, 0x10,
  0x82, 0x10, 0x41, 0x04, 0x10, 0x83, 0x08, 0x21, 0x02, 0x30, 0x42, 0x04,
  0x40, 0x88, 0x08, 0x80, 0x90, 0x19, 0x01, 0x20, 0x16, 0x02, 0x40, 0x28,
  0x05, 0x80, 0x50, 0x06, 0x00, 0xA0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00,
  0x30, 0x00, 0xC0, 0x09, 0x00, 0x26, 0x01, 0x08, 0x0C, 0x30, 0x20, 0x41,
  0x80, 0x84, 0x02, 0x30, 0x04, 0x80, 0x16, 0x00, 0x30, 0x00, 0xC0, 0x07,
  0x00, 0x16, 0x00, 0xC8, 0x02, 0x10, 0x18, 0x40, 0x40, 0x83, 0x02, 0x08,
  0x04, 0x40, 0x11, 0x00, 0x28, 0x00, 0xC0, 0x40, 0x02, 0x80, 0x09, 0x00,
  0x11, 0x00, 0x22, 0x00, 0xC4, 0x01, 0x0C, 0x02, 0x08, 0x04, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x40, 0x41, 0x80, 0x82, 0x01, 0x84, 0x01, 0x18, 0x02,
  0x20, 0x04, 0x40, 0x04, 0x80, 0x0A, 0x00, 0x14, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x60, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x04,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x80, 0x10,
  0x04, 0x00, 0x80, 0x3F, 0xF8, 0x00, 0x60, 0x70, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x03, 0x03, 0xC0, 0x78, 0x01, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x38, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x07, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x30, 0x02, 0x00, 0x40, 0x07, 0x80, 0xF0, 0x30, 0x04, 0x01, 0x80,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x07, 0x81, 0x80, 0x00, 0x3E, 0x01, 0xC3,
  0x01, 0x80, 0xEE, 0x00, 0x10,
};

const GFXglyph NotoSans_Condensed_Thin43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 31, 9, 3, -31 },
  { 9, 7, 11, 13, 3, -31 },
  { 19, 19, 31, 21, 1, -31 },
  { 93, 15, 36, 19, 2, -33 },
  { 161, 23, 31, 27, 2, -31 },
  { 251, 18, 31, 21, 2, -31 },
  { 321, 1, 11, 7, 3, -31 },
  { 323, 8, 38, 11, 2, -31 },
  { 361, 7, 38, 11, 2, -31 },
  { 395, 13, 13, 17, 2, -33 },
  { 417, 16, 20, 19, 2, -25 },
  { 457, 3, 11, 8, 2, -5 },
  { 462, 10, 1, 12, 1, -12 },
  { 464, 2, 3, 8, 3, -3 },
  { 465, 12, 31, 14, 1, -31 },
  { 512, 15, 31, 19, 2, -31 },
  { 571, 7, 31, 19, 4, -31 },
  { 599, 15, 31, 19, 2, -31 },
  { 658, 15, 31, 19, 2, -31 },
  { 717, 18, 31, 19, 1, -31 },
  { 787, 15, 31, 19, 2, -31 },
  { 846, 15, 32, 19, 2, -31 },
  { 906, 15, 31, 19, 2, -31 },
  { 965, 15, 31, 19, 2, -31 },
  { 1024, 15, 31, 19, 2, -31 },
  { 1083, 2, 23, 8, 3, -23 },
  { 1089, 3, 29, 8, 2, -23 },
  { 1100, 16, 18, 19, 2, -24 },
  { 1136, 16, 10, 19, 2, -20 },
  { 1156, 16, 18, 19, 2, -24 },
  { 1192, 11, 31, 13, 1, -31 },
  { 1235, 25, 35, 29, 2, -31 },
  { 1345, 19, 31, 19, 0, -31 },
  { 1419, 15, 31, 21, 4, -31 },
  { 1478, 17, 31, 20, 2, -31 },
  { 1544, 17, 31, 23, 4, -31 },
  { 1610, 12, 31, 19, 4, -31 },
  { 1657, 12, 31, 17, 4, -31 },
  { 1704, 20, 31, 25, 2, -31 },
  { 1782, 16, 31, 24, 4, -31 },
  { 1844, 6, 31, 10, 2, -31 },
  { 1868, 8, 39, 9, -3, -31 },
  { 1907, 15, 31, 19, 4, -31 },
  { 1966, 12, 31, 17, 4, -31 },
  { 2013, 23, 31, 30, 4, -31 },
  { 2103, 17, 31, 24, 4, -31 },
  { 2169, 21, 31, 25, 2, -31 },
  { 2251, 14, 31, 19, 4, -31 },
  { 2306, 21, 38, 25, 2, -31 },
  { 2406, 15, 31, 20, 4, -31 },
  { 2465, 15, 31, 19, 2, -31 },
  { 2524, 16, 31, 17, 0, -31 },
  { 2586, 17, 31, 24, 3, -31 },
  { 2652, 18, 31, 18, 0, -31 },
  { 2722, 29, 31, 31, 1, -31 },
  { 2835, 16, 31, 17, 0, -31 },
  { 2897, 16, 31, 16, 0, -31 },
  { 2959, 15, 31, 17, 1, -31 },
  { 3018, 8, 38, 13, 4, -31 },
  { 3056, 12, 31, 14, 1, -31 },
  { 3103, 9, 38, 13, 1, -31 },
  { 3146, 17, 16, 19, 1, -31 },
  { 3180, 17, 1, 17, 0, 4 },
  { 3183, 6, 7, 10, 2, -33 },
  { 3189, 12, 23, 18, 2, -23 },
  { 3224, 15, 33, 20, 3, -33 },
  { 3286, 13, 23, 16, 2, -23 },
  { 3324, 15, 33, 20, 2, -33 },
  { 3386, 14, 23, 18, 2, -23 },
  { 3427, 11, 33, 10, 0, -33 },
  { 3473, 15, 33, 20, 2, -23 },
  { 3535, 14, 33, 20, 3, -33 },
  { 3593, 2, 31, 8, 3, -31 },
  { 3601, 6, 41, 8, -1, -31 },
  { 3632, 12, 33, 16, 3, -33 },
  { 3682, 1, 33, 8, 3, -33 },
  { 3687, 23, 23, 29, 3, -23 },
  { 3754, 14, 23, 20, 3, -23 },
  { 3795, 15, 23, 20, 2, -23 },
  { 3839, 15, 33, 20, 3, -23 },
  { 3901, 15, 33, 20, 2, -23 },
  { 3963, 9, 23, 13, 3, -23 },
  { 3989, 12, 23, 15, 2, -23 },
  { 4024, 9, 28, 10, 1, -28 },
  { 4056, 13, 23, 20, 3, -23 },
  { 4094, 14, 23, 14, 0, -23 },
  { 4135, 23, 23, 24, 1, -23 },
  { 4202, 14, 23, 16, 1, -23 },
  { 4243, 15, 33, 15, 0, -23 },
  { 4305, 11, 23, 14, 1, -23 },
  { 4337, 11, 38, 15, 2, -31 },
  { 4390, 1, 44, 18, 9, -33 },
  { 4396, 11, 38, 15, 2, -31 },
  { 4449, 16, 4, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_Thin43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_THIN43PT7B_H_
