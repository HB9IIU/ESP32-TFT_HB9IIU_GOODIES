#ifndef _NOTOSANS_CONDENSED_THIN53PT7B_H_
#define _NOTOSANS_CONDENSED_THIN53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin53pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x00, 0x00, 0x7F, 0xC0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x00, 0x60, 0x30, 0x00, 0x40, 0x30,
  0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0x40, 0x20, 0x00, 0xC0, 0x20,
  0x00, 0xC0, 0x20, 0x00, 0x80, 0x60, 0x00, 0x80, 0x60, 0x00, 0x80, 0x40,
  0x00, 0x80, 0x40, 0x00, 0x80, 0x40, 0x3F, 0xFF, 0xFF, 0x01, 0x80, 0x40,
  0x01, 0x80, 0x40, 0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0, 0x01, 0x00, 0x80,
  0x01, 0x00, 0x80, 0x01, 0x00, 0x80, 0x03, 0x00, 0x80, 0x03, 0x00, 0x80,
  0x02, 0x01, 0x80, 0x02, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x02, 0x01, 0x00, 0x06, 0x01, 0x00, 0x06, 0x01, 0x00, 0x06, 0x01, 0x00,
  0x04, 0x03, 0x00, 0x04, 0x03, 0x00, 0x04, 0x02, 0x00, 0x04, 0x02, 0x00,
  0x0C, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x02, 0x00, 0x08, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x03, 0xFF, 0x01, 0xC4, 0x38,
  0x60, 0x81, 0x08, 0x10, 0x03, 0x02, 0x00, 0x40, 0x40, 0x18, 0x08, 0x03,
  0x01, 0x00, 0x60, 0x20, 0x0C, 0x04, 0x01, 0x80, 0x80, 0x10, 0x10, 0x03,
  0x02, 0x00, 0x20, 0x40, 0x03, 0x08, 0x00, 0x31, 0x00, 0x03, 0xA0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x17, 0x00, 0x02, 0x38, 0x00, 0x41, 0x80,
  0x08, 0x18, 0x01, 0x01, 0x00, 0x20, 0x30, 0x04, 0x06, 0x00, 0x80, 0xC0,
  0x10, 0x18, 0x02, 0x03, 0x00, 0x40, 0x60, 0x08, 0x08, 0x01, 0x03, 0x00,
  0x20, 0xCC, 0x04, 0x30, 0xF8, 0xBC, 0x03, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x1F, 0x00, 0x04, 0x03, 0x18,
  0x00, 0xC0, 0x60, 0xC0, 0x08, 0x04, 0x04, 0x01, 0x80, 0xC0, 0x40, 0x10,
  0x08, 0x06, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x02, 0x02, 0x00, 0x80,
  0x20, 0x60, 0x08, 0x02, 0x04, 0x00, 0x80, 0x20, 0x40, 0x08, 0x02, 0x0C,
  0x00, 0x80, 0x20, 0x80, 0x08, 0x02, 0x18, 0x00, 0x80, 0x21, 0x00, 0x08,
  0x02, 0x10, 0xF8, 0x80, 0x63, 0x18, 0xC8, 0x06, 0x23, 0x06, 0xC0, 0x46,
  0x20, 0x24, 0x04, 0x46, 0x02, 0x60, 0xC4, 0x60, 0x33, 0x18, 0xC4, 0x03,
  0x1F, 0x08, 0x40, 0x10, 0x01, 0x84, 0x01, 0x00, 0x10, 0x40, 0x10, 0x01,
  0x04, 0x01, 0x00, 0x30, 0x40, 0x10, 0x02, 0x04, 0x01, 0x00, 0x60, 0x40,
  0x10, 0x04, 0x04, 0x01, 0x00, 0x40, 0x40, 0x10, 0x0C, 0x04, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x08, 0x06, 0x02, 0x01, 0x80, 0x20, 0x20, 0x10, 0x03,
  0x06, 0x03, 0x00, 0x10, 0xC0, 0x20, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0C,
  0x18, 0x00, 0x30, 0x10, 0x00, 0x40, 0x30, 0x00, 0x80, 0x20, 0x01, 0x00,
  0x40, 0x06, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x08, 0x02, 0x00, 0x10, 0x04,
  0x00, 0x20, 0x18, 0x00, 0x60, 0x30, 0x00, 0x40, 0x40, 0x00, 0x81, 0x80,
  0x00, 0x86, 0x00, 0x01, 0x98, 0x00, 0x01, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x62, 0x00, 0x01, 0x86, 0x00, 0x06, 0x06, 0x00, 0x88,
  0x04, 0x01, 0x30, 0x0C, 0x06, 0x40, 0x0C, 0x08, 0x80, 0x08, 0x13, 0x00,
  0x08, 0x26, 0x00, 0x18, 0xCC, 0x00, 0x11, 0x18, 0x00, 0x16, 0x30, 0x00,
  0x38, 0x60, 0x00, 0x30, 0x40, 0x00, 0x60, 0xC0, 0x01, 0x61, 0x80, 0x06,
  0x61, 0x80, 0x18, 0x41, 0x80, 0xE0, 0xC1, 0xFF, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0xFF, 0xFC, 0x01, 0x01, 0x81, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x03, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x30,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x1C, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x18, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x08, 0x04,
  0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x81, 0x02, 0x71,
  0x1D, 0x0F, 0x60, 0x01, 0x80, 0x02, 0x80, 0x06, 0x40, 0x04, 0x60, 0x08,
  0x30, 0x10, 0x10, 0x30, 0x08, 0x20, 0x08, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x11, 0x33, 0x33, 0x26, 0x64,
  0x4C, 0x80, 0xFF, 0xE0, 0xFC, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x00, 0x07, 0xF8, 0x03, 0x07, 0x01, 0x80, 0x60,
  0x40, 0x08, 0x30, 0x03, 0x08, 0x00, 0x46, 0x00, 0x11, 0x00, 0x06, 0x40,
  0x00, 0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0x90, 0x00,
  0x24, 0x00, 0x19, 0x80, 0x04, 0x20, 0x01, 0x0C, 0x00, 0xC1, 0x00, 0x20,
  0x60, 0x18, 0x0E, 0x1C, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x70, 0x34, 0x19,
  0x0C, 0x4C, 0x16, 0x07, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xF8, 0x03, 0x81, 0xC1,
  0x80, 0x08, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0x01, 0xC1, 0x80, 0x0C, 0x60, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x40, 0x01, 0x8F, 0x00, 0xE0, 0x7F, 0xF0, 0x00, 0x20, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x05,
  0x80, 0x00, 0x36, 0x00, 0x00, 0x98, 0x00, 0x04, 0x60, 0x00, 0x31, 0x80,
  0x00, 0x86, 0x00, 0x06, 0x18, 0x00, 0x10, 0x60, 0x00, 0xC1, 0x80, 0x02,
  0x06, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x60, 0x02, 0x01, 0x80, 0x18, 0x06,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x80, 0x60, 0x06, 0x01,
  0x00, 0x18, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x08, 0x00,
  0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x06, 0x00, 0x7F, 0xF8, 0x18, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x04, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x32, 0x00, 0x18, 0xE0, 0x1C, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0xE0, 0x40, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x01, 0x00,
  0x00, 0x40, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x0F, 0xE0, 0x8E, 0x0E,
  0x26, 0x00, 0xCB, 0x00, 0x12, 0x80, 0x06, 0xC0, 0x00, 0xB0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x50, 0x00, 0x34, 0x00, 0x0D, 0x00, 0x03, 0x60, 0x00,
  0x88, 0x00, 0x63, 0x00, 0x10, 0x60, 0x0C, 0x0C, 0x06, 0x01, 0xFF, 0x00,
  0x0E, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00,
  0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0xC0, 0x60, 0x04, 0x08,
  0x00, 0x43, 0x00, 0x0C, 0x40, 0x00, 0x98, 0x00, 0x13, 0x00, 0x02, 0x60,
  0x00, 0x4C, 0x00, 0x08, 0x80, 0x01, 0x10, 0x00, 0x63, 0x00, 0x08, 0x30,
  0x03, 0x03, 0x00, 0xC0, 0x30, 0x30, 0x03, 0x98, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0x8E, 0x00, 0xE0, 0x60, 0x30, 0x06, 0x0C, 0x00, 0x61, 0x00,
  0x06, 0x60, 0x00, 0x48, 0x00, 0x0D, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0A, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00,
  0x08, 0xC0, 0x03, 0x0C, 0x00, 0xC0, 0xC0, 0x70, 0x0F, 0xF8, 0x00, 0x18,
  0x00, 0x07, 0xF8, 0x01, 0x81, 0x80, 0x60, 0x08, 0x18, 0x01, 0x82, 0x00,
  0x18, 0xC0, 0x01, 0x10, 0x00, 0x22, 0x00, 0x06, 0x40, 0x00, 0x58, 0x00,
  0x0B, 0x00, 0x01, 0x60, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x00, 0xF0, 0x00,
  0x1A, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x98, 0x00,
  0xB1, 0x00, 0x36, 0x18, 0x1C, 0x81, 0xFE, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x7F, 0xC0, 0x01, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x31, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x42, 0x31, 0x8C, 0x62, 0x31,
  0x88, 0x46, 0x20, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x00, 0x3F, 0xC3, 0x81, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00,
  0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x0E, 0x00, 0x30, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x08,
  0x0C, 0x00, 0x00, 0x18, 0x10, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x30,
  0x80, 0x00, 0x00, 0x23, 0x00, 0x1F, 0x80, 0x66, 0x00, 0xE1, 0x80, 0xC8,
  0x03, 0x01, 0x00, 0x90, 0x0C, 0x02, 0x01, 0x60, 0x10, 0x04, 0x02, 0xC0,
  0x60, 0x08, 0x07, 0x80, 0xC0, 0x30, 0x0E, 0x01, 0x00, 0x60, 0x1C, 0x02,
  0x00, 0xC0, 0x38, 0x0C, 0x01, 0x80, 0x70, 0x18, 0x03, 0x00, 0xE0, 0x30,
  0x06, 0x01, 0xC0, 0x60, 0x0C, 0x02, 0x80, 0xC0, 0x18, 0x05, 0x00, 0x80,
  0x30, 0x0B, 0x01, 0x00, 0xE0, 0x36, 0x02, 0x01, 0x40, 0x6C, 0x06, 0x02,
  0x80, 0x98, 0x04, 0x09, 0x83, 0x10, 0x0E, 0x71, 0x8C, 0x20, 0x07, 0x81,
  0xF0, 0x60, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0C, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xA0, 0x00, 0x01, 0x60, 0x00, 0x02, 0x40, 0x00, 0x0C,
  0x80, 0x00, 0x11, 0x00, 0x00, 0x23, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x04,
  0x00, 0x02, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x18, 0x10, 0x00, 0x20, 0x20,
  0x00, 0x40, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x80, 0x04, 0x01, 0x00,
  0x08, 0x03, 0x00, 0x30, 0x02, 0x00, 0x40, 0x04, 0x00, 0x80, 0x0C, 0x03,
  0xFF, 0xF8, 0x06, 0x00, 0x10, 0x08, 0x00, 0x20, 0x10, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0x80, 0x00, 0x81, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x02, 0x10, 0x00, 0x04, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0xFF, 0xF0,
  0x18, 0x1F, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x00,
  0xB0, 0x00, 0x16, 0x00, 0x02, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0x60, 0x00, 0x2C, 0x00, 0x05, 0x80, 0x01, 0xB0, 0x00, 0x26, 0x00, 0x0C,
  0xC0, 0x07, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x60, 0x03, 0x8C, 0x00, 0x19,
  0x80, 0x01, 0xB0, 0x00, 0x16, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x01, 0x8C,
  0x01, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0E, 0x01, 0xC0, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06,
  0x00, 0x00, 0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x3F, 0xF8, 0x00, 0x10, 0x00,
  0xFF, 0xE0, 0x03, 0x07, 0xF0, 0x0C, 0x00, 0x70, 0x30, 0x00, 0x60, 0xC0,
  0x00, 0xC3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00,
  0x33, 0x00, 0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x0B,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC, 0x00,
  0x02, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03, 0x0C, 0x00, 0x18,
  0x30, 0x01, 0xC0, 0xC0, 0x7C, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xE0, 0x0E, 0x03,
  0x80, 0x03, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x01, 0x40,
  0x00, 0x01, 0x40, 0x00, 0x01, 0x60, 0x00, 0x01, 0x20, 0x00, 0x01, 0x30,
  0x00, 0x01, 0x10, 0x00, 0x01, 0x18, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x06,
  0x00, 0x01, 0x03, 0x00, 0x01, 0x01, 0xC0, 0x0F, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x34, 0x3B,
  0xF0, 0xC0, 0x00, 0x58, 0x00, 0x1B, 0x00, 0x06, 0x60, 0x01, 0x8C, 0x00,
  0x21, 0x80, 0x0C, 0x30, 0x03, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18, 0x06,
  0x03, 0x01, 0x80, 0x60, 0x20, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x00, 0xC6, 0x00, 0x19, 0xC0, 0x03, 0x2C, 0x00, 0x6C, 0xC0,
  0x0F, 0x18, 0x01, 0xC1, 0x80, 0x30, 0x10, 0x06, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x03, 0x00, 0x40, 0x60, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x08,
  0x30, 0x01, 0x86, 0x00, 0x10, 0xC0, 0x03, 0x18, 0x00, 0x23, 0x00, 0x06,
  0x60, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x5D, 0x00, 0x00, 0x06, 0xE8, 0x00, 0x00, 0x37, 0x60, 0x00,
  0x01, 0x39, 0x00, 0x00, 0x19, 0xC8, 0x00, 0x00, 0xCE, 0x60, 0x00, 0x04,
  0x71, 0x00, 0x00, 0x63, 0x88, 0x00, 0x03, 0x1C, 0x60, 0x00, 0x10, 0xE1,
  0x00, 0x01, 0x87, 0x08, 0x00, 0x0C, 0x38, 0x60, 0x00, 0x41, 0xC1, 0x00,
  0x06, 0x0E, 0x08, 0x00, 0x30, 0x70, 0x60, 0x01, 0x03, 0x81, 0x00, 0x18,
  0x1C, 0x08, 0x00, 0xC0, 0xE0, 0x60, 0x04, 0x07, 0x01, 0x00, 0x60, 0x38,
  0x08, 0x02, 0x01, 0xC0, 0x60, 0x10, 0x0E, 0x01, 0x01, 0x80, 0x70, 0x08,
  0x08, 0x03, 0x80, 0x60, 0x40, 0x1C, 0x01, 0x06, 0x00, 0xE0, 0x08, 0x20,
  0x07, 0x00, 0x61, 0x00, 0x38, 0x01, 0x18, 0x01, 0xC0, 0x08, 0x80, 0x0E,
  0x00, 0x64, 0x00, 0x70, 0x01, 0x60, 0x03, 0x80, 0x0A, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x04, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x1D, 0x00, 0x00, 0xEC, 0x00, 0x07, 0x20, 0x00,
  0x39, 0x80, 0x01, 0xC4, 0x00, 0x0E, 0x30, 0x00, 0x70, 0x80, 0x03, 0x86,
  0x00, 0x1C, 0x10, 0x00, 0xE0, 0xC0, 0x07, 0x02, 0x00, 0x38, 0x18, 0x01,
  0xC0, 0x40, 0x0E, 0x03, 0x00, 0x70, 0x08, 0x03, 0x80, 0x60, 0x1C, 0x01,
  0x00, 0xE0, 0x0C, 0x07, 0x00, 0x20, 0x38, 0x01, 0x81, 0xC0, 0x04, 0x0E,
  0x00, 0x30, 0x70, 0x00, 0x83, 0x80, 0x06, 0x1C, 0x00, 0x10, 0xE0, 0x00,
  0x47, 0x00, 0x03, 0x38, 0x00, 0x09, 0xC0, 0x00, 0x6E, 0x00, 0x01, 0x70,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x00, 0xFF,
  0x80, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x03, 0x01, 0x80,
  0x00, 0xC0, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x18, 0x40, 0x00, 0x04, 0x60,
  0x00, 0x03, 0x30, 0x00, 0x01, 0x90, 0x00, 0x00, 0x48, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x90, 0x00, 0x00, 0x48, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18, 0x80, 0x00, 0x08, 0x60,
  0x00, 0x0C, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x06, 0x03, 0x00, 0x06, 0x00,
  0xC0, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0xFF, 0xC0, 0x30, 0x7E, 0x0C, 0x00, 0xE3, 0x00, 0x0C, 0xC0, 0x01, 0x30,
  0x00, 0x6C, 0x00, 0x0B, 0x00, 0x02, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xFF, 0xF8, 0x3F,
  0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xC0, 0x70, 0x01, 0x80, 0x0C, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x80, 0x00, 0x20, 0xC0, 0x00, 0x18,
  0x40, 0x00, 0x04, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x90, 0x00, 0x00,
  0x48, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x90,
  0x00, 0x00, 0x48, 0x00, 0x00, 0x26, 0x00, 0x00, 0x33, 0x00, 0x00, 0x18,
  0x80, 0x00, 0x08, 0x60, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x0E, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0xFF, 0xC0, 0x18, 0x7F, 0x83, 0x00, 0x38,
  0x60, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0x26, 0x00, 0x04,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x01, 0x30, 0x00, 0x26, 0x00, 0x0C, 0xC0, 0x01, 0x18, 0x00, 0x43,
  0x00, 0x38, 0x60, 0x3C, 0x0F, 0xFE, 0x01, 0x80, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0x80, 0xC0, 0x10, 0x18, 0x03, 0x03, 0x00, 0x20, 0x60, 0x06, 0x0C,
  0x00, 0x41, 0x80, 0x0C, 0x30, 0x00, 0x86, 0x00, 0x18, 0xC0, 0x01, 0x18,
  0x00, 0x33, 0x00, 0x02, 0x60, 0x00, 0x6C, 0x00, 0x05, 0x80, 0x00, 0xC0,
  0x03, 0xFF, 0x01, 0xC0, 0x38, 0x60, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x8E, 0x00, 0xE0, 0xFF, 0xF8, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xF0,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x05, 0x00, 0x00, 0x68, 0x00, 0x02, 0x60, 0x00, 0x11, 0x00,
  0x01, 0x8C, 0x00, 0x18, 0x30, 0x01, 0x80, 0xE0, 0x18, 0x01, 0xFF, 0x80,
  0x01, 0xC0, 0x00, 0x80, 0x00, 0x07, 0x80, 0x00, 0x09, 0x00, 0x00, 0x32,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x8C, 0x00, 0x01, 0x08, 0x00, 0x06, 0x10,
  0x00, 0x0C, 0x30, 0x00, 0x10, 0x20, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x80,
  0x01, 0x01, 0x80, 0x02, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x18, 0x06, 0x00,
  0x20, 0x0C, 0x00, 0x40, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x30, 0x04,
  0x00, 0x20, 0x18, 0x00, 0x40, 0x30, 0x00, 0xC0, 0x40, 0x01, 0x80, 0x80,
  0x01, 0x03, 0x00, 0x02, 0x06, 0x00, 0x06, 0x08, 0x00, 0x04, 0x10, 0x00,
  0x08, 0x60, 0x00, 0x10, 0x80, 0x00, 0x31, 0x00, 0x00, 0x26, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xA0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x02, 0x40,
  0x00, 0xE0, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x06, 0x60, 0x00, 0xB0, 0x00,
  0x66, 0x00, 0x19, 0x00, 0x04, 0x20, 0x01, 0x90, 0x00, 0x42, 0x00, 0x19,
  0x80, 0x0C, 0x30, 0x01, 0x18, 0x00, 0xC3, 0x00, 0x10, 0x80, 0x08, 0x10,
  0x03, 0x08, 0x00, 0x81, 0x00, 0x30, 0x80, 0x08, 0x10, 0x02, 0x0C, 0x01,
  0x81, 0x80, 0x20, 0xC0, 0x18, 0x18, 0x02, 0x04, 0x01, 0x00, 0x80, 0x60,
  0x40, 0x10, 0x08, 0x06, 0x06, 0x03, 0x00, 0xC0, 0x40, 0x60, 0x30, 0x0C,
  0x04, 0x02, 0x02, 0x00, 0x40, 0xC0, 0x20, 0x20, 0x04, 0x0C, 0x02, 0x06,
  0x00, 0x60, 0x80, 0x30, 0x60, 0x06, 0x08, 0x03, 0x04, 0x00, 0x20, 0x80,
  0x10, 0x40, 0x02, 0x18, 0x01, 0x0C, 0x00, 0x21, 0x80, 0x18, 0xC0, 0x03,
  0x10, 0x01, 0x88, 0x00, 0x31, 0x00, 0x08, 0x80, 0x01, 0x30, 0x00, 0x88,
  0x00, 0x13, 0x00, 0x09, 0x80, 0x01, 0xA0, 0x00, 0xD8, 0x00, 0x1A, 0x00,
  0x0D, 0x00, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x20, 0x00, 0x33, 0x00,
  0x02, 0x10, 0x00, 0x61, 0x80, 0x04, 0x08, 0x00, 0xC0, 0xC0, 0x08, 0x0C,
  0x01, 0x80, 0x40, 0x10, 0x06, 0x03, 0x00, 0x20, 0x20, 0x03, 0x02, 0x00,
  0x10, 0x60, 0x01, 0x84, 0x00, 0x08, 0xC0, 0x00, 0xC8, 0x00, 0x0D, 0x80,
  0x00, 0x50, 0x00, 0x07, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0x50,
  0x00, 0x0D, 0x80, 0x00, 0x88, 0x00, 0x18, 0xC0, 0x01, 0x04, 0x00, 0x30,
  0x60, 0x02, 0x02, 0x00, 0x60, 0x20, 0x04, 0x03, 0x00, 0xC0, 0x10, 0x08,
  0x01, 0x81, 0x80, 0x08, 0x10, 0x00, 0xC3, 0x00, 0x04, 0x30, 0x00, 0x66,
  0x00, 0x06, 0x60, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x02,
  0x40, 0x00, 0x66, 0x00, 0x04, 0x20, 0x00, 0x43, 0x00, 0x0C, 0x10, 0x00,
  0x81, 0x00, 0x18, 0x18, 0x01, 0x00, 0x80, 0x10, 0x0C, 0x03, 0x00, 0xC0,
  0x20, 0x04, 0x06, 0x00, 0x60, 0x40, 0x02, 0x04, 0x00, 0x30, 0xC0, 0x03,
  0x08, 0x00, 0x11, 0x80, 0x01, 0x98, 0x00, 0x09, 0x00, 0x00, 0xB0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x03, 0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xC0,
  0xC0, 0x00, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xF0, 0x00, 0x30,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x98, 0x00, 0x0C, 0xC0, 0x00,
  0x42, 0x00, 0x06, 0x18, 0x00, 0x20, 0x40, 0x03, 0x03, 0x00, 0x10, 0x08,
  0x01, 0x80, 0x60, 0x08, 0x01, 0x00, 0xC0, 0x0C, 0x04, 0x00, 0x20, 0x60,
  0x01, 0x82, 0x00, 0x04, 0x30, 0x00, 0x31, 0x00, 0x00, 0x98, 0x00, 0x07,
  0x80, 0x00, 0x10, 0xFF, 0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04,
  0x02, 0x01, 0x0F, 0xF8, 0x38, 0x0C, 0x20, 0x06, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x7F, 0x07, 0xE3, 0x1C, 0x03, 0x30, 0x03, 0x60, 0x03,
  0x40, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x05, 0x40, 0x05, 0x60, 0x09, 0x30, 0x11, 0x1F, 0xE1, 0x01, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20,
  0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00,
  0x02, 0x01, 0x00, 0x87, 0xFC, 0x23, 0x01, 0x89, 0x80, 0x32, 0xC0, 0x04,
  0xA0, 0x01, 0xA8, 0x00, 0x2C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x2E, 0x00, 0x0A, 0x80, 0x06, 0xB0, 0x03, 0x26,
  0x00, 0xC8, 0xC0, 0xE2, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0x03, 0xFE, 0x1C,
  0x04, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x08,
  0x3F, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00,
  0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x01, 0x07, 0xF8, 0x43, 0x03, 0x11,
  0x80, 0x64, 0xC0, 0x0D, 0x60, 0x01, 0x50, 0x00, 0x74, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x1D, 0x80,
  0x05, 0x20, 0x03, 0x4C, 0x00, 0x91, 0xC0, 0xC4, 0x3F, 0xE1, 0x00, 0x80,
  0x00, 0x07, 0xF8, 0x06, 0x0E, 0x06, 0x01, 0x86, 0x00, 0x46, 0x00, 0x33,
  0x00, 0x09, 0x00, 0x05, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x83, 0x00, 0xC0, 0xFF,
  0xC0, 0x0C, 0x00, 0x00, 0x40, 0x1F, 0xC1, 0x80, 0x08, 0x00, 0xC0, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x7F, 0xE0, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x07, 0xF8,
  0x47, 0x03, 0x11, 0x00, 0x24, 0xC0, 0x05, 0x60, 0x01, 0x50, 0x00, 0x34,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34,
  0x00, 0x15, 0x80, 0x05, 0x20, 0x03, 0x4C, 0x01, 0xB1, 0xC0, 0xCC, 0x1F,
  0xE3, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC6,
  0x00, 0x61, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x87, 0xF8, 0x8C, 0x0C, 0x98,
  0x06, 0xB0, 0x02, 0xA0, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x02, 0x0D, 0xF3, 0xC0, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0xD0, 0x01,
  0x20, 0x06, 0x40, 0x18, 0x80, 0x21, 0x00, 0x82, 0x03, 0x04, 0x0C, 0x08,
  0x10, 0x10, 0x60, 0x21, 0x80, 0x43, 0x00, 0x8A, 0x01, 0x36, 0x02, 0x44,
  0x05, 0x0C, 0x0E, 0x08, 0x18, 0x18, 0x20, 0x10, 0x40, 0x30, 0x80, 0x21,
  0x00, 0x62, 0x00, 0x44, 0x00, 0xC8, 0x00, 0x90, 0x01, 0xA0, 0x01, 0x40,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0x89, 0xC1, 0x86,
  0x0C, 0x90, 0x08, 0x80, 0x6A, 0x00, 0x58, 0x02, 0xA0, 0x05, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x60, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x87, 0xF8, 0x8C, 0x0C,
  0x98, 0x06, 0xB0, 0x03, 0xA0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x07, 0xF8, 0x03, 0x03, 0x81, 0x00, 0x30, 0xC0,
  0x04, 0x60, 0x01, 0x90, 0x00, 0x24, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xD0, 0x00, 0x34, 0x00, 0x09, 0x80, 0x06, 0x30, 0x01,
  0x04, 0x00, 0xC1, 0xC0, 0xE0, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0x87, 0xF8,
  0x23, 0x83, 0x89, 0x80, 0x32, 0x40, 0x04, 0xA0, 0x01, 0xA8, 0x00, 0x2C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x2A,
  0x00, 0x0A, 0x80, 0x06, 0xB0, 0x03, 0x26, 0x00, 0x88, 0xC0, 0xE2, 0x1F,
  0xE0, 0x80, 0x40, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x07, 0xF8, 0x43, 0x03, 0x11, 0x80, 0x64, 0xC0,
  0x0D, 0x60, 0x01, 0x50, 0x00, 0x74, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x34, 0x00, 0x15, 0x80, 0x05, 0x20, 0x02,
  0x4C, 0x01, 0xB1, 0xC0, 0xCC, 0x1F, 0xE3, 0x00, 0xC0, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x87, 0xF1,
  0x86, 0x60, 0x48, 0x0A, 0x01, 0x40, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x00, 0x0F, 0xF8, 0x70, 0x1D, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x05,
  0x00, 0x1B, 0x80, 0xE3, 0xFF, 0x80, 0x20, 0x00, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x07, 0xFF, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x1F, 0x80, 0xC0, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x05, 0x40, 0x05,
  0x60, 0x09, 0x30, 0x31, 0x1F, 0xE1, 0x02, 0x00, 0xC0, 0x00, 0xD0, 0x00,
  0x24, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0x08, 0x00, 0x42, 0x00, 0x30,
  0xC0, 0x08, 0x10, 0x02, 0x04, 0x01, 0x81, 0x80, 0x60, 0x60, 0x10, 0x08,
  0x04, 0x02, 0x03, 0x00, 0xC0, 0x80, 0x10, 0x20, 0x04, 0x18, 0x01, 0x06,
  0x00, 0x61, 0x00, 0x08, 0x40, 0x02, 0x30, 0x00, 0xC8, 0x00, 0x12, 0x00,
  0x05, 0x80, 0x01, 0x60, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x70,
  0x02, 0x40, 0x0D, 0x00, 0x24, 0x00, 0xD0, 0x02, 0x60, 0x09, 0x00, 0x66,
  0x00, 0x98, 0x06, 0x20, 0x18, 0x80, 0x42, 0x01, 0x88, 0x04, 0x30, 0x10,
  0x80, 0x43, 0x01, 0x0C, 0x0C, 0x10, 0x30, 0x40, 0x81, 0x03, 0x04, 0x08,
  0x18, 0x20, 0x40, 0x81, 0x82, 0x06, 0x18, 0x08, 0x60, 0x21, 0x00, 0x86,
  0x02, 0x10, 0x08, 0x40, 0x21, 0x00, 0xC4, 0x03, 0x30, 0x04, 0xC0, 0x12,
  0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x12, 0x00, 0x68, 0x01, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x40, 0x01, 0xB0, 0x01, 0x88, 0x00, 0xC6, 0x00, 0xC1, 0x00, 0x40,
  0xC0, 0x60, 0x30, 0x20, 0x08, 0x30, 0x06, 0x10, 0x01, 0x18, 0x00, 0xC8,
  0x00, 0x2C, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x02, 0xC0, 0x03,
  0x20, 0x01, 0x18, 0x01, 0x84, 0x00, 0x83, 0x00, 0xC0, 0x80, 0x40, 0x60,
  0x60, 0x10, 0x60, 0x0C, 0x20, 0x02, 0x30, 0x01, 0x90, 0x00, 0x58, 0x00,
  0x30, 0x40, 0x00, 0x58, 0x00, 0x32, 0x00, 0x08, 0x80, 0x02, 0x30, 0x01,
  0x8C, 0x00, 0x61, 0x00, 0x10, 0x40, 0x04, 0x18, 0x03, 0x02, 0x00, 0x80,
  0x80, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x01, 0x00, 0x40, 0x40, 0x18,
  0x30, 0x02, 0x08, 0x00, 0x82, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x01, 0x10,
  0x00, 0x44, 0x00, 0x1B, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x10, 0x00, 0x0C, 0x00, 0x02, 0x00,
  0x01, 0x80, 0x00, 0x40, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x80, 0x0C,
  0x00, 0x40, 0x06, 0x00, 0x20, 0x01, 0xFF, 0xF0, 0x00, 0x1C, 0x03, 0xE0,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x3C, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x02, 0x00, 0x08,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF0, 0x03, 0xF0, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x30, 0x00, 0x80, 0x0E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x17,
  0x3C, 0x01, 0xC0, 0x70, 0x78, 0x01, 0xFC,
};

const GFXglyph NotoSans_Condensed_Thin53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 38, 11, 4, -38 },
  { 16, 8, 14, 16, 4, -38 },
  { 30, 24, 38, 26, 1, -38 },
  { 144, 19, 43, 24, 2, -40 },
  { 247, 28, 38, 34, 3, -38 },
  { 380, 23, 39, 25, 2, -38 },
  { 493, 1, 14, 9, 4, -38 },
  { 495, 9, 46, 14, 3, -38 },
  { 547, 9, 46, 14, 2, -38 },
  { 599, 16, 16, 21, 3, -40 },
  { 631, 20, 24, 24, 2, -31 },
  { 691, 4, 13, 9, 2, -6 },
  { 698, 11, 1, 15, 2, -15 },
  { 700, 2, 3, 10, 4, -3 },
  { 701, 15, 38, 17, 1, -38 },
  { 773, 18, 38, 24, 3, -38 },
  { 859, 10, 38, 24, 4, -38 },
  { 907, 19, 38, 24, 2, -38 },
  { 998, 19, 39, 24, 2, -38 },
  { 1091, 22, 38, 24, 1, -38 },
  { 1196, 18, 38, 24, 3, -38 },
  { 1282, 18, 39, 24, 3, -38 },
  { 1370, 18, 38, 24, 3, -38 },
  { 1456, 19, 39, 24, 2, -38 },
  { 1549, 19, 39, 24, 2, -38 },
  { 1642, 2, 28, 10, 4, -28 },
  { 1649, 5, 35, 10, 2, -28 },
  { 1671, 20, 22, 24, 2, -30 },
  { 1726, 20, 13, 24, 2, -25 },
  { 1759, 20, 22, 24, 2, -30 },
  { 1814, 14, 38, 16, 1, -38 },
  { 1881, 31, 43, 36, 3, -38 },
  { 2048, 23, 38, 23, 0, -38 },
  { 2158, 19, 38, 26, 4, -38 },
  { 2249, 21, 39, 25, 3, -38 },
  { 2352, 22, 38, 29, 4, -38 },
  { 2457, 16, 38, 23, 4, -38 },
  { 2533, 16, 38, 21, 4, -38 },
  { 2609, 24, 39, 31, 3, -38 },
  { 2726, 21, 38, 29, 4, -38 },
  { 2826, 8, 38, 13, 2, -38 },
  { 2864, 9, 47, 11, -3, -38 },
  { 2917, 19, 38, 23, 4, -38 },
  { 3008, 16, 38, 21, 4, -38 },
  { 3084, 29, 38, 37, 4, -38 },
  { 3222, 21, 38, 30, 4, -38 },
  { 3322, 25, 39, 31, 3, -38 },
  { 3444, 18, 38, 24, 4, -38 },
  { 3530, 25, 47, 31, 3, -38 },
  { 3677, 19, 38, 24, 4, -38 },
  { 3768, 19, 39, 23, 2, -38 },
  { 3861, 20, 38, 21, 0, -38 },
  { 3956, 21, 39, 29, 4, -38 },
  { 4059, 23, 38, 23, 0, -38 },
  { 4169, 36, 38, 38, 1, -38 },
  { 4340, 20, 38, 20, 0, -38 },
  { 4435, 20, 38, 20, 0, -38 },
  { 4530, 18, 38, 21, 2, -38 },
  { 4616, 11, 46, 16, 4, -38 },
  { 4680, 15, 38, 17, 1, -38 },
  { 4752, 10, 46, 16, 2, -38 },
  { 4810, 21, 20, 24, 1, -38 },
  { 4863, 21, 1, 21, 0, 5 },
  { 4866, 8, 8, 12, 2, -40 },
  { 4874, 16, 29, 22, 2, -28 },
  { 4932, 18, 41, 25, 4, -40 },
  { 5025, 15, 29, 19, 3, -28 },
  { 5080, 18, 41, 25, 3, -40 },
  { 5173, 17, 29, 23, 3, -28 },
  { 5235, 13, 41, 12, 1, -41 },
  { 5302, 18, 41, 25, 3, -28 },
  { 5395, 16, 40, 24, 4, -40 },
  { 5475, 2, 38, 10, 4, -38 },
  { 5485, 7, 51, 10, -1, -38 },
  { 5530, 15, 40, 19, 4, -40 },
  { 5605, 1, 40, 9, 4, -40 },
  { 5610, 28, 28, 36, 4, -28 },
  { 5708, 16, 28, 24, 4, -28 },
  { 5764, 18, 29, 24, 3, -28 },
  { 5830, 18, 40, 25, 4, -28 },
  { 5920, 18, 40, 25, 3, -28 },
  { 6010, 11, 28, 16, 4, -28 },
  { 6049, 15, 29, 19, 2, -28 },
  { 6104, 11, 36, 13, 1, -35 },
  { 6154, 16, 29, 24, 4, -28 },
  { 6212, 18, 28, 18, 0, -28 },
  { 6275, 28, 28, 30, 1, -28 },
  { 6373, 17, 28, 19, 1, -28 },
  { 6433, 18, 41, 19, 0, -28 },
  { 6526, 13, 28, 17, 2, -28 },
  { 6572, 14, 46, 18, 2, -38 },
  { 6653, 1, 53, 23, 11, -40 },
  { 6660, 14, 46, 18, 2, -38 },
  { 6741, 20, 4, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Thin53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_THIN53PT7B_H_
