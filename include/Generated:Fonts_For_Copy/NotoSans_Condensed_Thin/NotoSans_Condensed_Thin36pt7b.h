#ifndef _NOTOSANS_CONDENSED_THIN36PT7B_H_
#define _NOTOSANS_CONDENSED_THIN36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin36pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x00, 0xF0, 0xC7, 0x1C, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x02, 0x08, 0x02, 0x08, 0x02, 0x08, 0x04, 0x08,
  0x04, 0x08, 0x04, 0x10, 0x04, 0x10, 0x04, 0x10, 0x7F, 0xFF, 0x04, 0x10,
  0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x08, 0x20, 0x08, 0x20, 0x08, 0x20,
  0x08, 0x20, 0xFF, 0xFE, 0x10, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0x40,
  0x10, 0x40, 0x10, 0x40, 0x10, 0x40, 0x20, 0x40, 0x02, 0x00, 0x10, 0x07,
  0xF8, 0x44, 0x24, 0x20, 0x21, 0x01, 0x08, 0x10, 0x40, 0x82, 0x02, 0x10,
  0x10, 0x80, 0x44, 0x01, 0xA0, 0x03, 0x00, 0x0E, 0x00, 0x4C, 0x02, 0x30,
  0x10, 0xC0, 0x82, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x42, 0x82,
  0x33, 0xFE, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x38, 0x02, 0x08, 0x80,
  0x41, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20, 0x81, 0x02, 0x10, 0x20, 0x42,
  0x04, 0x08, 0x80, 0x81, 0x10, 0x10, 0x24, 0x02, 0x04, 0x8E, 0x41, 0x12,
  0x28, 0x24, 0x84, 0x84, 0x90, 0x51, 0x22, 0x09, 0xC4, 0x81, 0x00, 0x90,
  0x20, 0x22, 0x04, 0x04, 0x40, 0x81, 0x08, 0x10, 0x21, 0x02, 0x04, 0x10,
  0x41, 0x02, 0x08, 0x20, 0x41, 0x04, 0x04, 0x41, 0x00, 0xF0, 0x07, 0x80,
  0x08, 0x40, 0x10, 0x40, 0x10, 0x20, 0x10, 0x20, 0x10, 0x20, 0x10, 0x20,
  0x10, 0x40, 0x10, 0x40, 0x08, 0x80, 0x09, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1A, 0x00, 0x21, 0x00, 0x20, 0x82, 0x40, 0x82, 0x40, 0x42, 0x80, 0x22,
  0x80, 0x34, 0x80, 0x14, 0x40, 0x08, 0x40, 0x1C, 0x40, 0x14, 0x20, 0x62,
  0x1F, 0x81, 0xFF, 0xA5, 0x50, 0x04, 0x21, 0x04, 0x20, 0x84, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x10, 0x41,
  0x02, 0x08, 0x10, 0x40, 0x81, 0xC0, 0x80, 0x80, 0x81, 0x03, 0x02, 0x04,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x04, 0x10, 0x60, 0x04, 0x00, 0x80,
  0x10, 0x42, 0x37, 0x58, 0x1C, 0x02, 0x80, 0x90, 0x21, 0x0C, 0x10, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0xFF, 0xFC, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x24, 0x96, 0x92, 0x80, 0xFF, 0xC0, 0x00,
  0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x20, 0x10, 0x04, 0x03, 0x00, 0x80,
  0x20, 0x10, 0x04, 0x01, 0x00, 0x80, 0x20, 0x00, 0x0F, 0x01, 0x0C, 0x20,
  0x44, 0x02, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x14, 0x02, 0x40, 0x22, 0x04, 0x30, 0x40, 0xF8, 0x04,
  0x31, 0x49, 0x46, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x1F, 0x0E, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x0F, 0xFF, 0x3F, 0x0C,
  0x0C, 0x80, 0x60, 0x02, 0x00, 0x20, 0x02, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x02, 0x00, 0x40, 0x18, 0x1E, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x80, 0x4F,
  0xF8, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24,
  0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40, 0x20, 0x80, 0x41, 0x01,
  0x02, 0x02, 0x04, 0x08, 0x08, 0x20, 0x10, 0x40, 0x21, 0x00, 0x42, 0x00,
  0x83, 0xFF, 0xF0, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20,
  0x00, 0x40, 0x7F, 0xE4, 0x00, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0F, 0xF8, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x20, 0x02, 0x80, 0xC7, 0xF0, 0x03, 0xE0, 0xC0, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x87, 0x09, 0x0C, 0xA0,
  0x2C, 0x02, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x14, 0x01, 0x40, 0x16, 0x02, 0x20, 0x61, 0xFC, 0xFF, 0xF0, 0x01, 0x00,
  0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x1F,
  0x82, 0x04, 0x40, 0x24, 0x02, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0x40,
  0x22, 0x06, 0x30, 0xC0, 0x90, 0x06, 0x01, 0x98, 0x20, 0x44, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x02, 0x60,
  0x61, 0xF8, 0x1F, 0x02, 0x08, 0x40, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x34, 0x05, 0x60,
  0xD1, 0xF1, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x08, 0x01, 0x87, 0xE0, 0xC0, 0x00, 0x60, 0x23, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x22, 0x26, 0x44, 0x48, 0x00, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x00, 0x7C, 0x41, 0x80, 0x40, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00,
  0x00, 0x78, 0x00, 0x1C, 0x38, 0x01, 0x00, 0x60, 0x10, 0x00, 0x81, 0x00,
  0x02, 0x10, 0x00, 0x10, 0x80, 0x00, 0x48, 0x00, 0x02, 0x40, 0x7C, 0x12,
  0x0C, 0x20, 0x60, 0x41, 0x03, 0x04, 0x08, 0x18, 0x20, 0x40, 0xC1, 0x02,
  0x06, 0x08, 0x10, 0x30, 0x40, 0x81, 0x82, 0x04, 0x0C, 0x10, 0x20, 0xA0,
  0x83, 0x05, 0x04, 0x18, 0x28, 0x11, 0x22, 0x20, 0x70, 0xE1, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x04, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x02,
  0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x04,
  0x20, 0x08, 0x20, 0x08, 0x10, 0x08, 0x10, 0x08, 0x10, 0x10, 0x08, 0x1F,
  0xF8, 0x10, 0x08, 0x20, 0x08, 0x20, 0x04, 0x20, 0x04, 0x20, 0x04, 0x40,
  0x04, 0x40, 0x02, 0x40, 0x02, 0x80, 0x02, 0x80, 0x01, 0xFE, 0x04, 0x06,
  0x20, 0x09, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x14,
  0x00, 0xA0, 0x09, 0x01, 0x8F, 0xF8, 0x40, 0x32, 0x00, 0xD0, 0x02, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x06,
  0x80, 0x67, 0xFC, 0x00, 0x03, 0xF8, 0x10, 0x11, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x0C, 0x04,
  0x0F, 0xF0, 0xFE, 0x02, 0x07, 0x08, 0x02, 0x20, 0x04, 0x80, 0x1A, 0x00,
  0x28, 0x00, 0xA0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x02, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x08, 0x80, 0xC3, 0xFC, 0x00,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x0F, 0xFD, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x1F, 0xFC,
  0xFF, 0xF0, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0xFF, 0xA0, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x00,
  0x01, 0xFC, 0x03, 0x01, 0x82, 0x00, 0x02, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x50, 0x00, 0x28, 0x00, 0x14, 0x00, 0x09, 0x00, 0x04, 0xC0,
  0x02, 0x30, 0x01, 0x0C, 0x01, 0x81, 0xFF, 0x00, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0xFE, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x10, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x27, 0xC0, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0xFE, 0x80,
  0x14, 0x01, 0x20, 0x19, 0x00, 0x88, 0x08, 0x40, 0xC2, 0x04, 0x10, 0x40,
  0x84, 0x04, 0x60, 0x22, 0x01, 0x20, 0x0A, 0x80, 0x56, 0x03, 0x10, 0x10,
  0x40, 0x82, 0x04, 0x08, 0x20, 0x41, 0x01, 0x08, 0x08, 0x40, 0x22, 0x00,
  0x90, 0x04, 0x80, 0x14, 0x00, 0xC0, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x3F, 0xF0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xD0, 0x00,
  0x3A, 0x00, 0x07, 0x40, 0x01, 0x64, 0x00, 0x2C, 0x80, 0x05, 0x90, 0x01,
  0x31, 0x00, 0x26, 0x20, 0x04, 0xC4, 0x01, 0x18, 0x40, 0x23, 0x08, 0x04,
  0x61, 0x01, 0x0C, 0x10, 0x21, 0x82, 0x04, 0x30, 0x41, 0x06, 0x04, 0x20,
  0xC0, 0x84, 0x18, 0x11, 0x03, 0x01, 0x20, 0x60, 0x2C, 0x0C, 0x05, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x04, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x68, 0x01,
  0xA0, 0x06, 0x40, 0x19, 0x00, 0x62, 0x01, 0x88, 0x06, 0x10, 0x18, 0x40,
  0x60, 0x81, 0x82, 0x06, 0x04, 0x18, 0x10, 0x60, 0x21, 0x80, 0x86, 0x01,
  0x18, 0x04, 0x60, 0x09, 0x80, 0x26, 0x00, 0x58, 0x01, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x10, 0x03, 0xF0, 0x06, 0x04, 0x04, 0x01, 0x04, 0x00, 0x42,
  0x00, 0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x11,
  0x00, 0x08, 0x80, 0x08, 0x20, 0x08, 0x08, 0x0C, 0x03, 0xF8, 0x00, 0xFC,
  0x08, 0x18, 0x80, 0x48, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x28, 0x02, 0x80, 0x48, 0x08, 0xFF, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x03, 0xF0, 0x06, 0x04, 0x04, 0x01, 0x04, 0x00, 0x42, 0x00,
  0x22, 0x00, 0x09, 0x00, 0x04, 0x80, 0x02, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x08, 0x20, 0x08, 0x08, 0x0C, 0x03, 0xF8, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x20, 0x00, 0x08, 0xFE, 0x04,
  0x0C, 0x20, 0x11, 0x00, 0x48, 0x02, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80,
  0x14, 0x01, 0x20, 0x09, 0x00, 0x48, 0x0C, 0x7F, 0xC2, 0x08, 0x10, 0x40,
  0x81, 0x04, 0x08, 0x20, 0x21, 0x01, 0x08, 0x04, 0x40, 0x22, 0x00, 0x90,
  0x04, 0x80, 0x14, 0x00, 0xC0, 0x0F, 0xC3, 0x03, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x80, 0x4F, 0xF8, 0xFF, 0xFC, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00, 0x90, 0x02,
  0x20, 0x10, 0x7F, 0x80, 0x80, 0x03, 0x00, 0x05, 0x00, 0x0A, 0x00, 0x24,
  0x00, 0x48, 0x00, 0x88, 0x01, 0x10, 0x04, 0x20, 0x08, 0x40, 0x10, 0x40,
  0x40, 0x80, 0x81, 0x01, 0x01, 0x02, 0x02, 0x08, 0x04, 0x10, 0x08, 0x20,
  0x08, 0x40, 0x11, 0x00, 0x22, 0x00, 0x24, 0x00, 0x50, 0x00, 0xA0, 0x01,
  0x40, 0x01, 0x80, 0x02, 0x00, 0xC0, 0x08, 0x00, 0xA0, 0x06, 0x00, 0x50,
  0x03, 0x00, 0x28, 0x01, 0x80, 0x24, 0x01, 0x40, 0x11, 0x00, 0xA0, 0x08,
  0x80, 0x48, 0x04, 0x40, 0x24, 0x02, 0x20, 0x12, 0x02, 0x08, 0x11, 0x01,
  0x04, 0x08, 0x40, 0x82, 0x04, 0x20, 0x41, 0x02, 0x10, 0x40, 0x42, 0x08,
  0x20, 0x21, 0x04, 0x10, 0x10, 0x81, 0x08, 0x08, 0x40, 0x88, 0x04, 0x20,
  0x44, 0x01, 0x20, 0x22, 0x00, 0x90, 0x09, 0x00, 0x48, 0x05, 0x00, 0x24,
  0x02, 0x80, 0x0C, 0x01, 0x40, 0x06, 0x00, 0xA0, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x10, 0x00, 0x40, 0x08, 0x80, 0x22, 0x01, 0x04, 0x04, 0x10, 0x20,
  0x40, 0x80, 0x82, 0x02, 0x10, 0x04, 0x40, 0x12, 0x00, 0x28, 0x00, 0xC0,
  0x01, 0x00, 0x0C, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x21, 0x00, 0x84,
  0x04, 0x08, 0x10, 0x20, 0x80, 0x42, 0x01, 0x10, 0x06, 0x40, 0x0B, 0x00,
  0x30, 0x80, 0x0C, 0x00, 0x50, 0x02, 0x80, 0x22, 0x01, 0x10, 0x10, 0x80,
  0x82, 0x04, 0x10, 0x40, 0x42, 0x02, 0x20, 0x11, 0x00, 0x48, 0x02, 0x80,
  0x0C, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x7F, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00,
  0x80, 0x10, 0x04, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x40, 0x10, 0x02,
  0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10,
  0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0xFF, 0x01, 0x00, 0x0C, 0x00, 0x28, 0x01, 0x20, 0x04,
  0x40, 0x21, 0x00, 0x82, 0x04, 0x08, 0x10, 0x10, 0x80, 0x42, 0x00, 0x90,
  0x02, 0x40, 0x06, 0x00, 0x10, 0xFF, 0xFC, 0xC1, 0x02, 0x04, 0x08, 0x10,
  0x1F, 0x84, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x03,
  0xE3, 0x84, 0x80, 0xA0, 0x14, 0x03, 0x80, 0x60, 0x0A, 0x03, 0x40, 0x6C,
  0x14, 0xFC, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x9F, 0x8A, 0x04, 0xC0, 0x2C, 0x02, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x02, 0xC0, 0x2A, 0x04, 0x9F, 0x80, 0x0F, 0xCC, 0x02, 0x01,
  0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x01, 0x00, 0x40, 0x0C, 0x01, 0xFC, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x1F, 0x92, 0x05, 0x40,
  0x34, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x40, 0x32, 0x05, 0x1F,
  0x90, 0x1F, 0x82, 0x04, 0x40, 0x44, 0x02, 0x80, 0x28, 0x02, 0x80, 0x18,
  0x01, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x02, 0x02, 0x1F, 0xC0, 0x03, 0x03, 0x30, 0x80, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x3F, 0x81, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x1F, 0x92, 0x05, 0x40, 0x34, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x03, 0x40, 0x32, 0x05, 0x1F, 0x90, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x06, 0xE1, 0xC0, 0xE0, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x9F, 0x94,
  0x1B, 0x01, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x70, 0x01, 0x55, 0x55, 0x55, 0x55, 0x50, 0x08, 0xC0, 0x00, 0x00,
  0x01, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x1C, 0x90, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0xA0, 0x48, 0x12, 0x08, 0x84, 0x23, 0x08,
  0x82, 0x40, 0xA8, 0x2A, 0x0C, 0x42, 0x10, 0x82, 0x20, 0x88, 0x12, 0x04,
  0x80, 0xA0, 0x28, 0x04, 0xFF, 0xFF, 0xFF, 0xE0, 0x9F, 0x0F, 0x94, 0x12,
  0x0B, 0x02, 0x81, 0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10,
  0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20,
  0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40,
  0x30, 0x08, 0x06, 0x01, 0x00, 0x80, 0x9F, 0x94, 0x0B, 0x01, 0x60, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x1F, 0x81, 0x03,
  0x10, 0x08, 0x80, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x50, 0x02, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x28, 0x01, 0x40, 0x0A, 0x00, 0x48, 0x02, 0x40,
  0x21, 0x03, 0x07, 0xE0, 0x9F, 0x8A, 0x04, 0xC0, 0x2C, 0x02, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x1C, 0x02, 0xC0, 0x2A, 0x04, 0x9F, 0x88, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x1F, 0x92, 0x05,
  0x40, 0x34, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x14, 0x03, 0x40, 0x32, 0x05,
  0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x9F, 0x43, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x1F, 0xD8, 0x14, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x60, 0x37, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x1F,
  0xC8, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x0F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x80, 0xA8, 0x34, 0xFC, 0x80, 0x80, 0x14, 0x01, 0x40, 0x24,
  0x02, 0x40, 0x22, 0x04, 0x20, 0x42, 0x04, 0x20, 0x41, 0x08, 0x10, 0x81,
  0x08, 0x09, 0x00, 0x90, 0x09, 0x00, 0x90, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x20, 0x14, 0x06, 0x01, 0x40, 0x60, 0x24, 0x05, 0x02, 0x40, 0x50,
  0x22, 0x09, 0x02, 0x20, 0x90, 0x42, 0x08, 0x84, 0x20, 0x88, 0x41, 0x10,
  0x84, 0x11, 0x08, 0x81, 0x10, 0x48, 0x11, 0x04, 0x80, 0xA0, 0x48, 0x0A,
  0x04, 0x80, 0xA0, 0x30, 0x0A, 0x03, 0x00, 0x40, 0x30, 0x04, 0x03, 0x00,
  0x80, 0x28, 0x09, 0x01, 0x10, 0x42, 0x08, 0x22, 0x02, 0x40, 0x50, 0x06,
  0x00, 0x80, 0x28, 0x05, 0x01, 0x10, 0x22, 0x08, 0x21, 0x04, 0x40, 0x48,
  0x0E, 0x00, 0x80, 0x40, 0x14, 0x01, 0x40, 0x12, 0x02, 0x20, 0x22, 0x02,
  0x20, 0x41, 0x04, 0x10, 0x41, 0x04, 0x08, 0x80, 0x88, 0x08, 0x80, 0x90,
  0x05, 0x00, 0x50, 0x05, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x90, 0x0E, 0x00, 0x7F, 0x80, 0x40,
  0x60, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02, 0x02, 0x01, 0x01,
  0x00, 0x80, 0x80, 0x40, 0x20, 0x3F, 0xE0, 0x01, 0x83, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x41,
  0xC0, 0xE0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x40, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC0, 0x38, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x10, 0x0F, 0x07, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC1, 0xC1, 0x80,
  0x7E, 0x06, 0x06, 0x38, 0x07, 0x00,
};

const GFXglyph NotoSans_Condensed_Thin36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 26, 7, 3, -26 },
  { 8, 6, 10, 11, 2, -26 },
  { 16, 16, 26, 18, 1, -26 },
  { 68, 13, 29, 16, 1, -27 },
  { 116, 19, 26, 23, 2, -26 },
  { 178, 16, 26, 17, 1, -26 },
  { 230, 2, 10, 6, 2, -26 },
  { 233, 6, 32, 9, 2, -26 },
  { 257, 7, 32, 9, 1, -26 },
  { 285, 11, 10, 15, 2, -27 },
  { 299, 14, 17, 16, 1, -21 },
  { 329, 3, 9, 6, 1, -4 },
  { 333, 8, 1, 10, 1, -10 },
  { 334, 1, 2, 7, 3, -2 },
  { 335, 10, 26, 12, 1, -26 },
  { 368, 12, 26, 16, 2, -26 },
  { 407, 6, 26, 16, 3, -26 },
  { 427, 12, 26, 16, 2, -26 },
  { 466, 12, 26, 16, 2, -26 },
  { 505, 15, 26, 16, 1, -26 },
  { 554, 12, 26, 16, 2, -26 },
  { 593, 12, 26, 16, 2, -26 },
  { 632, 12, 26, 16, 2, -26 },
  { 671, 12, 26, 16, 2, -26 },
  { 710, 12, 26, 16, 2, -26 },
  { 749, 1, 19, 7, 3, -19 },
  { 752, 4, 24, 7, 1, -19 },
  { 764, 14, 15, 16, 1, -20 },
  { 791, 14, 9, 16, 1, -17 },
  { 807, 14, 15, 16, 1, -20 },
  { 834, 9, 26, 11, 1, -26 },
  { 864, 21, 29, 25, 2, -26 },
  { 941, 16, 26, 16, 0, -26 },
  { 993, 13, 26, 17, 3, -26 },
  { 1036, 14, 26, 17, 2, -26 },
  { 1082, 14, 26, 19, 3, -26 },
  { 1128, 11, 26, 16, 3, -26 },
  { 1164, 11, 26, 14, 3, -26 },
  { 1200, 17, 26, 21, 2, -26 },
  { 1256, 14, 26, 20, 3, -26 },
  { 1302, 5, 26, 9, 2, -26 },
  { 1319, 6, 32, 7, -2, -26 },
  { 1343, 13, 26, 16, 3, -26 },
  { 1386, 10, 26, 14, 3, -26 },
  { 1419, 19, 26, 25, 3, -26 },
  { 1481, 14, 26, 20, 3, -26 },
  { 1527, 17, 26, 21, 2, -26 },
  { 1583, 12, 26, 16, 3, -26 },
  { 1622, 17, 32, 21, 2, -26 },
  { 1690, 13, 26, 16, 3, -26 },
  { 1733, 12, 26, 16, 2, -26 },
  { 1772, 14, 26, 14, 0, -26 },
  { 1818, 14, 26, 20, 3, -26 },
  { 1864, 15, 26, 15, 0, -26 },
  { 1913, 25, 26, 26, 0, -26 },
  { 1995, 14, 26, 14, 0, -26 },
  { 2041, 13, 26, 13, 0, -26 },
  { 2084, 12, 26, 14, 1, -26 },
  { 2123, 7, 32, 11, 3, -26 },
  { 2151, 10, 26, 12, 1, -26 },
  { 2184, 7, 32, 11, 1, -26 },
  { 2212, 14, 14, 16, 1, -26 },
  { 2237, 14, 1, 14, 0, 3 },
  { 2239, 6, 6, 8, 1, -28 },
  { 2244, 11, 19, 15, 1, -19 },
  { 2271, 12, 27, 17, 3, -27 },
  { 2312, 10, 19, 13, 2, -19 },
  { 2336, 12, 27, 17, 2, -27 },
  { 2377, 12, 19, 15, 2, -19 },
  { 2406, 10, 28, 8, 0, -28 },
  { 2441, 12, 28, 17, 2, -19 },
  { 2483, 11, 27, 16, 3, -27 },
  { 2521, 2, 26, 7, 2, -26 },
  { 2528, 5, 35, 7, -1, -26 },
  { 2550, 10, 27, 13, 3, -27 },
  { 2584, 1, 27, 6, 3, -27 },
  { 2588, 19, 19, 25, 3, -19 },
  { 2634, 11, 19, 16, 3, -19 },
  { 2661, 13, 19, 16, 2, -19 },
  { 2692, 12, 27, 17, 3, -19 },
  { 2733, 12, 27, 17, 2, -19 },
  { 2774, 7, 19, 11, 3, -19 },
  { 2791, 10, 19, 13, 1, -19 },
  { 2815, 7, 24, 9, 1, -24 },
  { 2836, 11, 19, 16, 3, -19 },
  { 2863, 12, 19, 12, 0, -19 },
  { 2892, 20, 19, 20, 0, -19 },
  { 2940, 11, 19, 13, 1, -19 },
  { 2967, 12, 28, 13, 0, -19 },
  { 3009, 9, 19, 11, 1, -19 },
  { 3031, 9, 32, 12, 2, -26 },
  { 3067, 1, 36, 15, 7, -27 },
  { 3072, 9, 32, 12, 2, -26 },
  { 3108, 14, 3, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Thin36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_THIN36PT7B_H_
