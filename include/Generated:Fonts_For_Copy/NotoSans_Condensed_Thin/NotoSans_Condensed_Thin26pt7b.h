#ifndef _NOTOSANS_CONDENSED_THIN26PT7B_H_
#define _NOTOSANS_CONDENSED_THIN26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x60, 0x99, 0x99, 0x99, 0x90, 0x08, 0x81, 0x10, 0x22,
  0x08, 0x41, 0x08, 0x21, 0x3F, 0xF8, 0x88, 0x11, 0x02, 0x20, 0x84, 0x10,
  0x8F, 0xFC, 0x42, 0x08, 0x81, 0x10, 0x22, 0x08, 0x41, 0x08, 0x00, 0x08,
  0x04, 0x0F, 0xC9, 0x08, 0x84, 0x42, 0x21, 0x10, 0x48, 0x14, 0x06, 0x01,
  0xC0, 0x90, 0x44, 0x22, 0x11, 0x08, 0x84, 0x72, 0xC5, 0x80, 0x80, 0x40,
  0x30, 0x21, 0x20, 0x84, 0x42, 0x21, 0x10, 0x84, 0x42, 0x12, 0x08, 0x48,
  0x21, 0x24, 0x85, 0x29, 0x15, 0x14, 0xA4, 0x4C, 0x91, 0x02, 0x44, 0x12,
  0x10, 0x44, 0x41, 0x11, 0x08, 0x44, 0x21, 0x11, 0x03, 0x80, 0x1C, 0x04,
  0x40, 0x88, 0x20, 0x82, 0x10, 0x44, 0x08, 0x80, 0xA0, 0x18, 0x03, 0x01,
  0x90, 0x22, 0x18, 0x23, 0x02, 0xA0, 0x54, 0x04, 0x80, 0xC8, 0x28, 0xF8,
  0x80, 0xFE, 0x08, 0x88, 0x44, 0x21, 0x08, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x42, 0x10, 0x42, 0x08, 0x60, 0x82, 0x10, 0x42, 0x08, 0x42, 0x10, 0x42,
  0x10, 0x84, 0x42, 0x10, 0x88, 0x42, 0x22, 0x00, 0x08, 0x08, 0x08, 0xEB,
  0x1C, 0x14, 0x24, 0x42, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x3F, 0xF0,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x55, 0xA0, 0xFC, 0xC0, 0x02,
  0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10,
  0x20, 0x81, 0x02, 0x00, 0x1E, 0x10, 0x90, 0x48, 0x14, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x02, 0x81, 0x41, 0x10,
  0x87, 0x80, 0x08, 0xCB, 0x90, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x3C, 0x21, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x00, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40, 0x40, 0x20, 0x20, 0x3F, 0xE0,
  0x1C, 0x61, 0x80, 0x40, 0x10, 0x08, 0x04, 0x02, 0x02, 0x02, 0x1E, 0x00,
  0xC0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xBF, 0x80, 0x00, 0x80,
  0x30, 0x06, 0x01, 0x40, 0x48, 0x09, 0x02, 0x20, 0x44, 0x10, 0x82, 0x10,
  0x82, 0x10, 0x44, 0x09, 0xFF, 0xC0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x7E, 0x00,
  0x80, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xBF, 0x80, 0x0F,
  0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x01, 0x08, 0xBB, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x05, 0x02, 0x81, 0x40, 0x90, 0x87, 0x80, 0xFF, 0x80, 0x40,
  0x20, 0x20, 0x10, 0x08, 0x08, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x00, 0x1C, 0x10, 0x90, 0x28, 0x18,
  0x0A, 0x05, 0x02, 0x42, 0x16, 0x0E, 0x08, 0xC8, 0x28, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xA0, 0x4F, 0xC0, 0x1C, 0x31, 0x10, 0x50, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xA0, 0x50, 0x67, 0xD0, 0x08, 0x04, 0x02, 0x02, 0x01,
  0x01, 0x1F, 0x00, 0xC0, 0x0C, 0x50, 0x00, 0x01, 0x56, 0x80, 0x00, 0x40,
  0x60, 0x60, 0x60, 0x60, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x00, 0x72, 0x30,
  0x41, 0x04, 0x10, 0x41, 0x08, 0x42, 0x08, 0x21, 0x04, 0x00, 0x00, 0x86,
  0x00, 0x00, 0xC0, 0x0E, 0x30, 0x10, 0x08, 0x20, 0x04, 0x20, 0x02, 0x40,
  0x02, 0x43, 0xE2, 0x44, 0x22, 0x84, 0x21, 0x84, 0x21, 0x88, 0x21, 0x88,
  0x21, 0x88, 0x22, 0x84, 0x62, 0x84, 0x62, 0x43, 0x9C, 0x40, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x0F, 0xE0, 0x04, 0x00, 0x80, 0x18, 0x05,
  0x00, 0xA0, 0x12, 0x04, 0x40, 0x88, 0x10, 0x82, 0x10, 0x82, 0x1F, 0xC2,
  0x04, 0x80, 0x90, 0x12, 0x01, 0x40, 0x30, 0x06, 0x00, 0x80, 0xFC, 0x41,
  0xA0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x02, 0x83, 0x7F, 0x20, 0x50, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xBF, 0x80, 0x07, 0x83, 0x04, 0x80,
  0x10, 0x04, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x20, 0x02, 0x00, 0x3F, 0x80, 0xFC,
  0x10, 0x62, 0x02, 0x40, 0x48, 0x05, 0x00, 0xA0, 0x14, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x05, 0x00, 0xA0, 0x14, 0x02, 0x80, 0x90, 0x23,
  0xF8, 0x00, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x07, 0xE0, 0x81, 0x10, 0x02, 0x00, 0x40, 0x04,
  0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x81, 0xF8, 0x01, 0x40, 0x14,
  0x01, 0x40, 0x14, 0x01, 0x20, 0x11, 0x01, 0x0F, 0xF0, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x7F, 0xF8, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0xF2, 0x22, 0x22,
  0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0xF0, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x86, 0x48, 0x80, 0xC0,
  0xA0, 0x50, 0x48, 0x44, 0x42, 0x21, 0x20, 0xA0, 0x58, 0x32, 0x11, 0x08,
  0x44, 0x22, 0x09, 0x04, 0x81, 0x40, 0x60, 0x20, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xFF, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xA0, 0x0E,
  0x80, 0x5A, 0x01, 0x64, 0x05, 0x90, 0x26, 0x40, 0x98, 0x82, 0x62, 0x11,
  0x88, 0x46, 0x11, 0x18, 0x48, 0x61, 0x21, 0x82, 0x86, 0x0C, 0x18, 0x10,
  0x40, 0x80, 0x60, 0x1C, 0x06, 0x81, 0xA0, 0x64, 0x19, 0x06, 0x21, 0x88,
  0x61, 0x18, 0x46, 0x09, 0x82, 0x60, 0x58, 0x16, 0x03, 0x80, 0xE0, 0x18,
  0x04, 0x0F, 0x80, 0x82, 0x08, 0x08, 0x80, 0x24, 0x01, 0x20, 0x09, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xA0, 0x05,
  0x00, 0x48, 0x02, 0x20, 0x20, 0x81, 0x03, 0xF0, 0xF8, 0x43, 0x20, 0x50,
  0x28, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x41, 0xBF, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x0F, 0x80, 0x82, 0x08, 0x08, 0x80,
  0x24, 0x01, 0x20, 0x09, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xA0, 0x05, 0x00, 0x48, 0x02, 0x20, 0x20, 0x81, 0x03,
  0xF0, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0xF8, 0x43, 0x20, 0x50,
  0x18, 0x0C, 0x06, 0x03, 0x02, 0x81, 0x41, 0x3F, 0x10, 0x88, 0x44, 0x12,
  0x09, 0x02, 0x81, 0x40, 0x60, 0x20, 0x1F, 0x10, 0x50, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x20, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0xBF, 0x80, 0xFF, 0xC2, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x50, 0x23, 0xF0, 0x80, 0x30, 0x06, 0x00, 0xA0, 0x24, 0x04, 0x80,
  0x90, 0x11, 0x04, 0x20, 0x84, 0x10, 0x44, 0x08, 0x81, 0x10, 0x22, 0x02,
  0x80, 0x50, 0x0A, 0x00, 0x80, 0x10, 0x00, 0x80, 0x40, 0x60, 0x10, 0x14,
  0x0C, 0x05, 0x03, 0x01, 0x40, 0xA0, 0x90, 0x28, 0x22, 0x12, 0x08, 0x84,
  0x82, 0x21, 0x11, 0x08, 0x44, 0x41, 0x11, 0x10, 0x48, 0x44, 0x12, 0x11,
  0x04, 0x82, 0x81, 0x20, 0xA0, 0x30, 0x28, 0x0C, 0x0A, 0x03, 0x03, 0x00,
  0x40, 0x40, 0x40, 0x50, 0x22, 0x08, 0x84, 0x21, 0x04, 0x41, 0x20, 0x28,
  0x0C, 0x01, 0x00, 0xC0, 0x28, 0x12, 0x04, 0x42, 0x10, 0x84, 0x40, 0x90,
  0x28, 0x04, 0x80, 0x60, 0x24, 0x09, 0x02, 0x41, 0x08, 0x42, 0x20, 0x48,
  0x12, 0x05, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0xFF, 0x00, 0x80, 0x40, 0x40, 0x20, 0x10, 0x10, 0x08, 0x08,
  0x04, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40, 0x40, 0x3F, 0xE0,
  0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x43, 0xE0, 0x81, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20,
  0x40, 0x80, 0x81, 0x01, 0x02, 0x04, 0x04, 0x08, 0xF8, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x04,
  0x03, 0x01, 0x40, 0x48, 0x22, 0x08, 0x44, 0x11, 0x02, 0x80, 0xA0, 0x10,
  0xFF, 0xC0, 0x84, 0x21, 0x3C, 0x42, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x61,
  0x81, 0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0xF9, 0x82, 0xC1, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xB0, 0x57, 0xC0, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x1F, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x7A, 0x43, 0x40, 0xA0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xA0, 0x50, 0x67, 0xD0, 0x1E, 0x10, 0x90, 0x48, 0x18, 0x0C,
  0x07, 0xFF, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0xF8, 0x0E, 0x20,
  0x81, 0x02, 0x04, 0x3E, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x00, 0x1E, 0x90, 0xD0, 0x28, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x19, 0xF4, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x4F, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC7,
  0xFF, 0xE0, 0x24, 0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0xC0,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC2, 0x85, 0x12, 0x45, 0x0B, 0x1A,
  0x22, 0x44, 0x85, 0x0A, 0x0C, 0x10, 0xFF, 0xFF, 0xF0, 0xBC, 0x73, 0x0A,
  0x28, 0x30, 0x60, 0x81, 0x82, 0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x82,
  0x06, 0x08, 0x18, 0x20, 0x60, 0x81, 0x82, 0x06, 0x08, 0x10, 0xBC, 0xC2,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x1E, 0x08, 0x44, 0x09, 0x02, 0x80, 0xA0, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x28, 0x09, 0x02, 0x41, 0x0F, 0x80, 0x9E, 0x70, 0xB0, 0x50, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x2C, 0x15, 0xF2, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x00, 0x1E, 0x90, 0xD0, 0x28, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x19, 0xF4, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0xBE, 0x31, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x40, 0x3E, 0x82, 0x04, 0x08, 0x08, 0x0C, 0x04, 0x06, 0x04, 0x08, 0x10,
  0x3F, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x1C, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x83, 0x7D, 0x80, 0xC0, 0x90, 0x48, 0x24, 0x12, 0x10,
  0x88, 0x44, 0x24, 0x0A, 0x05, 0x02, 0x80, 0x80, 0x40, 0x81, 0x06, 0x04,
  0x14, 0x28, 0x50, 0xA1, 0x42, 0x85, 0x0A, 0x22, 0x48, 0x89, 0x12, 0x24,
  0x48, 0x91, 0x41, 0x85, 0x06, 0x0C, 0x18, 0x30, 0x40, 0x80, 0x81, 0x82,
  0x42, 0x44, 0x24, 0x28, 0x10, 0x10, 0x28, 0x24, 0x44, 0x42, 0x82, 0x81,
  0x80, 0xA0, 0x50, 0x48, 0x24, 0x11, 0x08, 0x88, 0x44, 0x12, 0x0A, 0x05,
  0x02, 0x80, 0x80, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x1C, 0x00, 0xFC,
  0x10, 0x42, 0x08, 0x41, 0x08, 0x20, 0x84, 0x10, 0x83, 0xF0, 0x06, 0x10,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x86, 0x02, 0x04, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0x40, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x20, 0x70, 0x82, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x38, 0x00, 0xF8, 0x61, 0xE0,
};

const GFXglyph NotoSans_Condensed_Thin26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 19, 5, 2, -19 },
  { 4, 4, 7, 8, 2, -19 },
  { 8, 11, 19, 13, 1, -19 },
  { 35, 9, 22, 12, 1, -20 },
  { 60, 14, 19, 17, 1, -19 },
  { 94, 11, 19, 12, 1, -19 },
  { 121, 1, 7, 4, 2, -19 },
  { 122, 5, 23, 7, 1, -19 },
  { 137, 5, 23, 7, 1, -19 },
  { 152, 8, 8, 10, 1, -20 },
  { 160, 10, 12, 12, 1, -15 },
  { 175, 2, 6, 5, 1, -3 },
  { 177, 6, 1, 7, 1, -8 },
  { 178, 1, 2, 5, 2, -2 },
  { 179, 7, 19, 8, 1, -19 },
  { 196, 9, 19, 12, 1, -19 },
  { 218, 5, 19, 12, 2, -19 },
  { 230, 9, 19, 12, 1, -19 },
  { 252, 9, 19, 12, 1, -19 },
  { 274, 11, 19, 12, 0, -19 },
  { 301, 9, 19, 12, 1, -19 },
  { 323, 9, 19, 12, 1, -19 },
  { 345, 9, 19, 12, 1, -19 },
  { 367, 9, 19, 12, 1, -19 },
  { 389, 9, 19, 12, 1, -19 },
  { 411, 1, 14, 5, 2, -14 },
  { 413, 2, 17, 5, 1, -14 },
  { 418, 10, 11, 12, 1, -15 },
  { 432, 10, 6, 12, 1, -12 },
  { 440, 10, 11, 12, 1, -15 },
  { 454, 6, 19, 8, 1, -19 },
  { 469, 16, 21, 18, 1, -19 },
  { 511, 11, 19, 11, 0, -19 },
  { 538, 9, 19, 13, 2, -19 },
  { 560, 11, 19, 12, 1, -19 },
  { 587, 11, 19, 14, 2, -19 },
  { 614, 8, 19, 11, 2, -19 },
  { 633, 8, 19, 10, 2, -19 },
  { 652, 12, 19, 15, 1, -19 },
  { 681, 10, 19, 14, 2, -19 },
  { 705, 4, 19, 6, 1, -19 },
  { 715, 5, 24, 5, -2, -19 },
  { 730, 9, 19, 11, 2, -19 },
  { 752, 8, 19, 10, 2, -19 },
  { 771, 14, 19, 18, 2, -19 },
  { 805, 10, 19, 15, 2, -19 },
  { 829, 13, 19, 15, 1, -19 },
  { 860, 9, 19, 12, 2, -19 },
  { 882, 13, 23, 15, 1, -19 },
  { 920, 9, 19, 12, 2, -19 },
  { 942, 9, 19, 11, 1, -19 },
  { 964, 10, 19, 10, 0, -19 },
  { 988, 10, 19, 14, 2, -19 },
  { 1012, 11, 19, 11, 0, -19 },
  { 1039, 18, 19, 19, 0, -19 },
  { 1082, 10, 19, 10, 0, -19 },
  { 1106, 10, 19, 10, 0, -19 },
  { 1130, 9, 19, 10, 1, -19 },
  { 1152, 5, 23, 8, 2, -19 },
  { 1167, 7, 19, 8, 1, -19 },
  { 1184, 5, 23, 8, 1, -19 },
  { 1199, 10, 10, 12, 1, -19 },
  { 1212, 10, 1, 10, 0, 2 },
  { 1214, 4, 4, 6, 1, -20 },
  { 1216, 8, 14, 11, 1, -14 },
  { 1230, 9, 20, 12, 2, -20 },
  { 1253, 8, 14, 9, 1, -14 },
  { 1267, 9, 20, 12, 1, -20 },
  { 1290, 9, 14, 11, 1, -14 },
  { 1306, 7, 20, 6, 0, -20 },
  { 1324, 9, 20, 12, 1, -14 },
  { 1347, 8, 20, 12, 2, -20 },
  { 1367, 1, 19, 5, 2, -19 },
  { 1370, 3, 25, 5, 0, -19 },
  { 1380, 7, 20, 9, 2, -20 },
  { 1398, 1, 20, 5, 2, -20 },
  { 1401, 14, 14, 18, 2, -14 },
  { 1426, 8, 14, 12, 2, -14 },
  { 1440, 10, 14, 12, 1, -14 },
  { 1458, 9, 20, 12, 2, -14 },
  { 1481, 9, 20, 12, 1, -14 },
  { 1504, 5, 14, 8, 2, -14 },
  { 1513, 7, 14, 9, 1, -14 },
  { 1526, 6, 17, 6, 0, -17 },
  { 1539, 8, 14, 12, 2, -14 },
  { 1553, 9, 14, 9, 0, -14 },
  { 1569, 14, 14, 15, 0, -14 },
  { 1594, 8, 14, 9, 1, -14 },
  { 1608, 9, 20, 9, 0, -14 },
  { 1631, 6, 14, 8, 1, -14 },
  { 1642, 7, 23, 9, 1, -19 },
  { 1663, 1, 26, 11, 5, -20 },
  { 1667, 7, 23, 9, 1, -19 },
  { 1688, 10, 2, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_Thin26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_THIN26PT7B_H_
