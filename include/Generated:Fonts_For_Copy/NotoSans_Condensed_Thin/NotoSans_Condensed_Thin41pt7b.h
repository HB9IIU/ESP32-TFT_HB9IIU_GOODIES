#ifndef _NOTOSANS_CONDENSED_THIN41PT7B_H_
#define _NOTOSANS_CONDENSED_THIN41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin41pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x55, 0x55, 0x55, 0x50, 0x07, 0xC0, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xA1, 0x42, 0x85, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x20,
  0x20, 0x08, 0x08, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10,
  0x02, 0x04, 0x1F, 0xFF, 0xF0, 0x40, 0x40, 0x10, 0x10, 0x04, 0x08, 0x01,
  0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x02, 0x02, 0x0F, 0xFF,
  0xF8, 0x20, 0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40,
  0x18, 0x10, 0x04, 0x04, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x00,
  0x02, 0x00, 0x08, 0x00, 0xFC, 0x0E, 0x8E, 0x62, 0x0B, 0x08, 0x08, 0x20,
  0x20, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x20, 0x80, 0x42, 0x01, 0x88,
  0x01, 0xA0, 0x03, 0x80, 0x03, 0x80, 0x0B, 0x80, 0x23, 0x00, 0x86, 0x02,
  0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC0,
  0x86, 0xC2, 0x31, 0xFF, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x1C, 0x00,
  0x00, 0x88, 0x02, 0x04, 0x10, 0x08, 0x10, 0x40, 0x40, 0xC1, 0x01, 0x02,
  0x02, 0x0C, 0x08, 0x08, 0x20, 0x20, 0x20, 0x80, 0x80, 0x84, 0x02, 0x02,
  0x10, 0x08, 0x08, 0xC0, 0x20, 0x22, 0x00, 0x80, 0x88, 0xE2, 0x02, 0x44,
  0x64, 0x11, 0x20, 0x90, 0x4C, 0x82, 0x41, 0x22, 0x04, 0xD8, 0x98, 0x11,
  0xC4, 0x40, 0x40, 0x11, 0x01, 0x00, 0x44, 0x04, 0x02, 0x10, 0x10, 0x08,
  0x40, 0x40, 0x41, 0x01, 0x01, 0x04, 0x04, 0x04, 0x08, 0x10, 0x20, 0x20,
  0xC0, 0x80, 0x82, 0x04, 0x01, 0x08, 0x10, 0x07, 0xC0, 0x07, 0x00, 0x06,
  0x60, 0x04, 0x18, 0x02, 0x04, 0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x20, 0x08, 0x10, 0x04, 0x10, 0x01, 0x18, 0x00, 0x98,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x34, 0x00, 0x31, 0x00, 0x30, 0x40, 0x90,
  0x20, 0x50, 0x08, 0x28, 0x02, 0x14, 0x01, 0x0A, 0x00, 0x49, 0x00, 0x14,
  0x80, 0x0C, 0x40, 0x02, 0x20, 0x02, 0x88, 0x02, 0x62, 0x02, 0x10, 0xFE,
  0x04, 0xFF, 0xC0, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x60,
  0x40, 0x81, 0x03, 0x02, 0x04, 0x04, 0x08, 0x08, 0x18, 0x18, 0x80, 0x81,
  0x81, 0x01, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0x81, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x60, 0x81, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x83, 0x00, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0xC2,
  0x33, 0xAC, 0x07, 0x00, 0x50, 0x09, 0x01, 0x08, 0x10, 0x42, 0x06, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x01, 0xFF, 0xFC, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x2D,
  0xA4, 0xA4, 0x80, 0xFF, 0x80, 0xBC, 0x00, 0x30, 0x02, 0x00, 0x20, 0x04,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80,
  0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x00, 0x03, 0x00, 0x3B, 0x81, 0x03, 0x08, 0x04, 0x20, 0x09, 0x00,
  0x24, 0x00, 0x90, 0x03, 0x40, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0x50, 0x02, 0x40, 0x09, 0x80, 0x22,
  0x01, 0x0C, 0x04, 0x18, 0x20, 0x3F, 0x00, 0x03, 0x05, 0x09, 0x31, 0x61,
  0xC1, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x07, 0x00, 0xE7, 0x04, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x08, 0x00, 0x60, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10,
  0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0x00, 0xE7, 0x8C, 0x03, 0x20, 0x04,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x04, 0x00, 0x30, 0x01, 0x81, 0xF8, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x80, 0x03, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x20, 0x00, 0x80, 0x04, 0x80, 0x31, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x14, 0x00, 0x0A, 0x00, 0x09, 0x00, 0x04, 0x80, 0x04, 0x40, 0x02,
  0x20, 0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x01, 0x82, 0x00, 0x81, 0x00,
  0x80, 0x80, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x20, 0x08, 0x30, 0x04,
  0x10, 0x02, 0x18, 0x01, 0x08, 0x00, 0x87, 0xFF, 0xFC, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x3F, 0xF8, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x7F, 0xE1, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08, 0x00, 0x20, 0x01, 0x30,
  0x18, 0x7F, 0xC0, 0x00, 0xE0, 0x0E, 0xE0, 0xC0, 0x06, 0x00, 0x10, 0x00,
  0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0xC7, 0xC2, 0x60, 0xCB, 0x01, 0xA8, 0x02, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x07, 0x00, 0x14, 0x00, 0x50, 0x01, 0x40, 0x05, 0x00,
  0x12, 0x00, 0x88, 0x02, 0x10, 0x10, 0x3B, 0x80, 0x10, 0x00, 0xFF, 0xFC,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x08,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x73, 0x83, 0x01, 0x18, 0x02, 0x40, 0x09, 0x00, 0x34,
  0x00, 0x50, 0x01, 0x40, 0x0D, 0x00, 0x22, 0x00, 0x8C, 0x04, 0x18, 0x60,
  0x13, 0x00, 0x30, 0x03, 0x30, 0x18, 0x20, 0x80, 0x44, 0x00, 0xB0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x14, 0x00,
  0xD0, 0x02, 0x30, 0x30, 0x7F, 0x80, 0x07, 0x00, 0x63, 0x02, 0x02, 0x10,
  0x04, 0x40, 0x1A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x34, 0x00, 0xD0, 0x05, 0x20, 0x34,
  0x63, 0x90, 0xF8, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0xC1, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x02, 0xF0, 0x6D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xB6, 0x92, 0x92, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x1C, 0x3D, 0xC8, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x02, 0x00,
  0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x18, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x60, 0x06, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x10, 0x00, 0x04, 0x30, 0x00, 0x06,
  0x20, 0x00, 0x02, 0x60, 0x1F, 0x02, 0x40, 0x60, 0x82, 0x40, 0x40, 0x81,
  0x40, 0x81, 0x81, 0xC0, 0x81, 0x81, 0x81, 0x01, 0x81, 0x81, 0x01, 0x01,
  0x81, 0x01, 0x01, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01, 0x81, 0x01, 0x01,
  0x81, 0x01, 0x03, 0x81, 0x03, 0x02, 0xC1, 0x82, 0x82, 0x40, 0x86, 0x84,
  0x40, 0x7C, 0x7C, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x06, 0x00, 0x40,
  0x03, 0x83, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0A,
  0x00, 0x04, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x21, 0x00, 0x08, 0x40,
  0x02, 0x10, 0x00, 0x84, 0x00, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x03,
  0x03, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x07, 0xFF, 0x81, 0x00,
  0x20, 0x40, 0x08, 0x30, 0x03, 0x08, 0x00, 0x42, 0x00, 0x10, 0x80, 0x04,
  0x40, 0x00, 0x90, 0x00, 0x24, 0x00, 0x0B, 0x00, 0x02, 0x80, 0x00, 0x40,
  0xFF, 0xE1, 0x80, 0x33, 0x00, 0x26, 0x00, 0x2C, 0x00, 0x58, 0x00, 0xB0,
  0x01, 0x60, 0x02, 0xC0, 0x05, 0x80, 0x0B, 0x00, 0x36, 0x00, 0x4C, 0x03,
  0x1F, 0xF8, 0x30, 0x0C, 0x60, 0x04, 0xC0, 0x05, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x05, 0x80,
  0x0B, 0x00, 0x26, 0x01, 0x8F, 0xFC, 0x00, 0x00, 0x38, 0x03, 0xC7, 0x06,
  0x01, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x20, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x01, 0x01, 0xFF, 0xFF, 0xC0, 0x60, 0x18, 0x30,
  0x02, 0x18, 0x00, 0x8C, 0x00, 0x66, 0x00, 0x13, 0x00, 0x0D, 0x80, 0x02,
  0xC0, 0x01, 0x60, 0x00, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x58,
  0x00, 0x2C, 0x00, 0x16, 0x00, 0x0B, 0x00, 0x09, 0x80, 0x04, 0xC0, 0x04,
  0x60, 0x06, 0x30, 0x06, 0x18, 0x0E, 0x0F, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFB, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xDF, 0xFE, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x3C, 0x78, 0x18, 0x01, 0x86, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x1F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80,
  0x00, 0x50, 0x00, 0x09, 0x00, 0x01, 0x20, 0x00, 0x22, 0x00, 0x04, 0x60,
  0x00, 0x86, 0x00, 0x10, 0x70, 0x06, 0x03, 0xFF, 0x80, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xFC, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0xFC, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x03, 0x02, 0x06, 0xFC, 0xC0, 0x0D, 0x80, 0x13, 0x00, 0x46, 0x01,
  0x8C, 0x02, 0x18, 0x08, 0x30, 0x30, 0x60, 0xC0, 0xC1, 0x01, 0x84, 0x03,
  0x18, 0x06, 0x20, 0x0C, 0x80, 0x1A, 0x80, 0x3D, 0x80, 0x71, 0x00, 0xC3,
  0x01, 0x82, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x04, 0x18, 0x0C, 0x30, 0x08,
  0x60, 0x18, 0xC0, 0x11, 0x80, 0x13, 0x00, 0x26, 0x00, 0x2C, 0x00, 0x60,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0x40,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7D, 0x00, 0x01, 0x7A, 0x00,
  0x02, 0xF4, 0x00, 0x05, 0xE4, 0x00, 0x13, 0xC8, 0x00, 0x27, 0x90, 0x00,
  0x4F, 0x10, 0x01, 0x1E, 0x20, 0x02, 0x3C, 0x40, 0x04, 0x78, 0x40, 0x10,
  0xF0, 0x80, 0x21, 0xE1, 0x00, 0x43, 0xC1, 0x01, 0x07, 0x82, 0x02, 0x0F,
  0x04, 0x04, 0x1E, 0x04, 0x10, 0x3C, 0x08, 0x20, 0x78, 0x10, 0x40, 0xF0,
  0x11, 0x01, 0xE0, 0x22, 0x03, 0xC0, 0x44, 0x07, 0x80, 0x50, 0x0F, 0x00,
  0xA0, 0x1E, 0x01, 0xC0, 0x3C, 0x01, 0x00, 0x60, 0xC0, 0x01, 0xF0, 0x00,
  0xE8, 0x00, 0x7E, 0x00, 0x3D, 0x00, 0x1E, 0xC0, 0x0F, 0x20, 0x07, 0x98,
  0x03, 0xC4, 0x01, 0xE3, 0x00, 0xF0, 0x80, 0x78, 0x20, 0x3C, 0x10, 0x1E,
  0x04, 0x0F, 0x02, 0x07, 0x80, 0x83, 0xC0, 0x41, 0xE0, 0x10, 0xF0, 0x08,
  0x78, 0x02, 0x3C, 0x01, 0x1E, 0x00, 0x4F, 0x00, 0x27, 0x80, 0x09, 0xC0,
  0x04, 0xE0, 0x01, 0x70, 0x00, 0xB8, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x39, 0xE0, 0x0C, 0x03, 0x01, 0x80, 0x18, 0x10, 0x00, 0x82, 0x00,
  0x04, 0x20, 0x00, 0x44, 0x00, 0x06, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x24, 0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x24, 0x00, 0x02,
  0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x26, 0x00, 0x06, 0x20, 0x00,
  0x43, 0x00, 0x04, 0x10, 0x00, 0x80, 0x80, 0x10, 0x04, 0x02, 0x00, 0x3F,
  0xC0, 0xFF, 0xC3, 0x01, 0xCC, 0x01, 0x30, 0x02, 0xC0, 0x0B, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xB0, 0x02, 0xC0, 0x0B,
  0x00, 0x4C, 0x03, 0x3F, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x39, 0xE0, 0x0C, 0x03, 0x01,
  0x80, 0x18, 0x10, 0x00, 0x82, 0x00, 0x04, 0x20, 0x00, 0x44, 0x00, 0x02,
  0x40, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0xC0, 0x00,
  0x28, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x24, 0x00, 0x02, 0x40, 0x00, 0x24, 0x00, 0x02, 0x40,
  0x00, 0x26, 0x00, 0x06, 0x20, 0x00, 0x43, 0x00, 0x04, 0x10, 0x00, 0x80,
  0x80, 0x10, 0x04, 0x02, 0x00, 0x3F, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0xFF, 0xC1, 0x80, 0x63, 0x00, 0x66, 0x00, 0x4C, 0x00, 0x98, 0x00,
  0xB0, 0x01, 0x60, 0x02, 0xC0, 0x05, 0x80, 0x0B, 0x00, 0x26, 0x00, 0x4C,
  0x01, 0x98, 0x06, 0x30, 0x38, 0x7F, 0x80, 0xC1, 0x81, 0x81, 0x03, 0x03,
  0x06, 0x02, 0x0C, 0x06, 0x18, 0x04, 0x30, 0x0C, 0x60, 0x08, 0xC0, 0x19,
  0x80, 0x13, 0x00, 0x36, 0x00, 0x2C, 0x00, 0x60, 0x03, 0x80, 0x71, 0xE3,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06, 0x80, 0x33, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x60, 0x02, 0x20, 0x06, 0x18, 0x0C, 0x0F, 0xF0, 0x80, 0x00, 0xE0,
  0x00, 0x50, 0x00, 0x28, 0x00, 0x24, 0x00, 0x11, 0x00, 0x08, 0x80, 0x0C,
  0x40, 0x04, 0x20, 0x02, 0x08, 0x01, 0x04, 0x01, 0x02, 0x00, 0x80, 0x80,
  0x40, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x04, 0x08, 0x02, 0x0C, 0x01,
  0x04, 0x00, 0x82, 0x00, 0x21, 0x00, 0x11, 0x00, 0x08, 0x80, 0x02, 0x40,
  0x01, 0x60, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x18, 0x00, 0x08, 0x00, 0x80,
  0x04, 0x00, 0x38, 0x00, 0x40, 0x02, 0x80, 0x0A, 0x00, 0x2C, 0x00, 0xA0,
  0x02, 0x40, 0x0A, 0x00, 0x64, 0x00, 0xA0, 0x04, 0x40, 0x0B, 0x00, 0x44,
  0x01, 0x10, 0x04, 0x20, 0x11, 0x00, 0x42, 0x01, 0x10, 0x08, 0x20, 0x11,
  0x00, 0x82, 0x03, 0x08, 0x08, 0x30, 0x20, 0x80, 0x81, 0x02, 0x08, 0x10,
  0x10, 0x20, 0x81, 0x01, 0x02, 0x0C, 0x10, 0x18, 0x40, 0x41, 0x00, 0x84,
  0x04, 0x30, 0x08, 0x40, 0x42, 0x00, 0x84, 0x04, 0x20, 0x08, 0xC0, 0x22,
  0x00, 0x48, 0x02, 0x60, 0x04, 0x80, 0x24, 0x00, 0x48, 0x02, 0x40, 0x04,
  0x80, 0x34, 0x00, 0x70, 0x01, 0x40, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x03, 0x00, 0x18, 0x00, 0x60, 0x02, 0x20, 0x04, 0x30, 0x04, 0x10,
  0x0C, 0x18, 0x08, 0x08, 0x18, 0x08, 0x10, 0x04, 0x10, 0x04, 0x20, 0x02,
  0x20, 0x02, 0x40, 0x03, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x02, 0x40, 0x02, 0x40, 0x04, 0x20, 0x04, 0x20, 0x08, 0x10, 0x08,
  0x10, 0x18, 0x18, 0x10, 0x08, 0x30, 0x0C, 0x20, 0x04, 0x60, 0x04, 0x40,
  0x02, 0xC0, 0x03, 0x80, 0x02, 0x80, 0x0D, 0x00, 0x13, 0x00, 0x22, 0x00,
  0x84, 0x01, 0x04, 0x06, 0x08, 0x08, 0x18, 0x10, 0x10, 0x40, 0x20, 0x80,
  0x23, 0x00, 0x44, 0x00, 0xC8, 0x00, 0xA0, 0x01, 0x40, 0x01, 0x80, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x7F, 0xFC,
  0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08,
  0x00, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFF,
  0xFC, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF,
  0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x20, 0x01, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x40, 0x04, 0x00, 0x20,
  0x02, 0x00, 0x20, 0x01, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x80, 0x04,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x02, 0x00, 0x30, 0xFF, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF, 0x00, 0x80, 0x01, 0x40, 0x01,
  0x40, 0x02, 0x20, 0x06, 0x20, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x08, 0x18,
  0x08, 0x10, 0x0C, 0x30, 0x04, 0x20, 0x06, 0x60, 0x02, 0x40, 0x03, 0xC0,
  0x01, 0xFF, 0xFF, 0x81, 0x02, 0x04, 0x18, 0x30, 0x1F, 0x87, 0x0C, 0x00,
  0x20, 0x02, 0x00, 0x30, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x0F,
  0xF3, 0x01, 0x60, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x05, 0x40, 0x93, 0xF1, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x1F, 0x09, 0x83,
  0x2C, 0x04, 0xA0, 0x0B, 0x00, 0x2C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0xB0, 0x02, 0xA0, 0x12, 0x40, 0xC8, 0xFC, 0x00,
  0x07, 0xE0, 0xC1, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x04, 0x00, 0x60, 0x02, 0x00, 0x18, 0x00, 0xFF, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x1F, 0x11, 0x82, 0x4C, 0x05, 0x20, 0x0D, 0x00, 0x34, 0x00, 0x50,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x05, 0x00, 0x14, 0x00, 0xD0, 0x03, 0x20, 0x14,
  0xC0, 0xD0, 0xFC, 0x40, 0x07, 0xC0, 0xC3, 0x0C, 0x0C, 0x40, 0x24, 0x00,
  0xA0, 0x05, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40,
  0x01, 0x80, 0x87, 0xF8, 0x07, 0xE0, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x1F, 0xE0, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x07,
  0xC4, 0x60, 0x93, 0x01, 0x48, 0x03, 0x40, 0x0D, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x40, 0x05, 0x00, 0x34, 0x00, 0xC8, 0x05, 0x30, 0x24,
  0x3F, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x03,
  0x00, 0x0A, 0x00, 0x47, 0x06, 0x07, 0xE0, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x3E, 0x26,
  0x19, 0x60, 0x6A, 0x01, 0x60, 0x0B, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0xBC, 0x00,
  0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0xA0, 0x08, 0x30, 0xC0, 0x00, 0x00, 0x00,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x21, 0xBC,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x02, 0x80, 0x48, 0x0C, 0x80, 0x88, 0x10, 0x83, 0x08, 0x20,
  0x84, 0x08, 0x80, 0x98, 0x09, 0x40, 0xA4, 0x0C, 0x20, 0xC3, 0x08, 0x10,
  0x81, 0x88, 0x08, 0x80, 0xC8, 0x04, 0x80, 0x68, 0x02, 0x80, 0x30, 0xFF,
  0xFF, 0xFF, 0xFE, 0x8F, 0x83, 0xE2, 0x43, 0x18, 0x4A, 0x06, 0x80, 0xB0,
  0x0A, 0x03, 0xC0, 0x30, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x04,
  0x01, 0x80, 0x10, 0x06, 0x00, 0x40, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01,
  0x80, 0x10, 0x06, 0x00, 0x40, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01, 0x80,
  0x10, 0x06, 0x00, 0x40, 0x18, 0x01, 0x00, 0x60, 0x04, 0x01, 0x80, 0x10,
  0x06, 0x00, 0x40, 0x10, 0x87, 0xC4, 0xC3, 0x28, 0x05, 0x40, 0x2C, 0x01,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x07, 0xC0, 0x30, 0x60, 0x80, 0x63, 0x00, 0x44,
  0x00, 0xC8, 0x00, 0xB0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xA0, 0x01, 0x40, 0x02, 0x40, 0x04,
  0x80, 0x09, 0x80, 0x21, 0x00, 0xC1, 0x03, 0x01, 0xFC, 0x00, 0x87, 0xC2,
  0x60, 0xCB, 0x01, 0x28, 0x02, 0xC0, 0x0B, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x2A, 0x00, 0xA8, 0x04, 0x90, 0x32, 0x3F,
  0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x07, 0xC4, 0x60, 0x93, 0x01, 0x48,
  0x03, 0x40, 0x0D, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x40, 0x05,
  0x00, 0x34, 0x00, 0xC8, 0x05, 0x30, 0x24, 0x3F, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x40, 0x01, 0x8F, 0xCC, 0x6C, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x08, 0x04, 0x00, 0x1F, 0x8C, 0x0D, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0x80, 0x18,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x28, 0x0D, 0xFF, 0x00, 0x20, 0x20,
  0x20, 0x20, 0x20, 0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10,
  0x1F, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x0A, 0x80, 0x56, 0x04, 0x9F,
  0xC4, 0x80, 0x0F, 0x00, 0x24, 0x00, 0x90, 0x02, 0x40, 0x10, 0x80, 0x42,
  0x01, 0x08, 0x0C, 0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x10, 0x08, 0x40,
  0x21, 0x00, 0x8C, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x50, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x10, 0x02, 0x80, 0x30, 0x09, 0x00, 0x60,
  0x12, 0x01, 0x40, 0x26, 0x02, 0x80, 0x44, 0x04, 0x81, 0x08, 0x09, 0x02,
  0x10, 0x32, 0x04, 0x30, 0x44, 0x08, 0x20, 0x84, 0x30, 0x41, 0x08, 0x40,
  0x86, 0x10, 0x81, 0x88, 0x21, 0x01, 0x10, 0x62, 0x02, 0x20, 0x48, 0x04,
  0xC0, 0x90, 0x09, 0x01, 0x20, 0x0A, 0x02, 0x40, 0x14, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0x40, 0x18, 0x00, 0x80, 0x1A, 0x00, 0x98,
  0x0C, 0x40, 0x43, 0x06, 0x08, 0x20, 0x63, 0x01, 0x10, 0x05, 0x00, 0x28,
  0x00, 0x80, 0x0C, 0x00, 0x50, 0x06, 0xC0, 0x22, 0x03, 0x18, 0x10, 0x41,
  0x03, 0x08, 0x08, 0x80, 0x24, 0x01, 0x40, 0x04, 0x40, 0x05, 0x00, 0x14,
  0x00, 0x88, 0x02, 0x20, 0x08, 0x80, 0x62, 0x01, 0x04, 0x04, 0x10, 0x10,
  0x40, 0x80, 0x82, 0x02, 0x08, 0x08, 0x60, 0x31, 0x00, 0x44, 0x01, 0x10,
  0x04, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xE0, 0x03, 0x00, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20,
  0x09, 0x80, 0x3C, 0x00, 0x7F, 0xE0, 0x0C, 0x01, 0x00, 0x20, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0xFF, 0xC0, 0x03,
  0xC1, 0x80, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x38, 0x03, 0x00, 0x60,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x06, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0x70,
  0x30, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x0F, 0x00, 0x7E, 0x03, 0x06,
  0x0E, 0x03, 0xF0,
};

const GFXglyph NotoSans_Condensed_Thin41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 29, 8, 3, -29 },
  { 9, 7, 10, 12, 3, -29 },
  { 18, 18, 29, 20, 1, -29 },
  { 84, 14, 33, 18, 2, -31 },
  { 142, 22, 30, 26, 2, -30 },
  { 225, 17, 30, 20, 2, -30 },
  { 289, 1, 10, 7, 3, -29 },
  { 291, 7, 35, 11, 2, -29 },
  { 322, 7, 35, 11, 2, -29 },
  { 353, 12, 12, 17, 2, -31 },
  { 371, 15, 19, 18, 2, -24 },
  { 407, 3, 9, 7, 2, -4 },
  { 411, 9, 1, 12, 1, -12 },
  { 413, 2, 3, 8, 3, -3 },
  { 414, 12, 29, 13, 1, -29 },
  { 458, 14, 30, 18, 2, -30 },
  { 511, 8, 29, 18, 3, -29 },
  { 540, 14, 30, 18, 2, -30 },
  { 593, 14, 30, 18, 2, -30 },
  { 646, 17, 29, 18, 1, -29 },
  { 708, 14, 29, 18, 2, -29 },
  { 759, 14, 31, 18, 2, -30 },
  { 814, 14, 29, 18, 2, -29 },
  { 865, 14, 30, 18, 2, -30 },
  { 918, 14, 30, 18, 2, -30 },
  { 971, 2, 22, 8, 3, -22 },
  { 977, 3, 27, 8, 2, -22 },
  { 988, 15, 17, 18, 2, -23 },
  { 1020, 15, 9, 18, 2, -19 },
  { 1037, 15, 17, 18, 2, -23 },
  { 1069, 10, 30, 13, 1, -30 },
  { 1107, 24, 33, 28, 2, -29 },
  { 1206, 18, 29, 18, 0, -29 },
  { 1272, 15, 29, 20, 3, -29 },
  { 1327, 16, 30, 19, 2, -30 },
  { 1387, 17, 29, 22, 3, -29 },
  { 1449, 13, 29, 18, 3, -29 },
  { 1497, 13, 29, 16, 3, -29 },
  { 1545, 19, 30, 24, 2, -30 },
  { 1617, 16, 29, 23, 3, -29 },
  { 1675, 6, 29, 10, 2, -29 },
  { 1697, 8, 36, 8, -3, -29 },
  { 1733, 15, 29, 18, 3, -29 },
  { 1788, 12, 29, 16, 3, -29 },
  { 1832, 23, 29, 29, 3, -29 },
  { 1916, 17, 29, 23, 3, -29 },
  { 1978, 20, 30, 24, 2, -30 },
  { 2053, 14, 29, 18, 3, -29 },
  { 2104, 20, 37, 24, 2, -30 },
  { 2197, 15, 29, 19, 3, -29 },
  { 2252, 14, 30, 18, 2, -30 },
  { 2305, 16, 29, 16, 0, -29 },
  { 2363, 16, 29, 23, 3, -29 },
  { 2421, 17, 29, 17, 0, -29 },
  { 2483, 28, 29, 29, 1, -29 },
  { 2585, 16, 29, 16, 0, -29 },
  { 2643, 15, 29, 15, 0, -29 },
  { 2698, 14, 29, 16, 1, -29 },
  { 2749, 8, 35, 13, 3, -29 },
  { 2784, 12, 29, 13, 1, -29 },
  { 2828, 8, 35, 13, 1, -29 },
  { 2863, 16, 15, 18, 1, -29 },
  { 2893, 16, 1, 16, 0, 4 },
  { 2895, 6, 6, 10, 2, -31 },
  { 2900, 12, 22, 17, 2, -22 },
  { 2933, 14, 31, 19, 3, -31 },
  { 2988, 12, 22, 15, 2, -22 },
  { 3021, 14, 31, 19, 2, -31 },
  { 3076, 13, 22, 18, 2, -22 },
  { 3112, 11, 31, 9, 0, -31 },
  { 3155, 14, 32, 19, 2, -22 },
  { 3211, 13, 31, 19, 3, -31 },
  { 3262, 2, 30, 8, 3, -30 },
  { 3270, 6, 40, 8, -1, -30 },
  { 3300, 12, 31, 15, 3, -31 },
  { 3347, 1, 31, 7, 3, -31 },
  { 3351, 22, 22, 28, 3, -22 },
  { 3412, 13, 22, 19, 3, -22 },
  { 3448, 15, 22, 19, 2, -22 },
  { 3490, 14, 32, 19, 3, -22 },
  { 3546, 14, 32, 19, 2, -22 },
  { 3602, 9, 22, 12, 3, -22 },
  { 3627, 11, 22, 15, 2, -22 },
  { 3658, 8, 27, 10, 1, -27 },
  { 3685, 13, 22, 19, 3, -22 },
  { 3721, 14, 22, 14, 0, -22 },
  { 3760, 23, 22, 23, 0, -22 },
  { 3824, 13, 22, 15, 1, -22 },
  { 3860, 14, 32, 14, 0, -22 },
  { 3916, 11, 22, 13, 1, -22 },
  { 3947, 10, 35, 14, 2, -29 },
  { 3991, 1, 41, 17, 8, -31 },
  { 3997, 10, 35, 14, 2, -29 },
  { 4041, 15, 3, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_Thin41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_THIN41PT7B_H_
