#ifndef _NOTOSANS_CONDENSED_THIN19PT7B_H_
#define _NOTOSANS_CONDENSED_THIN19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE4, 0xB6, 0xDA, 0x11, 0x08, 0x84, 0x82, 0x47, 0xF8, 0x90,
  0x48, 0x44, 0x22, 0x7F, 0x89, 0x04, 0x82, 0x41, 0x20, 0x38, 0xAA, 0x44,
  0x89, 0x12, 0x1C, 0x0C, 0x14, 0x24, 0x48, 0x99, 0x4F, 0x04, 0x00, 0x61,
  0x24, 0x49, 0x22, 0x48, 0x92, 0x25, 0x29, 0x76, 0x69, 0x6A, 0x42, 0x91,
  0x24, 0x49, 0x22, 0x48, 0x70, 0x30, 0x48, 0x48, 0x48, 0x48, 0x48, 0x30,
  0x50, 0x91, 0x89, 0x86, 0x82, 0x86, 0x79, 0xF8, 0x25, 0x29, 0x24, 0x92,
  0x49, 0x12, 0x20, 0x91, 0x22, 0x49, 0x24, 0x92, 0x92, 0x80, 0x22, 0x97,
  0x8C, 0x48, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0xF0, 0xF0,
  0x80, 0x04, 0x10, 0x82, 0x08, 0x41, 0x04, 0x20, 0x84, 0x10, 0x42, 0x00,
  0x38, 0x8A, 0x14, 0x28, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x14, 0x24, 0x47,
  0x00, 0x2E, 0x92, 0x49, 0x24, 0x92, 0x40, 0x7A, 0x10, 0x41, 0x04, 0x10,
  0x42, 0x08, 0x42, 0x10, 0x43, 0xF0, 0x7A, 0x10, 0x41, 0x04, 0x17, 0x82,
  0x04, 0x10, 0x41, 0x07, 0xE0, 0x02, 0x04, 0x0A, 0x0A, 0x12, 0x12, 0x22,
  0x22, 0x42, 0x82, 0xFF, 0x02, 0x02, 0x02, 0x7D, 0x02, 0x04, 0x08, 0x10,
  0x3E, 0x02, 0x02, 0x04, 0x08, 0x10, 0x5F, 0x00, 0x1C, 0x41, 0x04, 0x08,
  0x12, 0x3B, 0x42, 0x83, 0x06, 0x0C, 0x14, 0x4F, 0x00, 0xFC, 0x10, 0x41,
  0x08, 0x20, 0x84, 0x10, 0x42, 0x08, 0x21, 0x00, 0x38, 0x8A, 0x14, 0x18,
  0x48, 0x8E, 0x24, 0x85, 0x06, 0x0C, 0x18, 0x4F, 0x00, 0x7A, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x7C, 0x10, 0x41, 0x0B, 0xC0, 0x80, 0x40, 0x80, 0xF0,
  0x02, 0x18, 0xC6, 0x08, 0x0C, 0x06, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x80, 0xC0, 0x60, 0x20, 0x63, 0x08, 0x60, 0xF0, 0x42, 0x10, 0x84, 0x44,
  0x21, 0x08, 0x00, 0x10, 0x0F, 0x06, 0x11, 0x01, 0x20, 0x18, 0x63, 0x12,
  0x64, 0x4C, 0x89, 0x91, 0x32, 0x26, 0x4C, 0xC6, 0x68, 0x00, 0x80, 0x08,
  0x00, 0xF8, 0x08, 0x08, 0x18, 0x14, 0x24, 0x24, 0x24, 0x22, 0x3E, 0x42,
  0x41, 0x81, 0x81, 0x81, 0xF2, 0x38, 0x61, 0x86, 0x1F, 0xA2, 0x86, 0x18,
  0x61, 0x87, 0xE0, 0x1F, 0x20, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x40, 0x40, 0x3F, 0xF1, 0x12, 0x14, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x5F, 0x00, 0xFC, 0x21, 0x08, 0x43, 0xF0, 0x84,
  0x21, 0x08, 0x7C, 0xFC, 0x21, 0x08, 0x42, 0x1F, 0x84, 0x21, 0x08, 0x40,
  0x1F, 0x10, 0x50, 0x08, 0x08, 0x04, 0x02, 0x01, 0x0F, 0x80, 0xC0, 0x60,
  0x28, 0x14, 0x09, 0xFC, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x40, 0xE9, 0x24, 0x92, 0x49, 0x25, 0xC0, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x86, 0x28, 0xA4, 0xA2, 0x8C, 0x28,
  0xA2, 0x49, 0x22, 0x86, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x7C, 0x80, 0x60, 0x18, 0x0E, 0x03, 0xC1, 0x70, 0x5A, 0x16, 0x89,
  0xA2, 0x64, 0x99, 0x46, 0x51, 0x8C, 0x62, 0x10, 0x83, 0x06, 0x0E, 0x1C,
  0x34, 0x68, 0xC9, 0x93, 0x16, 0x1C, 0x38, 0x30, 0x40, 0x1E, 0x30, 0x90,
  0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x28, 0x14, 0x11,
  0xF0, 0xF2, 0x28, 0x61, 0x86, 0x18, 0xBC, 0x82, 0x08, 0x20, 0x82, 0x00,
  0x1E, 0x10, 0x90, 0x50, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x28, 0x14, 0x11, 0xD0, 0x10, 0x04, 0x03, 0x00, 0xF2, 0x28, 0x61, 0x86,
  0x18, 0xBC, 0x92, 0x48, 0xA2, 0x86, 0x10, 0x3F, 0x08, 0x20, 0x82, 0x06,
  0x06, 0x04, 0x10, 0x41, 0x07, 0xE0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x3E, 0x81, 0x81, 0x81,
  0x42, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x14, 0x18, 0x18, 0x08, 0x82,
  0x0C, 0x10, 0x60, 0x82, 0x86, 0x14, 0x50, 0xA2, 0x89, 0x12, 0x44, 0x92,
  0x28, 0x91, 0x45, 0x0A, 0x28, 0x30, 0xC1, 0x04, 0x08, 0x20, 0x82, 0x85,
  0x11, 0x22, 0x83, 0x04, 0x08, 0x28, 0x50, 0x92, 0x24, 0x30, 0x40, 0x83,
  0x05, 0x12, 0x24, 0x45, 0x0A, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x00,
  0xFC, 0x10, 0x82, 0x10, 0x41, 0x08, 0x21, 0x04, 0x20, 0x83, 0xF0, 0xF2,
  0x49, 0x24, 0x92, 0x49, 0x24, 0xE0, 0x81, 0x04, 0x10, 0x20, 0x82, 0x04,
  0x10, 0x40, 0x82, 0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0xE0,
  0x08, 0x18, 0x14, 0x24, 0x22, 0x42, 0xC1, 0xFE, 0x91, 0x80, 0xF8, 0x42,
  0x13, 0xE6, 0x31, 0x8F, 0xC0, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x1C, 0x37, 0x80, 0x3A, 0x21, 0x08, 0x42, 0x10, 0x83,
  0xC0, 0x02, 0x04, 0x08, 0x17, 0xB0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x6F, 0x40, 0x7A, 0x18, 0x61, 0xFE, 0x08, 0x20, 0x81, 0xF0, 0x19, 0x08,
  0x84, 0x79, 0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x7E, 0x18, 0x61, 0x86,
  0x18, 0x61, 0x85, 0xF0, 0x41, 0x06, 0x17, 0x80, 0x82, 0x08, 0x20, 0xBF,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0xCF, 0xFC, 0x50, 0x55, 0x55,
  0x55, 0x58, 0x82, 0x08, 0x20, 0x8E, 0x29, 0x28, 0xA3, 0x49, 0x22, 0x8A,
  0x10, 0xFF, 0xFC, 0xBB, 0xD8, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61,
  0x0C, 0x21, 0x84, 0x30, 0x84, 0xBF, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x10, 0x79, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x84, 0xF0, 0xBD, 0x86,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC3, 0x7A, 0x04, 0x08, 0x10, 0x00, 0x7E,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0, 0x41, 0x04, 0x10, 0xBC, 0x88,
  0x88, 0x88, 0x88, 0xFC, 0x21, 0x06, 0x08, 0x21, 0x0F, 0x80, 0x44, 0xF4,
  0x44, 0x44, 0x44, 0x43, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xF0,
  0x86, 0x14, 0x51, 0x49, 0x22, 0x8C, 0x30, 0x40, 0x84, 0x61, 0x14, 0xA5,
  0x29, 0x4A, 0x52, 0xA3, 0x18, 0xC6, 0x31, 0x88, 0x40, 0x44, 0x88, 0xA1,
  0x41, 0x02, 0x0A, 0x24, 0x45, 0x0C, 0x83, 0x09, 0x12, 0x24, 0x85, 0x0A,
  0x14, 0x30, 0x20, 0x41, 0x02, 0x04, 0x30, 0x00, 0xF1, 0x12, 0x24, 0x48,
  0x8F, 0x19, 0x08, 0x42, 0x10, 0x88, 0xC2, 0x08, 0x42, 0x10, 0x84, 0x18,
  0xFF, 0xFF, 0xE0, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x19, 0x08, 0x42, 0x10,
  0x84, 0xC0, 0x61, 0x3C,
};

const GFXglyph NotoSans_Condensed_Thin19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 14, 4, 1, -14 },
  { 3, 3, 5, 6, 1, -14 },
  { 5, 9, 14, 9, 0, -14 },
  { 21, 7, 15, 9, 1, -14 },
  { 35, 10, 14, 12, 1, -14 },
  { 53, 8, 14, 9, 1, -14 },
  { 67, 1, 5, 3, 1, -14 },
  { 68, 3, 17, 5, 1, -14 },
  { 75, 3, 17, 5, 1, -14 },
  { 82, 6, 5, 8, 1, -14 },
  { 86, 7, 9, 9, 1, -11 },
  { 94, 1, 4, 3, 1, -2 },
  { 95, 4, 1, 5, 1, -6 },
  { 96, 1, 1, 4, 1, -1 },
  { 97, 6, 14, 6, 0, -14 },
  { 108, 7, 14, 9, 1, -14 },
  { 121, 3, 14, 9, 2, -14 },
  { 127, 6, 14, 9, 1, -14 },
  { 138, 6, 14, 9, 1, -14 },
  { 149, 8, 14, 9, 0, -14 },
  { 163, 7, 14, 9, 1, -14 },
  { 176, 7, 14, 9, 1, -14 },
  { 189, 6, 14, 9, 1, -14 },
  { 200, 7, 14, 9, 1, -14 },
  { 213, 6, 14, 9, 1, -14 },
  { 224, 1, 10, 4, 1, -10 },
  { 226, 1, 12, 4, 1, -10 },
  { 228, 7, 8, 9, 1, -11 },
  { 235, 7, 5, 9, 1, -9 },
  { 240, 7, 8, 9, 1, -11 },
  { 247, 5, 14, 6, 0, -14 },
  { 256, 11, 16, 13, 1, -14 },
  { 278, 8, 14, 8, 0, -14 },
  { 292, 6, 14, 9, 2, -14 },
  { 303, 8, 14, 9, 1, -14 },
  { 317, 7, 14, 10, 2, -14 },
  { 330, 5, 14, 8, 2, -14 },
  { 339, 5, 14, 7, 2, -14 },
  { 348, 9, 14, 11, 1, -14 },
  { 364, 7, 14, 10, 2, -14 },
  { 377, 3, 14, 5, 1, -14 },
  { 383, 3, 17, 4, -1, -14 },
  { 390, 6, 14, 8, 2, -14 },
  { 401, 5, 14, 7, 2, -14 },
  { 410, 10, 14, 13, 2, -14 },
  { 428, 7, 14, 11, 2, -14 },
  { 441, 9, 14, 11, 1, -14 },
  { 457, 6, 14, 9, 2, -14 },
  { 468, 9, 17, 11, 1, -14 },
  { 488, 6, 14, 9, 2, -14 },
  { 499, 6, 14, 8, 1, -14 },
  { 510, 7, 14, 7, 0, -14 },
  { 523, 8, 14, 11, 1, -14 },
  { 537, 8, 14, 8, 0, -14 },
  { 551, 13, 14, 14, 0, -14 },
  { 574, 7, 14, 7, 0, -14 },
  { 587, 7, 14, 7, 0, -14 },
  { 600, 6, 14, 8, 1, -14 },
  { 611, 3, 17, 6, 2, -14 },
  { 618, 6, 14, 6, 0, -14 },
  { 629, 3, 17, 6, 1, -14 },
  { 636, 8, 7, 9, 0, -14 },
  { 643, 7, 1, 7, 0, 1 },
  { 644, 3, 3, 4, 1, -15 },
  { 646, 5, 10, 8, 1, -10 },
  { 653, 7, 14, 9, 1, -14 },
  { 666, 5, 10, 7, 1, -10 },
  { 673, 7, 14, 9, 1, -14 },
  { 686, 6, 10, 8, 1, -10 },
  { 694, 5, 15, 4, 0, -15 },
  { 704, 6, 15, 9, 1, -10 },
  { 716, 6, 14, 9, 1, -14 },
  { 727, 1, 14, 4, 1, -14 },
  { 729, 2, 19, 4, 0, -14 },
  { 734, 6, 14, 7, 1, -14 },
  { 745, 1, 14, 3, 1, -14 },
  { 747, 11, 10, 13, 1, -10 },
  { 761, 6, 10, 9, 1, -10 },
  { 769, 7, 10, 9, 1, -10 },
  { 778, 7, 14, 9, 1, -10 },
  { 791, 6, 14, 9, 1, -10 },
  { 802, 4, 10, 6, 1, -10 },
  { 807, 5, 10, 7, 1, -10 },
  { 814, 4, 12, 5, 0, -12 },
  { 820, 6, 10, 9, 1, -10 },
  { 828, 6, 10, 6, 0, -10 },
  { 836, 10, 10, 11, 0, -10 },
  { 849, 7, 10, 7, 0, -10 },
  { 858, 7, 15, 7, 0, -10 },
  { 872, 4, 10, 6, 1, -10 },
  { 877, 5, 17, 7, 1, -14 },
  { 888, 1, 19, 8, 4, -14 },
  { 891, 5, 17, 7, 1, -14 },
  { 902, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Thin19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_THIN19PT7B_H_
