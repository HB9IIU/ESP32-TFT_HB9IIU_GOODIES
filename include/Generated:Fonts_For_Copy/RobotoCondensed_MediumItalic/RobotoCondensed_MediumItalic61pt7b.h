#ifndef _ROBOTOCONDENSED_MEDIUMITALIC61PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x3F, 0x3E, 0x3E, 0x7E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0xF8, 0x7C,
  0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0xF8, 0x3C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x78, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C,
  0x1F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xC0,
  0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x41, 0xF0, 0x7C, 0x07, 0x0F, 0x83, 0xE0, 0x3C, 0x7C, 0x0F, 0x03, 0xE3,
  0xC0, 0xF8, 0x3E, 0x1E, 0x07, 0xC1, 0xF0, 0xF0, 0x3E, 0x1F, 0x07, 0x81,
  0xF1, 0xF0, 0x3C, 0x0F, 0x9F, 0x01, 0xF0, 0xF8, 0xF8, 0x0F, 0x87, 0xCF,
  0x80, 0x7F, 0xFC, 0xF8, 0x01, 0xFF, 0xE7, 0xC0, 0x07, 0xFE, 0x7C, 0x00,
  0x1F, 0xE7, 0xC0, 0x00, 0x10, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF1,
  0xFC, 0x00, 0x1F, 0x3F, 0xF8, 0x00, 0xF9, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF,
  0x00, 0xF9, 0xF8, 0xF8, 0x07, 0xCF, 0x83, 0xE0, 0x7C, 0x7C, 0x1F, 0x07,
  0xC7, 0xC0, 0xF8, 0x3E, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x3E, 0x0F,
  0x81, 0xF3, 0xE0, 0x7C, 0x0F, 0x1F, 0x03, 0xE0, 0xF8, 0xF0, 0x1F, 0x07,
  0xC3, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x3F, 0xC0, 0x01,
  0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0xC0, 0xF8, 0x3F, 0xFF, 0x87,
  0xE1, 0xFE, 0xFE, 0x1F, 0x8F, 0xF3, 0xFC, 0x7E, 0x3F, 0x87, 0xF3, 0xF9,
  0xFC, 0x0F, 0xEF, 0xC7, 0xF0, 0x3F, 0xBF, 0x1F, 0xC0, 0x7F, 0xF8, 0x7F,
  0x01, 0xFF, 0xE3, 0xF8, 0x03, 0xFF, 0x8F, 0xF0, 0x0F, 0xFC, 0x1F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x1F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0xFF, 0x00, 0xFF, 0xE1, 0xFC, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x78, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x60, 0x3E, 0x02, 0x3C, 0x1F, 0x0F, 0x3F, 0x8F, 0x3F,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFB, 0xE0, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF8,
  0x1F, 0x01, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x0C, 0x01, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87,
  0xF1, 0xFC, 0x3F, 0x03, 0xC0, 0x30, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x1F, 0x1F, 0xCF, 0xFF, 0xFB,
  0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F,
  0x87, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01,
  0xF9, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0,
  0x03, 0xFB, 0xF8, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F, 0xCF,
  0xE0, 0x07, 0xE7, 0xF0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01, 0xFC,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF,
  0x7F, 0x3F, 0x3C, 0x1F, 0x98, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x3F,
  0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x87, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F,
  0x87, 0xF0, 0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x1F, 0xF1, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xFC,
  0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x07,
  0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xC0, 0x3F, 0xBF, 0xF0, 0x3F, 0x7F,
  0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xC1,
  0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFE, 0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0xCF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xE7,
  0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x07, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07,
  0xF8, 0x7F, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7E,
  0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00,
  0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F,
  0xF3, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F,
  0x01, 0xFE, 0x7F, 0x83, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFD, 0xF8, 0x03, 0xF3, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xC0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F,
  0x80, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x02, 0x00,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0xFC, 0x00, 0xFC, 0x01, 0xE0, 0x3E,
  0x00, 0xFF, 0xC0, 0x7C, 0x1F, 0x00, 0xFF, 0xF8, 0x0F, 0x07, 0xC0, 0x7F,
  0xFF, 0x03, 0xC3, 0xE0, 0x3F, 0xFF, 0xC0, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0,
  0x3C, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xC7,
  0xC0, 0xF8, 0x0F, 0x80, 0xF1, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0xF8, 0x1F,
  0x80, 0xF8, 0x0F, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0x1F,
  0x01, 0xF7, 0xC0, 0xFC, 0x07, 0xC0, 0x79, 0xF0, 0x3E, 0x01, 0xF0, 0x1E,
  0x7C, 0x0F, 0x80, 0xF8, 0x07, 0x9F, 0x07, 0xE0, 0x3E, 0x01, 0xE7, 0xC1,
  0xF8, 0x0F, 0x80, 0xF9, 0xF0, 0x7E, 0x03, 0xE0, 0x3C, 0x78, 0x1F, 0x81,
  0xF0, 0x0F, 0x1E, 0x07, 0xC0, 0x7C, 0x07, 0xCF, 0x81, 0xF8, 0x3F, 0x01,
  0xE3, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0xF8, 0x1F, 0x87, 0xF0, 0x3C, 0x3E,
  0x07, 0xF3, 0xFC, 0x1F, 0x07, 0x80, 0xFF, 0xFF, 0xDF, 0x81, 0xE0, 0x3F,
  0xFB, 0xFF, 0xC0, 0x78, 0x07, 0xFC, 0xFF, 0xE0, 0x1F, 0x01, 0xFE, 0x1F,
  0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x00, 0x38, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF1,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0,
  0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFF, 0x07, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x03, 0xF8,
  0x03, 0xFE, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0xFE, 0x3F, 0x80, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xF9,
  0xFC, 0x03, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xE7, 0xF0, 0x0F, 0xFF, 0x8F,
  0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8,
  0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x07,
  0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x01,
  0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x00, 0x1F,
  0xF1, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x7E, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x7E, 0xFC, 0x00, 0xFD, 0xFC, 0x0F, 0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0xFE,
  0x7C, 0x01, 0xF9, 0xF8, 0x0F, 0xE7, 0xC0, 0x1F, 0xBF, 0x80, 0xFE, 0x7C,
  0x03, 0xF3, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x3F, 0x80, 0xFC, 0x7E, 0x07,
  0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x01, 0xFC, 0x7E, 0x0F, 0xC7,
  0xF0, 0x1F, 0xC7, 0xE0, 0xFC, 0x7F, 0x01, 0xFC, 0x3E, 0x1F, 0x87, 0xF0,
  0x1F, 0xC3, 0xE1, 0xF8, 0x7F, 0x01, 0xFC, 0x3E, 0x3F, 0x0F, 0xE0, 0x3F,
  0x83, 0xE3, 0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x7E, 0x0F, 0xE0, 0x3F, 0x83,
  0xF7, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x7C, 0x0F, 0xE0, 0x3F, 0x81, 0xFF,
  0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x0F,
  0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0x00,
  0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0x00, 0xFE, 0x03, 0xFF,
  0x80, 0x1F, 0xC0, 0x3F, 0xF8, 0x01, 0xFC, 0x07, 0xFF, 0x80, 0x1F, 0xC0,
  0x7F, 0xFC, 0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0x7C, 0x01,
  0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0x80, 0x7F, 0x7E, 0x03, 0xF8, 0x0F, 0xF3,
  0xE0, 0x3F, 0x80, 0xFE, 0x3E, 0x03, 0xF8, 0x0F, 0xE3, 0xF0, 0x3F, 0x80,
  0xFE, 0x3F, 0x07, 0xF8, 0x0F, 0xE1, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0x87,
  0xF0, 0x1F, 0xC1, 0xF8, 0x7F, 0x01, 0xFC, 0x0F, 0x87, 0xF0, 0x1F, 0xC0,
  0xFC, 0x7F, 0x01, 0xFC, 0x0F, 0xCF, 0xE0, 0x1F, 0xC0, 0x7C, 0xFE, 0x01,
  0xFC, 0x07, 0xCF, 0xE0, 0x3F, 0x80, 0x7E, 0xFE, 0x03, 0xF8, 0x07, 0xEF,
  0xE0, 0x3F, 0x80, 0x3E, 0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0x80,
  0x3F, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x1F, 0xFC, 0x07,
  0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0xFF, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE,
  0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x03, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x0F,
  0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xDF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFF,
  0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F,
  0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE1,
  0xFC, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x1F,
  0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF0, 0x07, 0xF7, 0xF0,
  0x07, 0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xFC, 0x03, 0xF9, 0xFC, 0x03, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xFF, 0x00, 0xFC, 0x7F, 0x01, 0xFF, 0x80, 0xFE,
  0x3F, 0x80, 0xFF, 0xC0, 0x7F, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0x0F, 0xE0,
  0x7F, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x7C,
  0x0F, 0xC1, 0xFC, 0x1F, 0xBE, 0x0F, 0xE0, 0xFE, 0x0F, 0x9F, 0x07, 0xF0,
  0x7F, 0x0F, 0xCF, 0x83, 0xF0, 0x3F, 0x87, 0xE7, 0xC3, 0xF8, 0x1F, 0xC3,
  0xE3, 0xE1, 0xFC, 0x0F, 0xE3, 0xF1, 0xF0, 0xFC, 0x07, 0xF1, 0xF8, 0xF8,
  0xFE, 0x03, 0xF9, 0xF8, 0x7C, 0x7F, 0x01, 0xFC, 0xFC, 0x3E, 0x3F, 0x00,
  0xFE, 0x7C, 0x1F, 0x3F, 0x80, 0x7F, 0x7E, 0x0F, 0x9F, 0xC0, 0x3F, 0xBF,
  0x07, 0xCF, 0xC0, 0x1F, 0xDF, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8,
  0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFF, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xF7, 0x80, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7,
  0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC1, 0xF8, 0x7C, 0x1F, 0x87, 0xE3, 0xF0,
  0x3E, 0x3F, 0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x03, 0xEF, 0xC0, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xE3, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F,
  0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F,
  0xE3, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01,
  0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xF3, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFB, 0xF8, 0x0F,
  0xF1, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0xFF, 0x80, 0x1F, 0xBF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0x3F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC7, 0xF0, 0x03,
  0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE3, 0xFE, 0x03, 0xF8, 0x7F, 0xF3, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFB, 0xFF, 0xF8, 0x3F, 0x3F, 0xFE, 0x07, 0xE7,
  0xFF, 0x81, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFC,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0xF3,
  0xF8, 0x07, 0xFF, 0xDF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE7, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01,
  0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0,
  0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0x80, 0x07, 0xF8,
  0xFC, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xF1, 0xFE, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x7F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x20,
  0x7F, 0x00, 0xF0, 0x7F, 0xC7, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F, 0xC0,
  0x3F, 0xFC, 0xFC, 0x03, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xBF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF9, 0xFF, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1,
  0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0xC0,
  0x03, 0xFE, 0xFE, 0x00, 0x01, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x18, 0x01, 0xFE, 0x01, 0xF0, 0x1F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x3F,
  0xE0, 0x1F, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xF9, 0xFF, 0x07, 0xF8, 0x1F, 0xC3, 0xFC, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07,
  0xF0, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x87, 0xF0,
  0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x70, 0x07, 0xE0, 0x1F, 0xC0,
  0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7E, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x81, 0xFE,
  0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x00, 0x7E, 0x1F, 0xE0, 0x07,
  0xF1, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xE0,
  0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x01, 0xF9, 0xFF, 0x03,
  0xFE, 0x00, 0xFD, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xF3, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF1,
  0xFF, 0xF3, 0xFE, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x7E, 0x00,
  0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC3, 0xF0, 0x07, 0xF0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x1F,
  0x80, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xC0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0x0F,
  0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0xFE,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0x80,
  0x7F, 0x7F, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x7F, 0xE7, 0xFC, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8,
  0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE3, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF7, 0xF0,
  0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0xFF, 0x1F, 0xC0, 0xFF, 0x0F, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE7, 0xFC, 0x00,
  0x3F, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xF8, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7E, 0x7F, 0xFC, 0x07, 0xF3, 0xFF, 0xC0,
  0x3F, 0x87, 0xF8, 0x01, 0xFC, 0x04, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xF0, 0x3F, 0xF8, 0xFC, 0x1F, 0xFF,
  0x7F, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0x8F, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x8F,
  0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFE, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFB, 0xF8, 0x00,
  0x20, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x77, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x7F,
  0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF0,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x01, 0x00, 0x00,
  0x0F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0x7E, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xE0,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0xE0, 0x01, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFE,
  0x7E, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0,
  0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0xBF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3F, 0x7E, 0x03, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x01, 0xF9, 0xF8, 0x1F,
  0xE0, 0x3F, 0x3F, 0x03, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x81, 0xF8, 0xFC,
  0x1F, 0xF0, 0x7F, 0x1F, 0x83, 0xFF, 0x0F, 0xE3, 0xF0, 0xFF, 0xE1, 0xF8,
  0x7E, 0x1F, 0xFC, 0x7F, 0x0F, 0xC3, 0xEF, 0x8F, 0xC1, 0xF8, 0xFD, 0xF1,
  0xF8, 0x3F, 0x1F, 0x3E, 0x7F, 0x07, 0xE7, 0xE7, 0xCF, 0xC0, 0x7C, 0xF8,
  0xF9, 0xF8, 0x0F, 0xBF, 0x1F, 0x7E, 0x01, 0xF7, 0xE3, 0xEF, 0xC0, 0x3E,
  0xF8, 0x7D, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xF8,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x7F, 0x87, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0xC1,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x3F,
  0x3F, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x40, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x1F, 0x1F, 0xFC, 0x01, 0xF3, 0xFF, 0xE0, 0x1F, 0x3F,
  0xFF, 0x03, 0xF7, 0xFF, 0xF8, 0x3E, 0x7E, 0x3F, 0xC7, 0xEF, 0xC1, 0xFF,
  0xFE, 0xFC, 0x0F, 0xFF, 0xCF, 0x80, 0x7F, 0xF8, 0xF8, 0x03, 0xFF, 0x8F,
  0x80, 0x1F, 0xF0, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 44, 15, 1, -43 },
  { 84, 16, 16, 19, 5, -46 },
  { 116, 30, 43, 32, 2, -43 },
  { 278, 27, 57, 30, 2, -50 },
  { 471, 29, 45, 38, 5, -44 },
  { 635, 30, 45, 33, 1, -44 },
  { 804, 8, 15, 10, 4, -46 },
  { 819, 18, 63, 19, 3, -49 },
  { 961, 19, 62, 19, -3, -48 },
  { 1109, 25, 26, 26, 3, -43 },
  { 1191, 25, 32, 29, 2, -36 },
  { 1291, 11, 17, 13, -3, -7 },
  { 1315, 14, 6, 18, 2, -22 },
  { 1326, 9, 9, 16, 1, -8 },
  { 1337, 27, 47, 21, -3, -43 },
  { 1496, 25, 45, 30, 3, -44 },
  { 1637, 17, 43, 30, 7, -43 },
  { 1729, 28, 44, 30, 0, -44 },
  { 1883, 27, 45, 30, 1, -44 },
  { 2035, 27, 43, 30, 1, -43 },
  { 2181, 28, 44, 30, 2, -43 },
  { 2335, 24, 44, 30, 3, -43 },
  { 2467, 28, 43, 30, 3, -43 },
  { 2618, 26, 45, 30, 2, -44 },
  { 2765, 24, 44, 30, 4, -44 },
  { 2897, 13, 34, 15, 1, -33 },
  { 2953, 16, 43, 14, -3, -33 },
  { 3039, 23, 28, 26, 2, -33 },
  { 3120, 24, 18, 29, 3, -29 },
  { 3174, 25, 28, 27, 1, -33 },
  { 3262, 21, 45, 26, 5, -44 },
  { 3381, 42, 56, 45, 1, -42 },
  { 3675, 33, 43, 35, -2, -43 },
  { 3853, 31, 43, 33, 1, -43 },
  { 4020, 31, 45, 34, 3, -44 },
  { 4195, 31, 43, 34, 1, -43 },
  { 4362, 31, 43, 29, 1, -43 },
  { 4529, 30, 43, 28, 1, -43 },
  { 4691, 31, 45, 35, 3, -44 },
  { 4866, 36, 43, 36, 1, -43 },
  { 5060, 15, 43, 15, 1, -43 },
  { 5141, 30, 44, 29, 0, -43 },
  { 5306, 36, 43, 33, 1, -43 },
  { 5500, 24, 43, 28, 1, -43 },
  { 5629, 44, 43, 45, 1, -43 },
  { 5866, 36, 43, 36, 1, -43 },
  { 6060, 31, 45, 36, 3, -44 },
  { 6235, 32, 43, 33, 1, -43 },
  { 6407, 31, 52, 36, 3, -44 },
  { 6609, 31, 43, 32, 1, -43 },
  { 6776, 31, 45, 31, 1, -44 },
  { 6951, 29, 43, 32, 5, -43 },
  { 7107, 33, 44, 34, 2, -43 },
  { 7289, 32, 43, 34, 5, -43 },
  { 7461, 41, 43, 45, 6, -43 },
  { 7682, 37, 43, 33, -2, -43 },
  { 7881, 31, 43, 32, 5, -43 },
  { 8048, 34, 43, 31, -1, -43 },
  { 8231, 20, 60, 15, -1, -50 },
  { 8381, 13, 47, 22, 5, -43 },
  { 8458, 20, 60, 15, -3, -50 },
  { 8608, 20, 22, 23, 2, -43 },
  { 8663, 23, 6, 24, -3, 0 },
  { 8681, 12, 9, 19, 6, -46 },
  { 8695, 25, 34, 28, 1, -33 },
  { 8802, 27, 47, 29, 0, -46 },
  { 8961, 24, 34, 27, 2, -33 },
  { 9063, 29, 47, 29, 2, -46 },
  { 9234, 24, 34, 28, 2, -33 },
  { 9336, 21, 47, 19, 2, -47 },
  { 9460, 29, 45, 30, 0, -33 },
  { 9624, 26, 46, 29, 0, -46 },
  { 9774, 14, 45, 14, 1, -45 },
  { 9853, 21, 57, 14, -6, -45 },
  { 10003, 29, 46, 28, 0, -46 },
  { 10170, 14, 46, 14, 1, -46 },
  { 10251, 41, 33, 44, 0, -33 },
  { 10421, 26, 33, 29, 0, -33 },
  { 10529, 25, 34, 30, 2, -33 },
  { 10636, 29, 45, 29, -2, -33 },
  { 10800, 26, 45, 29, 2, -33 },
  { 10947, 20, 33, 19, 0, -33 },
  { 11030, 24, 34, 27, 1, -33 },
  { 11132, 17, 41, 18, 2, -40 },
  { 11220, 26, 33, 29, 2, -32 },
  { 11328, 24, 32, 26, 3, -32 },
  { 11424, 35, 32, 38, 4, -32 },
  { 11564, 29, 32, 26, -2, -32 },
  { 11680, 29, 44, 26, -2, -32 },
  { 11840, 27, 32, 26, -1, -32 },
  { 11948, 18, 59, 18, 2, -48 },
  { 12081, 13, 51, 15, 1, -43 },
  { 12164, 18, 59, 18, -2, -48 },
  { 12297, 28, 13, 34, 3, -25 },
};

const GFXfont RobotoCondensed_MediumItalic61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC61PT7B_H_
