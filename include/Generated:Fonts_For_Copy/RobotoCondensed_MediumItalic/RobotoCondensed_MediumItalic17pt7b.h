#ifndef _ROBOTOCONDENSED_MEDIUMITALIC17PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x26, 0x66, 0x00, 0x44, 0x5A, 0xD5, 0xA0, 0x0B, 0x1A,
  0x12, 0x16, 0x7F, 0x24, 0x2C, 0xFE, 0x48, 0x58, 0xD0, 0x90, 0x08, 0x10,
  0xF3, 0xF6, 0x6C, 0xD8, 0x38, 0x1C, 0x1A, 0x36, 0x6F, 0xCE, 0x08, 0x10,
  0x61, 0x62, 0x5C, 0xAB, 0x9F, 0x0F, 0x9D, 0x53, 0xA6, 0x68, 0x60, 0x1E,
  0x0F, 0x0C, 0x86, 0xC3, 0xE0, 0xC0, 0xE4, 0xDA, 0xCF, 0x63, 0x1F, 0x87,
  0x60, 0x5F, 0x08, 0xCC, 0x46, 0x23, 0x18, 0xC6, 0x31, 0x08, 0x43, 0x18,
  0x42, 0x00, 0x10, 0x86, 0x10, 0x84, 0x21, 0x08, 0xC6, 0x31, 0x18, 0xCC,
  0x44, 0x00, 0x18, 0x23, 0x5B, 0xE3, 0x0B, 0x12, 0x00, 0x18, 0x30, 0x47,
  0xFF, 0xC6, 0x0C, 0x18, 0x20, 0x6D, 0xAC, 0xFE, 0xE8, 0x02, 0x06, 0x04,
  0x0C, 0x0C, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x3C, 0xFD,
  0x9E, 0x3C, 0x78, 0xF1, 0xE6, 0xCD, 0x9B, 0xE3, 0x80, 0x1B, 0xBC, 0x63,
  0x18, 0xC4, 0x63, 0x18, 0xC0, 0x1E, 0x3F, 0x33, 0x63, 0x03, 0x06, 0x0C,
  0x18, 0x30, 0x70, 0xFE, 0xFE, 0x1E, 0x3E, 0x63, 0x03, 0x03, 0x1E, 0x1C,
  0x06, 0x06, 0xC6, 0x7C, 0x38, 0x07, 0x07, 0x0E, 0x1E, 0x16, 0x36, 0x66,
  0xFF, 0xFE, 0x0C, 0x0C, 0x0C, 0x3E, 0x7D, 0x83, 0x07, 0x9F, 0x83, 0x02,
  0x0D, 0x9B, 0xE3, 0x80, 0x0C, 0xF7, 0x18, 0xFB, 0xFC, 0xF1, 0xCF, 0x3F,
  0x9C, 0x7F, 0xFE, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60,
  0xC0, 0x1E, 0x3F, 0x33, 0x33, 0x33, 0x3E, 0x3C, 0x66, 0x66, 0x66, 0x7C,
  0x38, 0x3C, 0xF9, 0x9E, 0x3C, 0x78, 0xDF, 0x3E, 0x0C, 0x31, 0xC3, 0x00,
  0x33, 0x00, 0x00, 0x0E, 0x40, 0x38, 0xC0, 0x00, 0x00, 0x04, 0x63, 0x19,
  0x80, 0x02, 0x1C, 0xF3, 0x86, 0x07, 0x07, 0x02, 0x7F, 0xF8, 0x07, 0xEF,
  0xC0, 0x20, 0xE0, 0xF0, 0x70, 0xE7, 0x18, 0x40, 0x39, 0xFC, 0xC3, 0x1C,
  0xE3, 0x18, 0x00, 0x06, 0x18, 0x07, 0xC0, 0xC6, 0x18, 0x23, 0x01, 0x23,
  0x96, 0x49, 0x4C, 0x94, 0x99, 0x59, 0x3D, 0x92, 0xDB, 0x6C, 0xDC, 0x40,
  0x04, 0x00, 0x32, 0x01, 0xE0, 0x03, 0x01, 0xC0, 0x70, 0x34, 0x0D, 0x82,
  0x61, 0x98, 0x7E, 0x3F, 0x8C, 0x66, 0x19, 0x82, 0x3F, 0x1F, 0x8C, 0x66,
  0x33, 0x3B, 0xF9, 0xF8, 0xC6, 0x63, 0x31, 0xBF, 0x9F, 0x80, 0x1E, 0x3F,
  0x63, 0x63, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xC6, 0xFE, 0x78, 0x3E, 0x1F,
  0x8C, 0x66, 0x33, 0x1B, 0x0D, 0x86, 0xC6, 0x63, 0x31, 0xBF, 0x9F, 0x80,
  0x3F, 0x9F, 0xCC, 0x06, 0x03, 0x03, 0xF1, 0xF8, 0xC0, 0x60, 0x30, 0x3F,
  0x9F, 0xC0, 0x3F, 0x9F, 0x8C, 0x06, 0x03, 0x03, 0xF1, 0xF8, 0xC0, 0x60,
  0x30, 0x30, 0x18, 0x00, 0x1E, 0x3F, 0x63, 0x63, 0xC0, 0xCF, 0xCF, 0xC3,
  0xC7, 0xC6, 0xFE, 0x7C, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x30, 0xDF, 0xE7,
  0xF9, 0x86, 0x61, 0x98, 0x6C, 0x13, 0x0C, 0x33, 0x33, 0x36, 0x66, 0x66,
  0x6C, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0xC6, 0xCC, 0x7C,
  0x78, 0x31, 0xCC, 0x63, 0x30, 0xD8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x66,
  0x19, 0x8C, 0x73, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60,
  0xC3, 0xFF, 0xF0, 0x38, 0x39, 0xC3, 0x8E, 0x1C, 0x71, 0xE2, 0x8F, 0x34,
  0x59, 0xB6, 0x8D, 0xAC, 0x6F, 0x63, 0x73, 0x31, 0x99, 0x88, 0xC0, 0x30,
  0xCE, 0x33, 0x8C, 0xE3, 0x3C, 0x9B, 0x66, 0x59, 0x96, 0x67, 0x98, 0xEC,
  0x33, 0x0C, 0x1E, 0x1F, 0x98, 0xCC, 0x2C, 0x36, 0x1B, 0x0D, 0x86, 0xC3,
  0x63, 0x3F, 0x8F, 0x00, 0x3F, 0x1F, 0xCC, 0x66, 0x33, 0x1B, 0x0D, 0xFC,
  0xFC, 0x60, 0x30, 0x30, 0x18, 0x00, 0x1E, 0x3F, 0x63, 0x63, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0x7C, 0x0E, 0x04, 0x3F, 0x1F, 0xCC, 0x66,
  0x33, 0x3B, 0xF9, 0xF8, 0xCC, 0x66, 0x33, 0x31, 0x98, 0x60, 0x1E, 0x1F,
  0x8C, 0x66, 0x33, 0x01, 0xE0, 0x38, 0x0E, 0xC3, 0x31, 0x9F, 0x87, 0x80,
  0x7F, 0xFF, 0x86, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x00, 0x61, 0xB1, 0x98, 0xCC, 0x6C, 0x36, 0x1B, 0x0D, 0x8C, 0xC6,
  0x63, 0x3F, 0x0F, 0x00, 0xE1, 0xB1, 0xD8, 0xCC, 0x66, 0x63, 0x31, 0xB0,
  0xD8, 0x28, 0x1C, 0x0E, 0x06, 0x00, 0xCC, 0x79, 0x8F, 0x33, 0x6E, 0x6D,
  0xCD, 0xAB, 0x3D, 0x67, 0x2C, 0xE7, 0x1C, 0xE3, 0x1C, 0x63, 0x00, 0x31,
  0xCC, 0x63, 0x30, 0x7C, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x36, 0x19, 0x86,
  0x63, 0x0C, 0x63, 0xB1, 0x99, 0x8C, 0xC2, 0xC1, 0xE0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x00, 0x3F, 0x9F, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x60, 0x30, 0x30, 0x3F, 0x9F, 0xC0, 0x39, 0xCC, 0x63, 0x11, 0x8C, 0x63,
  0x18, 0xCC, 0x63, 0x1C, 0xE0, 0x46, 0x66, 0x66, 0x62, 0x33, 0x33, 0x30,
  0x1C, 0xE1, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x30, 0xC6, 0x38,
  0xE0, 0x31, 0x9C, 0xBD, 0xCC, 0xFF, 0xF8, 0xC9, 0x80, 0x1C, 0x7D, 0x98,
  0x33, 0xEC, 0xF1, 0x7E, 0x7C, 0x30, 0x30, 0x30, 0x30, 0x2E, 0x7E, 0x63,
  0x63, 0x62, 0x66, 0x46, 0xFE, 0xDC, 0x1C, 0x7D, 0x9B, 0x04, 0x18, 0x11,
  0xBE, 0x38, 0x01, 0x01, 0x80, 0xC0, 0x63, 0xB3, 0xF9, 0x88, 0xCC, 0x46,
  0x63, 0x31, 0x8F, 0xC7, 0x40, 0x1C, 0x7D, 0x9B, 0x37, 0xE8, 0x10, 0x3E,
  0x3C, 0x19, 0xD8, 0xCF, 0x79, 0x88, 0xC6, 0x31, 0x8C, 0x00, 0x3B, 0x7F,
  0x63, 0x66, 0x46, 0xC6, 0x46, 0x7E, 0x74, 0x0C, 0xFC, 0x78, 0x30, 0x60,
  0xC1, 0x86, 0xEF, 0xD9, 0xB3, 0x66, 0xCF, 0x1E, 0x3C, 0xC0, 0x33, 0x03,
  0x66, 0x66, 0x66, 0xCC, 0x0C, 0x30, 0x03, 0x18, 0x61, 0x86, 0x18, 0x43,
  0x0C, 0x33, 0xCE, 0x00, 0x30, 0x30, 0x30, 0x30, 0x27, 0x6E, 0x6C, 0x78,
  0x78, 0x78, 0x4C, 0xCC, 0xCE, 0x33, 0x33, 0x36, 0x66, 0x66, 0x6C, 0xC0,
  0x2E, 0xE7, 0xFE, 0x66, 0x36, 0x62, 0x66, 0x66, 0x66, 0x46, 0x6C, 0x46,
  0xCC, 0x60, 0x2E, 0xFD, 0x9B, 0x36, 0x6C, 0xF1, 0xE3, 0xCC, 0x1C, 0x3E,
  0x62, 0x63, 0x42, 0xC6, 0x46, 0x7C, 0x38, 0x17, 0x1F, 0x8C, 0x66, 0x33,
  0x11, 0x99, 0x8C, 0xFE, 0x6E, 0x30, 0x18, 0x08, 0x00, 0x3B, 0x7F, 0x62,
  0x66, 0x46, 0xC6, 0xC6, 0x7E, 0x7C, 0x0C, 0x0C, 0x0C, 0x2D, 0xE6, 0x18,
  0x61, 0x84, 0x30, 0xC0, 0x3C, 0xFD, 0x9B, 0x83, 0xC1, 0xB1, 0x3E, 0x78,
  0x66, 0xFF, 0x6C, 0xCC, 0xCE, 0xE0, 0x47, 0x8F, 0x36, 0x6C, 0xD9, 0xB3,
  0x7E, 0xE8, 0xCD, 0x9B, 0x36, 0xCD, 0x8A, 0x1C, 0x30, 0x60, 0xCC, 0xF3,
  0x2D, 0xDB, 0x76, 0xF7, 0x39, 0xCE, 0x63, 0x98, 0xC6, 0x00, 0x66, 0x26,
  0x3C, 0x38, 0x38, 0x38, 0x68, 0xEC, 0xCC, 0x33, 0x19, 0x8D, 0x86, 0xC3,
  0x60, 0xE0, 0x70, 0x30, 0x18, 0x18, 0x1C, 0x1C, 0x00, 0x7E, 0xFC, 0x30,
  0xC3, 0x86, 0x18, 0x7E, 0xFC, 0x0C, 0x61, 0x8C, 0x30, 0xC3, 0x18, 0xC1,
  0x86, 0x18, 0x61, 0x86, 0x08, 0x33, 0x22, 0x22, 0x66, 0x44, 0x44, 0x4C,
  0x10, 0x61, 0x86, 0x18, 0x61, 0x86, 0x1C, 0xC3, 0x0C, 0x30, 0x86, 0x30,
  0x63, 0xF2, 0x9E, 0x8C,
};

const GFXglyph RobotoCondensed_MediumItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 5, 4, 5, 1, -13 },
  { 10, 8, 12, 9, 1, -12 },
  { 22, 7, 16, 8, 1, -14 },
  { 36, 7, 12, 10, 2, -12 },
  { 47, 9, 12, 9, 0, -12 },
  { 61, 2, 4, 3, 1, -13 },
  { 62, 5, 18, 5, 1, -14 },
  { 74, 5, 18, 5, -1, -14 },
  { 86, 7, 7, 7, 1, -12 },
  { 93, 7, 9, 8, 1, -10 },
  { 101, 3, 5, 4, -1, -2 },
  { 103, 4, 2, 5, 1, -6 },
  { 104, 3, 2, 5, 0, -2 },
  { 105, 8, 13, 6, -1, -12 },
  { 118, 7, 12, 8, 1, -12 },
  { 129, 5, 12, 8, 2, -12 },
  { 137, 8, 12, 8, 0, -12 },
  { 149, 8, 12, 8, 0, -12 },
  { 161, 8, 12, 8, 0, -12 },
  { 173, 7, 12, 8, 1, -12 },
  { 184, 6, 12, 8, 1, -12 },
  { 193, 8, 12, 8, 1, -12 },
  { 205, 8, 12, 8, 0, -12 },
  { 217, 7, 12, 8, 1, -12 },
  { 228, 4, 9, 4, 0, -9 },
  { 233, 5, 12, 4, -1, -9 },
  { 241, 7, 8, 7, 0, -9 },
  { 248, 7, 5, 8, 1, -8 },
  { 253, 7, 8, 8, 0, -9 },
  { 260, 6, 12, 7, 1, -12 },
  { 269, 12, 16, 13, 0, -12 },
  { 293, 10, 12, 10, -1, -12 },
  { 308, 9, 12, 9, 0, -12 },
  { 322, 8, 12, 9, 1, -12 },
  { 334, 9, 12, 9, 0, -12 },
  { 348, 9, 12, 8, 0, -12 },
  { 362, 9, 12, 8, 0, -12 },
  { 376, 8, 12, 10, 1, -12 },
  { 388, 10, 12, 10, 0, -12 },
  { 403, 4, 12, 4, 0, -12 },
  { 409, 8, 12, 8, 0, -12 },
  { 421, 10, 12, 9, 0, -12 },
  { 436, 7, 12, 8, 0, -12 },
  { 447, 13, 12, 12, 0, -12 },
  { 467, 10, 12, 10, 0, -12 },
  { 482, 9, 12, 10, 1, -12 },
  { 496, 9, 12, 9, 0, -12 },
  { 510, 8, 14, 10, 1, -12 },
  { 524, 9, 12, 9, 0, -12 },
  { 538, 9, 12, 9, 0, -12 },
  { 552, 9, 12, 9, 1, -12 },
  { 566, 9, 12, 9, 1, -12 },
  { 580, 9, 12, 9, 1, -12 },
  { 594, 11, 12, 12, 2, -12 },
  { 611, 10, 12, 9, 0, -12 },
  { 626, 9, 12, 9, 1, -12 },
  { 640, 9, 12, 9, 0, -12 },
  { 654, 5, 17, 4, 0, -14 },
  { 665, 4, 13, 6, 1, -12 },
  { 672, 6, 17, 4, -1, -14 },
  { 685, 5, 6, 6, 1, -12 },
  { 689, 7, 2, 7, -1, 0 },
  { 691, 3, 3, 5, 2, -13 },
  { 693, 7, 9, 8, 0, -9 },
  { 701, 8, 13, 8, 0, -13 },
  { 714, 7, 9, 8, 0, -9 },
  { 722, 9, 13, 8, 0, -13 },
  { 737, 7, 9, 8, 0, -9 },
  { 745, 5, 13, 5, 1, -13 },
  { 754, 8, 12, 8, 0, -9 },
  { 766, 7, 13, 8, 0, -13 },
  { 778, 4, 12, 4, 0, -12 },
  { 784, 6, 15, 4, -2, -12 },
  { 796, 8, 13, 8, 0, -13 },
  { 809, 4, 13, 4, 0, -13 },
  { 816, 12, 9, 12, 0, -9 },
  { 830, 7, 9, 8, 0, -9 },
  { 838, 8, 9, 8, 0, -9 },
  { 847, 9, 12, 8, -1, -9 },
  { 861, 8, 12, 8, 0, -9 },
  { 873, 6, 9, 5, 0, -9 },
  { 880, 7, 9, 8, 0, -9 },
  { 888, 4, 11, 5, 1, -11 },
  { 894, 7, 9, 8, 1, -9 },
  { 902, 7, 9, 7, 1, -9 },
  { 910, 10, 9, 11, 1, -9 },
  { 922, 8, 9, 7, 0, -9 },
  { 931, 9, 12, 7, -1, -9 },
  { 945, 7, 9, 7, 0, -9 },
  { 953, 6, 16, 5, 0, -13 },
  { 965, 4, 14, 4, 0, -12 },
  { 972, 6, 16, 5, -1, -13 },
  { 984, 8, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_MediumItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC17PT7B_H_
