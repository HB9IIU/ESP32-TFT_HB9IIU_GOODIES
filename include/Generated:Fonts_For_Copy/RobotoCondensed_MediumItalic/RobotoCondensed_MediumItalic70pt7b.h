#ifndef _ROBOTOCONDENSED_MEDIUMITALIC70PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x38, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0xFC,
  0x7E, 0x1F, 0x8F, 0xC3, 0xE1, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3F, 0x0F, 0xC7,
  0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x1F,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F,
  0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFE, 0x1F,
  0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x60, 0xFC, 0x0F, 0x80, 0x78, 0x7E, 0x07, 0xC0, 0x3E, 0x3E, 0x03,
  0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x1F, 0x0F, 0xC0,
  0x7C, 0x1F, 0x87, 0xE0, 0x3E, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0x81, 0xF8,
  0x1F, 0x8F, 0xC0, 0x7C, 0x0F, 0x8F, 0xC0, 0x3F, 0x0F, 0xC7, 0xC0, 0x1F,
  0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0xE7, 0xE0, 0x03, 0xFF, 0xE7, 0xE0, 0x00,
  0xFF, 0xE3, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x7C, 0x7F, 0xF0, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x7E, 0x7F,
  0xFE, 0x00, 0x3E, 0x3F, 0xFF, 0x80, 0x3F, 0x3F, 0x07, 0xC0, 0x3F, 0x1F,
  0x83, 0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0xC1, 0xF0, 0x1F, 0x8F, 0xC0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x03, 0xE7, 0xE0,
  0x1F, 0x03, 0xF0, 0xE0, 0x0F, 0xC1, 0xF0, 0x30, 0x07, 0xF3, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC7, 0xFC,
  0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0x07, 0xFF, 0xF8, 0x1F, 0xC3,
  0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0x8F, 0xF8, 0xFE,
  0x3F, 0xE1, 0xFE, 0x3F, 0x8F, 0xF0, 0x7F, 0xCF, 0xE7, 0xFC, 0x0F, 0xF7,
  0xF1, 0xFE, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0x1F, 0xE0, 0x1F,
  0xFF, 0x87, 0xF8, 0x03, 0xFF, 0xE1, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0x80,
  0x1F, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFD, 0xFF,
  0x00, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xFE, 0x0F, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x9F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x0F, 0xC0, 0x23, 0xC0, 0xF8, 0x1E,
  0x7F, 0x0F, 0x87, 0xF7, 0xFC, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0x3E, 0x00, 0x0F, 0xE3, 0xF0, 0x01, 0xFC, 0x3F,
  0x00, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01,
  0xE0, 0x0F, 0x80, 0x0C, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xE0, 0x06, 0x00,
  0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFF, 0xFC, 0x08, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00,
  0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC,
  0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF8, 0xFE,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00,
  0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0xFF,
  0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0x7F,
  0x80, 0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00,
  0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x0F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xE3, 0xFC,
  0xF0, 0x3F, 0x8C, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F,
  0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0x83,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF0,
  0xFF, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0x0F, 0x80, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x1F, 0xEF, 0xFE, 0x01, 0xFD, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF0, 0x3F, 0xE7, 0xFE, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8,
  0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xF7, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF,
  0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xE7, 0xF0, 0x01,
  0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7,
  0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0x83, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFC, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF8, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF8, 0x01,
  0xFC, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8,
  0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x1F, 0xF9, 0xFF, 0x07, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0x00, 0x3F, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x0F, 0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE,
  0x03, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x01, 0xF8, 0x03, 0x80, 0x00, 0x00, 0x04, 0x00, 0x07, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x40, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xFF,
  0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x7C, 0x1F, 0x80, 0x3F, 0xFF,
  0xC0, 0xF8, 0x7E, 0x00, 0xFF, 0xFF, 0x81, 0xF0, 0xFC, 0x03, 0xFC, 0x3F,
  0x01, 0xE1, 0xF0, 0x0F, 0xE0, 0x7E, 0x03, 0xC7, 0xE0, 0x1F, 0x80, 0xF8,
  0x07, 0x8F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x3E, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0xF9, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF7, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xEF, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xDF, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xBE, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x3D,
  0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFB, 0xF0, 0x3F, 0x80, 0x7C, 0x01, 0xF7,
  0xE0, 0x7E, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x9F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x7C,
  0x07, 0xE0, 0x3F, 0x00, 0x78, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF1, 0xF0,
  0x1F, 0x81, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0x87, 0xC0,
  0x7F, 0x0F, 0xF0, 0x3E, 0x0F, 0x80, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x7E, 0x01,
  0xFF, 0x8F, 0xFF, 0x00, 0xFC, 0x01, 0xFE, 0x0F, 0xFC, 0x00, 0xF8, 0x00,
  0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x87, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x7F, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x3F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07,
  0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0x3F,
  0xFF, 0xC7, 0xF8, 0x03, 0xFF, 0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0xC7, 0xF8,
  0x07, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0xF8,
  0xFF, 0x80, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xC0,
  0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x0F,
  0xF0, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x00, 0x3F,
  0xDF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF9, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x03,
  0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x7F,
  0x80, 0x7F, 0x9F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF0, 0x03, 0xF9,
  0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x8F, 0xC0, 0x1F,
  0xCF, 0xF0, 0x0F, 0xF1, 0xFC, 0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0x80,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x3F, 0x87, 0xF0, 0x07, 0xF8, 0xFE,
  0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1,
  0xF8, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0x07, 0xE0, 0xFF, 0x00, 0xFF,
  0x07, 0xE1, 0xFC, 0x3F, 0xE0, 0x1F, 0xE0, 0xFC, 0x3F, 0x07, 0xF8, 0x03,
  0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xF9, 0xF8, 0x1F, 0xE0,
  0x1F, 0xF0, 0x3F, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xEF, 0xE0, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00,
  0x07, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x00,
  0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xF0,
  0x0F, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xFB, 0xF0, 0x03, 0xFC, 0x03, 0xFD,
  0xF8, 0x03, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x3F, 0x00,
  0xFF, 0x00, 0xFF, 0x1F, 0x80, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC7, 0xF0, 0x1F, 0xE0, 0x1F, 0xE1, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0x83,
  0xFC, 0x03, 0xFC, 0x0F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0xFF, 0x00,
  0xFF, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x80, 0xFC, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xE0, 0x0F, 0xCF,
  0xF0, 0x0F, 0xF0, 0x07, 0xEF, 0xF8, 0x07, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFF,
  0xC0, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x03, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC1, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x00,
  0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF,
  0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF8, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF,
  0x80, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xEF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0xBF, 0x80, 0x0F, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x3F, 0xF0, 0x03,
  0xFC, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xE3, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xC7, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xFC, 0x03, 0xFC,
  0x3F, 0x80, 0x7F, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0xF0, 0x1F, 0xE0,
  0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0x03,
  0xF8, 0x1F, 0xDF, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xBF, 0x83, 0xFC, 0x0F,
  0xE0, 0x7E, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0xFE, 0x1F, 0xE0, 0x3F,
  0x83, 0xF9, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xE3, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC3, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x87, 0xE3, 0xFC, 0x03, 0xF8,
  0x7E, 0x0F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0x0F, 0xF3,
  0xF0, 0x3F, 0x3F, 0xC0, 0x1F, 0xE7, 0xE0, 0x7E, 0x7F, 0x00, 0x3F, 0xDF,
  0xC0, 0xFC, 0xFE, 0x00, 0x7F, 0xBF, 0x01, 0xFB, 0xFC, 0x00, 0xFF, 0xFE,
  0x03, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x03,
  0xFD, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xF9, 0xFE, 0x00,
  0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0xEF, 0x80, 0x1F, 0xBE, 0x00, 0xFE, 0xFC, 0x03, 0xF3, 0xF0, 0x1F, 0xCF,
  0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x7F, 0x07, 0xC1,
  0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F, 0x01, 0xF9, 0xFC, 0x07, 0xE7, 0xE0,
  0x1F, 0xBF, 0x80, 0x7E, 0xFE, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFE, 0x1F, 0xE3, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x1F, 0xC7, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0xCF,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x80,
  0xFF, 0x87, 0xF8, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0x7F, 0x80, 0x7F,
  0xC7, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x0F, 0x80, 0x01, 0xFC, 0xFF, 0xC0,
  0x07, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07,
  0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF,
  0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFE, 0xFF, 0xFF, 0x81, 0xFC, 0xFF, 0xFE, 0x03,
  0xF8, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xCF, 0xF0,
  0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x03, 0xFC, 0x00,
  0x7F, 0xE1, 0xFC, 0x00, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xEF, 0xE0, 0x00, 0x7F, 0xE7, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x1F,
  0xC0, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0x7F, 0x7F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x60, 0x7F, 0x80, 0x1E,
  0x07, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xC0, 0x0F, 0xFF, 0x9F, 0xE0,
  0x1F, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFD, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0x00,
  0x01, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x04, 0x00, 0x1F, 0xE0, 0x07, 0x00, 0x1F, 0xF0,
  0x03, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xC0, 0x03, 0xFC,
  0xFF, 0xC0, 0x0F, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xC1, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0,
  0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF,
  0x81, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0xC0, 0x0F, 0xE0, 0xFF,
  0xC0, 0x0F, 0xF0, 0xFF, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x7F,
  0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x7F,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xF0, 0x00, 0x3F, 0xE3, 0xF8, 0x00, 0x3F,
  0xE1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFD,
  0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x07, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8,
  0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x3F, 0xDF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0x83, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD,
  0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFE,
  0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xF9, 0xFE,
  0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x01,
  0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x9F, 0xF8, 0x00, 0x3F, 0xDF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0,
  0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xF9, 0xFF, 0xFC, 0x01,
  0xFC, 0x7F, 0xFC, 0x01, 0xFE, 0x1F, 0xF8, 0x00, 0xFF, 0x01, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0xC3, 0xF8, 0x07, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0xCF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xF7, 0xF0, 0x00, 0xFF, 0xDF, 0xE0, 0x00, 0x3C, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x03, 0xF9, 0xFC, 0x0F, 0xF7,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0x84, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x8F,
  0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x03,
  0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xC0,
  0x0F, 0xFC, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F,
  0x00, 0xFF, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFE,
  0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE7,
  0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0xBF,
  0xC0, 0x1F, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xFC, 0x07,
  0xF8, 0xFE, 0x07, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFF, 0x03, 0xFC, 0x3F,
  0x81, 0xFF, 0x81, 0xFC, 0x1F, 0xC1, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0, 0xFF,
  0xE0, 0xFF, 0x07, 0xF0, 0xFF, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0xF8, 0x3F,
  0x81, 0xFC, 0x3F, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x3E, 0x1F, 0xC0, 0x7F,
  0x1F, 0x9F, 0x9F, 0xE0, 0x3F, 0x9F, 0xCF, 0xCF, 0xE0, 0x1F, 0xCF, 0xC7,
  0xE7, 0xF0, 0x0F, 0xEF, 0xE3, 0xF7, 0xF0, 0x07, 0xF7, 0xE1, 0xFB, 0xF8,
  0x03, 0xFB, 0xF0, 0xFD, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF7, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F,
  0xF8, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFC,
  0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x0F, 0xC3, 0xFF, 0xC0, 0x07, 0xE1, 0xFF, 0xF0,
  0x03, 0xF1, 0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xFF, 0x01, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFC, 0xFF, 0x1F, 0xF1, 0xFC, 0x7F, 0x07, 0xFF, 0xFE, 0x3F, 0x01,
  0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0x0F, 0xC0,
  0x07, 0xFF, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 51, 17, 2, -50 },
  { 103, 19, 18, 22, 5, -53 },
  { 146, 35, 50, 36, 2, -50 },
  { 365, 31, 66, 34, 2, -58 },
  { 621, 33, 52, 43, 6, -51 },
  { 836, 34, 52, 38, 1, -51 },
  { 1057, 9, 18, 11, 5, -53 },
  { 1078, 22, 72, 22, 3, -56 },
  { 1276, 21, 72, 22, -3, -56 },
  { 1465, 28, 30, 30, 4, -50 },
  { 1570, 30, 37, 33, 2, -42 },
  { 1709, 13, 19, 15, -4, -8 },
  { 1740, 17, 7, 21, 2, -25 },
  { 1755, 9, 10, 19, 2, -9 },
  { 1767, 31, 54, 24, -4, -50 },
  { 1977, 29, 52, 34, 3, -51 },
  { 2166, 20, 50, 34, 8, -50 },
  { 2291, 33, 51, 34, 0, -51 },
  { 2502, 31, 52, 34, 1, -51 },
  { 2704, 31, 50, 34, 1, -50 },
  { 2898, 31, 51, 34, 3, -50 },
  { 3096, 28, 51, 34, 3, -50 },
  { 3275, 32, 50, 34, 4, -50 },
  { 3475, 31, 52, 34, 2, -51 },
  { 3677, 27, 51, 34, 5, -51 },
  { 3850, 14, 39, 18, 2, -38 },
  { 3919, 18, 49, 16, -3, -38 },
  { 4030, 27, 32, 30, 2, -38 },
  { 4138, 28, 22, 33, 3, -34 },
  { 4215, 27, 32, 31, 2, -37 },
  { 4323, 25, 52, 30, 5, -51 },
  { 4486, 47, 64, 52, 2, -49 },
  { 4862, 38, 50, 40, -3, -50 },
  { 5100, 35, 50, 38, 1, -50 },
  { 5319, 36, 52, 39, 3, -51 },
  { 5553, 36, 50, 39, 1, -50 },
  { 5778, 35, 50, 34, 1, -50 },
  { 5997, 35, 50, 32, 1, -50 },
  { 6216, 36, 52, 40, 3, -51 },
  { 6450, 41, 50, 42, 1, -50 },
  { 6707, 17, 50, 18, 1, -50 },
  { 6814, 34, 51, 33, 0, -50 },
  { 7031, 41, 50, 37, 1, -50 },
  { 7288, 27, 50, 32, 1, -50 },
  { 7457, 51, 50, 51, 1, -50 },
  { 7776, 41, 50, 42, 1, -50 },
  { 8033, 36, 52, 41, 3, -51 },
  { 8267, 37, 50, 38, 1, -50 },
  { 8499, 36, 60, 41, 3, -51 },
  { 8769, 36, 50, 37, 1, -50 },
  { 8994, 35, 52, 36, 1, -51 },
  { 9222, 33, 50, 36, 6, -50 },
  { 9429, 37, 51, 38, 3, -50 },
  { 9665, 36, 50, 39, 6, -50 },
  { 9890, 47, 50, 51, 7, -50 },
  { 10184, 43, 50, 38, -2, -50 },
  { 10453, 35, 50, 36, 6, -50 },
  { 10672, 39, 50, 36, -1, -50 },
  { 10916, 23, 68, 18, -1, -57 },
  { 11112, 15, 54, 26, 6, -50 },
  { 11214, 23, 68, 18, -4, -57 },
  { 11410, 22, 25, 26, 3, -50 },
  { 11479, 27, 7, 27, -4, 0 },
  { 11503, 14, 10, 22, 7, -52 },
  { 11521, 28, 39, 32, 1, -38 },
  { 11658, 31, 54, 34, 0, -53 },
  { 11868, 28, 39, 31, 2, -38 },
  { 12005, 33, 54, 34, 2, -53 },
  { 12228, 28, 39, 32, 2, -38 },
  { 12365, 24, 54, 22, 3, -54 },
  { 12527, 33, 52, 34, 0, -38 },
  { 12742, 30, 53, 33, 0, -53 },
  { 12941, 16, 51, 16, 1, -51 },
  { 13043, 24, 65, 16, -7, -51 },
  { 13238, 33, 53, 32, 0, -53 },
  { 13457, 17, 53, 16, 1, -53 },
  { 13570, 48, 38, 51, 0, -38 },
  { 13798, 30, 38, 33, 0, -38 },
  { 13941, 29, 39, 34, 2, -38 },
  { 14083, 33, 52, 34, -2, -38 },
  { 14298, 31, 52, 34, 2, -38 },
  { 14500, 23, 38, 22, 0, -38 },
  { 14610, 28, 39, 31, 1, -38 },
  { 14747, 18, 47, 21, 3, -46 },
  { 14853, 30, 38, 33, 2, -37 },
  { 14996, 27, 37, 30, 4, -37 },
  { 15121, 41, 37, 44, 4, -37 },
  { 15311, 33, 37, 30, -2, -37 },
  { 15464, 33, 51, 29, -2, -37 },
  { 15675, 31, 37, 30, -1, -37 },
  { 15819, 21, 67, 21, 2, -55 },
  { 15995, 15, 59, 17, 1, -50 },
  { 16106, 22, 68, 21, -3, -55 },
  { 16293, 33, 15, 39, 3, -28 },
};

const GFXfont RobotoCondensed_MediumItalic70pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic70pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic70pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC70PT7B_H_
