#ifndef _ROBOTOCONDENSED_MEDIUMITALIC48PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0x00,
  0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x71, 0xEF, 0x1E,
  0xF1, 0xEF, 0x1C, 0xE1, 0xCE, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x0F, 0x0E,
  0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C,
  0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xF0, 0xE0,
  0x00, 0xF1, 0xE0, 0x00, 0xE1, 0xE0, 0x01, 0xE1, 0xC0, 0x01, 0xE3, 0xC0,
  0x01, 0xC3, 0xC0, 0x03, 0xC3, 0x80, 0x03, 0xC7, 0x80, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x0F, 0x0E, 0x00,
  0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00,
  0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xF0, 0xFC, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0xC0,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8,
  0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xC0, 0x01, 0xE7, 0x80, 0x07, 0x87, 0x03, 0x0F, 0x0F, 0x07, 0x9C, 0x1E,
  0x1E, 0x38, 0x3C, 0x78, 0xF0, 0x78, 0xF1, 0xE0, 0xE3, 0xC3, 0xC3, 0xCF,
  0x03, 0x87, 0xBC, 0x07, 0x9E, 0x78, 0x0F, 0xFD, 0xE0, 0x0F, 0xF7, 0x80,
  0x0F, 0x8F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC7, 0x80,
  0x07, 0xBF, 0xC0, 0x1E, 0xFF, 0xC0, 0x7B, 0xE7, 0x80, 0xF7, 0x87, 0x03,
  0xCF, 0x0E, 0x0F, 0x3C, 0x1E, 0x1C, 0x78, 0x38, 0x78, 0xF0, 0x71, 0xE1,
  0xE0, 0xE7, 0x83, 0xC3, 0xC7, 0x07, 0x87, 0x84, 0x07, 0x9E, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x3E,
  0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x7C, 0x7F,
  0xF0, 0xF9, 0xFF, 0xF1, 0xF3, 0xF7, 0xE3, 0xCF, 0xC7, 0xEF, 0x9F, 0x0F,
  0xDF, 0x7E, 0x0F, 0xFC, 0xFC, 0x1F, 0xF9, 0xF8, 0x1F, 0xE3, 0xF0, 0x1F,
  0xC7, 0xE0, 0x3F, 0x07, 0xE0, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFC, 0xF8, 0x0F, 0xE1, 0xF8, 0x3C, 0x78, 0xF1,
  0xE3, 0xCF, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x80, 0x00, 0x04, 0x00, 0x18,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x02, 0x00, 0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x02, 0x07, 0x80, 0x38, 0x78, 0xF7, 0xF7, 0x3F, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x0F,
  0xBC, 0x01, 0xF1, 0xE0, 0x3E, 0x1E, 0x03, 0xC1, 0xF0, 0x18, 0x0E, 0x00,
  0x80, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0x7C, 0x3E, 0x1F, 0x87, 0xC1, 0xE0, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xEF, 0xFC, 0x7D, 0xFB, 0xFF, 0xEF, 0xCF, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x1F, 0x81, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF7, 0xE0, 0x1F, 0x7E, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7,
  0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7E,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x0F,
  0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0xC3,
  0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0x7E, 0x71, 0xF2, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0,
  0x1F, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3F,
  0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0x87, 0xE1, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0xC0, 0x3E, 0x3F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xE1, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF7, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0xF8,
  0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF8, 0x1F, 0x87, 0xC1, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xBF, 0x03, 0xEF, 0xF0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x07, 0xCF, 0xC0, 0xFD, 0xF0, 0x1F, 0xBE,
  0x01, 0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xF9, 0xF0, 0x3F, 0x3E, 0x07, 0xE7, 0xE1, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0,
  0xFC, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xF8, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F,
  0x1F, 0x83, 0xF0, 0x7C, 0x3F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C,
  0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xE0,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF,
  0xC1, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x7E, 0x07,
  0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0xCF, 0xC3, 0xF9, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xF3, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0x80, 0x00,
  0x0F, 0x83, 0xF1, 0xFC, 0x3F, 0x0F, 0x81, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1E, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x08, 0x00,
  0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xC7,
  0xFF, 0xF7, 0xF1, 0xFB, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x03, 0x81, 0xE0, 0x3F,
  0x01, 0xC1, 0xE0, 0x3F, 0xE0, 0xF0, 0xF0, 0x3F, 0xF8, 0x78, 0xF0, 0x3F,
  0xFC, 0x1C, 0x78, 0x3E, 0x1E, 0x0E, 0x38, 0x3E, 0x0E, 0x07, 0x3C, 0x1E,
  0x0F, 0x07, 0x9E, 0x1F, 0x07, 0x83, 0xCE, 0x0F, 0x03, 0xC1, 0xEF, 0x07,
  0x81, 0xE0, 0xF7, 0x87, 0xC1, 0xE0, 0x73, 0xC3, 0xC0, 0xF0, 0x39, 0xC1,
  0xE0, 0x78, 0x1D, 0xE0, 0xF0, 0x3C, 0x1E, 0xF0, 0x78, 0x3C, 0x0E, 0x78,
  0x3C, 0x1E, 0x07, 0x3C, 0x3E, 0x1F, 0x07, 0x9E, 0x0F, 0x0F, 0x83, 0x8F,
  0x07, 0x8F, 0xC3, 0xC7, 0x83, 0xFF, 0xF3, 0xC3, 0xC1, 0xFF, 0x7F, 0xC1,
  0xE0, 0x7F, 0x3F, 0xC0, 0xF0, 0x1E, 0x0F, 0x80, 0x38, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00,
  0x3E, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0xFC, 0x1F, 0x83, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x3F, 0x00, 0xF8,
  0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x07, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xC0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3F,
  0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x1F,
  0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x3F,
  0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E,
  0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7E, 0x00, 0xFC,
  0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7C, 0x0F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x3E,
  0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xFF, 0x1F, 0x03, 0xFF, 0x8F, 0x81,
  0xFF, 0xCF, 0xC0, 0xFF, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x83,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xE1, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8,
  0x07, 0xC0, 0x7F, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xF8, 0x7F, 0x00, 0x0F, 0x8F, 0xE0,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xDF, 0x80, 0x03,
  0xF9, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC,
  0x0F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0,
  0x07, 0xBE, 0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFB, 0xC0, 0x3F, 0xF0, 0x3E,
  0x78, 0x0F, 0xBE, 0x07, 0xCF, 0x01, 0xF7, 0xC0, 0xF9, 0xE0, 0x7C, 0xF8,
  0x1F, 0x3C, 0x0F, 0xBF, 0x03, 0xE7, 0xC3, 0xE7, 0xE0, 0xFC, 0xF8, 0x7C,
  0xF8, 0x1F, 0x9F, 0x1F, 0x1F, 0x03, 0xE1, 0xE3, 0xE3, 0xE0, 0x7C, 0x3C,
  0x78, 0xFC, 0x0F, 0x87, 0x9F, 0x1F, 0x83, 0xF0, 0xF3, 0xC3, 0xF0, 0x7E,
  0x1E, 0xF8, 0x7C, 0x0F, 0xC3, 0xDE, 0x0F, 0x81, 0xF0, 0x7F, 0xC3, 0xF0,
  0x3E, 0x0F, 0xF0, 0x7E, 0x07, 0xC0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3E, 0x07, 0xF0, 0x03,
  0xE0, 0x7F, 0x80, 0x3E, 0x0F, 0xF8, 0x07, 0xE0, 0xFF, 0x80, 0x7E, 0x0F,
  0xFC, 0x07, 0xE0, 0xFF, 0xC0, 0x7C, 0x0F, 0xBC, 0x07, 0xC0, 0xFB, 0xC0,
  0x7C, 0x1F, 0xBE, 0x0F, 0xC1, 0xF9, 0xE0, 0xFC, 0x1F, 0x9E, 0x0F, 0xC1,
  0xF1, 0xF0, 0xF8, 0x1F, 0x1F, 0x0F, 0x81, 0xF0, 0xF1, 0xF8, 0x3F, 0x0F,
  0x9F, 0x83, 0xF0, 0xF9, 0xF8, 0x3F, 0x07, 0x9F, 0x03, 0xE0, 0x79, 0xF0,
  0x3E, 0x07, 0xDF, 0x07, 0xE0, 0x3F, 0xF0, 0x7E, 0x03, 0xFF, 0x07, 0xE0,
  0x3F, 0xF0, 0x7E, 0x03, 0xFE, 0x07, 0xC0, 0x1F, 0xE0, 0x7C, 0x01, 0xFE,
  0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0xF8,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0x83,
  0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7C,
  0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x3F,
  0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3E, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xC0, 0x0F,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x01, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0x03, 0xF8, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x8F,
  0xC0, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD,
  0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x9F, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x01,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x7F, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x01, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x3E,
  0x0F, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7E,
  0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8,
  0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7C, 0x1F,
  0x80, 0x7E, 0x07, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xE7, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xE3, 0xE0,
  0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0xBE, 0x01, 0xF0, 0x0F, 0xDF, 0x00, 0xF8, 0x07, 0xCF, 0x80, 0xFC,
  0x03, 0xE7, 0xC0, 0x7E, 0x03, 0xF3, 0xE0, 0x3F, 0x01, 0xF1, 0xF0, 0x3F,
  0x80, 0xF8, 0xF8, 0x1F, 0xC0, 0xFC, 0x7C, 0x1F, 0xE0, 0x7C, 0x3E, 0x0F,
  0xF8, 0x3E, 0x1F, 0x07, 0xFC, 0x3F, 0x0F, 0x87, 0xFE, 0x1F, 0x07, 0xC3,
  0xFF, 0x0F, 0x83, 0xE1, 0xEF, 0x8F, 0xC1, 0xF1, 0xF7, 0xC7, 0xC0, 0xF8,
  0xFB, 0xE3, 0xE0, 0x7C, 0x78, 0xF3, 0xF0, 0x3E, 0x7C, 0x79, 0xF0, 0x1F,
  0x3C, 0x3C, 0xF8, 0x0F, 0x9E, 0x1E, 0x7C, 0x07, 0xDF, 0x0F, 0x7C, 0x03,
  0xEF, 0x07, 0xBE, 0x01, 0xFF, 0x83, 0xDF, 0x00, 0xFF, 0xC1, 0xFF, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF0,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3F, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F,
  0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xF8, 0x1F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03,
  0xDC, 0x0F, 0x3C, 0x1E, 0x78, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x87,
  0x9F, 0x0F, 0xBC, 0x0F, 0xF8, 0x1E, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFC, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x78, 0x3E, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE1,
  0xFC, 0xFE, 0x3F, 0x0F, 0xC7, 0xC0, 0xF9, 0xF8, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xC1, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x0F, 0xCF, 0xC3, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F,
  0xDF, 0x81, 0xF1, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xF8, 0x3F, 0x0F, 0x80,
  0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x01, 0xF9, 0xF0, 0x0F,
  0xCF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xFC,
  0x1F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xEF, 0xFC, 0x3F, 0x7F, 0xC1,
  0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x7E,
  0x03, 0xE7, 0xE0, 0x3E, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7C,
  0xFC, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0xE7, 0xC0, 0xFF, 0xEF, 0x81, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x03, 0xE1,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x1F,
  0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8, 0x1F, 0x87,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xBE,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E,
  0x3E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x10, 0x7E, 0x07, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x3C,
  0x03, 0xFC, 0xF8, 0x1F, 0xFD, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xF8, 0x3F, 0x87, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E,
  0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x07, 0xC0,
  0x3E, 0x1F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xCF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x04, 0x01, 0xF0, 0x1C,
  0x07, 0xE0, 0x3F, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xF8, 0x3E, 0x0F,
  0x81, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3F, 0x03, 0xF1,
  0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x01,
  0xF1, 0xF8, 0x1F, 0x80, 0x03, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x7E, 0x0F,
  0xE0, 0xFC, 0x3F, 0x81, 0xF0, 0xFE, 0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xE0,
  0x0F, 0x9F, 0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0x7C, 0x00, 0xFC, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xE1,
  0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xE0,
  0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0xF8, 0x07, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xF9, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7E, 0x1F, 0xE0,
  0xF8, 0x3E, 0x07, 0xE0, 0x7C, 0x3F, 0x03, 0xF0, 0x3E, 0x1F, 0x81, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x81, 0xF8, 0xFC, 0x0F,
  0xC0, 0xFC, 0x7C, 0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3E, 0x1F, 0x01,
  0xF0, 0x1F, 0x1F, 0x80, 0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x07, 0xE3, 0xE0, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC0, 0x7C, 0x7E, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0x8F, 0x80, 0x7D, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC3, 0xF0, 0x3F, 0x1F, 0x01, 0xF8,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x81,
  0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x1F,
  0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x07,
  0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8,
  0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC7, 0xC0, 0x1F, 0x7F, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x0F, 0xC7,
  0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0,
  0x7E, 0x3F, 0x83, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xBF, 0xF0,
  0x7E, 0xFF, 0x81, 0xF8, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0xF8,
  0x3F, 0xE7, 0xC3, 0xFF, 0xBE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xC1,
  0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F,
  0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF8,
  0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x1F, 0xEF, 0x80, 0x7E, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xDF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0xFC,
  0x3E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x1F, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x81, 0xF9, 0xFC, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC3,
  0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xE0, 0x3F, 0x01, 0xF3, 0xF0, 0x3F, 0x3E,
  0x03, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7E, 0x03, 0xE7,
  0xE0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C,
  0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F,
  0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xFC, 0x3F, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xDF, 0x01, 0xF8, 0x00, 0xF8,
  0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0xBE, 0x07,
  0xCF, 0x83, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x07, 0xC7, 0xC1,
  0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x3D,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x03, 0xFF, 0x81, 0xF0, 0x3E, 0xF8, 0x1F, 0x03, 0xEF, 0x83, 0xF0, 0x7E,
  0xF8, 0x3F, 0x07, 0xCF, 0x83, 0xF0, 0x7C, 0xF8, 0x7F, 0x0F, 0x8F, 0x87,
  0xF0, 0xF8, 0xF8, 0xFF, 0x0F, 0x8F, 0x8F, 0xF1, 0xF0, 0xF8, 0xFF, 0x1F,
  0x0F, 0x9E, 0x79, 0xF0, 0x79, 0xE7, 0xBE, 0x07, 0xBE, 0x7B, 0xE0, 0x7B,
  0xC7, 0xBC, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F,
  0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07,
  0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F,
  0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0xFC, 0x00, 0xF9,
  0xF0, 0x01, 0xF7, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7C, 0x00,
  0x7C, 0xF8, 0x01, 0xF8, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F,
  0x07, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x07,
  0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x07,
  0xE0, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE1, 0xF0, 0x03, 0xE3, 0xF0, 0x03,
  0xE3, 0xE0, 0x03, 0xE7, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x03,
  0xEF, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x10, 0x00, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x08,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x3C, 0xFF, 0xC0, 0xF1, 0xFF,
  0xC1, 0xE7, 0xFF, 0xC7, 0xCF, 0x8F, 0xFF, 0x3E, 0x0F, 0xFE, 0x78, 0x0F,
  0xF8, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoCondensed_MediumItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 34, 12, 1, -34 },
  { 48, 12, 12, 15, 4, -36 },
  { 66, 24, 34, 25, 1, -34 },
  { 168, 21, 43, 23, 2, -39 },
  { 281, 23, 34, 30, 4, -34 },
  { 379, 23, 34, 26, 1, -34 },
  { 477, 7, 12, 8, 3, -36 },
  { 488, 15, 49, 15, 2, -38 },
  { 580, 15, 49, 15, -2, -38 },
  { 672, 20, 20, 21, 2, -34 },
  { 722, 20, 25, 23, 2, -29 },
  { 785, 10, 13, 10, -3, -5 },
  { 802, 11, 5, 14, 2, -17 },
  { 809, 7, 6, 13, 1, -6 },
  { 815, 22, 37, 16, -3, -34 },
  { 917, 20, 34, 23, 2, -34 },
  { 1002, 14, 34, 23, 5, -34 },
  { 1062, 22, 34, 23, 0, -34 },
  { 1156, 21, 34, 23, 1, -34 },
  { 1246, 22, 34, 23, 0, -34 },
  { 1340, 21, 34, 23, 2, -34 },
  { 1430, 19, 34, 23, 2, -34 },
  { 1511, 22, 34, 23, 2, -34 },
  { 1605, 21, 34, 23, 1, -34 },
  { 1695, 19, 34, 23, 3, -34 },
  { 1776, 10, 26, 12, 1, -26 },
  { 1809, 13, 34, 11, -2, -26 },
  { 1865, 19, 22, 21, 1, -26 },
  { 1918, 19, 15, 23, 2, -23 },
  { 1954, 19, 22, 21, 1, -26 },
  { 2007, 17, 34, 20, 4, -34 },
  { 2080, 33, 44, 36, 1, -33 },
  { 2262, 26, 34, 27, -2, -34 },
  { 2373, 24, 34, 26, 1, -34 },
  { 2475, 24, 34, 26, 2, -34 },
  { 2577, 24, 34, 26, 1, -34 },
  { 2679, 24, 34, 23, 1, -34 },
  { 2781, 23, 34, 22, 1, -34 },
  { 2879, 25, 34, 27, 2, -34 },
  { 2986, 28, 34, 29, 1, -34 },
  { 3105, 11, 34, 12, 1, -34 },
  { 3152, 23, 34, 23, 0, -34 },
  { 3250, 28, 34, 26, 1, -34 },
  { 3369, 18, 34, 22, 1, -34 },
  { 3446, 35, 34, 35, 1, -34 },
  { 3595, 28, 34, 29, 1, -34 },
  { 3714, 25, 34, 28, 2, -34 },
  { 3821, 25, 34, 26, 1, -34 },
  { 3928, 25, 40, 28, 2, -34 },
  { 4053, 24, 34, 25, 1, -34 },
  { 4155, 24, 34, 25, 1, -34 },
  { 4257, 23, 34, 25, 4, -34 },
  { 4355, 25, 34, 26, 2, -34 },
  { 4462, 25, 34, 27, 4, -34 },
  { 4569, 33, 34, 35, 4, -34 },
  { 4710, 29, 34, 26, -1, -34 },
  { 4834, 24, 34, 25, 4, -34 },
  { 4936, 27, 34, 25, -1, -34 },
  { 5051, 16, 47, 12, -1, -39 },
  { 5145, 11, 37, 18, 4, -34 },
  { 5196, 16, 47, 12, -3, -39 },
  { 5290, 15, 17, 18, 2, -34 },
  { 5322, 19, 5, 19, -3, 0 },
  { 5334, 9, 7, 15, 5, -36 },
  { 5342, 19, 26, 22, 1, -26 },
  { 5404, 21, 36, 23, 0, -36 },
  { 5499, 20, 26, 21, 1, -26 },
  { 5564, 23, 36, 23, 1, -36 },
  { 5668, 20, 26, 22, 1, -26 },
  { 5733, 16, 36, 15, 2, -36 },
  { 5805, 23, 36, 23, 0, -26 },
  { 5909, 21, 36, 23, 0, -36 },
  { 6004, 11, 36, 11, 1, -36 },
  { 6054, 16, 46, 11, -5, -36 },
  { 6146, 23, 36, 22, 0, -36 },
  { 6250, 11, 36, 11, 1, -36 },
  { 6300, 33, 26, 35, 0, -26 },
  { 6408, 21, 26, 23, 0, -26 },
  { 6477, 21, 26, 23, 1, -26 },
  { 6546, 22, 36, 23, -1, -26 },
  { 6645, 21, 36, 23, 1, -26 },
  { 6740, 16, 26, 15, 0, -26 },
  { 6792, 19, 26, 21, 1, -26 },
  { 6854, 13, 32, 14, 2, -32 },
  { 6906, 20, 26, 23, 2, -26 },
  { 6971, 18, 26, 20, 3, -26 },
  { 7030, 28, 26, 30, 3, -26 },
  { 7121, 23, 26, 21, -1, -26 },
  { 7196, 24, 36, 20, -2, -26 },
  { 7304, 22, 26, 21, -1, -26 },
  { 7376, 15, 45, 14, 1, -37 },
  { 7461, 10, 40, 12, 1, -34 },
  { 7511, 15, 46, 14, -2, -37 },
  { 7598, 23, 10, 27, 2, -19 },
};

const GFXfont RobotoCondensed_MediumItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC48PT7B_H_
