#ifndef _ROBOTOCONDENSED_MEDIUMITALIC36PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x00, 0x00, 0x00, 0x60, 0xF0,
  0xF0, 0xF0, 0x60, 0x73, 0xB9, 0xDC, 0xEE, 0x7E, 0x37, 0x3B, 0x9D, 0xCE,
  0xC6, 0x00, 0x00, 0x71, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00,
  0xE7, 0x00, 0x31, 0xC0, 0x1C, 0x70, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF0, 0x39, 0xC0, 0x0C, 0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0x63, 0x80,
  0x38, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x71, 0x80, 0x1C,
  0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x1C, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x01, 0xF8, 0x03,
  0xFC, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F,
  0x80, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x0E, 0x30, 0x46, 0x18, 0x77, 0x0C, 0x73, 0x86, 0x39, 0xC7, 0x38,
  0xE3, 0xB8, 0x3F, 0x9C, 0x1F, 0xDC, 0x07, 0xDC, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x78, 0x0E, 0xFE, 0x07, 0x7F, 0x07, 0x71, 0xC7, 0x38, 0xE3,
  0x9C, 0x73, 0x8E, 0x3B, 0x86, 0x1D, 0x83, 0x9C, 0x41, 0xFE, 0x00, 0x7E,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0xC0,
  0xF1, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x1C, 0x38, 0x0E, 0x3C, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x1C, 0xFF, 0x1E, 0xFB,
  0xCF, 0x79, 0xE7, 0x78, 0x7F, 0xBC, 0x3F, 0xDE, 0x0F, 0xCF, 0x07, 0xE7,
  0x81, 0xE3, 0xF7, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xC7, 0x80, 0x77,
  0x7F, 0xEE, 0xEE, 0xC0, 0x00, 0x40, 0x18, 0x07, 0x81, 0xE0, 0x78, 0x0E,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x0C, 0x00, 0x80, 0x02, 0x00, 0x60, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0x30, 0x04, 0x00, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x63, 0x87, 0xEE, 0xFF, 0xFF, 0xCF, 0xFE,
  0x07, 0x80, 0x3E, 0x01, 0xDC, 0x0E, 0x70, 0x78, 0xE1, 0xC3, 0x82, 0x04,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x9E, 0x3C, 0xF0, 0xC0, 0x7F, 0x3F,
  0xBF, 0xC0, 0x77, 0xBF, 0xE7, 0x00, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xE3, 0xC3, 0xC7,
  0x83, 0x9E, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF7, 0x81,
  0xEF, 0x03, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3,
  0xC1, 0xE7, 0x03, 0xCF, 0x0F, 0x1E, 0x1E, 0x3E, 0xF8, 0x3F, 0xF0, 0x7F,
  0xC0, 0x3E, 0x00, 0x00, 0xC0, 0xF1, 0xFD, 0xFF, 0x7F, 0xBF, 0xEC, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFB, 0xE0, 0xF0, 0xF0, 0xF0,
  0x7C, 0x78, 0x1E, 0x3C, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x07, 0xFC,
  0x0F, 0xFC, 0x1F, 0xBE, 0x1E, 0x1E, 0x3C, 0x1E, 0x3C, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x07, 0xF8, 0x07, 0xE0, 0x07, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x3C,
  0xF0, 0x78, 0xF0, 0x78, 0xFD, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xEF, 0x01, 0xE7, 0x80,
  0xE3, 0xC0, 0xF3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C,
  0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x83, 0xE7, 0xC0,
  0x61, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x1E, 0x07, 0x87, 0x83, 0xC3, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x7F, 0x83, 0xFE, 0x0F,
  0x80, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xEF, 0x87, 0xFF, 0x1F,
  0xFE, 0xFE, 0xFB, 0xE1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x07, 0xFC, 0x1E, 0xF0, 0x7B, 0xC3, 0xE7, 0xDF, 0x1F, 0xF8, 0x3F, 0xC0,
  0x7E, 0x00, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x0F, 0xBE, 0x1F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1F, 0x3C, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x78,
  0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C,
  0xF8, 0x78, 0x7D, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0xFF, 0x0F, 0xFC, 0xFF, 0xF7, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xFC, 0xFD, 0xFF, 0xEF, 0xFE,
  0x3E, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE3, 0xFE, 0x1F,
  0xE0, 0xFC, 0x07, 0x80, 0x00, 0x0C, 0x3C, 0xF8, 0xF1, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xF1, 0xF3, 0xC3, 0x80, 0x03,
  0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x08, 0x00, 0x00, 0x04, 0x00, 0x70,
  0x07, 0x80, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x08,
  0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xFC, 0x10, 0x00, 0xE0,
  0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x00,
  0xFC, 0x0F, 0xE1, 0xFF, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00, 0x20,
  0x00, 0x0F, 0x83, 0xFE, 0x7F, 0xF7, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x78, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFC, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x0E, 0x07, 0x00, 0x06, 0x0F, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x1C, 0x0F, 0x03, 0x1C, 0x3F, 0xC3, 0x38, 0x7F,
  0xE3, 0x38, 0x71, 0xC3, 0x70, 0xE1, 0xC3, 0x70, 0xE1, 0xC3, 0x71, 0xC1,
  0xC3, 0xE1, 0xC3, 0x83, 0xE1, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0x83,
  0x06, 0xE3, 0x87, 0x0E, 0xE3, 0x87, 0x0E, 0xE3, 0xCF, 0x1C, 0xE3, 0xFF,
  0xB8, 0xE1, 0xFB, 0xF0, 0xE0, 0xE1, 0xE0, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0,
  0x3C, 0x38, 0x07, 0x87, 0x01, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0xDF,
  0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3C, 0x07, 0xFE, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0xC3,
  0xC0, 0xF8, 0x78, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0x7E, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x83, 0xC1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0xF8, 0xF0,
  0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E, 0x07, 0x8F, 0x01,
  0xE3, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x0F,
  0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xC0, 0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0, 0x1E,
  0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0xF0,
  0xF0, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1E, 0x07,
  0x8F, 0x01, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x1F, 0xEF, 0x07, 0xFB, 0xC3,
  0xFE, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F,
  0x3E, 0x07, 0xC7, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xF8, 0x00,
  0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x1E, 0x0F,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x1F, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x7C, 0x03, 0xC1, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x00,
  0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0,
  0xF0, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x87, 0xC3, 0xC3,
  0xC1, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x07, 0xC0,
  0x3C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x79,
  0xF0, 0x01, 0xEF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xDE, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x0F, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0x7C, 0x07, 0x81,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x3E, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x07,
  0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x07,
  0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0x77,
  0x01, 0xFC, 0x1E, 0xE0, 0x7F, 0x83, 0xDC, 0x0F, 0xF0, 0x7B, 0x81, 0xDE,
  0x0F, 0x70, 0x7B, 0xC1, 0xEF, 0x0E, 0x78, 0x3D, 0xE3, 0xDE, 0x0F, 0x9C,
  0x73, 0xC1, 0xE3, 0x9E, 0x78, 0x3C, 0x73, 0x8F, 0x07, 0x8E, 0xF1, 0xE0,
  0xF1, 0xDC, 0x7C, 0x1E, 0x3B, 0x8F, 0x07, 0xC7, 0xF1, 0xE0, 0xF0, 0xFC,
  0x3C, 0x1E, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x0F,
  0x07, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0, 0xFC, 0x07, 0x83,
  0xF0, 0x1E, 0x0F, 0xC0, 0x78, 0x3F, 0x81, 0xE0, 0xFE, 0x07, 0x83, 0xF8,
  0x3E, 0x1F, 0xE0, 0xF0, 0x7F, 0xC3, 0xC1, 0xE7, 0x0F, 0x07, 0x9C, 0x3C,
  0x1E, 0x79, 0xF0, 0x78, 0xE7, 0x83, 0xE3, 0x9E, 0x0F, 0x0F, 0x78, 0x3C,
  0x1D, 0xE0, 0xF0, 0x77, 0x83, 0xC1, 0xFE, 0x0F, 0x07, 0xF0, 0x7C, 0x0F,
  0xC1, 0xE0, 0x3F, 0x07, 0x80, 0xFC, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC1,
  0xE0, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x1F, 0x07, 0x8F, 0x81, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x03, 0xDE,
  0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x1F, 0x3E, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x03,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x1F, 0x1F, 0x01,
  0xE1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3E, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x07, 0x8F, 0x81, 0xF3, 0xC0, 0x3D, 0xE0,
  0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F, 0x3E, 0x0F, 0x87, 0xFF, 0xC1, 0xFF,
  0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1C,
  0x00, 0x02, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x03,
  0xE3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF8,
  0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0xC3, 0xC0, 0x78,
  0x78, 0x0F, 0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFE, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x8F, 0x01, 0xF3,
  0xC0, 0x78, 0xF0, 0x1E, 0x3E, 0x0F, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F,
  0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x01, 0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E,
  0x3C, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x78,
  0xF0, 0x0F, 0x1E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE3,
  0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x87,
  0x81, 0xF0, 0xF0, 0x3C, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x01,
  0xFC, 0x00, 0xF0, 0x03, 0xFF, 0x00, 0xFB, 0xE0, 0x1F, 0x7C, 0x03, 0xC7,
  0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xC0, 0xF8, 0x78, 0x1E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF0, 0x3C, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0x1C, 0x07, 0xF8, 0x1E, 0x07, 0xBC, 0x0F,
  0x03, 0xDE, 0x07, 0x81, 0xEF, 0x07, 0xE1, 0xE3, 0x83, 0xF0, 0xF1, 0xC1,
  0xF8, 0x78, 0xE1, 0xFC, 0x78, 0x70, 0xFE, 0x3C, 0x38, 0x77, 0x1E, 0x1C,
  0x7B, 0x8E, 0x0E, 0x39, 0xCF, 0x07, 0x1C, 0xE7, 0x83, 0x9E, 0x73, 0x81,
  0xCE, 0x3B, 0xC0, 0xEF, 0x1D, 0xE0, 0x77, 0x0E, 0xE0, 0x3B, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xF0,
  0x7C, 0x03, 0xC3, 0xE0, 0x0F, 0x8F, 0x00, 0x1E, 0x7C, 0x00, 0x79, 0xE0,
  0x01, 0xEF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE,
  0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x0F, 0x00,
  0x7C, 0x3C, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xE0, 0x7C, 0x07, 0x83, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xE7, 0x80, 0xF9, 0xE0, 0x7C, 0x78,
  0x1E, 0x1F, 0x0F, 0x83, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x3C,
  0x01, 0xCF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1F, 0x83, 0xF0, 0x7E, 0x00, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0xF0, 0x7F,
  0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x0F, 0xE0,
  0xFC, 0x0F, 0xC0, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xEE,
  0x0E, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38, 0xE7, 0x0E, 0x70, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xF1, 0xE1, 0xE1, 0xC0, 0x03, 0xE0,
  0x3F, 0xE1, 0xFF, 0x8F, 0x9F, 0x3C, 0x3C, 0xF0, 0xF0, 0x03, 0xC1, 0xFF,
  0x3F, 0xFD, 0xFF, 0xE7, 0x87, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0xBE, 0xFC, 0xFF, 0xF1, 0xFF, 0xC3, 0xEF, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x78, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x1E, 0x0F, 0x3E, 0x0F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x7C, 0x3E, 0x7F, 0xFC, 0x7F, 0xFC, 0xF7, 0xF8,
  0xF3, 0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x9F, 0x3C, 0x3D, 0xE0,
  0xF7, 0x81, 0xDE, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x7B, 0xC1, 0xEF, 0x0F, 0x9F, 0x7C, 0x7F, 0xE0, 0xFF, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x07, 0xCF, 0x0F, 0xFF, 0x0F, 0xFF, 0x87,
  0xFF, 0xC7, 0xC3, 0xE3, 0xC0, 0xF1, 0xE0, 0x79, 0xE0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0xC1,
  0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x07, 0x9E, 0x00, 0x03, 0xE0,
  0x1F, 0xF0, 0x7F, 0xE1, 0xFB, 0xE3, 0xC3, 0xCF, 0x03, 0x9E, 0x07, 0x3C,
  0x0E, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x0C, 0x3F, 0x78, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x00, 0xF8,
  0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x7F,
  0xE3, 0xFE, 0x1F, 0xF0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE7, 0x87, 0xFB, 0xC3, 0xFF,
  0xC3, 0xF7, 0xE3, 0xE0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1,
  0xF0, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xCF, 0x00, 0x0F,
  0x80, 0x07, 0x82, 0x07, 0xC1, 0xC7, 0xC1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F,
  0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x78, 0x3F, 0xF8, 0x7F, 0xF8, 0xFD,
  0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78,
  0x3D, 0xE0, 0x7B, 0xC1, 0xE0, 0x02, 0x03, 0x83, 0xE1, 0xF0, 0x70, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x00,
  0x00, 0x20, 0x03, 0x80, 0x3E, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x0F, 0x8F, 0x0F, 0x87, 0x8F, 0x83, 0xCF, 0x81, 0xEF, 0x81,
  0xF7, 0x80, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF0, 0xF0, 0x78,
  0x78, 0x78, 0x3E, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C,
  0x00, 0x1E, 0x78, 0x3C, 0x1F, 0xFC, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xBF,
  0xDF, 0x1E, 0x1F, 0x0F, 0x1E, 0x1F, 0x0F, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E,
  0x0F, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x3C, 0x1E, 0x0F, 0x78, 0x3C,
  0x1F, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x3C,
  0x1E, 0x78, 0x3C, 0x1E, 0xF0, 0x78, 0x3E, 0xF0, 0x78, 0x3C, 0x1E, 0x78,
  0x3F, 0xF8, 0x7F, 0xF8, 0xFD, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3D, 0xE0, 0x7B, 0xC1, 0xE0, 0x03, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xFB, 0xE3, 0xC3, 0xEF, 0x03, 0xDE, 0x07, 0xBC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xDE, 0x07,
  0xBE, 0x1E, 0x3E, 0x7C, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x0F, 0x3C,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFB, 0xF0, 0xF0, 0xF8, 0xF0, 0x3C, 0x78,
  0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE7, 0x81, 0xE3,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x7C, 0x7E, 0x7C, 0x3F, 0xFC, 0x3D, 0xFE,
  0x1E, 0x7C, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x07, 0xCF, 0x1F, 0xEE, 0x3F, 0xFE,
  0x3F, 0x7E, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78,
  0xFD, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x1E, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0xF1,
  0xFF, 0x1F, 0xF1, 0xFE, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xF1, 0xE1,
  0xE7, 0x83, 0xCF, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xC0, 0x07, 0x9E, 0x07, 0x9E, 0x1E, 0x3E, 0x7C, 0x7F, 0xF0, 0x7F,
  0xC0, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x1F, 0xF7, 0xFF,
  0xFF, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x7E, 0x1F, 0x83, 0xE0, 0x78, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x3E, 0x70, 0xF0,
  0x3F, 0xC1, 0xEF, 0x07, 0xBC, 0x3E, 0x70, 0xF1, 0xC3, 0xC7, 0x1E, 0x1E,
  0x78, 0x79, 0xC1, 0xEF, 0x07, 0xBC, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x70, 0x7F,
  0x87, 0x83, 0xFC, 0x3C, 0x3D, 0xE1, 0xE1, 0xEF, 0x1F, 0x0E, 0x78, 0xF8,
  0xF1, 0xCF, 0xE7, 0x8E, 0x77, 0x38, 0x73, 0xBB, 0xC3, 0xB9, 0xDC, 0x1D,
  0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC,
  0x0F, 0x87, 0xC0, 0x78, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0x1F,
  0x0F, 0x87, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0,
  0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7B, 0x80, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0x78, 0x3C,
  0x1E, 0x3E, 0x0F, 0x00, 0x1E, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC3,
  0xE1, 0xE1, 0xE0, 0x71, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07,
  0xBC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xC0,
  0x00, 0x60, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0xF8, 0x1E,
  0x03, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0x80, 0x0E,
  0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0E,
  0x1C, 0x30, 0x00, 0x04, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0,
  0x1F, 0x01, 0xE0, 0xF8, 0x3E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0,
  0x10, 0x00, 0x1E, 0x00, 0x3F, 0x07, 0x7F, 0x87, 0xFF, 0xC7, 0xE3, 0xFF,
  0xE1, 0xFE, 0xE0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_MediumItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 26, 9, 1, -26 },
  { 27, 9, 9, 11, 3, -27 },
  { 38, 18, 26, 19, 1, -26 },
  { 97, 16, 33, 17, 1, -30 },
  { 163, 17, 26, 22, 3, -26 },
  { 219, 17, 26, 20, 1, -26 },
  { 275, 4, 9, 6, 3, -27 },
  { 280, 11, 37, 11, 2, -29 },
  { 331, 11, 37, 11, -2, -29 },
  { 382, 14, 15, 15, 2, -26 },
  { 409, 15, 19, 17, 1, -21 },
  { 445, 7, 10, 8, -2, -4 },
  { 454, 9, 3, 11, 1, -12 },
  { 458, 5, 5, 10, 1, -5 },
  { 462, 16, 28, 12, -2, -26 },
  { 518, 15, 26, 17, 2, -26 },
  { 567, 10, 26, 17, 4, -26 },
  { 600, 17, 26, 17, 0, -26 },
  { 656, 16, 26, 17, 1, -26 },
  { 708, 17, 26, 17, 0, -26 },
  { 764, 17, 26, 17, 1, -26 },
  { 820, 14, 26, 17, 2, -26 },
  { 866, 16, 26, 17, 2, -26 },
  { 918, 16, 26, 17, 1, -26 },
  { 970, 13, 26, 17, 3, -26 },
  { 1013, 7, 20, 9, 1, -20 },
  { 1031, 10, 26, 8, -2, -20 },
  { 1064, 14, 16, 16, 1, -19 },
  { 1092, 14, 12, 17, 2, -18 },
  { 1113, 14, 16, 16, 1, -19 },
  { 1141, 12, 26, 15, 3, -26 },
  { 1180, 24, 33, 27, 1, -25 },
  { 1279, 19, 26, 21, -1, -26 },
  { 1341, 19, 26, 19, 0, -26 },
  { 1403, 18, 26, 20, 2, -26 },
  { 1462, 19, 26, 20, 0, -26 },
  { 1524, 19, 26, 17, 0, -26 },
  { 1586, 18, 26, 17, 0, -26 },
  { 1645, 18, 26, 21, 2, -26 },
  { 1704, 22, 26, 22, 0, -26 },
  { 1776, 8, 26, 9, 1, -26 },
  { 1802, 17, 26, 17, 0, -26 },
  { 1858, 22, 26, 19, 0, -26 },
  { 1930, 15, 26, 17, 0, -26 },
  { 1979, 27, 26, 26, 0, -26 },
  { 2067, 22, 26, 22, 0, -26 },
  { 2139, 18, 26, 21, 2, -26 },
  { 2198, 20, 26, 20, 0, -26 },
  { 2263, 18, 30, 21, 2, -26 },
  { 2331, 19, 26, 19, 0, -26 },
  { 2393, 18, 26, 19, 1, -26 },
  { 2452, 17, 26, 19, 3, -26 },
  { 2508, 19, 26, 20, 1, -26 },
  { 2570, 19, 26, 20, 3, -26 },
  { 2632, 25, 26, 26, 3, -26 },
  { 2714, 22, 26, 19, -1, -26 },
  { 2786, 18, 26, 19, 3, -26 },
  { 2845, 19, 26, 18, 0, -26 },
  { 2907, 11, 36, 9, 0, -30 },
  { 2957, 8, 28, 13, 3, -26 },
  { 2985, 12, 36, 9, -2, -30 },
  { 3039, 12, 13, 13, 1, -26 },
  { 3059, 14, 3, 14, -2, 0 },
  { 3065, 7, 5, 11, 4, -27 },
  { 3070, 14, 19, 17, 1, -19 },
  { 3104, 16, 27, 17, 0, -27 },
  { 3158, 14, 19, 16, 1, -19 },
  { 3192, 17, 27, 17, 1, -27 },
  { 3250, 15, 19, 17, 1, -19 },
  { 3286, 13, 27, 11, 1, -27 },
  { 3330, 17, 26, 17, 0, -19 },
  { 3386, 15, 27, 17, 0, -27 },
  { 3437, 9, 27, 8, 0, -27 },
  { 3468, 13, 34, 8, -4, -27 },
  { 3524, 17, 27, 16, 0, -27 },
  { 3582, 9, 27, 8, 0, -27 },
  { 3613, 24, 19, 26, 0, -19 },
  { 3670, 15, 19, 17, 0, -19 },
  { 3706, 15, 19, 17, 1, -19 },
  { 3742, 17, 26, 17, -1, -19 },
  { 3798, 16, 26, 17, 1, -19 },
  { 3850, 12, 19, 11, 0, -19 },
  { 3879, 15, 19, 16, 0, -19 },
  { 3915, 10, 24, 11, 1, -24 },
  { 3945, 16, 19, 17, 1, -19 },
  { 3983, 14, 19, 15, 2, -19 },
  { 4017, 21, 19, 22, 2, -19 },
  { 4067, 17, 19, 16, -1, -19 },
  { 4108, 17, 26, 15, -1, -19 },
  { 4164, 15, 19, 16, 0, -19 },
  { 4200, 11, 34, 11, 1, -28 },
  { 4247, 7, 31, 9, 1, -26 },
  { 4275, 11, 34, 11, -1, -28 },
  { 4322, 16, 8, 20, 2, -15 },
};

const GFXfont RobotoCondensed_MediumItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC36PT7B_H_
