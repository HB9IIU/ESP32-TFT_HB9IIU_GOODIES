#ifndef _ROBOTOCONDENSED_MEDIUMITALIC41PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x3E, 0x0F, 0x83, 0xE0,
  0x70, 0x00, 0x38, 0xE7, 0x3D, 0xE7, 0xBC, 0xE7, 0x1C, 0xE3, 0x9C, 0x73,
  0x9C, 0xE3, 0x9C, 0x70, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x38,
  0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C,
  0x38, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x03, 0x8E, 0x00,
  0x1C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x8E,
  0x00, 0x38, 0xE0, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07,
  0x1C, 0x00, 0x78, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x70, 0x01, 0xE3, 0x80,
  0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F,
  0x1F, 0x03, 0xC7, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x7C,
  0x7C, 0x3E, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x38, 0xE0, 0x8F, 0x1C, 0x1D, 0xC3, 0x87, 0x38,
  0x71, 0xE7, 0x0E, 0x38, 0xE1, 0xCE, 0x1C, 0x7B, 0x83, 0x8E, 0xF0, 0x7F,
  0xDC, 0x07, 0xF7, 0x00, 0x7D, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x78, 0x03,
  0xBF, 0x80, 0xF7, 0xF8, 0x1D, 0xE7, 0x07, 0x38, 0xF1, 0xEF, 0x0E, 0x39,
  0xC3, 0xCE, 0x38, 0x7B, 0x87, 0x0E, 0xF0, 0xE1, 0xCC, 0x1E, 0x78, 0x01,
  0xFE, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07, 0xBE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x0E, 0x3F, 0xF1,
  0xE7, 0xCF, 0x9E, 0x7C, 0xF9, 0xEF, 0x87, 0xFE, 0xF8, 0x7F, 0xCF, 0x83,
  0xFC, 0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xFC, 0x3F, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0x7C, 0x0F, 0xC3, 0xE0, 0x7B, 0xDE, 0xE7, 0x3B, 0xDE,
  0xE7, 0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x02,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x03, 0x8E, 0x19, 0xF7, 0x7F, 0xFF, 0xFF, 0x1F, 0xFE, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xEF, 0x01, 0xE3, 0x81, 0xE1, 0xE0, 0x60, 0x70,
  0x10, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0xF8, 0xF0, 0x60, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFE, 0x7F, 0xFF, 0xF7, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xF0, 0xF0, 0xF0, 0x7C, 0xF8, 0x3E, 0x78,
  0x0F, 0x3C, 0x07, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x01, 0xF7, 0x80, 0xFB,
  0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBC, 0x07,
  0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xC0, 0xF9, 0xF0, 0x78, 0xF8,
  0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x60,
  0x3C, 0x3F, 0x9F, 0xFF, 0xFD, 0xFF, 0xBC, 0xF6, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0xFC, 0x7E, 0x1F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x87, 0xC1,
  0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x3C, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0xF8, 0xFC, 0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x07, 0xBE, 0x01, 0xE7, 0xC0, 0x78, 0xF8,
  0x0F, 0x1F, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0xE1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xDF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xC3, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x1F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x3E, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0x7C, 0x7C, 0x7F, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE,
  0x0F, 0x87, 0xC3, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC1, 0xF1, 0xF0, 0x78, 0x3C, 0x3E, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3E, 0x1E, 0x1F, 0x07, 0xC7, 0xC0, 0xF1, 0xE0, 0x3C,
  0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0x7C, 0x3E, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3E, 0x3E, 0x7C, 0x1E, 0x78, 0x1E, 0xF8,
  0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8,
  0x3E, 0xF8, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x7F,
  0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0xF8, 0xF8, 0xF8, 0x70, 0x03, 0xC0, 0x7C, 0x1F, 0x81, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x10, 0x00, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x7E, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0,
  0x7F, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC,
  0x10, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x80, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xC7, 0xCF,
  0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xC0, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x60, 0xE0, 0x3E, 0x07, 0x1E, 0x0F, 0xF0, 0x71,
  0xC1, 0xFF, 0x87, 0x3C, 0x3E, 0x38, 0x73, 0x83, 0xC7, 0x87, 0x78, 0x78,
  0x78, 0x77, 0x07, 0x07, 0x07, 0x70, 0xF0, 0x70, 0x77, 0x0F, 0x0F, 0x07,
  0xF0, 0xE0, 0xE0, 0xEF, 0x1E, 0x0E, 0x0E, 0xE1, 0xE0, 0xE0, 0xEE, 0x1E,
  0x1E, 0x0C, 0xE1, 0xE1, 0xE1, 0xCE, 0x1E, 0x3C, 0x1C, 0xE1, 0xE7, 0xE3,
  0x8E, 0x0F, 0xEF, 0xF0, 0xE0, 0xFC, 0xFE, 0x0E, 0x07, 0x87, 0xC0, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x30, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0,
  0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00,
  0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x83, 0xF0, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE1, 0xE0,
  0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x3C,
  0x07, 0xC3, 0xC0, 0x7C, 0x7C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7,
  0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80, 0xFC, 0xF8, 0x1F, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8,
  0x78, 0x03, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xF3, 0xE0, 0x07, 0xDF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x07,
  0x8F, 0x80, 0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x01, 0xF0, 0x7C,
  0x1F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xF8, 0x7E, 0x07, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x00,
  0xF0, 0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xE0,
  0x1F, 0x1F, 0x01, 0xF0, 0xF8, 0x3F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8,
  0x78, 0x03, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0xFF, 0xDF,
  0x07, 0xFC, 0xF8, 0x3F, 0xE7, 0xC1, 0xFF, 0x3E, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7E,
  0x1F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80,
  0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1E, 0x00,
  0x7C, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF0, 0x03, 0xE0, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x07, 0x83, 0xE0, 0x7C, 0x7E, 0x07, 0xFF, 0xC0, 0x3F, 0xF8,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x7E, 0x0F, 0x80, 0xFC,
  0x0F, 0x80, 0xFC, 0x0F, 0x81, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0x07, 0xE0,
  0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00,
  0x1F, 0x7E, 0x00, 0x1E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x78, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x7F,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE,
  0x1E, 0xF0, 0x1F, 0xF0, 0xF7, 0x80, 0xFF, 0x87, 0xBC, 0x0F, 0xFC, 0x3D,
  0xE0, 0x7B, 0xC3, 0xEF, 0x07, 0xDE, 0x1F, 0x78, 0x3C, 0xF0, 0xFB, 0xC1,
  0xEF, 0x87, 0x8E, 0x1E, 0x7C, 0x3C, 0x70, 0xF3, 0xE1, 0xE3, 0xCF, 0x1E,
  0x1F, 0x1E, 0x78, 0xF0, 0xF8, 0xF7, 0x8F, 0x87, 0xC7, 0xBC, 0x7C, 0x3E,
  0x3F, 0xC3, 0xE1, 0xE0, 0xFE, 0x1F, 0x1F, 0x07, 0xE0, 0xF0, 0xF8, 0x3F,
  0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x1F,
  0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F,
  0xC0, 0x1E, 0x0F, 0xC0, 0x3E, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x3E, 0x1F,
  0xE0, 0x3E, 0x1F, 0xE0, 0x3E, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x7C, 0x1F,
  0x70, 0x7C, 0x1E, 0x78, 0x7C, 0x3E, 0x78, 0x7C, 0x3E, 0x78, 0x78, 0x3E,
  0x3C, 0x78, 0x3E, 0x3C, 0xF8, 0x3E, 0x3C, 0xF8, 0x3C, 0x1C, 0xF8, 0x7C,
  0x1E, 0xF8, 0x7C, 0x1E, 0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x78,
  0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xE0, 0xF8,
  0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8,
  0x7C, 0x03, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBC, 0x00, 0x79, 0xE0, 0x03, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x0F, 0x81, 0xF8, 0x7E,
  0x1F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xF8, 0x1F, 0x87, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF3, 0xE0, 0x1F, 0x1F,
  0x03, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFC, 0x3F, 0x0F, 0x80, 0xF8, 0x7C, 0x03,
  0xC7, 0xC0, 0x1F, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00, 0x3E,
  0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x79, 0xF0, 0x03, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x0F, 0x81, 0xF8, 0x7E, 0x1F, 0x83,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xF8,
  0x3F, 0x07, 0x80, 0xF8, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1F, 0x00, 0xF0,
  0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x03,
  0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x3C, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x8F, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0,
  0x0F, 0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F,
  0x0F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x01,
  0xF0, 0x7E, 0x1F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01,
  0xF8, 0x7C, 0x07, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x03, 0xE0,
  0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xE0, 0x0F, 0x8F, 0x80, 0x1E,
  0x3C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0xF8,
  0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x0F, 0x01, 0xFF, 0x01, 0xF0, 0x1E, 0xF0, 0x1F, 0x03, 0xEF, 0x01, 0xF0,
  0x3E, 0xF0, 0x3F, 0x03, 0xCF, 0x03, 0xF0, 0x7C, 0xF0, 0x7F, 0x07, 0xCF,
  0x07, 0xF0, 0x78, 0xF0, 0x7F, 0x0F, 0x8F, 0x0F, 0xF0, 0xF8, 0xF0, 0xF7,
  0x0F, 0x0F, 0x0F, 0x71, 0xF0, 0xF1, 0xE7, 0x1F, 0x0F, 0x1E, 0x71, 0xE0,
  0xF1, 0xC7, 0x3E, 0x0F, 0x3C, 0x73, 0xE0, 0xF3, 0xC7, 0x3C, 0x0F, 0x38,
  0x73, 0xC0, 0xFF, 0x87, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x7E,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0x87, 0xC0,
  0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0x78, 0x00, 0x3E,
  0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xC0,
  0x7C, 0x1F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x1E, 0x1F, 0x00,
  0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1D, 0xC1, 0xEE, 0x0E, 0x70, 0xF3, 0xC7, 0x1E, 0x78, 0xF3,
  0xC3, 0xBC, 0x1D, 0xE0, 0xE0, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF8, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFF, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x1E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F,
  0xBC, 0x1F, 0x3C, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xCF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE1, 0xF1, 0xF0,
  0x7C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF8, 0x1F,
  0x3E, 0x07, 0xCF, 0x01, 0xF3, 0xC0, 0x7D, 0xF0, 0x1E, 0x7C, 0x0F, 0x9F,
  0x03, 0xE7, 0xE1, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x3E, 0xFF, 0x0F, 0x9F,
  0x80, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE1, 0xF1,
  0xE0, 0x79, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x79, 0xF0, 0x3C, 0xF8,
  0x3E, 0x3E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x3E,
  0x7C, 0x0F, 0xF7, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xF1, 0xF8, 0x3C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x0F,
  0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xFC, 0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0x3C, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE3, 0xF1, 0xF1, 0xF0, 0x79, 0xF0, 0x3E, 0xF8, 0x1F, 0x7F,
  0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x08, 0x3E, 0x0E, 0x1F, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFE,
  0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x01, 0xFF, 0x8F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE0, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x01, 0xF1, 0xE0, 0xFF, 0x3C, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xF8, 0x7E,
  0x3E, 0x0F, 0x8F, 0x80, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xC7, 0x80, 0xF9,
  0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x07, 0xC3, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81,
  0xFF, 0xF0, 0x1F, 0xBE, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x0E,
  0x0F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xCF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xE3, 0xE1, 0xF0, 0x78, 0x78, 0x1F,
  0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x3E, 0x3C, 0x0F, 0x8F,
  0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x07, 0xC7, 0x81,
  0xF1, 0xE0, 0x7C, 0x78, 0x1F, 0x3E, 0x07, 0x8F, 0x81, 0xE0, 0x03, 0x81,
  0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0xF0,
  0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x00,
  0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x0F,
  0xF0, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x7E, 0x0F, 0x07, 0xC0, 0xF0,
  0xF8, 0x1F, 0x1F, 0x81, 0xF3, 0xF0, 0x1F, 0x7E, 0x01, 0xE7, 0xC0, 0x1E,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xC7, 0x80, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x3E, 0x07, 0x83, 0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xF0,
  0x78, 0x1E, 0x07, 0x80, 0x0F, 0x3E, 0x0F, 0x80, 0xFF, 0xF3, 0xFC, 0x0F,
  0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0x8F, 0xE3, 0xF1, 0xF0, 0x7C,
  0x1F, 0x1E, 0x07, 0xC1, 0xF1, 0xE0, 0x78, 0x1F, 0x3E, 0x07, 0x81, 0xF3,
  0xE0, 0x78, 0x1E, 0x3E, 0x0F, 0x81, 0xE3, 0xE0, 0xF8, 0x1E, 0x3C, 0x0F,
  0x83, 0xE3, 0xC0, 0xF0, 0x3E, 0x7C, 0x0F, 0x03, 0xE7, 0xC0, 0xF0, 0x3C,
  0x7C, 0x1F, 0x03, 0xC7, 0xC1, 0xF0, 0x7C, 0x78, 0x1F, 0x07, 0xC7, 0x81,
  0xE0, 0x7C, 0xF8, 0x1E, 0x07, 0xCF, 0x81, 0xE0, 0x78, 0x0F, 0x3E, 0x03,
  0xDF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x8F, 0x87, 0xC1, 0xF1, 0xE0,
  0x7C, 0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x81, 0xE3, 0xE0, 0xF8, 0xF0, 0x3E,
  0x3C, 0x0F, 0x8F, 0x03, 0xE7, 0xC0, 0xF1, 0xF0, 0x3C, 0x7C, 0x1F, 0x1E,
  0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x80, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF9, 0xF0, 0x7D,
  0xF0, 0x1E, 0xF8, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3D, 0xF0, 0x3E, 0x78, 0x1F, 0x3E,
  0x1F, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x00, 0x07, 0x9F,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFC, 0x3E, 0x1F, 0x07,
  0xC3, 0xC0, 0xF8, 0x78, 0x0F, 0x1F, 0x01, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0xE1, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0x87, 0xDF, 0xE0,
  0xF9, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE3,
  0xC3, 0xFC, 0xF1, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0x1F, 0x8F, 0x83, 0xE7,
  0xC0, 0xF9, 0xF0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x1E,
  0x3F, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xCF, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x38, 0x7F, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x7C, 0x78, 0x3E, 0x3C, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3E, 0x1F, 0x1F, 0xFF, 0x87, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xE3, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0xC7, 0x81, 0xF3,
  0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xC0, 0xF8, 0xF0,
  0x3E, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x78, 0x1F,
  0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x3E, 0x1F, 0x1F, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xCF, 0x00, 0xF8, 0x1F, 0xF8,
  0x1F, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0x78,
  0x78, 0x78, 0xF8, 0x78, 0xF0, 0x3C, 0xF0, 0x3D, 0xE0, 0x3D, 0xE0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0xF0, 0x78, 0x1F, 0xE0, 0xF0, 0x7F, 0xC1,
  0xE0, 0xF7, 0x87, 0xC1, 0xEF, 0x0F, 0x87, 0xDE, 0x3F, 0x0F, 0x3C, 0x7E,
  0x1E, 0x78, 0xFE, 0x7C, 0xF3, 0xFC, 0xF1, 0xE7, 0x79, 0xE3, 0xDE, 0xF7,
  0x87, 0xBD, 0xEF, 0x0F, 0xF3, 0xDE, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x83, 0xE1,
  0xF0, 0xF8, 0x3E, 0x1F, 0x03, 0xC7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBE, 0x00,
  0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x1F,
  0x3C, 0x03, 0xE7, 0xC0, 0xF8, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF1, 0xF0,
  0x3E, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x3C, 0x1F, 0x07, 0x83, 0xE0,
  0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1F, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x10, 0x03, 0x80, 0x3E, 0x03, 0xE0, 0x3E,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x07, 0xF0, 0x3F, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x18, 0x00, 0x07, 0x07, 0x07, 0x0F,
  0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x38, 0x01, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xF0, 0x1D, 0xFF, 0x07, 0xBF, 0xF0, 0xFF, 0x9F, 0x3D, 0xE1, 0xFF,
  0xBC, 0x1F, 0xE7, 0x01, 0xF8, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 29, 10, 1, -29 },
  { 38, 11, 10, 13, 3, -31 },
  { 52, 21, 29, 21, 1, -29 },
  { 129, 18, 37, 20, 1, -33 },
  { 213, 19, 29, 25, 4, -29 },
  { 282, 20, 29, 22, 1, -29 },
  { 355, 5, 10, 7, 3, -31 },
  { 362, 12, 42, 13, 2, -33 },
  { 425, 13, 42, 13, -2, -33 },
  { 494, 17, 17, 18, 2, -29 },
  { 531, 17, 21, 19, 1, -24 },
  { 576, 8, 11, 9, -2, -5 },
  { 587, 10, 4, 12, 1, -14 },
  { 592, 5, 5, 11, 1, -5 },
  { 596, 18, 32, 14, -2, -29 },
  { 668, 17, 29, 20, 2, -29 },
  { 730, 11, 29, 20, 5, -29 },
  { 770, 19, 29, 20, 0, -29 },
  { 839, 18, 29, 20, 1, -29 },
  { 905, 19, 29, 20, 0, -29 },
  { 974, 18, 29, 20, 2, -29 },
  { 1040, 16, 29, 20, 2, -29 },
  { 1098, 19, 29, 20, 2, -29 },
  { 1167, 18, 29, 20, 1, -29 },
  { 1233, 16, 29, 20, 3, -29 },
  { 1291, 8, 22, 10, 1, -22 },
  { 1313, 11, 28, 9, -2, -22 },
  { 1352, 16, 19, 18, 1, -22 },
  { 1390, 16, 13, 20, 2, -20 },
  { 1416, 16, 19, 18, 1, -22 },
  { 1454, 15, 29, 17, 3, -29 },
  { 1509, 28, 37, 31, 1, -28 },
  { 1639, 23, 29, 23, -2, -29 },
  { 1723, 20, 29, 22, 1, -29 },
  { 1796, 21, 29, 23, 2, -29 },
  { 1873, 21, 29, 23, 1, -29 },
  { 1950, 20, 29, 20, 1, -29 },
  { 2023, 20, 29, 19, 1, -29 },
  { 2096, 21, 29, 23, 2, -29 },
  { 2173, 24, 29, 25, 1, -29 },
  { 2260, 10, 29, 10, 1, -29 },
  { 2297, 20, 29, 19, 0, -29 },
  { 2370, 24, 29, 22, 1, -29 },
  { 2457, 16, 29, 19, 1, -29 },
  { 2515, 29, 29, 30, 1, -29 },
  { 2621, 24, 29, 24, 1, -29 },
  { 2708, 21, 29, 24, 2, -29 },
  { 2785, 21, 29, 22, 1, -29 },
  { 2862, 21, 34, 24, 2, -29 },
  { 2952, 21, 29, 22, 1, -29 },
  { 3029, 20, 29, 21, 1, -29 },
  { 3102, 20, 29, 21, 3, -29 },
  { 3175, 22, 29, 23, 1, -29 },
  { 3255, 22, 29, 23, 3, -29 },
  { 3335, 28, 29, 30, 4, -29 },
  { 3437, 25, 29, 22, -1, -29 },
  { 3528, 21, 29, 21, 3, -29 },
  { 3605, 22, 29, 21, 0, -29 },
  { 3685, 14, 41, 10, -1, -34 },
  { 3757, 8, 32, 15, 4, -29 },
  { 3789, 13, 41, 10, -2, -34 },
  { 3856, 13, 15, 15, 1, -29 },
  { 3881, 16, 4, 16, -2, 0 },
  { 3889, 8, 6, 13, 4, -31 },
  { 3895, 16, 22, 19, 1, -22 },
  { 3939, 18, 31, 20, 0, -31 },
  { 4009, 17, 22, 18, 1, -22 },
  { 4056, 20, 31, 20, 1, -31 },
  { 4134, 17, 22, 19, 1, -22 },
  { 4181, 14, 31, 13, 2, -31 },
  { 4236, 19, 30, 20, 0, -22 },
  { 4308, 18, 31, 19, 0, -31 },
  { 4378, 10, 30, 10, 0, -30 },
  { 4416, 14, 38, 9, -4, -30 },
  { 4483, 20, 31, 19, 0, -31 },
  { 4561, 10, 31, 10, 0, -31 },
  { 4600, 28, 22, 30, 0, -22 },
  { 4677, 18, 22, 19, 0, -22 },
  { 4727, 17, 22, 20, 1, -22 },
  { 4774, 19, 30, 20, -1, -22 },
  { 4846, 18, 30, 20, 1, -22 },
  { 4914, 13, 22, 13, 0, -22 },
  { 4950, 17, 22, 18, 0, -22 },
  { 4997, 11, 27, 12, 1, -27 },
  { 5035, 18, 22, 19, 1, -22 },
  { 5085, 16, 22, 17, 2, -22 },
  { 5129, 23, 22, 25, 3, -22 },
  { 5193, 19, 22, 18, -1, -22 },
  { 5246, 19, 30, 17, -1, -22 },
  { 5318, 18, 22, 18, 0, -22 },
  { 5368, 13, 39, 12, 1, -32 },
  { 5432, 8, 34, 10, 1, -29 },
  { 5466, 13, 39, 12, -2, -32 },
  { 5530, 19, 9, 23, 2, -17 },
};

const GFXfont RobotoCondensed_MediumItalic41pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic41pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic41pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC41PT7B_H_
