#ifndef _ROBOTOCONDENSED_MEDIUMITALIC72PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0x80, 0x07, 0x00, 0x00, 0x3F, 0x07, 0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F,
  0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0xFC, 0x7E,
  0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF8,
  0x3E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC7,
  0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x80, 0xF8,
  0x1F, 0x80, 0x78, 0x7E, 0x07, 0xE0, 0x1F, 0x1F, 0x81, 0xF8, 0x0F, 0xC7,
  0xC0, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x81, 0xF0, 0x7C, 0x07, 0xE0, 0xFC,
  0x1F, 0x01, 0xF8, 0x7E, 0x07, 0xC0, 0x7E, 0x1F, 0x01, 0xF0, 0x1F, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC7, 0xE0, 0x1F, 0x83, 0xF1, 0xF0, 0x07, 0xE1, 0xF8,
  0xFC, 0x00, 0xFF, 0xFE, 0x7E, 0x00, 0x3F, 0xFF, 0x3F, 0x00, 0x07, 0xFF,
  0x8F, 0xC0, 0x00, 0xFF, 0xC7, 0xE0, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x00, 0xF8, 0xFF, 0xE0, 0x00, 0x7E, 0x7F, 0xFC, 0x00, 0x3F, 0x3F,
  0xFF, 0x00, 0x0F, 0x8F, 0xFF, 0xE0, 0x07, 0xE7, 0xF1, 0xF8, 0x03, 0xF1,
  0xF8, 0x3E, 0x01, 0xF8, 0xFC, 0x0F, 0xC0, 0x7E, 0x3F, 0x03, 0xF0, 0x3F,
  0x0F, 0x80, 0xFC, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0xC3,
  0xF0, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0xFC, 0x7C, 0x07, 0xE0, 0x3E,
  0x3F, 0x01, 0xF8, 0x1F, 0x8F, 0x80, 0x3E, 0x07, 0xE1, 0xC0, 0x0F, 0xC3,
  0xF0, 0x10, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x0F, 0xE3, 0xFE, 0x00,
  0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xC3, 0xFF, 0xFE, 0x07, 0xF1, 0xFF,
  0x7F, 0xC1, 0xFC, 0xFF, 0x9F, 0xF0, 0x7F, 0x3F, 0xC3, 0xFE, 0x3F, 0x9F,
  0xF0, 0x7F, 0x8F, 0xE7, 0xF8, 0x1F, 0xF3, 0xFB, 0xFE, 0x03, 0xFD, 0xFC,
  0xFF, 0x00, 0xFF, 0xFF, 0x3F, 0xC0, 0x1F, 0xFF, 0xCF, 0xF0, 0x07, 0xFF,
  0xE3, 0xFC, 0x00, 0xFF, 0xF8, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xC0, 0x07,
  0xFF, 0x0F, 0xF0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xC0,
  0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x7F, 0xC0,
  0x7F, 0xFF, 0x9F, 0xF0, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF1, 0xF8, 0xFC, 0x7E, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x07, 0xC0,
  0x01, 0xC0, 0x3E, 0x03, 0x9F, 0xC1, 0xF0, 0xFC, 0xFF, 0x9F, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xE0, 0x07,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x03,
  0xC0, 0x02, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC, 0x1C, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x00,
  0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x80,
  0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE,
  0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07,
  0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x00, 0xFF,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xF1, 0xFC, 0xF8,
  0x3F, 0xCE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x87, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFE,
  0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xE0,
  0x1F, 0xF0, 0x00, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE1,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x07,
  0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF1, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xE7,
  0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF9,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x1F,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xE1,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC7, 0xFC, 0x1F, 0xF0,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE,
  0x7F, 0xC0, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xE7, 0xF8, 0x03,
  0xFE, 0x7F, 0x80, 0x7F, 0xE7, 0xFC, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xF7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xF8,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x07, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC0,
  0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xE0,
  0x7F, 0x9F, 0xF0, 0x1F, 0xE7, 0xF8, 0x07, 0xFD, 0xFE, 0x01, 0xFF, 0x7F,
  0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3E, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x01, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0x81, 0xF8, 0x03, 0xFF, 0xFE, 0x03, 0xC0, 0xFC, 0x03,
  0xFF, 0xFF, 0x01, 0xF0, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0xF8, 0x7E, 0x01,
  0xFC, 0x0F, 0xC0, 0x7C, 0x3F, 0x01, 0xFC, 0x07, 0xC0, 0x3E, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0x8F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xCF, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xE7, 0xE0,
  0x3F, 0x00, 0xFC, 0x01, 0xF3, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFB, 0xF0,
  0x1F, 0x80, 0x3F, 0x00, 0xF9, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x7C, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x7E,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xBF, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xDF,
  0x80, 0xFC, 0x03, 0xF0, 0x07, 0xCF, 0xC0, 0xFE, 0x01, 0xF8, 0x03, 0xE7,
  0xE0, 0x7F, 0x00, 0xFC, 0x01, 0xF3, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF1,
  0xF0, 0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x7C,
  0x7C, 0x07, 0xF0, 0x3F, 0x80, 0x7C, 0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0x3E,
  0x1F, 0x01, 0xFC, 0x1F, 0xE0, 0x3E, 0x0F, 0x80, 0x7F, 0x1F, 0xF8, 0x3F,
  0x07, 0xC0, 0x3F, 0xFF, 0xFC, 0x7F, 0x03, 0xE0, 0x1F, 0xFF, 0x7F, 0xFF,
  0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFF,
  0x00, 0x7E, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x01, 0xFE,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFE, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xE0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F,
  0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xFF,
  0xC7, 0xFC, 0x03, 0xFF, 0xFE, 0x3F, 0xC0, 0x1F, 0xFF, 0xF1, 0xFE, 0x00,
  0xFF, 0xFF, 0x0F, 0xF0, 0x07, 0xFF, 0xF8, 0x7F, 0x80, 0x3F, 0xFF, 0xC3,
  0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0xC0,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xBF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xF8,
  0x00, 0x07, 0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xF9,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x3F, 0x9F, 0x80,
  0x03, 0xFB, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x7F, 0x9F,
  0xC0, 0x07, 0xF7, 0xF8, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x7F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x80,
  0x7F, 0x9F, 0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF8, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFC, 0x07, 0xF8,
  0xFF, 0x00, 0xFF, 0x0F, 0xC0, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x07,
  0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0x7E, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0xE0, 0x1F,
  0xE0, 0x7E, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xE7, 0xF0, 0x3F, 0xC0,
  0x3F, 0xE0, 0x7E, 0x7F, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x1F,
  0xFF, 0xE0, 0x07, 0xF8, 0x03, 0xFD, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x9F,
  0x80, 0x3F, 0xE0, 0x0F, 0xF3, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x7F, 0x00,
  0xFF, 0x00, 0x7F, 0xCF, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x1F, 0xC0, 0xFF, 0x80, 0x3F, 0xC3, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xC3, 0xFE, 0x00, 0xFF, 0x01, 0xF8,
  0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x03, 0xFC, 0x07, 0xF1, 0xFE,
  0x00, 0xFF, 0x80, 0x7E, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xE7, 0xF8, 0x03,
  0xFC, 0x01, 0xFD, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xBF, 0xE0, 0x0F, 0xF0,
  0x03, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xE7,
  0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0x7F, 0x9F, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01,
  0xFF, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFE,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xFC, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07,
  0xFC, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0xFF,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFF,
  0x3F, 0xC0, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x03, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF,
  0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01,
  0xFF, 0xC3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0xFF,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x03, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x3F,
  0xEF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x3F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x03, 0xFE,
  0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x1F,
  0xDF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xDF, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xE7, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xF9, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xC1, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0xFF, 0x01, 0xFF, 0xF0,
  0x1F, 0xE0, 0x7F, 0x80, 0xFD, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0xFC,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x7E, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x3F,
  0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x9F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F, 0xCF,
  0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xE3,
  0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xE1, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF0,
  0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE0, 0x0F, 0xF1, 0xF8,
  0x3F, 0x8F, 0xE0, 0x03, 0xF9, 0xFC, 0x0F, 0xCF, 0xF0, 0x01, 0xFC, 0xFE,
  0x07, 0xE7, 0xF8, 0x00, 0xFE, 0x7E, 0x03, 0xF3, 0xF8, 0x00, 0x7F, 0x7F,
  0x01, 0xFB, 0xFC, 0x00, 0x3F, 0xBF, 0x80, 0xFD, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xBF,
  0xC0, 0x00, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x1F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0xFF,
  0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xC7, 0xC0, 0x7F, 0x1F, 0x81, 0xF8,
  0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7E,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF7, 0xF0, 0x0F, 0xDF, 0xC0, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xF0, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x8F, 0xF0, 0xFF, 0xC0,
  0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x1F, 0xE3, 0xFC, 0x00, 0xFF,
  0x1F, 0xE0, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0x8F, 0xF8, 0x03, 0xFC, 0x7F,
  0x80, 0x1F, 0xE3, 0xFE, 0x01, 0xFF, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC3,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFB, 0xFC, 0x07, 0xFF, 0x9F, 0xE0, 0x1F, 0xF8, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0x00, 0x01, 0xFE, 0x7F, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFE, 0x03,
  0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F,
  0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xBF, 0xFF, 0xC0, 0x7F, 0x3F, 0xFF, 0x80, 0x7F, 0x1F, 0xFF, 0x00, 0xFF,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x7F,
  0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F,
  0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x3E, 0x03, 0xFC, 0x00, 0x7F, 0xE1, 0xFE, 0x00, 0x3F, 0xFE, 0x7F,
  0x80, 0x1F, 0xFF, 0xDF, 0xE0, 0x0F, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0x8F, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x80, 0x3F, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF3, 0xFC, 0x00,
  0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0x01, 0xFE, 0x00, 0x18, 0x0F, 0xF8, 0x03, 0xE0, 0x7F, 0xF0,
  0x7F, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xE1, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0xE3,
  0xFC, 0x01, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xBF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE,
  0x03, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFB, 0xFC, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x00, 0xF8,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x0E,
  0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x0F, 0x80, 0x01, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE0,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x7F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0xC0, 0x07, 0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x1F, 0xF1,
  0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03,
  0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x7F, 0xFC, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0xC3, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0x83, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0xFF, 0xC0,
  0x07, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC3, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07,
  0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF,
  0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC7, 0xFE, 0x00, 0x07, 0xF7, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFE,
  0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xBF, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xE0, 0x07, 0xF9, 0xFF, 0xF0, 0x03,
  0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0xE7, 0xF0,
  0x3F, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x87,
  0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0xFF,
  0x80, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF8,
  0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE,
  0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0x9F, 0xE0, 0x00, 0x78, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xFC, 0xFF, 0x01, 0xFD, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC3,
  0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3,
  0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xC8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F,
  0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F,
  0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC3, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF1, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xF7, 0xF8, 0x00, 0xFF, 0xCF, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0x7F,
  0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F,
  0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFF, 0x00,
  0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFD,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xC0,
  0x0F, 0xF7, 0xF0, 0x07, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0x01, 0xFE,
  0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x9F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC7, 0xF0,
  0x1F, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFF,
  0x81, 0xFE, 0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xF8, 0x1F,
  0xC1, 0xFC, 0x1F, 0xFE, 0x0F, 0xF0, 0x7F, 0x07, 0xFF, 0x83, 0xF8, 0x1F,
  0xC1, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0xFF, 0xF8, 0x7F, 0x81, 0xFC, 0x3F,
  0x7E, 0x1F, 0xC0, 0x7F, 0x1F, 0xDF, 0x87, 0xF0, 0x1F, 0xC7, 0xE7, 0xE3,
  0xFC, 0x07, 0xF3, 0xF9, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x7F, 0x7F, 0x80,
  0x7F, 0x3F, 0x0F, 0xDF, 0xC0, 0x1F, 0xDF, 0xC3, 0xF7, 0xF0, 0x07, 0xF7,
  0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0x8F,
  0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFE,
  0x7F, 0x80, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x3F,
  0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF8, 0x0F, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x7F,
  0xF8, 0x00, 0xFC, 0x3F, 0xFF, 0x00, 0x7F, 0x1F, 0xFF, 0xE0, 0x1F, 0x8F,
  0xFF, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0x03, 0xF8, 0xFE, 0x3F, 0xF1, 0xFC,
  0x7F, 0x03, 0xFF, 0xFF, 0x1F, 0x80, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0xFF,
  0xE3, 0xF8, 0x03, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 17, 52, 18, 2, -51 },
  { 112, 19, 18, 22, 6, -54 },
  { 155, 36, 51, 38, 2, -51 },
  { 385, 32, 67, 35, 2, -59 },
  { 653, 34, 53, 44, 6, -52 },
  { 879, 34, 53, 39, 2, -52 },
  { 1105, 9, 18, 12, 5, -54 },
  { 1126, 22, 73, 22, 3, -57 },
  { 1327, 22, 73, 22, -3, -57 },
  { 1528, 29, 31, 31, 4, -51 },
  { 1641, 30, 37, 34, 2, -42 },
  { 1780, 14, 20, 16, -4, -8 },
  { 1815, 17, 7, 22, 2, -25 },
  { 1830, 9, 10, 19, 2, -9 },
  { 1842, 32, 55, 24, -4, -51 },
  { 2062, 30, 53, 35, 3, -52 },
  { 2261, 20, 51, 35, 8, -51 },
  { 2389, 34, 52, 35, 0, -52 },
  { 2610, 32, 53, 35, 1, -52 },
  { 2822, 32, 51, 35, 1, -51 },
  { 3026, 32, 52, 35, 3, -51 },
  { 3234, 29, 52, 35, 3, -51 },
  { 3423, 33, 51, 35, 4, -51 },
  { 3634, 32, 53, 35, 2, -52 },
  { 3846, 28, 52, 35, 5, -52 },
  { 4028, 14, 40, 18, 2, -39 },
  { 4098, 19, 51, 16, -3, -39 },
  { 4220, 28, 33, 31, 2, -39 },
  { 4336, 29, 22, 34, 3, -34 },
  { 4416, 28, 33, 32, 2, -39 },
  { 4532, 26, 53, 30, 5, -52 },
  { 4705, 49, 66, 54, 2, -50 },
  { 5110, 39, 51, 41, -3, -51 },
  { 5359, 36, 51, 39, 1, -51 },
  { 5589, 37, 53, 40, 3, -52 },
  { 5835, 37, 51, 40, 1, -51 },
  { 6071, 36, 51, 34, 1, -51 },
  { 6301, 36, 51, 33, 1, -51 },
  { 6531, 37, 53, 41, 3, -52 },
  { 6777, 43, 51, 43, 1, -51 },
  { 7052, 18, 51, 18, 1, -51 },
  { 7167, 35, 52, 34, 0, -51 },
  { 7395, 42, 51, 38, 1, -51 },
  { 7663, 28, 51, 33, 1, -51 },
  { 7842, 52, 51, 53, 1, -51 },
  { 8174, 43, 51, 43, 1, -51 },
  { 8449, 37, 53, 42, 3, -52 },
  { 8695, 38, 51, 39, 1, -51 },
  { 8938, 37, 61, 42, 3, -52 },
  { 9221, 37, 51, 38, 1, -51 },
  { 9457, 36, 53, 37, 1, -52 },
  { 9696, 35, 51, 37, 6, -51 },
  { 9920, 38, 52, 40, 3, -51 },
  { 10167, 38, 51, 40, 6, -51 },
  { 10410, 49, 51, 53, 7, -51 },
  { 10723, 44, 51, 39, -2, -51 },
  { 11004, 36, 51, 37, 6, -51 },
  { 11234, 40, 51, 37, -1, -51 },
  { 11489, 24, 71, 18, -1, -59 },
  { 11702, 16, 55, 26, 6, -51 },
  { 11812, 23, 71, 18, -4, -59 },
  { 12017, 22, 26, 27, 3, -51 },
  { 12089, 28, 7, 28, -4, 0 },
  { 12114, 14, 11, 22, 7, -54 },
  { 12134, 29, 40, 33, 1, -39 },
  { 12279, 32, 55, 35, 0, -54 },
  { 12499, 29, 40, 32, 2, -39 },
  { 12644, 34, 55, 35, 2, -54 },
  { 12878, 29, 40, 33, 2, -39 },
  { 13023, 24, 55, 23, 3, -55 },
  { 13188, 34, 54, 35, 0, -39 },
  { 13418, 31, 54, 34, 0, -54 },
  { 13628, 17, 52, 17, 1, -52 },
  { 13739, 24, 67, 16, -7, -52 },
  { 13940, 34, 54, 33, 0, -54 },
  { 14170, 17, 54, 17, 1, -54 },
  { 14285, 49, 39, 52, 0, -39 },
  { 14524, 31, 39, 34, 0, -39 },
  { 14676, 30, 40, 35, 2, -39 },
  { 14826, 34, 54, 35, -2, -39 },
  { 15056, 31, 54, 35, 2, -39 },
  { 15266, 24, 39, 22, 0, -39 },
  { 15383, 29, 40, 32, 1, -39 },
  { 15528, 19, 48, 21, 3, -47 },
  { 15642, 31, 39, 34, 2, -38 },
  { 15794, 28, 38, 31, 4, -38 },
  { 15927, 42, 38, 45, 4, -38 },
  { 16127, 34, 38, 31, -2, -38 },
  { 16289, 34, 53, 30, -2, -38 },
  { 16515, 32, 38, 31, -1, -38 },
  { 16667, 22, 69, 21, 2, -56 },
  { 16857, 15, 61, 17, 1, -51 },
  { 16972, 22, 69, 21, -3, -56 },
  { 17162, 34, 15, 40, 3, -29 },
};

const GFXfont RobotoCondensed_MediumItalic72pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic72pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic72pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC72PT7B_H_
