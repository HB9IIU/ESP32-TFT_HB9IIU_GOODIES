#ifndef _ROBOTOCONDENSED_MEDIUMITALIC10PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x20, 0xFC, 0x19, 0x5E, 0x6F, 0xB1, 0x80, 0x11, 0x92,
  0x83, 0x0A, 0x4E, 0x40, 0xC5, 0xB8, 0x47, 0x54, 0xC0, 0x32, 0x94, 0xCF,
  0xC9, 0xE0, 0xE0, 0x12, 0x44, 0x44, 0x88, 0x44, 0x48, 0x92, 0x92, 0x90,
  0x4F, 0x4A, 0x21, 0x3C, 0x42, 0x00, 0x5C, 0xE0, 0xC0, 0x08, 0x84, 0x42,
  0x21, 0x08, 0x32, 0x52, 0xAD, 0x29, 0x80, 0x75, 0xA4, 0x90, 0x32, 0xC4,
  0x22, 0x23, 0xC0, 0x32, 0xC4, 0x61, 0x49, 0x80, 0x19, 0x8C, 0xAF, 0x08,
  0x80, 0x3A, 0x1C, 0x21, 0x69, 0x80, 0x36, 0x75, 0xD5, 0x60, 0xF3, 0x26,
  0x4C, 0x80, 0x32, 0xD6, 0xED, 0x49, 0x80, 0x6A, 0xBA, 0xE6, 0xC0, 0x40,
  0xC0, 0x40, 0xA8, 0x16, 0xC2, 0x70, 0x70, 0x43, 0x3C, 0xF4, 0xA8, 0x20,
  0x1C, 0x45, 0x6B, 0x5A, 0xB5, 0x6F, 0x40, 0x70, 0x11, 0x8C, 0x97, 0xE6,
  0x20, 0x7A, 0x52, 0xE4, 0xEF, 0xC0, 0x39, 0x24, 0x10, 0xC1, 0x27, 0x00,
  0x72, 0x52, 0x94, 0xEF, 0xC0, 0x7A, 0x10, 0xE4, 0x63, 0xC0, 0x7A, 0x10,
  0xE4, 0x62, 0x00, 0x39, 0x24, 0x16, 0xC9, 0x27, 0x00, 0x45, 0x14, 0xDE,
  0x4B, 0x28, 0x80, 0x49, 0x25, 0xA0, 0x08, 0xC4, 0x21, 0x49, 0x80, 0x4D,
  0x67, 0x18, 0x53, 0x49, 0x80, 0x44, 0x44, 0x4C, 0xF0, 0x62, 0xCD, 0x9B,
  0x56, 0xFA, 0xA5, 0x00, 0x65, 0x96, 0xD6, 0x5B, 0x68, 0x80, 0x39, 0x24,
  0xD2, 0xC9, 0x27, 0x00, 0x7A, 0x52, 0xF4, 0x62, 0x00, 0x39, 0x24, 0xD2,
  0xC9, 0x27, 0x06, 0x7A, 0x52, 0xE5, 0x6A, 0x60, 0x3A, 0x50, 0x61, 0xCD,
  0xC0, 0xFB, 0x10, 0x84, 0x21, 0x00, 0x4D, 0x24, 0x92, 0xCB, 0x67, 0x00,
  0x8C, 0xA5, 0x4A, 0x31, 0x00, 0x97, 0x6A, 0xD5, 0xED, 0x9B, 0x26, 0x00,
  0x49, 0xA3, 0x0C, 0x71, 0x49, 0x80, 0x9C, 0xB8, 0xC4, 0x21, 0x00, 0x78,
  0xC4, 0x46, 0x23, 0xC0, 0x69, 0x24, 0xB4, 0x98, 0xAA, 0xD5, 0x32, 0x22,
  0x22, 0x26, 0x44, 0x26, 0x65, 0x70, 0x90, 0x75, 0x79, 0xF0, 0x44, 0x47,
  0x5D, 0x9F, 0x75, 0x89, 0x60, 0x08, 0x42, 0xE5, 0x4A, 0x4E, 0x75, 0xF8,
  0x70, 0x36, 0x46, 0x44, 0x4C, 0x6A, 0xA5, 0x27, 0x0B, 0x80, 0x44, 0x47,
  0x5D, 0x99, 0x45, 0x68, 0x20, 0x92, 0x92, 0xC0, 0x42, 0x10, 0xA6, 0x72,
  0x92, 0x49, 0x24, 0xA4, 0x7E, 0xA5, 0x4C, 0xA9, 0x40, 0x75, 0xD9, 0x90,
  0x75, 0x99, 0x60, 0x75, 0x59, 0xF8, 0x80, 0x7A, 0xA5, 0x27, 0x08, 0x80,
  0x69, 0x48, 0x75, 0x69, 0x60, 0x4B, 0xA4, 0x90, 0x5A, 0xB5, 0x27, 0x00,
  0xB7, 0x68, 0xAF, 0x7D, 0x6B, 0x00, 0x53, 0x18, 0xCA, 0x00, 0x52, 0x98,
  0xC4, 0x22, 0x00, 0x73, 0x64, 0xF0, 0x25, 0x2C, 0x92, 0x48, 0x55, 0x6A,
  0x49, 0x22, 0x96, 0x90, 0x6C, 0xC0,
};

const GFXglyph RobotoCondensed_MediumItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 2, 0, -7 },
  { 4, 2, 3, 3, 1, -8 },
  { 5, 5, 7, 5, 0, -7 },
  { 10, 5, 9, 5, 0, -8 },
  { 16, 5, 7, 6, 1, -7 },
  { 21, 5, 7, 5, 0, -7 },
  { 26, 1, 3, 2, 1, -8 },
  { 27, 4, 10, 3, 0, -8 },
  { 32, 3, 10, 3, 0, -8 },
  { 36, 4, 4, 4, 1, -7 },
  { 38, 5, 5, 5, 0, -6 },
  { 42, 2, 3, 2, -1, -1 },
  { 43, 3, 1, 3, 0, -4 },
  { 44, 2, 1, 3, 0, -1 },
  { 45, 5, 8, 3, -1, -7 },
  { 50, 5, 7, 5, 0, -7 },
  { 55, 3, 7, 5, 1, -7 },
  { 58, 5, 7, 5, 0, -7 },
  { 63, 5, 7, 5, 0, -7 },
  { 68, 5, 7, 5, 0, -7 },
  { 73, 5, 7, 5, 0, -7 },
  { 78, 4, 7, 5, 0, -7 },
  { 82, 4, 7, 5, 1, -7 },
  { 86, 5, 7, 5, 0, -7 },
  { 91, 4, 7, 5, 1, -7 },
  { 95, 2, 5, 3, 0, -5 },
  { 97, 2, 7, 2, 0, -5 },
  { 99, 4, 4, 4, 0, -5 },
  { 101, 4, 3, 5, 0, -5 },
  { 103, 4, 4, 4, 0, -5 },
  { 105, 3, 7, 4, 1, -7 },
  { 108, 7, 9, 7, 0, -7 },
  { 116, 5, 7, 6, 0, -7 },
  { 121, 5, 7, 5, 0, -7 },
  { 126, 6, 7, 6, 0, -7 },
  { 132, 5, 7, 6, 0, -7 },
  { 137, 5, 7, 5, 0, -7 },
  { 142, 5, 7, 5, 0, -7 },
  { 147, 6, 7, 6, 0, -7 },
  { 153, 6, 7, 6, 0, -7 },
  { 159, 3, 7, 3, 0, -7 },
  { 162, 5, 7, 5, 0, -7 },
  { 167, 6, 7, 5, 0, -7 },
  { 173, 4, 7, 5, 0, -7 },
  { 177, 7, 7, 7, 0, -7 },
  { 184, 6, 7, 6, 0, -7 },
  { 190, 6, 7, 6, 0, -7 },
  { 196, 5, 7, 5, 0, -7 },
  { 201, 6, 8, 6, 0, -7 },
  { 207, 5, 7, 5, 0, -7 },
  { 212, 5, 7, 5, 0, -7 },
  { 217, 5, 7, 5, 1, -7 },
  { 222, 6, 7, 6, 0, -7 },
  { 228, 5, 7, 6, 1, -7 },
  { 233, 7, 7, 7, 1, -7 },
  { 240, 6, 7, 5, 0, -7 },
  { 246, 5, 7, 5, 1, -7 },
  { 251, 5, 7, 5, 0, -7 },
  { 256, 3, 10, 3, 0, -8 },
  { 260, 2, 8, 4, 1, -7 },
  { 262, 4, 10, 3, -1, -8 },
  { 267, 4, 4, 4, 0, -7 },
  { 269, 4, 1, 4, -1, 0 },
  { 270, 2, 2, 3, 1, -8 },
  { 271, 4, 5, 5, 0, -5 },
  { 274, 4, 8, 5, 0, -8 },
  { 278, 4, 5, 4, 0, -5 },
  { 281, 5, 8, 5, 0, -8 },
  { 286, 4, 5, 5, 0, -5 },
  { 289, 4, 8, 3, 0, -8 },
  { 293, 5, 7, 5, 0, -5 },
  { 298, 4, 8, 5, 0, -8 },
  { 302, 2, 7, 2, 0, -7 },
  { 304, 3, 9, 2, -1, -7 },
  { 308, 5, 8, 5, 0, -8 },
  { 313, 3, 8, 2, 0, -8 },
  { 316, 7, 5, 7, 0, -5 },
  { 321, 4, 5, 5, 0, -5 },
  { 324, 4, 5, 5, 0, -5 },
  { 327, 4, 7, 5, 0, -5 },
  { 331, 5, 7, 5, 0, -5 },
  { 336, 3, 5, 3, 0, -5 },
  { 338, 4, 5, 4, 0, -5 },
  { 341, 3, 7, 3, 0, -7 },
  { 344, 5, 5, 5, 0, -5 },
  { 348, 3, 5, 4, 1, -5 },
  { 350, 5, 5, 6, 1, -5 },
  { 354, 5, 5, 4, 0, -5 },
  { 358, 5, 7, 4, 0, -5 },
  { 363, 4, 5, 4, 0, -5 },
  { 366, 3, 10, 3, 0, -8 },
  { 370, 2, 8, 2, 0, -7 },
  { 372, 3, 10, 3, 0, -8 },
  { 376, 5, 2, 6, 0, -4 },
};

const GFXfont RobotoCondensed_MediumItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC10PT7B_H_
