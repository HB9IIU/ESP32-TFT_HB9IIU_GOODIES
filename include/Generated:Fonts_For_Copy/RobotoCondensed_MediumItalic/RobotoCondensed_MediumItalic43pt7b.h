#ifndef _ROBOTOCONDENSED_MEDIUMITALIC43PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x07, 0x00, 0x3C, 0xF3, 0x8F, 0x38, 0xE7, 0x8E, 0x79, 0xE7,
  0x9E, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xE1, 0x80, 0x00, 0x1C, 0x38,
  0x00, 0x71, 0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xF0, 0x00,
  0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x78,
  0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0xE1, 0xC0,
  0x03, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x0F,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0x8E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xE7, 0xC1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x87, 0x81, 0xF0, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x9F, 0x01,
  0xF3, 0xE0, 0x3E, 0x3C, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E, 0x1F, 0x8F,
  0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0x9E, 0x08, 0xF0, 0xE0, 0xCF, 0x0E, 0x1E, 0xE0,
  0xE3, 0xCE, 0x1E, 0x38, 0xE1, 0xE7, 0x8E, 0x1C, 0xF0, 0xF3, 0xCE, 0x07,
  0xF9, 0xC0, 0x7F, 0xBC, 0x01, 0xE3, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0xF8, 0x03, 0xDF, 0xC0, 0x7B, 0xFE, 0x07, 0x3C,
  0xE0, 0xE7, 0x8F, 0x1E, 0x70, 0xF1, 0xC7, 0x0F, 0x38, 0x70, 0xF7, 0x87,
  0x0F, 0xF0, 0x70, 0xE2, 0x07, 0x9E, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0xF8, 0x0F,
  0x87, 0x80, 0x7C, 0x7C, 0x01, 0xE7, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0xF1, 0xFF,
  0xC7, 0x8F, 0xBE, 0x3C, 0xF8, 0xF9, 0xE7, 0xC7, 0xDF, 0x7C, 0x1F, 0xF3,
  0xE0, 0xFF, 0x9F, 0x03, 0xF8, 0xF8, 0x1F, 0xC7, 0xC0, 0x7C, 0x1F, 0x0F,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFD, 0xF0, 0x1F, 0x8F, 0xC0,
  0x38, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0xF3, 0xCE, 0x00, 0x00, 0x08, 0x01,
  0xC0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x08, 0x00, 0x01, 0x00, 0x0C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x38, 0x67, 0xCE,
  0x7B, 0xFF, 0xFF, 0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x0F, 0x70, 0x07, 0x9E, 0x03, 0xC7, 0x81, 0xF0, 0xF0, 0x38, 0x38, 0x04,
  0x04, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x1F, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E,
  0x3C, 0x7C, 0x78, 0xF8, 0xF0, 0x60, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x31,
  0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0x8F,
  0x87, 0xC1, 0xE1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xF7,
  0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xE0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3E, 0x3E, 0x0F, 0x87,
  0xC7, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x30, 0x0F, 0x07, 0xF1, 0xFE, 0x7F, 0xEF, 0xFE, 0xFF, 0xEE, 0x3E, 0x83,
  0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xE3, 0xE0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFC, 0x7C, 0x3E, 0x0F, 0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x1F, 0x1F, 0x03, 0xE1, 0xF1, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0xFC, 0x00, 0xF7, 0xC0, 0x1E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x0F,
  0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x7C, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1,
  0xF1, 0xF8, 0x0C, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x1F, 0x1F,
  0x07, 0xC1, 0xF1, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0xBE, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E,
  0x7C, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x3C, 0x1F, 0x1F, 0x1F, 0x8F,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0,
  0x7C, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0x7C, 0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xF8, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xE3, 0xE0, 0xF8, 0x3C, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x1F, 0x0F, 0x83, 0xE1, 0xF8, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F,
  0xF0, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xC3, 0xF3, 0xF1, 0xF0, 0xF9, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C,
  0x07, 0xBE, 0x03, 0xFF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x7E, 0x7C, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0xFB,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x06, 0x07,
  0x87, 0xE3, 0xF1, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x1F, 0x0F, 0xC7, 0xE3, 0xE0,
  0xE0, 0x00, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x80, 0x01,
  0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0x80, 0x7F, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x02,
  0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC0, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x03, 0xE0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xF7, 0xE7, 0xEF, 0x87, 0xFE, 0x0F, 0xFC,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0x80,
  0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x78, 0x0F, 0x81, 0xC3, 0x81, 0xFE,
  0x0E, 0x3C, 0x1F, 0xF8, 0x71, 0xC1, 0xF3, 0xC3, 0x9E, 0x1E, 0x1E, 0x1C,
  0xE0, 0xF0, 0xF0, 0xE7, 0x0F, 0x07, 0x07, 0x78, 0x78, 0x38, 0x3B, 0xC3,
  0x83, 0xC1, 0xDC, 0x3C, 0x1E, 0x0E, 0xE1, 0xE0, 0xE0, 0x7F, 0x0F, 0x07,
  0x03, 0xF8, 0x78, 0x78, 0x3B, 0xC3, 0x83, 0xC1, 0xDE, 0x1C, 0x1E, 0x0E,
  0xE0, 0xE1, 0xE0, 0xE7, 0x07, 0x8F, 0x07, 0x38, 0x3E, 0xFC, 0x71, 0xC1,
  0xFF, 0xFF, 0x0E, 0x07, 0xE7, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C,
  0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x3F, 0x87, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07,
  0xE7, 0xE0, 0x3E, 0x3E, 0x07, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF0, 0x3E, 0x03, 0xE1, 0xF0, 0x0F,
  0x87, 0xC0, 0x3E, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xF3, 0xC0, 0x07, 0xDF,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xE1, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0x87, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x01, 0xE1, 0xF0,
  0x07, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x0F,
  0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x00,
  0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0x83, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x0F,
  0x8F, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x07,
  0xFE, 0x7C, 0x1F, 0xF3, 0xE0, 0x7F, 0xCF, 0x83, 0xFF, 0x3E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xF1, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x3E, 0x1F,
  0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x9F, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x3F,
  0x03, 0xE0, 0x3F, 0x83, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x1F,
  0x80, 0x7C, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F,
  0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01, 0xF7,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF, 0x80, 0x07, 0xE7, 0xC0, 0x07,
  0xE3, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3F, 0x00,
  0x7C, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8,
  0x7F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83,
  0xFC, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x3F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3D, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xE7,
  0x81, 0xEF, 0x83, 0xCF, 0x07, 0xDF, 0x0F, 0x9E, 0x0F, 0x3C, 0x1F, 0x3C,
  0x3E, 0xF8, 0x3E, 0x78, 0x79, 0xF0, 0x7C, 0xF0, 0xF3, 0xE0, 0xF9, 0xE3,
  0xC7, 0xC1, 0xE3, 0xC7, 0x8F, 0x87, 0xC3, 0x9E, 0x3E, 0x0F, 0x87, 0xBC,
  0x7C, 0x1F, 0x0F, 0xF0, 0xF8, 0x3E, 0x1F, 0xE1, 0xF0, 0x7C, 0x3F, 0xC3,
  0xE1, 0xF0, 0x7F, 0x07, 0xC3, 0xE0, 0xFE, 0x1F, 0x07, 0xC1, 0xF8, 0x3E,
  0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xFC,
  0x03, 0xE0, 0xFE, 0x01, 0xF0, 0x7F, 0x00, 0xF8, 0x3F, 0xC0, 0x7C, 0x1F,
  0xE0, 0x3E, 0x1F, 0xF0, 0x1F, 0x0F, 0xBC, 0x1F, 0x07, 0xDE, 0x0F, 0x83,
  0xEF, 0x07, 0xC1, 0xF7, 0x83, 0xE0, 0xF9, 0xE1, 0xF0, 0xF8, 0xF0, 0xF8,
  0x7C, 0x78, 0xF8, 0x3E, 0x1E, 0x7C, 0x1F, 0x0F, 0x3E, 0x0F, 0x87, 0x9F,
  0x07, 0xC3, 0xCF, 0x87, 0xC0, 0xF7, 0xC3, 0xE0, 0x7F, 0xC1, 0xF0, 0x3F,
  0xE0, 0xF8, 0x0F, 0xF0, 0x7C, 0x07, 0xF8, 0x7E, 0x03, 0xFC, 0x3E, 0x00,
  0xFE, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00,
  0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x1F, 0x07, 0xF1, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xF8, 0x1F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF8,
  0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xF1, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x40, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0x83, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x01,
  0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x0F, 0x80, 0xFC, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x8F,
  0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFE, 0x3F, 0x07, 0xC0, 0xFC, 0x7E, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC3, 0xE0, 0x7E, 0x1F,
  0xC7, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF1, 0xF0,
  0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xE3,
  0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF3, 0xE0, 0x07,
  0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3F, 0x01, 0xF8,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x0F, 0x80, 0x1E,
  0x1F, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0xC0,
  0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x3F, 0x03, 0xEF, 0x81, 0xF8,
  0x1F, 0x7C, 0x0F, 0xC0, 0xFB, 0xE0, 0xFE, 0x0F, 0x9F, 0x07, 0xF0, 0x7C,
  0xF8, 0x3F, 0x83, 0xE7, 0xC3, 0xFC, 0x3E, 0x3E, 0x1F, 0xE1, 0xF1, 0xF0,
  0xFF, 0x0F, 0x8F, 0x8F, 0x78, 0xF8, 0x7C, 0x7B, 0xC7, 0xC3, 0xE3, 0xDE,
  0x3E, 0x1F, 0x3C, 0x71, 0xE0, 0xF9, 0xE3, 0x9F, 0x07, 0xDE, 0x1C, 0xF8,
  0x3E, 0xF0, 0xE7, 0x80, 0xF7, 0x87, 0x7C, 0x07, 0xF8, 0x3F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03,
  0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x03,
  0xE3, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x7E, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xBE, 0x00,
  0xFC, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3E, 0x07,
  0x83, 0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0xF8,
  0x01, 0xE7, 0xC0, 0x0F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x00, 0xF0,
  0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0,
  0x78, 0x3E, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x0F,
  0x87, 0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x0F, 0xF0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x07, 0xF8, 0x3F, 0xC3, 0xDE, 0x1E, 0x71, 0xE3, 0x8F, 0x1C, 0xF0, 0xF7,
  0x87, 0xF8, 0x3F, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7C, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x81, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE7, 0xF1, 0xF3,
  0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C, 0x1F, 0x3E, 0x1F,
  0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFD, 0xF0, 0x7C, 0xF8, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF3, 0xE0, 0x3F, 0xFE, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x8F, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x03, 0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF8,
  0x3E, 0x3F, 0x8F, 0xC7, 0xFF, 0xF0, 0xF7, 0xFE, 0x3E, 0x7F, 0x87, 0xC7,
  0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0xF9,
  0xF0, 0x7C, 0xF0, 0x1E, 0xF8, 0x0F, 0x7C, 0x07, 0xBE, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0xF8,
  0x1F, 0x3C, 0x0F, 0x1F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x1F, 0x1F, 0x01, 0xFE, 0xF8, 0x1F, 0xF7, 0xC1, 0xFF, 0xFC,
  0x1F, 0x8F, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC0, 0xF8, 0x7E, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0x78, 0x01,
  0xF3, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F,
  0x0F, 0x8F, 0x81, 0xE3, 0xE0, 0x79, 0xF0, 0x1E, 0x7C, 0x07, 0x9F, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0x07, 0xE1, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFC, 0xFF, 0xE0, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x01, 0xF8, 0xF0, 0x3F, 0xDF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xC7, 0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0x87, 0xE0, 0xF8, 0x3F,
  0x1F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0xF8, 0x07, 0xCF, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x20, 0x3E, 0x07, 0x07, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE7, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC7, 0xF1, 0xF1, 0xF0, 0x7C, 0x7C, 0x0F, 0x1F, 0x03,
  0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x78, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0x00, 0x00,
  0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x1F,
  0x1F, 0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFD, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x3C, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0x0F, 0x9F, 0x07, 0xC0, 0x7B, 0xFC, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F, 0x9F, 0x8F, 0x83, 0xF0, 0x7C,
  0x7C, 0x1F, 0x83, 0xE3, 0xE0, 0xF8, 0x1F, 0x1E, 0x07, 0xC0, 0xF8, 0xF0,
  0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x3E, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x7C,
  0x0F, 0x1F, 0x03, 0xC0, 0xF8, 0xF0, 0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x3E,
  0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x0F, 0x9F, 0x03, 0xE0, 0x78, 0xF8,
  0x1E, 0x07, 0xC7, 0x81, 0xF0, 0x3E, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x7C,
  0x0F, 0x80, 0x0F, 0x1F, 0x03, 0xDF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xC7, 0xC7, 0xC1, 0xF1, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x07, 0xCF, 0x81,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xC0, 0xF9,
  0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78,
  0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xFE, 0x1F, 0x8F, 0x8F, 0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0x9F, 0x07, 0xC7, 0xE3,
  0xF1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0x9F,
  0x80, 0x7B, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE3, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1E, 0x1E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7C, 0x3F, 0x0F, 0xC3, 0xFF, 0xF8,
  0x3D, 0xFF, 0x87, 0xDF, 0xF0, 0x7C, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF1, 0xE0, 0xFF, 0x7C, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE3, 0xF0, 0xFC, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x3E, 0x7C, 0x07, 0xCF, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0x03,
  0xE1, 0xF0, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xEF,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xBC,
  0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE,
  0x1F, 0x8F, 0x87, 0xC1, 0xF1, 0xE0, 0x7C, 0x7C, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x00, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0xC7, 0xC3, 0xF1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x81, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0xE0, 0x7F, 0x0F, 0xE1, 0xF8, 0x1F, 0x00, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x07, 0xC7, 0xC0, 0xF8,
  0xF8, 0x1F, 0x0F, 0x07, 0xE1, 0xF1, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xBC, 0x07, 0xEF, 0x80, 0xF8, 0x0F, 0xBC, 0x07, 0xDE, 0x07, 0xCF,
  0x03, 0xE7, 0x83, 0xE3, 0xE1, 0xF1, 0xF0, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x03, 0xDF, 0x01, 0xEF, 0x00, 0xF7,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF0, 0x3C, 0x0F, 0x78, 0x1E, 0x0F,
  0xBC, 0x1F, 0x07, 0xDE, 0x0F, 0x83, 0xCF, 0x0F, 0xC3, 0xE7, 0x87, 0xE1,
  0xF3, 0xC3, 0xF0, 0xF1, 0xE3, 0xF8, 0xF8, 0xF1, 0xFC, 0x78, 0x79, 0xEE,
  0x3C, 0x3C, 0xF7, 0xBE, 0x1E, 0xF3, 0xDE, 0x0F, 0x79, 0xEF, 0x07, 0xBC,
  0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x07,
  0x87, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x3C, 0xF8, 0x03, 0xDF, 0x00,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0xBE,
  0x01, 0xF3, 0xE0, 0x1F, 0x1E, 0x03, 0xE1, 0xF0, 0x7E, 0x1F, 0x07, 0xC1,
  0xF0, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0xF0, 0x3F, 0x0F, 0x03, 0xE0,
  0xF8, 0x3E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x7B, 0xE0, 0x07, 0xBE,
  0x00, 0x7B, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0x08, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC1, 0xFC,
  0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0E, 0x00, 0x10,
  0x00, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x83,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x70, 0x01, 0x00, 0x00, 0x0F, 0x00, 0x01,
  0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0xFF, 0x0F, 0x79, 0xF9, 0xEF, 0x0F, 0xFE,
  0xF0, 0x7F, 0xCF, 0x03, 0xF8, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 31, 11, 1, -31 },
  { 40, 12, 11, 13, 3, -32 },
  { 57, 22, 31, 22, 1, -31 },
  { 143, 19, 39, 21, 1, -35 },
  { 236, 20, 31, 27, 4, -31 },
  { 314, 21, 31, 23, 1, -31 },
  { 396, 6, 11, 7, 3, -32 },
  { 405, 13, 44, 13, 2, -34 },
  { 477, 13, 44, 13, -2, -34 },
  { 549, 18, 18, 18, 2, -31 },
  { 590, 18, 23, 20, 1, -26 },
  { 642, 8, 12, 9, -2, -5 },
  { 654, 10, 4, 13, 1, -15 },
  { 659, 6, 6, 12, 1, -6 },
  { 664, 19, 34, 15, -2, -31 },
  { 745, 18, 31, 21, 2, -31 },
  { 815, 12, 31, 21, 5, -31 },
  { 862, 20, 31, 21, 0, -31 },
  { 940, 19, 31, 21, 1, -31 },
  { 1014, 20, 31, 21, 0, -31 },
  { 1092, 19, 31, 21, 2, -31 },
  { 1166, 17, 31, 21, 2, -31 },
  { 1232, 20, 31, 21, 2, -31 },
  { 1310, 19, 31, 21, 1, -31 },
  { 1384, 17, 31, 21, 3, -31 },
  { 1450, 9, 24, 11, 1, -24 },
  { 1477, 11, 31, 10, -2, -24 },
  { 1520, 17, 19, 19, 1, -23 },
  { 1561, 17, 12, 21, 2, -20 },
  { 1587, 17, 20, 19, 1, -23 },
  { 1630, 15, 31, 18, 3, -31 },
  { 1689, 29, 40, 32, 1, -30 },
  { 1834, 24, 31, 25, -2, -31 },
  { 1927, 21, 31, 23, 1, -31 },
  { 2009, 22, 31, 24, 2, -31 },
  { 2095, 22, 31, 24, 1, -31 },
  { 2181, 21, 31, 21, 1, -31 },
  { 2263, 21, 31, 20, 1, -31 },
  { 2345, 22, 31, 25, 2, -31 },
  { 2431, 25, 31, 26, 1, -31 },
  { 2528, 10, 31, 11, 1, -31 },
  { 2567, 21, 31, 20, 0, -31 },
  { 2649, 25, 31, 23, 1, -31 },
  { 2746, 16, 31, 20, 1, -31 },
  { 2808, 31, 31, 32, 1, -31 },
  { 2929, 25, 31, 26, 1, -31 },
  { 3026, 22, 31, 25, 2, -31 },
  { 3112, 23, 31, 23, 1, -31 },
  { 3202, 22, 36, 25, 2, -31 },
  { 3301, 22, 31, 23, 1, -31 },
  { 3387, 21, 31, 22, 1, -31 },
  { 3469, 21, 31, 22, 3, -31 },
  { 3551, 22, 31, 24, 2, -31 },
  { 3637, 23, 31, 24, 3, -31 },
  { 3727, 29, 31, 32, 4, -31 },
  { 3840, 26, 31, 23, -1, -31 },
  { 3941, 21, 31, 22, 4, -31 },
  { 4023, 23, 31, 22, 0, -31 },
  { 4113, 14, 42, 11, -1, -35 },
  { 4187, 9, 34, 16, 4, -31 },
  { 4226, 14, 42, 11, -2, -35 },
  { 4300, 13, 15, 16, 2, -31 },
  { 4325, 16, 4, 17, -2, 0 },
  { 4333, 9, 6, 13, 4, -32 },
  { 4340, 17, 23, 20, 1, -23 },
  { 4389, 19, 32, 21, 0, -32 },
  { 4465, 17, 23, 19, 1, -23 },
  { 4514, 21, 32, 21, 1, -32 },
  { 4598, 18, 23, 20, 1, -23 },
  { 4650, 14, 32, 13, 2, -32 },
  { 4706, 20, 32, 21, 0, -23 },
  { 4786, 18, 32, 20, 0, -32 },
  { 4858, 11, 32, 10, 0, -32 },
  { 4902, 14, 41, 10, -4, -32 },
  { 4974, 21, 32, 19, 0, -32 },
  { 5058, 11, 32, 10, 0, -32 },
  { 5102, 29, 23, 31, 0, -23 },
  { 5186, 18, 23, 20, 0, -23 },
  { 5238, 18, 23, 21, 1, -23 },
  { 5290, 20, 32, 21, -1, -23 },
  { 5370, 19, 32, 21, 1, -23 },
  { 5446, 14, 23, 13, 0, -23 },
  { 5487, 18, 23, 19, 0, -23 },
  { 5539, 11, 28, 13, 2, -28 },
  { 5578, 19, 23, 20, 1, -23 },
  { 5633, 17, 23, 18, 2, -23 },
  { 5682, 25, 23, 27, 3, -23 },
  { 5754, 20, 23, 19, -1, -23 },
  { 5812, 20, 32, 18, -1, -23 },
  { 5892, 18, 23, 19, 0, -23 },
  { 5944, 13, 42, 13, 1, -34 },
  { 6013, 9, 37, 10, 1, -31 },
  { 6055, 14, 42, 13, -2, -34 },
  { 6129, 20, 9, 24, 2, -17 },
};

const GFXfont RobotoCondensed_MediumItalic43pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic43pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic43pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC43PT7B_H_
