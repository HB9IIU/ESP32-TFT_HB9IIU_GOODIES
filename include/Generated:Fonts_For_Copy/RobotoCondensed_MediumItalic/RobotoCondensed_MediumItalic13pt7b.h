#ifndef _ROBOTOCONDENSED_MEDIUMITALIC13PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xB4, 0x86, 0xC0, 0xF6, 0x80, 0x0A, 0x28, 0x53, 0xF2, 0x9F,
  0x8A, 0x28, 0x50, 0x08, 0xE2, 0xD9, 0x20, 0xE0, 0xB2, 0x49, 0xC2, 0x00,
  0x62, 0x5A, 0x9C, 0x10, 0xF5, 0x75, 0x1C, 0x38, 0x58, 0xB1, 0xC3, 0x4A,
  0xB7, 0x64, 0x7C, 0xA8, 0x12, 0x44, 0x88, 0x88, 0x88, 0x88, 0x40, 0x21,
  0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x21, 0x3E, 0xCE, 0x48, 0x10, 0x41,
  0x1F, 0x30, 0xC2, 0x00, 0x6D, 0x60, 0x60, 0x70, 0x04, 0x20, 0x84, 0x10,
  0xC2, 0x18, 0x43, 0x00, 0x72, 0xF3, 0x19, 0xCE, 0x56, 0xE0, 0x17, 0xB3,
  0x22, 0x26, 0x60, 0x39, 0xB4, 0x43, 0x18, 0xC2, 0x10, 0xF8, 0x39, 0xB6,
  0xC3, 0x38, 0x2C, 0xB6, 0x70, 0x0C, 0x71, 0xCA, 0x69, 0x2F, 0xC6, 0x10,
  0x7A, 0x11, 0xED, 0x8E, 0x72, 0xE0, 0x33, 0x31, 0x6D, 0xCE, 0x72, 0xE0,
  0xFC, 0x21, 0x84, 0x30, 0x86, 0x30, 0xC0, 0x38, 0xB6, 0x4B, 0x39, 0x2C,
  0x96, 0x70, 0x76, 0xF7, 0x3D, 0xB8, 0x44, 0xC0, 0x2C, 0x00, 0xB0, 0x33,
  0x00, 0x00, 0x66, 0x4C, 0x09, 0xD9, 0xC3, 0x88, 0xF8, 0x3C, 0x43, 0x86,
  0x36, 0x40, 0x76, 0xC4, 0x66, 0x20, 0x08, 0xC0, 0x0F, 0x08, 0xC8, 0x29,
  0xD5, 0xAA, 0x96, 0x53, 0x2A, 0x9F, 0x20, 0x10, 0x07, 0x80, 0x08, 0x38,
  0x71, 0xE2, 0x4C, 0x9F, 0x62, 0x84, 0x3C, 0x4D, 0x9B, 0x27, 0x88, 0x91,
  0x66, 0xF8, 0x39, 0xBC, 0x60, 0x82, 0x08, 0xB6, 0x70, 0x3C, 0x49, 0x9B,
  0x34, 0x68, 0x91, 0x66, 0xF8, 0x3E, 0x41, 0x83, 0x07, 0x88, 0x10, 0x60,
  0xF8, 0x3E, 0x41, 0x83, 0x07, 0x88, 0x10, 0x60, 0xC0, 0x39, 0xBC, 0x60,
  0x82, 0x78, 0xF2, 0x78, 0x23, 0x23, 0x62, 0x62, 0x7E, 0x46, 0x46, 0xC6,
  0xC4, 0x25, 0xB6, 0x92, 0xC0, 0x04, 0x10, 0xC3, 0x08, 0x2C, 0xB6, 0x70,
  0x26, 0x26, 0x6C, 0x78, 0x70, 0x78, 0x48, 0xCC, 0xCC, 0x21, 0x18, 0xC4,
  0x21, 0x18, 0xF8, 0x31, 0xCC, 0x67, 0x19, 0xCA, 0x53, 0x95, 0x65, 0x53,
  0x64, 0xC9, 0x00, 0x23, 0x33, 0x72, 0x72, 0x5A, 0x4E, 0x4E, 0xCE, 0xC4,
  0x39, 0xBC, 0x61, 0x86, 0x38, 0xF6, 0x70, 0x3C, 0x4D, 0x8B, 0x34, 0x6F,
  0x90, 0x60, 0xC0, 0x39, 0xBC, 0x61, 0x86, 0x38, 0xF6, 0x70, 0x60, 0x80,
  0x3C, 0x4D, 0x9B, 0x34, 0xCF, 0x12, 0x66, 0xCC, 0x3C, 0x49, 0x9B, 0x03,
  0x81, 0xB3, 0x26, 0x78, 0xFC, 0xC3, 0x08, 0x20, 0x86, 0x18, 0x60, 0x22,
  0xC5, 0x9B, 0x34, 0x68, 0x91, 0x26, 0x78, 0xC7, 0x8B, 0x32, 0x45, 0x8A,
  0x1C, 0x30, 0x60, 0xC9, 0xEC, 0xF6, 0x5B, 0x6F, 0xB7, 0x53, 0xB9, 0x98,
  0xCC, 0x00, 0x66, 0x26, 0x3C, 0x38, 0x18, 0x38, 0x68, 0x4C, 0xCC, 0xC5,
  0x99, 0x62, 0x87, 0x04, 0x18, 0x30, 0x60, 0x7E, 0x0C, 0x30, 0xC1, 0x06,
  0x18, 0x60, 0xFC, 0x32, 0x66, 0x64, 0x44, 0x4C, 0xCC, 0xC0, 0xD9, 0x24,
  0x93, 0x6C, 0x30, 0x84, 0x23, 0x18, 0xC4, 0x21, 0x18, 0xCE, 0x00, 0x11,
  0x8C, 0xA5, 0x80, 0xF8, 0x4C, 0x3B, 0x42, 0xFC, 0xED, 0xE0, 0x21, 0x86,
  0x1E, 0x6D, 0x34, 0xF3, 0xCB, 0xE0, 0x39, 0xA4, 0xF0, 0xC1, 0x67, 0x00,
  0x04, 0x08, 0x11, 0xA6, 0xC9, 0xB2, 0x64, 0xD8, 0xD0, 0x39, 0xA4, 0xFE,
  0xC1, 0x27, 0x00, 0x19, 0x88, 0xE6, 0x31, 0x88, 0x42, 0x00, 0x35, 0xB4,
  0xF3, 0xCB, 0x67, 0x86, 0x9B, 0xC0, 0x21, 0x86, 0x1E, 0x6D, 0x34, 0xB2,
  0xCB, 0x60, 0x24, 0x36, 0x92, 0xD8, 0x11, 0x03, 0x32, 0x22, 0x66, 0x64,
  0xC0, 0x21, 0x86, 0x1B, 0x59, 0xC7, 0x34, 0xDB, 0x60, 0x25, 0xB6, 0x92,
  0xD8, 0x7B, 0x36, 0xD3, 0x69, 0x3C, 0x96, 0x4B, 0x64, 0x79, 0xB4, 0xD2,
  0xCB, 0x2D, 0x80, 0x39, 0xB4, 0xF3, 0xCD, 0x27, 0x00, 0x79, 0xB4, 0xD3,
  0x4F, 0x2F, 0x20, 0x82, 0x00, 0x35, 0xB4, 0xF2, 0xCB, 0x66, 0x86, 0x18,
  0x40, 0x77, 0x44, 0xCC, 0xC0, 0x3A, 0x50, 0x61, 0xED, 0xC0, 0x22, 0x76,
  0x64, 0x44, 0x60, 0x6D, 0x34, 0xD2, 0xCB, 0x67, 0x80, 0x9C, 0xAD, 0x4A,
  0x63, 0x00, 0x93, 0x6E, 0xD5, 0xAD, 0xDB, 0x36, 0x00, 0x4D, 0xE3, 0x0C,
  0x71, 0x4D, 0x80, 0x4D, 0x25, 0x94, 0x71, 0x86, 0x18, 0x42, 0x00, 0x7C,
  0x61, 0x0C, 0x63, 0x0F, 0x80, 0x13, 0x22, 0x26, 0xC4, 0x44, 0x42, 0x24,
  0xA4, 0x92, 0x52, 0x00, 0x20, 0x84, 0x23, 0x08, 0x44, 0x21, 0x18, 0x80,
  0xE6, 0xA9, 0x80,
};

const GFXglyph RobotoCondensed_MediumItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -10 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 11, 6, 0, -10 },
  { 24, 6, 9, 8, 1, -9 },
  { 31, 7, 9, 7, 0, -9 },
  { 39, 2, 3, 2, 1, -10 },
  { 40, 4, 13, 4, 1, -10 },
  { 47, 4, 13, 4, -1, -10 },
  { 54, 5, 6, 6, 1, -9 },
  { 58, 6, 7, 6, 0, -8 },
  { 64, 3, 4, 3, -1, -1 },
  { 66, 3, 1, 4, 0, -4 },
  { 67, 2, 2, 4, 0, -2 },
  { 68, 6, 10, 4, -1, -9 },
  { 76, 5, 9, 6, 1, -9 },
  { 82, 4, 9, 6, 1, -9 },
  { 87, 6, 9, 6, 0, -9 },
  { 94, 6, 9, 6, 0, -9 },
  { 101, 6, 9, 6, 0, -9 },
  { 108, 5, 9, 6, 1, -9 },
  { 114, 5, 9, 6, 1, -9 },
  { 120, 6, 9, 6, 1, -9 },
  { 127, 6, 9, 6, 0, -9 },
  { 134, 5, 9, 6, 1, -9 },
  { 140, 3, 7, 3, 0, -7 },
  { 143, 4, 10, 3, -1, -7 },
  { 148, 5, 6, 6, 0, -7 },
  { 152, 5, 3, 6, 1, -6 },
  { 154, 5, 6, 6, 0, -7 },
  { 158, 5, 9, 6, 1, -9 },
  { 164, 9, 12, 10, 0, -9 },
  { 178, 7, 9, 7, 0, -9 },
  { 186, 7, 9, 7, 0, -9 },
  { 194, 6, 9, 7, 1, -9 },
  { 201, 7, 9, 7, 0, -9 },
  { 209, 7, 9, 6, 0, -9 },
  { 217, 7, 9, 6, 0, -9 },
  { 225, 6, 9, 7, 1, -9 },
  { 232, 8, 9, 8, 0, -9 },
  { 241, 3, 9, 3, 0, -9 },
  { 245, 6, 9, 6, 0, -9 },
  { 252, 8, 9, 7, 0, -9 },
  { 261, 5, 9, 6, 0, -9 },
  { 267, 10, 9, 10, 0, -9 },
  { 279, 8, 9, 8, 0, -9 },
  { 288, 6, 9, 8, 1, -9 },
  { 295, 7, 9, 7, 0, -9 },
  { 303, 6, 11, 8, 1, -9 },
  { 312, 7, 9, 7, 0, -9 },
  { 320, 7, 9, 7, 0, -9 },
  { 328, 6, 9, 7, 1, -9 },
  { 335, 7, 9, 7, 0, -9 },
  { 343, 7, 9, 7, 1, -9 },
  { 351, 9, 9, 10, 1, -9 },
  { 362, 8, 9, 7, 0, -9 },
  { 371, 7, 9, 7, 1, -9 },
  { 379, 7, 9, 7, 0, -9 },
  { 387, 4, 13, 3, 0, -11 },
  { 394, 3, 10, 5, 1, -9 },
  { 398, 5, 13, 3, -1, -11 },
  { 407, 5, 5, 5, 0, -9 },
  { 411, 5, 1, 5, -1, 0 },
  { 412, 3, 2, 4, 1, -10 },
  { 413, 5, 7, 6, 0, -7 },
  { 418, 6, 10, 6, 0, -10 },
  { 426, 6, 7, 6, 0, -7 },
  { 432, 7, 10, 6, 0, -10 },
  { 441, 6, 7, 6, 0, -7 },
  { 447, 5, 10, 4, 0, -10 },
  { 454, 6, 10, 6, 0, -7 },
  { 462, 6, 10, 6, 0, -10 },
  { 470, 3, 10, 3, 0, -10 },
  { 474, 4, 13, 3, -1, -10 },
  { 481, 6, 10, 6, 0, -10 },
  { 489, 3, 10, 3, 0, -10 },
  { 493, 9, 7, 9, 0, -7 },
  { 501, 6, 7, 6, 0, -7 },
  { 507, 6, 7, 6, 0, -7 },
  { 513, 6, 10, 6, 0, -7 },
  { 521, 6, 10, 6, 0, -7 },
  { 529, 4, 7, 4, 0, -7 },
  { 533, 5, 7, 6, 0, -7 },
  { 538, 4, 9, 4, 0, -9 },
  { 543, 6, 7, 6, 0, -7 },
  { 549, 5, 7, 6, 1, -7 },
  { 554, 7, 7, 8, 1, -7 },
  { 561, 6, 7, 6, 0, -7 },
  { 567, 6, 10, 5, 0, -7 },
  { 575, 6, 7, 6, 0, -7 },
  { 581, 4, 12, 4, 0, -10 },
  { 587, 3, 11, 3, 0, -9 },
  { 592, 5, 12, 4, -1, -10 },
  { 600, 6, 3, 7, 1, -5 },
};

const GFXfont RobotoCondensed_MediumItalic13pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic13pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic13pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC13PT7B_H_
