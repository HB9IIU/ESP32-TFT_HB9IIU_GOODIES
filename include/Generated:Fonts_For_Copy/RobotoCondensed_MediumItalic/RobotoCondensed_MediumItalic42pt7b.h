#ifndef _ROBOTOCONDENSED_MEDIUMITALIC42PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xE0,
  0xF8, 0x1C, 0x00, 0x38, 0xE7, 0x1C, 0xE3, 0xBC, 0xF7, 0x9E, 0xE3, 0x9C,
  0x73, 0x8E, 0x71, 0xDC, 0x73, 0x8E, 0x00, 0x00, 0x1C, 0x78, 0x01, 0xE3,
  0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01,
  0xC7, 0x80, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x71,
  0xE0, 0x03, 0x8E, 0x00, 0x3C, 0x70, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x07, 0x1E, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x78,
  0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x3C,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xC7, 0xC1,
  0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC3,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xF1, 0xE0, 0x3E, 0x3C, 0x07, 0x87, 0xC1, 0xF0, 0xFC,
  0x7E, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x1D, 0xC3, 0xC3, 0xB8,
  0x78, 0xE7, 0x0E, 0x3C, 0xE1, 0xCF, 0x1C, 0x39, 0xC3, 0xCF, 0x70, 0x3F,
  0xDE, 0x07, 0xF3, 0x80, 0x7C, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xCF, 0x80, 0x7B, 0xF8, 0x1E, 0xFF, 0x83, 0xBC, 0xF0, 0xE7, 0x0E, 0x3C,
  0xE1, 0xC7, 0x1C, 0x39, 0xC3, 0x87, 0x78, 0xF0, 0xFE, 0x0E, 0x3D, 0x81,
  0xC7, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xC7, 0x80, 0x78, 0x78,
  0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x87, 0x80, 0xF8, 0xF0, 0x07, 0x9F,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFF,
  0x0F, 0x1F, 0xF0, 0xF3, 0xEF, 0x8F, 0x7C, 0xF9, 0xE7, 0xC7, 0xDE, 0xF8,
  0x7F, 0xEF, 0x83, 0xFC, 0xF8, 0x3F, 0xCF, 0x81, 0xF8, 0xF8, 0x1F, 0x8F,
  0xC3, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xF3, 0xE0, 0xFC, 0x3E,
  0x3B, 0xDE, 0xF7, 0xB9, 0xDE, 0xF7, 0x38, 0x00, 0x10, 0x01, 0x80, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0C, 0x00, 0x20, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x10, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x03, 0x07, 0x0D, 0xF3, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xFE, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xF3, 0x80, 0xF1, 0xE0, 0xF0, 0x70,
  0x38, 0x38, 0x08, 0x08, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E,
  0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xF0, 0x60, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF,
  0x31, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0xF8, 0xF8, 0x3C, 0xF8, 0x1E, 0x7C,
  0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB,
  0xC0, 0x7D, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x03,
  0xDF, 0x03, 0xEF, 0x01, 0xF7, 0x80, 0xFB, 0xC0, 0x79, 0xF0, 0x7C, 0xF8,
  0x3C, 0x3C, 0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x00, 0x20, 0x1E, 0x07, 0xE3, 0xFE, 0xFF, 0xEF, 0xFE, 0xFB, 0xCC, 0x3C,
  0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xC3, 0xE0, 0xF8, 0x3E,
  0x0F, 0x81, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7,
  0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F, 0x1F, 0x87, 0xFF,
  0xE1, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1E, 0xF8, 0x07, 0x9E, 0x01, 0xF3,
  0xC0, 0x3C, 0xF8, 0x0F, 0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x7C, 0x1E, 0x0F,
  0x07, 0xC1, 0xE0, 0xF0, 0x7C, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFB, 0xE0, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF1, 0xE0, 0x3E,
  0x3C, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x3E, 0x1F, 0x8F, 0xC1, 0xFF, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7E, 0x3F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x7E,
  0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83, 0xC0,
  0xF0, 0xF8, 0x1E, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83,
  0xE0, 0xF8, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFE,
  0x07, 0xC3, 0xE1, 0xF0, 0x3C, 0x3E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x1E,
  0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0x78, 0x1F, 0x0F, 0x87, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFE, 0x3E, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0x7C, 0x7E, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x06, 0x07, 0x87, 0xC3,
  0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x1E, 0x1F, 0x0F, 0xC7, 0xC1, 0xC0, 0x00, 0x80,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C,
  0x0F, 0x00, 0x40, 0x00, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x7E, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x78, 0x00, 0x18, 0x00, 0x08, 0x3F, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0xCF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0,
  0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x70, 0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xFF,
  0xE7, 0xE7, 0xEF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70,
  0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x78,
  0x1F, 0x03, 0x87, 0x81, 0xFE, 0x0C, 0x38, 0x3F, 0xF8, 0x73, 0xC1, 0xE3,
  0xC3, 0x9C, 0x1E, 0x1C, 0x1C, 0xE1, 0xE0, 0xE0, 0xEF, 0x0F, 0x0F, 0x07,
  0x70, 0x70, 0x78, 0x73, 0x87, 0x83, 0x83, 0x9C, 0x3C, 0x1C, 0x1D, 0xE1,
  0xE1, 0xE0, 0xEF, 0x0E, 0x0F, 0x07, 0x70, 0xF0, 0x70, 0x73, 0x87, 0x83,
  0x83, 0x9C, 0x3C, 0x3C, 0x1C, 0xE1, 0xE3, 0xE1, 0xC7, 0x07, 0xBF, 0x1E,
  0x38, 0x3F, 0xBF, 0xE1, 0xC1, 0xFD, 0xFE, 0x0F, 0x07, 0x83, 0xC0, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x04, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x7D,
  0xE0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x0F,
  0x00, 0x3E, 0x1E, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x07, 0xC0, 0xF0,
  0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xC0, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0xF8,
  0x00, 0xF9, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0x07,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x3F,
  0x07, 0xC0, 0xFC, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF8, 0x7C, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x7C, 0x0F, 0xC3,
  0xF0, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xF8, 0x7F, 0x07, 0xC0, 0xF8, 0x3C, 0x03, 0xC3, 0xE0, 0x1F, 0x1F, 0x00,
  0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xE0, 0x0F, 0x9F,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F,
  0x8F, 0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xC7, 0xC1, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0xFC, 0x7C, 0x03,
  0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x7F, 0xCF, 0x07, 0xFE,
  0xF8, 0x3F, 0xF7, 0xC1, 0xFF, 0xBE, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x07, 0xE3,
  0xF0, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x3E, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0x07, 0xC1, 0xF0, 0x78, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x3F, 0x07,
  0xE7, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFE, 0x00,
  0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0xFC, 0x0F, 0x81, 0xF8,
  0x0F, 0x83, 0xF0, 0x0F, 0x83, 0xF0, 0x0F, 0x07, 0xE0, 0x1F, 0x0F, 0xC0,
  0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00,
  0x1E, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x3F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xE1, 0xEF, 0x01, 0xEF, 0x07,
  0xBC, 0x07, 0xBC, 0x1E, 0xF0, 0x3D, 0xF0, 0xFB, 0xC0, 0xF7, 0xC3, 0xE7,
  0x87, 0x9F, 0x0F, 0x9E, 0x1E, 0x78, 0x3E, 0x78, 0xF1, 0xE0, 0xF1, 0xE3,
  0xCF, 0x83, 0xC7, 0x9F, 0x3E, 0x1F, 0x1E, 0x78, 0xF8, 0x7C, 0x79, 0xE3,
  0xE1, 0xF0, 0xEF, 0x0F, 0x07, 0xC3, 0xBC, 0x7C, 0x1F, 0x0F, 0xE1, 0xF0,
  0xF8, 0x3F, 0x87, 0xC3, 0xE0, 0xFC, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x3E,
  0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x70, 0x3E, 0x00, 0x07,
  0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x0F, 0xE0, 0x1F, 0x0F,
  0xE0, 0x1F, 0x0F, 0xE0, 0x1E, 0x0F, 0xE0, 0x3E, 0x1F, 0xF0, 0x3E, 0x1F,
  0xF0, 0x3E, 0x1F, 0xF0, 0x3E, 0x1F, 0x78, 0x3E, 0x1F, 0x78, 0x3C, 0x1E,
  0x78, 0x7C, 0x3E, 0x38, 0x7C, 0x3E, 0x3C, 0x7C, 0x3E, 0x3C, 0x7C, 0x3E,
  0x1C, 0x7C, 0x3E, 0x1E, 0x78, 0x3C, 0x1E, 0xF8, 0x7C, 0x1E, 0xF8, 0x7C,
  0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x07, 0xF0, 0xF8,
  0x07, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x03, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE7, 0xC0, 0x07, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9E, 0x00,
  0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x7C,
  0x07, 0xC1, 0xF8, 0x7E, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0x81, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC7,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x3E, 0x1E, 0x00, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x3F, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0xFE, 0x3F, 0x0F, 0xC0, 0xFC, 0x7C, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0,
  0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x80, 0x07,
  0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF8, 0x3F,
  0x07, 0xC0, 0x7C, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xE0, 0x3F, 0x1F, 0x03, 0xF0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0x07,
  0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F,
  0x81, 0xF0, 0x78, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x3F, 0x07, 0xC0, 0xF8, 0x7C, 0x03,
  0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0xF8, 0xF8, 0x03,
  0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF8, 0x07, 0xC3,
  0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0,
  0x1E, 0x1F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E,
  0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xF0, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7D, 0xF0, 0x03,
  0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x87, 0xC0, 0x1E, 0x3E, 0x00, 0x78, 0xF8, 0x01, 0xE7, 0xC0, 0x07,
  0x9F, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0xF7, 0xC0, 0x78,
  0x0F, 0xBE, 0x07, 0xC0, 0x7D, 0xF0, 0x3E, 0x03, 0xCF, 0x81, 0xF0, 0x3E,
  0x7C, 0x1F, 0x81, 0xF3, 0xE0, 0xFC, 0x0F, 0x1F, 0x07, 0xF0, 0xF8, 0xF8,
  0x7F, 0x87, 0xC7, 0xC3, 0xFC, 0x3C, 0x3E, 0x3D, 0xE3, 0xE1, 0xF1, 0xEF,
  0x1F, 0x0F, 0x8F, 0x78, 0xF0, 0x7C, 0xF3, 0xCF, 0x83, 0xE7, 0x9E, 0x7C,
  0x1F, 0x3C, 0xF3, 0xC0, 0xFB, 0xC7, 0x9E, 0x07, 0xDE, 0x3D, 0xF0, 0x3E,
  0xF1, 0xEF, 0x01, 0xFF, 0x0F, 0x78, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x83,
  0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x0F,
  0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF0, 0x00,
  0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x83,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x07, 0xE0,
  0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xEF, 0x80, 0x7C, 0x7C, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xC1,
  0xF0, 0x3C, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x1E,
  0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xF0,
  0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1F, 0x0F, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xC0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x83, 0xDE, 0x1E, 0xF1, 0xE7,
  0x8F, 0x1C, 0xF0, 0xE7, 0x87, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x7C, 0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x01,
  0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1, 0xF1, 0xF0, 0x78,
  0xF8, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x01, 0xFF, 0x87, 0xFF, 0xC7, 0xFF,
  0xE7, 0xE1, 0xE7, 0xE0, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x3F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFB, 0xE0, 0xF9, 0xF0, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0xF8,
  0x07, 0xBF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xE1, 0xF0, 0xF8, 0x1E,
  0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C,
  0x7C, 0x07, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF1,
  0xF0, 0x3E, 0x3F, 0x0F, 0xC7, 0xFF, 0xF0, 0xF7, 0xFE, 0x3E, 0xFF, 0x07,
  0xC7, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1,
  0xF1, 0xF0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7D, 0xF0, 0x3C,
  0xF8, 0x3E, 0x3E, 0x3F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x03, 0xE3, 0xC0, 0xFF, 0x7C, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x3F, 0x1F, 0xC3, 0xE0, 0xFC, 0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x78, 0x0F,
  0x87, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x0F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x07, 0xC7, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xDE, 0x01, 0xF9, 0xE0, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF0, 0x1E,
  0xF8, 0x0F, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x0C, 0x3E, 0x0E, 0x1F,
  0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xF0,
  0x3F, 0xC1, 0xFF, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x07, 0xFF, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x81, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x7F, 0xDF, 0x0F, 0xFD, 0xE0,
  0xFF, 0xFE, 0x1F, 0x87, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3C,
  0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0xC7, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x83, 0xE1,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xEF, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x02, 0x03, 0xE0, 0x70, 0x7E, 0x0F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF3, 0xE0, 0x3D,
  0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1E, 0x07,
  0xC7, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0x8F, 0x81, 0xE3,
  0xC0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0xF1, 0xF0,
  0x3C, 0x78, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0x03, 0xC1,
  0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0xF8,
  0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x00,
  0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x83,
  0xF0, 0xF0, 0x7E, 0x1F, 0x0F, 0xC1, 0xF1, 0xF8, 0x1F, 0x3F, 0x01, 0xF3,
  0xE0, 0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xF7, 0x80, 0x7E, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0x78, 0x3E, 0x07, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0x0F, 0x3E, 0x07, 0xC0, 0x7B, 0xFC, 0xFF, 0x03, 0xFF, 0xEF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE1, 0xF8, 0xFF, 0x1F, 0x0F, 0x83, 0xF0, 0x78, 0x7C,
  0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x1E, 0x1E, 0x07, 0xC0, 0xF1, 0xF0, 0x3E,
  0x0F, 0x8F, 0x81, 0xE0, 0x7C, 0x7C, 0x0F, 0x03, 0xE3, 0xE0, 0xF8, 0x1F,
  0x1E, 0x07, 0xC0, 0xF0, 0xF0, 0x3E, 0x07, 0x8F, 0x81, 0xF0, 0x7C, 0x7C,
  0x0F, 0x03, 0xE3, 0xE0, 0x78, 0x1F, 0x1E, 0x07, 0xC0, 0xF8, 0xF0, 0x3E,
  0x07, 0x8F, 0x81, 0xF0, 0x3C, 0x7C, 0x0F, 0x83, 0xE0, 0x0F, 0x3E, 0x03,
  0xDF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x8F, 0xC7, 0xC1, 0xF1, 0xF0,
  0x7C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x1E,
  0x3C, 0x0F, 0x8F, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x1F,
  0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xC0, 0x01,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0x0F, 0x8F, 0x83,
  0xE7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0x78,
  0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8,
  0x00, 0x07, 0x9F, 0x00, 0x7B, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xC3, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xE0, 0x3E,
  0x1E, 0x03, 0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3D, 0xFE, 0x07, 0xC7, 0xC0, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE3, 0xC1, 0xFF, 0x78,
  0x7F, 0xEF, 0x0F, 0xFF, 0xE3, 0xF0, 0xFC, 0x7C, 0x1F, 0x9F, 0x01, 0xE3,
  0xE0, 0x3C, 0x78, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F,
  0x87, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x3C, 0x3D,
  0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF1, 0xF0, 0xF8, 0xF0,
  0x3C, 0x78, 0x1E, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0xF0, 0x3E, 0x78, 0x1F,
  0x3E, 0x1F, 0x1F, 0xFF, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x3F, 0xFF, 0xFE, 0xFF, 0xDF,
  0xF8, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFE, 0x0F, 0xC1, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x81, 0xE3, 0xC0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0x7C, 0xF8, 0x3E, 0x1F, 0x1F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xCF, 0x80, 0xF8, 0x0F, 0xFC, 0x0F, 0x9E, 0x07, 0xCF, 0x07,
  0xC7, 0x83, 0xE3, 0xC1, 0xE1, 0xE1, 0xF0, 0xF8, 0xF0, 0x7C, 0x78, 0x3E,
  0x7C, 0x0F, 0x3C, 0x07, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x38, 0x1F, 0xF0, 0x7C, 0x1E, 0xF0, 0x7C, 0x3E,
  0xF0, 0xFC, 0x3E, 0xF0, 0xFC, 0x3C, 0xF0, 0xFC, 0x7C, 0xF1, 0xFC, 0x78,
  0xF1, 0xFC, 0x78, 0xF3, 0xFC, 0xF8, 0xF3, 0xDC, 0xF0, 0xF7, 0x9C, 0xF0,
  0xF7, 0x9D, 0xF0, 0xF7, 0x1D, 0xE0, 0xFF, 0x1D, 0xE0, 0xFF, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80,
  0xF8, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x83, 0xF0,
  0xF8, 0x3E, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x07, 0xCF, 0x80, 0x3D, 0xF0,
  0x03, 0xDF, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFB,
  0xC0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E, 0x1E, 0x07, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x0F, 0x03, 0xE0,
  0xF0, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0x7B, 0xE0, 0x07, 0xBC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x80,
  0x00, 0x18, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x38, 0x00, 0x40, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78,
  0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x00, 0x01, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0xFC, 0x0F, 0x80,
  0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x0E, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x0E, 0x3F, 0xC0,
  0xE7, 0xFE, 0x1E, 0x79, 0xF3, 0xEF, 0x0F, 0xFC, 0xF0, 0x7F, 0xCE, 0x03,
  0xF8, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 30, 10, 1, -30 },
  { 39, 11, 11, 13, 3, -32 },
  { 55, 21, 30, 22, 1, -30 },
  { 134, 19, 38, 20, 1, -34 },
  { 225, 19, 30, 26, 4, -30 },
  { 297, 20, 30, 23, 1, -30 },
  { 372, 5, 11, 7, 3, -32 },
  { 379, 13, 42, 13, 2, -33 },
  { 448, 13, 43, 13, -2, -33 },
  { 518, 17, 18, 18, 2, -30 },
  { 557, 18, 22, 20, 1, -25 },
  { 607, 8, 12, 9, -2, -5 },
  { 619, 10, 4, 13, 1, -15 },
  { 624, 6, 6, 11, 1, -6 },
  { 629, 18, 33, 14, -2, -30 },
  { 704, 17, 30, 20, 2, -30 },
  { 768, 12, 30, 20, 5, -30 },
  { 813, 20, 30, 20, 0, -30 },
  { 888, 18, 30, 20, 1, -30 },
  { 956, 19, 30, 20, 0, -30 },
  { 1028, 19, 30, 20, 2, -30 },
  { 1100, 16, 30, 20, 2, -30 },
  { 1160, 19, 30, 20, 2, -30 },
  { 1232, 19, 30, 20, 1, -30 },
  { 1304, 16, 30, 20, 3, -30 },
  { 1364, 9, 23, 11, 1, -23 },
  { 1390, 11, 30, 10, -2, -23 },
  { 1432, 16, 20, 18, 1, -23 },
  { 1472, 17, 13, 20, 2, -20 },
  { 1500, 17, 19, 19, 1, -22 },
  { 1541, 15, 30, 18, 3, -30 },
  { 1598, 29, 38, 31, 1, -29 },
  { 1736, 23, 30, 24, -2, -30 },
  { 1823, 21, 30, 23, 1, -30 },
  { 1902, 21, 30, 23, 2, -30 },
  { 1981, 21, 30, 23, 1, -30 },
  { 2060, 21, 30, 20, 1, -30 },
  { 2139, 20, 30, 19, 1, -30 },
  { 2214, 21, 30, 24, 2, -30 },
  { 2293, 24, 30, 25, 1, -30 },
  { 2383, 10, 30, 11, 1, -30 },
  { 2421, 20, 30, 20, 0, -30 },
  { 2496, 24, 30, 22, 1, -30 },
  { 2586, 16, 30, 19, 1, -30 },
  { 2646, 30, 30, 31, 1, -30 },
  { 2759, 24, 30, 25, 1, -30 },
  { 2849, 22, 30, 25, 2, -30 },
  { 2932, 22, 30, 23, 1, -30 },
  { 3015, 21, 35, 25, 2, -30 },
  { 3107, 21, 30, 22, 1, -30 },
  { 3186, 21, 30, 22, 1, -30 },
  { 3265, 21, 30, 22, 3, -30 },
  { 3344, 22, 30, 23, 2, -30 },
  { 3427, 22, 30, 23, 3, -30 },
  { 3510, 29, 30, 31, 4, -30 },
  { 3619, 25, 30, 23, -1, -30 },
  { 3713, 20, 30, 22, 4, -30 },
  { 3788, 23, 30, 21, 0, -30 },
  { 3875, 14, 41, 11, -1, -34 },
  { 3947, 9, 33, 15, 4, -30 },
  { 3985, 13, 41, 11, -2, -34 },
  { 4052, 13, 15, 16, 2, -30 },
  { 4077, 16, 4, 16, -2, 0 },
  { 4085, 8, 6, 13, 4, -31 },
  { 4091, 17, 22, 19, 1, -22 },
  { 4138, 19, 32, 20, 0, -32 },
  { 4214, 17, 22, 19, 1, -22 },
  { 4261, 20, 32, 20, 1, -32 },
  { 4341, 17, 22, 19, 1, -22 },
  { 4388, 14, 32, 13, 2, -32 },
  { 4444, 20, 31, 20, 0, -22 },
  { 4522, 18, 32, 20, 0, -32 },
  { 4594, 10, 30, 10, 0, -30 },
  { 4632, 14, 39, 10, -4, -30 },
  { 4701, 20, 32, 19, 0, -32 },
  { 4781, 11, 32, 10, 0, -32 },
  { 4825, 29, 22, 30, 0, -22 },
  { 4905, 18, 22, 20, 0, -22 },
  { 4955, 18, 22, 20, 1, -22 },
  { 5005, 20, 31, 20, -1, -22 },
  { 5083, 19, 31, 20, 1, -22 },
  { 5157, 14, 22, 13, 0, -22 },
  { 5196, 17, 22, 19, 0, -22 },
  { 5243, 11, 28, 12, 2, -28 },
  { 5282, 18, 22, 20, 1, -22 },
  { 5332, 17, 22, 18, 2, -22 },
  { 5379, 24, 22, 26, 3, -22 },
  { 5445, 20, 22, 18, -1, -22 },
  { 5500, 20, 31, 18, -1, -22 },
  { 5578, 18, 22, 18, 0, -22 },
  { 5628, 13, 40, 12, 1, -33 },
  { 5693, 9, 36, 10, 1, -30 },
  { 5734, 13, 41, 12, -2, -33 },
  { 5801, 20, 9, 23, 2, -17 },
};

const GFXfont RobotoCondensed_MediumItalic42pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic42pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic42pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC42PT7B_H_
