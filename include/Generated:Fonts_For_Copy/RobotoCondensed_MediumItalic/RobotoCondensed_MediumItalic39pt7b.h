#ifndef _ROBOTOCONDENSED_MEDIUMITALIC39PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0xF8, 0x7C, 0x3C, 0x0E, 0x00, 0x79, 0xDE, 0x77,
  0x1D, 0xC7, 0x73, 0xDC, 0xE7, 0x3B, 0x8E, 0xE3, 0xB8, 0xC0, 0x00, 0x38,
  0xE0, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE0, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x07, 0x1C, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F,
  0xFE, 0x0F, 0x8F, 0x87, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x79, 0xF0, 0x3C, 0xF8,
  0x1E, 0x7C, 0x0F, 0x1E, 0x0F, 0x8F, 0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC0, 0x1F, 0x80, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3C, 0xE0, 0x87, 0x0C,
  0x1C, 0xE1, 0xC7, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0x71, 0xCE, 0x0E, 0x3B,
  0x81, 0xFE, 0xF0, 0x1F, 0xDC, 0x01, 0xE7, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x78, 0x03, 0x9F, 0x80, 0x77, 0xF8, 0x1D, 0xE7, 0x07, 0x38,
  0x71, 0xE7, 0x0E, 0x38, 0xE1, 0x8E, 0x1C, 0x73, 0xC3, 0x8E, 0x30, 0x71,
  0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC3,
  0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x71, 0xFF, 0x0E, 0x7D, 0xF3,
  0xCF, 0x9E, 0x7B, 0xE3, 0xEF, 0x7C, 0x3F, 0xCF, 0x07, 0xF9, 0xE0, 0x7E,
  0x3E, 0x0F, 0xC7, 0xC1, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xBE,
  0x07, 0xE3, 0xE0, 0x7B, 0xDC, 0xE7, 0x7B, 0x9C, 0xE7, 0x00, 0x00, 0x20,
  0x06, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x02, 0x00,
  0x30, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0x60, 0x04, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x71, 0xC7, 0x7D, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x1E, 0xE0,
  0x3C, 0xF0, 0x78, 0x70, 0x30, 0x70, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x3C, 0xF9, 0xE1,
  0x80, 0x7F, 0xBF, 0xDF, 0xFF, 0xF0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x1F,
  0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78,
  0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x60,
  0x3C, 0x1F, 0x9F, 0xF7, 0xFE, 0xFF, 0x9C, 0xF6, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0x87,
  0xC3, 0xC1, 0xF1, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF3, 0xFF, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0xF3, 0xC0, 0xF9, 0xF0, 0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7B, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x9F, 0x03, 0xC7, 0xC0,
  0xF1, 0xE0, 0x78, 0x78, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x7C, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE0, 0xF0, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xF0, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x7B, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0x87, 0xFE, 0x0F, 0xFC,
  0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xBE, 0x1F, 0x3C, 0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0x7C, 0x00,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE0,
  0xF8, 0xF8, 0xF8, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x07,
  0xC7, 0xC7, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xF0, 0x7C,
  0x78, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE7,
  0xC0, 0xF3, 0xE0, 0xF8, 0xF0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x07, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xC3,
  0xCF, 0x07, 0x9E, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xDE, 0x07, 0xBE, 0x1F, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF0, 0x7D, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x7F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1E, 0x1F, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0xF8, 0xF8, 0xF8, 0x70, 0x03, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x10, 0x00, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x3F, 0x80, 0xFC,
  0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFE,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x20, 0x3F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0xFF, 0xC0, 0x10, 0x00, 0x38, 0x00, 0x78, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0xFC,
  0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0x7C, 0x00, 0xE0,
  0x01, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x78, 0x7B,
  0xE1, 0xFF, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x01, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x07, 0xC1, 0xC3, 0xC3,
  0xFC, 0x18, 0x70, 0xFF, 0xC3, 0x1E, 0x1E, 0x38, 0x63, 0x87, 0x87, 0x0E,
  0x70, 0xE1, 0xC1, 0x9C, 0x3C, 0x38, 0x33, 0x87, 0x07, 0x06, 0x71, 0xE0,
  0xE1, 0xDE, 0x3C, 0x3C, 0x3B, 0x87, 0x87, 0x07, 0x70, 0xE0, 0xE0, 0xEE,
  0x1C, 0x1C, 0x39, 0xC3, 0x87, 0x87, 0x38, 0x70, 0xF0, 0xC7, 0x0F, 0x3E,
  0x38, 0xE1, 0xFD, 0xFE, 0x1C, 0x1F, 0xBF, 0x83, 0x81, 0xC3, 0xE0, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x03, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0xF0, 0x03,
  0xE7, 0x80, 0x1E, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF3,
  0xE0, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0x78, 0xF8, 0x1F, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x1F, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xE0, 0x7C, 0x7C, 0x07,
  0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F,
  0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xF8, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01,
  0xEF, 0x80, 0x3D, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x03, 0xCF, 0x00, 0x79, 0xF0, 0x1F, 0x3E, 0x03, 0xE3, 0xE0, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x07, 0xC1, 0xF0,
  0x3E, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E,
  0x01, 0xE3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE3,
  0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x7C,
  0x78, 0x07, 0x87, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x83, 0xE1, 0xF0,
  0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x83, 0xFE, 0xF8, 0x3F, 0xCF,
  0x87, 0xFC, 0xF8, 0x7F, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C,
  0xF0, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x87, 0xC1, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0,
  0x0F, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78,
  0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C,
  0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE3, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x3E,
  0x07, 0xE0, 0xF0, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x07, 0xE0, 0x7C, 0x3F,
  0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0x79, 0xF0, 0x01,
  0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0x78, 0x01, 0xF9, 0xF0, 0x07, 0xC7, 0xC0,
  0x1E, 0x0F, 0x80, 0x78, 0x3E, 0x01, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x03,
  0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x1E, 0xE0, 0x7B, 0xC3, 0xEE, 0x07, 0xBC,
  0x3C, 0xE0, 0xF3, 0xC3, 0xCF, 0x0F, 0x7C, 0x3C, 0xF0, 0xE7, 0x83, 0xCF,
  0x1E, 0x78, 0x7C, 0xF1, 0xC7, 0x87, 0xCF, 0x3C, 0xF8, 0x7C, 0x73, 0x8F,
  0x87, 0x87, 0x78, 0xF8, 0x78, 0x77, 0x8F, 0x07, 0x87, 0xF0, 0xF0, 0xF8,
  0x7F, 0x0F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x7E, 0x1F, 0x0F, 0x07, 0xC1,
  0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x78, 0x3E, 0x00, 0xF0, 0x7E, 0x01, 0xE0, 0xFC, 0x07, 0xC3, 0xF8,
  0x0F, 0x87, 0xF8, 0x1F, 0x0F, 0xF0, 0x3C, 0x1E, 0xE0, 0x78, 0x3D, 0xE1,
  0xF0, 0x7B, 0xC3, 0xE1, 0xF3, 0x87, 0xC3, 0xE7, 0x0F, 0x07, 0xCF, 0x1E,
  0x0F, 0x1E, 0x3C, 0x1E, 0x1C, 0xF8, 0x7C, 0x3D, 0xF0, 0xF8, 0x7B, 0xE1,
  0xF0, 0x77, 0x83, 0xE0, 0xEF, 0x07, 0x81, 0xFE, 0x0F, 0x03, 0xFC, 0x3E,
  0x03, 0xF8, 0x7C, 0x07, 0xF0, 0xF8, 0x0F, 0xC1, 0xE0, 0x0F, 0x83, 0xC0,
  0x1F, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFC, 0x1F, 0x83, 0xE1, 0xF0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0,
  0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78,
  0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x80, 0x78,
  0xF8, 0x0F, 0x87, 0xC1, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xE3,
  0xE0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F,
  0x87, 0xE1, 0xF0, 0x3E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xF7,
  0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x1E,
  0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03,
  0xCF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x0F, 0x87, 0xC1,
  0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x03,
  0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1E, 0x01, 0xE1, 0xE0,
  0x1E, 0x1E, 0x03, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xC3, 0xC0, 0x7C, 0x3E, 0x07,
  0xC3, 0xE0, 0x78, 0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xF8, 0x3E, 0x3E, 0x07,
  0xC7, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x78, 0x07, 0xCF, 0x00, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xC3, 0xE0, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0,
  0x0F, 0x0F, 0x80, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x1E, 0x1E,
  0x00, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xF0, 0x3E,
  0x0F, 0x83, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x07,
  0xC7, 0x80, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x3E, 0x03, 0xC3, 0xE0,
  0x1E, 0x1F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x80, 0x3E, 0x78, 0x01, 0xF7,
  0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x81, 0xFF, 0x03,
  0xE0, 0x7B, 0xC0, 0xF8, 0x1E, 0xF0, 0x7E, 0x0F, 0xBC, 0x1F, 0x83, 0xCF,
  0x07, 0xE0, 0xF3, 0xC3, 0xF8, 0x7C, 0xF0, 0xFE, 0x1E, 0x3C, 0x3B, 0x87,
  0x8F, 0x1E, 0xE3, 0xE3, 0xC7, 0xB8, 0xF0, 0xF1, 0xCE, 0x3C, 0x3C, 0xF3,
  0x8F, 0x0F, 0x3C, 0xE7, 0x83, 0xCE, 0x39, 0xE0, 0xF7, 0x8E, 0x78, 0x3D,
  0xE3, 0xBC, 0x0F, 0x70, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x7E, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x01, 0xE1, 0xF0, 0x01, 0xF3, 0xE0, 0x01,
  0xF7, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xEF, 0x00, 0x07, 0xCF, 0x00, 0x07,
  0xCF, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x87, 0x80, 0x1F, 0x07, 0xC0, 0x3F,
  0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xF8,
  0x03, 0xE7, 0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0x83,
  0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xE1, 0xE0, 0x3E, 0x3E, 0x01, 0xE7, 0xC0,
  0x1E, 0x7C, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0xC1, 0xCE, 0x1E, 0x70, 0xE3,
  0x8F, 0x1C, 0x70, 0xE7, 0x87, 0xB8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xE0, 0xF8, 0xF0, 0xF1, 0xE1, 0xE1, 0xC0, 0x03, 0xF0, 0x1F,
  0xF8, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x83, 0xC0, 0x07, 0x80, 0x0F,
  0x07, 0xFE, 0x3F, 0xFC, 0xFF, 0xFB, 0xE1, 0xEF, 0x83, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x3E, 0xF0, 0xFD, 0xFF, 0xF3, 0xFF, 0xE3, 0xFF, 0xC1, 0xE7,
  0xC0, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x7C, 0x07, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xF1, 0xF0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E,
  0x07, 0x9F, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xFB, 0xE0, 0x7D,
  0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x1F, 0x7F,
  0x8F, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x3E,
  0x1E, 0x7C, 0x1E, 0x78, 0x1F, 0x78, 0x0F, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0xF8, 0x3C, 0x78,
  0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC7, 0x81, 0xFE, 0xF0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x7C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0,
  0x3C, 0x3C, 0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x7C, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xDE, 0x01, 0xF3, 0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x1F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x1F,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x18, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF0, 0x0F, 0xC0,
  0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xC0, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0x01, 0xF3, 0xC1, 0xFE, 0xF0, 0xFF, 0xBC, 0x7F, 0xFF,
  0x1F, 0x0F, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x9F,
  0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xF0, 0x7C, 0x7C, 0x3F, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8,
  0x0F, 0x9E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x60, 0x7C, 0x3F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x7C, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0,
  0xF8, 0xF0, 0x7C, 0x78, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x3C,
  0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xC0, 0x03,
  0x81, 0xE0, 0x7C, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x00,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x07, 0xC1, 0xE1,
  0xF0, 0x7C, 0x7C, 0x0F, 0x9F, 0x81, 0xE7, 0xE0, 0x3C, 0xF8, 0x07, 0xBE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xEF, 0x00, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC3, 0xC0, 0x78, 0x7C,
  0x0F, 0x0F, 0x81, 0xE0, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x00, 0x0F,
  0x7C, 0x1F, 0x07, 0xFF, 0x9F, 0xE1, 0xFF, 0xF7, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0x0F, 0xC3, 0xC7, 0x83, 0xE0, 0xF1, 0xE0, 0xF8, 0x3C, 0xF8, 0x3E,
  0x0F, 0x3E, 0x0F, 0x03, 0xCF, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x7C, 0xF0,
  0x3C, 0x1F, 0x3C, 0x1F, 0x07, 0xDF, 0x07, 0xC1, 0xE7, 0xC1, 0xE0, 0x79,
  0xE0, 0x78, 0x1E, 0x78, 0x1E, 0x0F, 0x9E, 0x07, 0x83, 0xE7, 0x83, 0xE0,
  0xFB, 0xE0, 0xF8, 0x3C, 0xF8, 0x3C, 0x0F, 0x00, 0x0F, 0x3C, 0x0F, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF8, 0xF0, 0x7C, 0x78, 0x3E, 0x7C,
  0x1F, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x81, 0xE3, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x0F,
  0x9F, 0x07, 0xCF, 0x83, 0xC0, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F,
  0xFE, 0x3E, 0x1F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x1E, 0xF8,
  0x3E, 0x78, 0x3C, 0x7F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x07,
  0xBE, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0x87, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C,
  0x78, 0x0F, 0x1E, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x3E, 0x3E,
  0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE1, 0xF7, 0xF8, 0x7C, 0xF8, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC7, 0x87, 0xFB, 0xC7, 0xFF, 0xE7,
  0xFF, 0xF3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x3E, 0x78, 0x1F,
  0x7C, 0x0F, 0xBE, 0x07, 0x9F, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF3, 0xC0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x7C, 0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81,
  0xF7, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x78, 0xFF, 0xC7, 0xFE,
  0x3F, 0xE1, 0xFF, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFF, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0xF8, 0x3E,
  0x78, 0x3E, 0x78, 0x3C, 0x7E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0xFF, 0xDF, 0xFB, 0xFE, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x1F, 0xC3, 0xF8, 0x3F, 0x03, 0xE0,
  0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0,
  0x78, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF8, 0x7C,
  0x3F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xF7, 0x80, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0xF3, 0xC3, 0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x3E, 0x3C, 0x78,
  0x78, 0xF0, 0xF3, 0xC1, 0xE7, 0x81, 0xCF, 0x03, 0xBC, 0x07, 0x78, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0,
  0x00, 0xF8, 0x38, 0x1F, 0xF0, 0xF0, 0x7D, 0xE1, 0xE0, 0xF3, 0xC3, 0xC1,
  0xE7, 0x8F, 0xC7, 0x8F, 0x1F, 0x8F, 0x1E, 0x7F, 0x1E, 0x3C, 0xFE, 0x78,
  0x79, 0xDC, 0xF0, 0xF7, 0xBB, 0xC1, 0xEE, 0x77, 0x83, 0xFC, 0xEF, 0x07,
  0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81,
  0xE0, 0x00, 0x0F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7, 0x80,
  0x79, 0xF0, 0x0F, 0x7C, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0xFB, 0xC0, 0x1E, 0x3C, 0x07, 0xC7, 0x81, 0xF0, 0xF0, 0x3E,
  0x1F, 0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xC3, 0xE0, 0xF8, 0x7C, 0x1E, 0x07,
  0x87, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x0F,
  0x3E, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x30,
  0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x7E, 0x0F,
  0xC0, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x04, 0x00, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x02, 0x00, 0x1C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x3E, 0x00,
  0xE0, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x77, 0xFC, 0x3D, 0xFF,
  0x8E, 0xF1, 0xFF, 0xB8, 0x3F, 0xEE, 0x07, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_MediumItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 28, 10, 1, -28 },
  { 33, 10, 10, 12, 3, -29 },
  { 46, 20, 28, 20, 1, -28 },
  { 116, 17, 36, 19, 1, -32 },
  { 193, 19, 28, 24, 3, -28 },
  { 260, 19, 28, 21, 1, -28 },
  { 327, 5, 10, 6, 3, -29 },
  { 334, 12, 40, 12, 2, -31 },
  { 394, 12, 40, 12, -2, -31 },
  { 454, 16, 17, 17, 2, -28 },
  { 488, 17, 20, 18, 1, -23 },
  { 531, 7, 11, 8, -2, -4 },
  { 541, 9, 4, 12, 1, -14 },
  { 546, 5, 5, 11, 1, -5 },
  { 550, 17, 30, 13, -2, -28 },
  { 614, 16, 28, 19, 2, -28 },
  { 670, 11, 28, 19, 4, -28 },
  { 709, 18, 28, 19, 0, -28 },
  { 772, 17, 28, 19, 1, -28 },
  { 832, 18, 28, 19, 0, -28 },
  { 895, 17, 28, 19, 2, -28 },
  { 955, 15, 28, 19, 2, -28 },
  { 1008, 18, 28, 19, 2, -28 },
  { 1071, 17, 28, 19, 1, -28 },
  { 1131, 15, 28, 19, 3, -28 },
  { 1184, 8, 21, 10, 1, -21 },
  { 1205, 11, 28, 9, -2, -21 },
  { 1244, 15, 18, 17, 1, -21 },
  { 1278, 15, 12, 19, 2, -19 },
  { 1301, 15, 18, 17, 1, -21 },
  { 1335, 14, 28, 16, 3, -28 },
  { 1384, 27, 36, 29, 1, -27 },
  { 1506, 21, 28, 22, -1, -28 },
  { 1580, 19, 28, 21, 1, -28 },
  { 1647, 19, 28, 22, 2, -28 },
  { 1714, 20, 28, 21, 1, -28 },
  { 1784, 19, 28, 19, 1, -28 },
  { 1851, 19, 28, 18, 1, -28 },
  { 1918, 20, 28, 22, 2, -28 },
  { 1988, 23, 28, 23, 1, -28 },
  { 2069, 9, 28, 10, 1, -28 },
  { 2101, 19, 28, 18, 0, -28 },
  { 2168, 22, 28, 21, 1, -28 },
  { 2245, 15, 28, 18, 1, -28 },
  { 2298, 28, 28, 29, 1, -28 },
  { 2396, 23, 28, 23, 1, -28 },
  { 2477, 20, 28, 23, 2, -28 },
  { 2547, 20, 28, 21, 1, -28 },
  { 2617, 20, 33, 23, 2, -28 },
  { 2700, 20, 28, 21, 1, -28 },
  { 2770, 19, 28, 20, 1, -28 },
  { 2837, 19, 28, 20, 3, -28 },
  { 2904, 21, 28, 21, 1, -28 },
  { 2978, 21, 28, 22, 3, -28 },
  { 3052, 26, 28, 29, 4, -28 },
  { 3143, 24, 28, 21, -1, -28 },
  { 3227, 20, 28, 20, 3, -28 },
  { 3297, 21, 28, 20, 0, -28 },
  { 3371, 12, 38, 10, 0, -32 },
  { 3428, 9, 30, 14, 3, -28 },
  { 3462, 13, 38, 10, -2, -32 },
  { 3524, 13, 14, 14, 1, -28 },
  { 3547, 15, 4, 15, -2, 0 },
  { 3555, 7, 6, 12, 4, -30 },
  { 3561, 15, 21, 18, 1, -21 },
  { 3601, 17, 29, 19, 0, -29 },
  { 3663, 16, 21, 17, 1, -21 },
  { 3705, 19, 29, 19, 1, -29 },
  { 3774, 16, 21, 18, 1, -21 },
  { 3816, 14, 29, 12, 1, -29 },
  { 3867, 18, 29, 19, 0, -21 },
  { 3933, 17, 29, 18, 0, -29 },
  { 3995, 10, 29, 9, 0, -29 },
  { 4032, 13, 37, 9, -4, -29 },
  { 4093, 19, 29, 18, 0, -29 },
  { 4162, 10, 29, 9, 0, -29 },
  { 4199, 26, 21, 28, 0, -21 },
  { 4268, 17, 21, 18, 0, -21 },
  { 4313, 16, 21, 19, 1, -21 },
  { 4355, 18, 29, 19, -1, -21 },
  { 4421, 17, 29, 19, 1, -21 },
  { 4483, 13, 21, 12, 0, -21 },
  { 4518, 16, 21, 17, 0, -21 },
  { 4560, 11, 26, 11, 1, -26 },
  { 4596, 17, 21, 18, 1, -21 },
  { 4641, 15, 21, 17, 2, -21 },
  { 4681, 23, 21, 24, 2, -21 },
  { 4742, 19, 21, 17, -1, -21 },
  { 4792, 19, 29, 16, -1, -21 },
  { 4861, 17, 21, 17, 0, -21 },
  { 4906, 12, 37, 11, 1, -30 },
  { 4962, 8, 33, 9, 1, -28 },
  { 4995, 13, 37, 11, -2, -30 },
  { 5056, 18, 8, 22, 2, -15 },
};

const GFXfont RobotoCondensed_MediumItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC39PT7B_H_
