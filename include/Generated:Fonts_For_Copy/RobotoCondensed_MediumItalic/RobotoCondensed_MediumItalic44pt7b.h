#ifndef _ROBOTOCONDENSED_MEDIUMITALIC44PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83,
  0xE0, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x07, 0x00, 0x3C, 0xF3, 0xCF, 0x38, 0xF3, 0x8E, 0x78, 0xE7,
  0x8E, 0x79, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xF1, 0xC0, 0x00, 0x1E, 0x3C,
  0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x70, 0x00,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xE3, 0xC0, 0x07, 0x8E, 0x00,
  0x1C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x78,
  0xF0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xF1, 0xC0,
  0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x1E, 0x00, 0x3C, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0x7E,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87,
  0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xE3, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0x9E,
  0x00, 0x70, 0xE0, 0xEF, 0x0E, 0x0E, 0xF0, 0xE1, 0xCE, 0x0E, 0x3C, 0xE0,
  0xE7, 0x8E, 0x1E, 0x70, 0xF1, 0xEF, 0x0F, 0x3D, 0xE0, 0x7F, 0xDC, 0x03,
  0xFB, 0x80, 0x1E, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE7, 0xC0, 0x1E, 0xFE,
  0x03, 0xDF, 0xE0, 0x3B, 0xCF, 0x07, 0x38, 0x70, 0xF7, 0x87, 0x1E, 0x78,
  0x71, 0xC7, 0x87, 0x3C, 0x70, 0x77, 0x87, 0x07, 0x70, 0x78, 0xF2, 0x07,
  0x9E, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x7E, 0x7C, 0x03, 0xE1,
  0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01,
  0xE3, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x79, 0xFF, 0xC3, 0xCF, 0xBF, 0x3E, 0xF8,
  0xF9, 0xE7, 0xC7, 0xEF, 0x7C, 0x1F, 0xFB, 0xE0, 0x7F, 0x9F, 0x03, 0xFC,
  0xF8, 0x0F, 0xC7, 0xE0, 0x7C, 0x1F, 0x8F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0xFD, 0xF8, 0x1F, 0x87, 0xC0, 0x3C, 0xE7, 0x9E, 0x79, 0xE7,
  0x1C, 0xF3, 0xCF, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00, 0x40,
  0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x08, 0x3C, 0x17, 0x8E, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0,
  0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xDE, 0x01, 0xE7, 0x80, 0xF0,
  0xF0, 0x7C, 0x3C, 0x0E, 0x07, 0x00, 0x01, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x7C, 0x78,
  0xF8, 0xF0, 0x60, 0xFF, 0xFF, 0xEF, 0xFB, 0xFE, 0x33, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F,
  0x8F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x0F, 0x3E, 0x03, 0xCF, 0x80,
  0xF3, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F,
  0x87, 0xC7, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFF, 0x7F, 0xF7, 0xFE, 0xFF, 0xEE, 0x3E,
  0x83, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7E, 0x3F,
  0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFC, 0x7E, 0x3F, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x83, 0xE1, 0xF8,
  0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xE0, 0x07, 0xBE,
  0x00, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0xC7,
  0xC0, 0xF8, 0x7C, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0,
  0xF8, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xEF, 0x80, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xF3, 0xF8, 0x0C, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xF0, 0x7C, 0x7E,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0xBE, 0x07, 0xFF,
  0xC7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0x7E, 0xFC, 0x1F, 0x7C, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x1F, 0x3E, 0x1F, 0x9F, 0x9F, 0x87, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0x80, 0x1F, 0x80, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xE7, 0xE0,
  0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xE0, 0xF0, 0x3E,
  0x0F, 0x03, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0x7F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xF1, 0xF0, 0x3E, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x7C,
  0x0F, 0x87, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xE3, 0xF1, 0xF1, 0xF0, 0xF9, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x7F, 0xF8, 0x3E, 0x7C, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0,
  0xFB, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x07,
  0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x1F, 0x0F, 0xC7, 0xE3,
  0xF0, 0xF0, 0x01, 0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFE, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0x3E, 0x7C, 0x3F, 0x7C,
  0x1F, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x38, 0x1C,
  0x07, 0xC0, 0x70, 0xF0, 0x7F, 0xC1, 0xC7, 0x83, 0xFF, 0x87, 0x1E, 0x1F,
  0x9E, 0x1C, 0x70, 0x78, 0x78, 0x73, 0xC3, 0xC1, 0xC1, 0xCE, 0x0F, 0x0F,
  0x07, 0x38, 0x78, 0x3C, 0x1D, 0xE1, 0xE0, 0xF0, 0x77, 0x87, 0x83, 0x81,
  0xDC, 0x3C, 0x0E, 0x0F, 0x70, 0xF0, 0x78, 0x3B, 0xC3, 0xC1, 0xE0, 0xEF,
  0x0F, 0x07, 0x03, 0xBC, 0x3C, 0x1C, 0x1E, 0xF0, 0xF0, 0xF0, 0x73, 0xC3,
  0xC3, 0xC1, 0xCE, 0x0F, 0x1F, 0x0E, 0x38, 0x3E, 0xFC, 0x78, 0xF0, 0xFF,
  0x7F, 0xC3, 0xC1, 0xF9, 0xFE, 0x0F, 0x03, 0xC3, 0xE0, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x00, 0x7F, 0x0F, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x78, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3E, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x83, 0xF8, 0x3E, 0x03,
  0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x03, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E,
  0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x8F, 0x81, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xF3, 0xF8,
  0x3E, 0x03, 0xE1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xF1, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0x87, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0x7C,
  0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x01, 0xF9, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x3F, 0x0F,
  0x83, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xF3, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xFE, 0x7C, 0x1F,
  0xFB, 0xF0, 0x7F, 0xEF, 0x81, 0xFF, 0xBE, 0x00, 0x7E, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF8,
  0x0F, 0xC7, 0xF9, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x9F, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x1F, 0x83, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8,
  0x1F, 0xC0, 0x7C, 0x1F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F,
  0x8F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07, 0xCF, 0xE0, 0x03, 0xE7, 0xE0, 0x01,
  0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF, 0x80, 0x07, 0xE7, 0xE0,
  0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0x78, 0x0F,
  0xFC, 0x1F, 0x78, 0x0F, 0x7C, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E,
  0xF8, 0x3E, 0x78, 0x3E, 0xF8, 0x3E, 0x78, 0x3C, 0xF8, 0x3E, 0x78, 0x7C,
  0xF8, 0x3E, 0x78, 0x78, 0xF8, 0x3E, 0x3C, 0xF9, 0xF0, 0x3E, 0x3C, 0xF1,
  0xF0, 0x7C, 0x3C, 0xF1, 0xF0, 0x7C, 0x3D, 0xE1, 0xF0, 0x7C, 0x3D, 0xE1,
  0xF0, 0x7C, 0x3F, 0xC3, 0xF0, 0x7C, 0x3F, 0xC3, 0xE0, 0x7C, 0x3F, 0x83,
  0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x03,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC1, 0xF0, 0x03, 0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x80, 0x3E, 0x0F, 0xE0,
  0x0F, 0x83, 0xFC, 0x03, 0xE0, 0xFF, 0x01, 0xF0, 0x3F, 0xC0, 0x7C, 0x0F,
  0xF8, 0x1F, 0x07, 0xDE, 0x07, 0xC1, 0xF7, 0x81, 0xF0, 0x7D, 0xE0, 0x7C,
  0x1F, 0x3C, 0x3E, 0x07, 0xCF, 0x0F, 0x83, 0xF3, 0xC3, 0xE0, 0xF8, 0x78,
  0xF8, 0x3E, 0x1E, 0x3E, 0x0F, 0x87, 0x9F, 0x83, 0xE1, 0xF7, 0xC0, 0xF8,
  0x3D, 0xF0, 0x7E, 0x0F, 0x7C, 0x1F, 0x03, 0xDF, 0x07, 0xC0, 0x7F, 0xC1,
  0xF0, 0x1F, 0xF0, 0x7C, 0x07, 0xF8, 0x1F, 0x00, 0xFE, 0x0F, 0x80, 0x3F,
  0x83, 0xE0, 0x0F, 0xE0, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0x3F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C,
  0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xFE, 0x7F, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x1F, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00,
  0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F,
  0x8F, 0xC0, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0x3F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E,
  0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF,
  0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x7C,
  0x03, 0xE0, 0xF8, 0x0F, 0xC1, 0xFE, 0x7F, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0x83, 0xF8,
  0x3E, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C,
  0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3F, 0x1F, 0x00, 0xF8, 0x7C, 0x07,
  0xE3, 0xF0, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0xF3, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F, 0x87, 0xE0, 0x3F, 0x1F, 0x00,
  0x7C, 0x7C, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF0, 0x1F, 0x07,
  0xF1, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0xF8, 0x03, 0xE1,
  0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0xFC, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC1,
  0xF8, 0x1F, 0x81, 0xFC, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB,
  0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xCF, 0x80, 0x1F, 0x9F, 0x80, 0x3E, 0x3F,
  0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xF0, 0x0F, 0x07,
  0xC0, 0x1E, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xE7, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xBE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xBE,
  0x03, 0xE0, 0x3E, 0xF8, 0x1F, 0x80, 0xFB, 0xE0, 0x7E, 0x07, 0xCF, 0x81,
  0xF8, 0x1F, 0x3E, 0x0F, 0xF0, 0x7C, 0xF8, 0x3F, 0xC3, 0xE3, 0xE0, 0xFF,
  0x0F, 0x8F, 0x87, 0xBC, 0x3E, 0x3E, 0x1E, 0xF1, 0xF0, 0xF8, 0xFB, 0xC7,
  0xC3, 0xE3, 0xCF, 0x1F, 0x0F, 0x8F, 0x3C, 0xF8, 0x1E, 0x7C, 0xF3, 0xE0,
  0x79, 0xE3, 0xCF, 0x81, 0xE7, 0x8F, 0x7C, 0x07, 0xBC, 0x3D, 0xF0, 0x1E,
  0xF0, 0xF7, 0xC0, 0x7B, 0xC3, 0xDE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8,
  0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF0,
  0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF,
  0xC0, 0x3F, 0x1F, 0x00, 0xFC, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0,
  0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xE0,
  0x07, 0x8F, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83,
  0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83,
  0xC1, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0xF7, 0x03, 0xDC, 0x1E, 0x70, 0x79, 0xC3, 0xC7, 0x8F, 0x1E, 0x78, 0x79,
  0xE1, 0xEF, 0x87, 0xBC, 0x0E, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF8, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xF7, 0xF1,
  0xF3, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBF,
  0x1F, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7C, 0xF8, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x9F, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xC7, 0xE1,
  0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x01, 0xE1, 0xE0, 0x1E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x07, 0xC7, 0xE0, 0xFC, 0x7F, 0x1F, 0x87, 0xFF,
  0xF8, 0x7B, 0xFF, 0x0F, 0x9F, 0xE0, 0xF8, 0xF8, 0x00, 0x01, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x8F, 0x8F, 0x81, 0xE3, 0xE0,
  0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3C, 0xF8, 0x1F, 0x1F,
  0x07, 0xC7, 0xC7, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0xFC, 0xF8, 0x0F, 0xF7, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFE, 0x3F, 0x87, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0x80, 0x7C, 0x7C, 0x03, 0xC3, 0xE0,
  0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1,
  0xF8, 0x3E, 0x07, 0xE7, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFB,
  0xE0, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0x8F, 0x8F, 0x81, 0xF3, 0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0x87, 0xE1, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x01, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x1F, 0xFE, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0xF8, 0x1F, 0xE7, 0x81, 0xFF, 0xBC, 0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x0F,
  0x81, 0xF8, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC1, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x18, 0x0F, 0xC0, 0xF0, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x7C,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xF1, 0xF8, 0xFC, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9,
  0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x03, 0xE7,
  0xC0, 0x78, 0xF8, 0x1F, 0x00, 0x00, 0x80, 0x78, 0x1F, 0x83, 0xF0, 0x3C,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xC0, 0x00, 0x0C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0xFE, 0x1F, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0x87, 0xE0,
  0x7C, 0x7E, 0x03, 0xE7, 0xE0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x3F, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC3, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0xF0, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x00,
  0x0F, 0x9F, 0x03, 0xE0, 0x3F, 0xFE, 0x3F, 0xC0, 0xFF, 0xFD, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x1F, 0xC7, 0xF8, 0xFC, 0x7E, 0x0F, 0xC1, 0xF1, 0xF0,
  0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x7C, 0x78, 0x0F,
  0x01, 0xF3, 0xE0, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x3E, 0x3E, 0x07, 0xC0,
  0xF8, 0xF8, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x0F, 0x8F, 0x01, 0xE0, 0x3C,
  0x7C, 0x0F, 0x81, 0xF1, 0xF0, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0x1F, 0x1F,
  0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x3C, 0x07, 0x8F, 0x81,
  0xF0, 0x3E, 0x00, 0x0F, 0x9F, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFC, 0x7E, 0x3F, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xE7, 0xC0, 0x7C, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3E, 0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xF8, 0xFC, 0x7E, 0x0F,
  0x8F, 0x81, 0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F,
  0xFC, 0x01, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E,
  0xF8, 0x0F, 0x8F, 0x83, 0xF1, 0xF8, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFE, 0x3F, 0x07, 0xE0, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xE3, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8,
  0x3E, 0x7F, 0x81, 0xF1, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF1, 0xE0, 0xFF, 0x3C, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xF8, 0xFE, 0x7C, 0x0F, 0xDF, 0x81, 0xF3, 0xE0, 0x3E,
  0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0, 0x1F, 0x7C, 0x03, 0xCF, 0x80, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x83, 0xE1,
  0xF8, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xE7, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xBC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF1,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF9, 0xE0, 0x3E,
  0xF0, 0x1E, 0x7C, 0x1F, 0x3E, 0x1F, 0x8F, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF,
  0x80, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0xC0,
  0xFC, 0x0F, 0xE1, 0xFC, 0x3F, 0x81, 0xF0, 0x1F, 0x03, 0xE3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xC0, 0x7C, 0x78, 0x1F, 0x0F,
  0x83, 0xE1, 0xF9, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xBC, 0x07,
  0xE7, 0x80, 0xF8, 0x0F, 0x9E, 0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x7C, 0x7C, 0x0F, 0x1E,
  0x03, 0xCF, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00,
  0xF7, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07,
  0xFC, 0x1F, 0x03, 0xDE, 0x0F, 0x83, 0xEF, 0x07, 0xE1, 0xF7, 0x87, 0xF1,
  0xF3, 0xC3, 0xF8, 0xF9, 0xE3, 0xFC, 0x78, 0xF1, 0xFE, 0x7C, 0x78, 0xFF,
  0x3E, 0x3C, 0xF7, 0x9E, 0x1E, 0x7B, 0xDF, 0x0F, 0x79, 0xEF, 0x07, 0xFC,
  0xF7, 0x83, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x03,
  0xC0, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x81,
  0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x01, 0xE7, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xBE, 0x00, 0xFC, 0xF0, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1,
  0xF0, 0x3E, 0x07, 0xC3, 0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x7C, 0x0F,
  0x83, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E,
  0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x01, 0xE7, 0xC0,
  0x0F, 0x3E, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x08, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C,
  0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x00, 0x01, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x70, 0x01, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x03, 0xCF, 0xF8, 0x1C, 0xFF, 0xE1, 0xE7, 0xDF,
  0x9F, 0x78, 0x7F, 0xF3, 0xC1, 0xFF, 0x9E, 0x07, 0xF8, 0x00, 0x0F, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 31, 11, 1, -31 },
  { 40, 12, 11, 14, 3, -33 },
  { 57, 22, 31, 23, 1, -31 },
  { 143, 20, 40, 21, 1, -36 },
  { 243, 20, 31, 27, 4, -31 },
  { 321, 21, 31, 24, 1, -31 },
  { 403, 6, 11, 7, 3, -33 },
  { 412, 13, 45, 14, 2, -35 },
  { 486, 14, 45, 14, -2, -35 },
  { 565, 18, 19, 19, 2, -31 },
  { 608, 19, 23, 21, 1, -26 },
  { 663, 8, 12, 10, -2, -5 },
  { 675, 10, 4, 13, 2, -15 },
  { 680, 6, 6, 12, 1, -6 },
  { 685, 20, 34, 15, -3, -31 },
  { 770, 18, 31, 21, 2, -31 },
  { 840, 12, 31, 21, 5, -31 },
  { 887, 21, 31, 21, 0, -31 },
  { 969, 19, 31, 21, 1, -31 },
  { 1043, 20, 31, 21, 0, -31 },
  { 1121, 20, 31, 21, 2, -31 },
  { 1199, 17, 31, 21, 2, -31 },
  { 1265, 20, 31, 21, 2, -31 },
  { 1343, 20, 31, 21, 1, -31 },
  { 1421, 17, 31, 21, 3, -31 },
  { 1487, 9, 24, 11, 1, -24 },
  { 1514, 12, 31, 10, -2, -24 },
  { 1561, 17, 20, 19, 1, -24 },
  { 1604, 18, 13, 21, 2, -21 },
  { 1634, 17, 21, 20, 1, -24 },
  { 1679, 16, 31, 19, 3, -31 },
  { 1741, 30, 41, 33, 1, -31 },
  { 1895, 24, 31, 25, -2, -31 },
  { 1988, 22, 31, 24, 1, -31 },
  { 2074, 22, 31, 24, 2, -31 },
  { 2160, 22, 31, 24, 1, -31 },
  { 2246, 22, 31, 21, 1, -31 },
  { 2332, 21, 31, 20, 1, -31 },
  { 2414, 22, 31, 25, 2, -31 },
  { 2500, 26, 31, 26, 1, -31 },
  { 2601, 10, 31, 11, 1, -31 },
  { 2640, 21, 31, 21, 0, -31 },
  { 2722, 25, 31, 23, 1, -31 },
  { 2819, 17, 31, 20, 1, -31 },
  { 2885, 32, 31, 32, 1, -31 },
  { 3009, 26, 31, 26, 1, -31 },
  { 3110, 23, 31, 26, 2, -31 },
  { 3200, 23, 31, 24, 1, -31 },
  { 3290, 23, 36, 26, 2, -31 },
  { 3394, 22, 31, 23, 1, -31 },
  { 3480, 22, 31, 23, 1, -31 },
  { 3566, 21, 31, 23, 4, -31 },
  { 3648, 23, 31, 24, 2, -31 },
  { 3738, 23, 31, 24, 4, -31 },
  { 3828, 30, 31, 32, 4, -31 },
  { 3945, 27, 31, 24, -1, -31 },
  { 4050, 22, 31, 23, 4, -31 },
  { 4136, 25, 31, 22, -1, -31 },
  { 4233, 15, 43, 11, -1, -36 },
  { 4314, 9, 34, 16, 4, -31 },
  { 4353, 14, 43, 11, -2, -36 },
  { 4429, 14, 16, 16, 2, -31 },
  { 4457, 17, 4, 17, -3, 0 },
  { 4466, 9, 6, 14, 4, -33 },
  { 4473, 17, 23, 20, 1, -23 },
  { 4522, 20, 33, 21, 0, -33 },
  { 4605, 18, 23, 20, 1, -23 },
  { 4657, 21, 33, 21, 1, -33 },
  { 4744, 18, 23, 20, 1, -23 },
  { 4796, 15, 33, 14, 2, -33 },
  { 4858, 21, 32, 21, 0, -23 },
  { 4942, 19, 33, 21, 0, -33 },
  { 5021, 11, 32, 10, 0, -32 },
  { 5065, 16, 41, 10, -5, -32 },
  { 5147, 21, 33, 20, 0, -33 },
  { 5234, 11, 33, 10, 0, -33 },
  { 5280, 30, 23, 32, 0, -23 },
  { 5367, 19, 23, 21, 0, -23 },
  { 5422, 19, 23, 21, 1, -23 },
  { 5477, 21, 32, 21, -1, -23 },
  { 5561, 19, 32, 21, 1, -23 },
  { 5637, 14, 23, 14, 0, -23 },
  { 5678, 17, 23, 19, 1, -23 },
  { 5727, 11, 29, 13, 2, -29 },
  { 5767, 19, 23, 21, 1, -23 },
  { 5822, 18, 23, 19, 2, -23 },
  { 5874, 25, 23, 27, 3, -23 },
  { 5946, 21, 23, 19, -1, -23 },
  { 6007, 21, 32, 18, -1, -23 },
  { 6091, 19, 23, 19, 0, -23 },
  { 6146, 14, 42, 13, 1, -34 },
  { 6220, 9, 37, 11, 1, -31 },
  { 6262, 14, 42, 13, -2, -34 },
  { 6336, 21, 9, 24, 2, -17 },
};

const GFXfont RobotoCondensed_MediumItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC44PT7B_H_
