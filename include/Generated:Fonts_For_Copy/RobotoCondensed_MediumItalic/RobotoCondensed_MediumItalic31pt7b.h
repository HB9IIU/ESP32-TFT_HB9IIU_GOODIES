#ifndef _ROBOTOCONDENSED_MEDIUMITALIC31PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE1, 0xC7,
  0x0E, 0x1C, 0x00, 0x00, 0x03, 0x87, 0x8E, 0x1C, 0x00, 0x33, 0xB9, 0x9C,
  0xCE, 0xE6, 0x73, 0x31, 0x99, 0xCC, 0x00, 0xCE, 0x03, 0x9C, 0x06, 0x30,
  0x0C, 0xE0, 0x39, 0xC0, 0x63, 0x00, 0xCE, 0x1F, 0xFF, 0x3F, 0xFE, 0x0C,
  0xE0, 0x39, 0xC0, 0x73, 0x00, 0xC6, 0x1F, 0xFF, 0x3F, 0xFE, 0x0C, 0x60,
  0x39, 0xC0, 0x73, 0x00, 0xC6, 0x03, 0x9C, 0x07, 0x30, 0x0C, 0x60, 0x00,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0xF8, 0x0F, 0xF0, 0x3F, 0xE1, 0xE7,
  0x87, 0x0E, 0x3C, 0x38, 0xF0, 0xF3, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xCF, 0x07, 0x3C, 0x1C, 0xF0,
  0xF3, 0xC7, 0x87, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x3C, 0x01, 0xF8, 0x0E, 0x70, 0x39, 0xC6, 0xC7, 0x3B, 0x1C, 0xCC,
  0x66, 0x3B, 0xB8, 0x7E, 0xC1, 0xE6, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x70,
  0x3F, 0xE1, 0xDD, 0xC6, 0xE3, 0x33, 0x8D, 0xCE, 0x3E, 0x39, 0xD0, 0xE6,
  0x01, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0xF3, 0x81,
  0xC7, 0x83, 0x8E, 0x07, 0x1C, 0x0E, 0x78, 0x1F, 0xE0, 0x1F, 0x80, 0x3C,
  0x01, 0xF8, 0xE7, 0xF9, 0xCE, 0x7B, 0xBC, 0xF7, 0x70, 0xFC, 0xE1, 0xF9,
  0xC1, 0xE3, 0xC3, 0xC7, 0xFF, 0xC7, 0xFF, 0x83, 0xE7, 0x80, 0x77, 0x77,
  0x66, 0xEE, 0x00, 0x40, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0x80, 0x20, 0x08, 0x06, 0x03, 0x80, 0xE0, 0x70,
  0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1C, 0x0E, 0x0E,
  0x07, 0x07, 0x07, 0x03, 0x01, 0x00, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0xE6, 0x7F, 0xFF, 0x3F, 0xE0, 0xE0, 0x1F, 0x03, 0xB0, 0x73, 0x8E, 0x1C,
  0x01, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x71, 0xCF, 0x38, 0xE7, 0x3C, 0x60, 0x7F,
  0xFF, 0xF8, 0xEF, 0xFE, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x03, 0xE0,
  0x7F, 0x87, 0xFE, 0x3C, 0xF3, 0xC3, 0x9C, 0x1C, 0xE0, 0xEF, 0x07, 0x78,
  0x3B, 0xC1, 0xDC, 0x1E, 0xE0, 0xF7, 0x07, 0xF8, 0x3B, 0xC1, 0xDE, 0x0E,
  0xF0, 0xF3, 0x87, 0x1C, 0x78, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x01, 0x83,
  0xCF, 0xEF, 0xF7, 0xF3, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0x01,
  0xF0, 0x1F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1C, 0x1C, 0xF0, 0x73, 0xC1, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xE0, 0x07, 0xC0, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x83, 0x9C, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0xE0, 0xF7, 0x07, 0x3C, 0x79, 0xFF, 0x87, 0xF8,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x3B, 0x81, 0xFE, 0x07, 0x78, 0x39, 0xE1, 0xE7, 0x07, 0x1C, 0x38,
  0x71, 0xE3, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0x8F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0xF0, 0x73, 0xC3,
  0xC7, 0x1E, 0x1F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x81,
  0xFC, 0x1F, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x78, 0x3F, 0xE3, 0xFF,
  0x9E, 0x3C, 0xF0, 0xE7, 0x07, 0xB8, 0x3F, 0xC1, 0xCE, 0x0E, 0x70, 0x73,
  0x87, 0x9E, 0x78, 0xFF, 0xC3, 0xFC, 0x0F, 0x80, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x7F, 0x87, 0xFE, 0x3C, 0xF3, 0xC3, 0x9E, 0x1C, 0xF0, 0xE7, 0x8F,
  0x1C, 0x70, 0xFF, 0x87, 0xF0, 0x7F, 0xC7, 0x8E, 0x38, 0x7B, 0xC1, 0xDE,
  0x1E, 0xF0, 0xF7, 0x87, 0xBC, 0x78, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0x07,
  0x81, 0xFC, 0x3F, 0xE3, 0x8F, 0x78, 0xF7, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x0F, 0xF0, 0xF7, 0x1F, 0x7F, 0xE7, 0xFE, 0x1F, 0xE0, 0x1C, 0x03,
  0xC0, 0x78, 0x0F, 0x87, 0xF0, 0x7C, 0x07, 0x00, 0x3C, 0xF3, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x3C, 0xE0, 0x0E, 0x0F, 0x0F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x38,
  0x38, 0x38, 0x78, 0x70, 0xF0, 0xE0, 0x40, 0x00, 0x10, 0x07, 0x01, 0xE0,
  0x7E, 0x3F, 0x8F, 0xE0, 0xF8, 0x0F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x7C, 0x01, 0xC0, 0x08, 0x3F, 0xF9, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xE7, 0xFF, 0x00, 0x20, 0x03, 0x80,
  0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x03, 0xF0, 0xFE,
  0x7F, 0x8F, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x0F, 0x87, 0xF9, 0xFF,
  0xBC, 0xF7, 0x0F, 0xE1, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xC0, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x07,
  0x80, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xF8, 0x78, 0x0F,
  0x00, 0xC0, 0xE0, 0x07, 0x06, 0x00, 0x18, 0x70, 0x00, 0xC7, 0x07, 0x83,
  0x38, 0x7F, 0x19, 0x87, 0x38, 0xDC, 0x71, 0x86, 0xC3, 0x0C, 0x36, 0x38,
  0xE1, 0xF1, 0xC7, 0x1F, 0x8C, 0x38, 0xD8, 0xE1, 0x86, 0xC7, 0x1C, 0x36,
  0x38, 0xE3, 0xB1, 0xC7, 0x19, 0x8F, 0xF9, 0x8C, 0x3E, 0xFC, 0x61, 0xE7,
  0x83, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x0C, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03,
  0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0xE0,
  0x70, 0x70, 0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1E, 0x03, 0x9E, 0x01,
  0xCF, 0x00, 0xE7, 0x00, 0x77, 0x80, 0x3C, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F,
  0xFE, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C,
  0x1E, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x38, 0x1C, 0x38,
  0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xC0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x1C,
  0x0F, 0x3C, 0x0F, 0x38, 0x0F, 0x38, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x1C, 0x70,
  0x1C, 0x70, 0x3C, 0x78, 0x78, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0E, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x07, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x78,
  0x78, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x7F,
  0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x1C, 0x0F, 0x3C, 0x0F, 0x38,
  0x07, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0xFE, 0x70,
  0xFE, 0x70, 0xFE, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x7C,
  0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x38, 0x07, 0x07, 0x00, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0,
  0xF0, 0x1C, 0x1C, 0x03, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xC0, 0x78, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x0F, 0x0F,
  0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x07, 0x00, 0xE1, 0xE0, 0x3C, 0x00,
  0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8F,
  0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x8E, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x78, 0x38, 0xF0, 0xF1, 0xE1, 0xE1, 0xE7, 0x83, 0xFF, 0x03, 0xFC, 0x03,
  0xE0, 0x00, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x38, 0x3E, 0x07, 0x0F, 0x81,
  0xE3, 0xE0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1D, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7D, 0xE0, 0x0F,
  0x3C, 0x01, 0xC3, 0x80, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x38,
  0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07,
  0xFF, 0x7F, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x01,
  0xF8, 0x7C, 0x03, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0x70, 0x7F,
  0x0E, 0xE0, 0xFE, 0x1D, 0xC3, 0xFC, 0x3B, 0x87, 0x70, 0xF7, 0x0E, 0xE1,
  0xEE, 0x39, 0xC3, 0xDC, 0x77, 0x87, 0x39, 0xCF, 0x0E, 0x33, 0x9C, 0x1C,
  0x7E, 0x38, 0x78, 0xFC, 0x70, 0xF1, 0xF1, 0xE1, 0xE3, 0xE3, 0xC3, 0x87,
  0x87, 0x87, 0x0F, 0x0E, 0x1E, 0x0C, 0x1C, 0x00, 0x0F, 0x01, 0xE1, 0xE0,
  0x38, 0x3C, 0x07, 0x07, 0xC0, 0xE1, 0xF8, 0x3C, 0x3F, 0x07, 0x87, 0xF0,
  0xF0, 0xFE, 0x1C, 0x1D, 0xC3, 0x83, 0x9C, 0x70, 0xF3, 0x9E, 0x1E, 0x73,
  0xC3, 0xC6, 0x78, 0x78, 0xEE, 0x0E, 0x1D, 0xC1, 0xC1, 0xF8, 0x78, 0x3F,
  0x0F, 0x07, 0xE1, 0xE0, 0xFC, 0x38, 0x0F, 0x07, 0x01, 0xE1, 0xE0, 0x3C,
  0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1F, 0x1E, 0x0F, 0x3C,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x78, 0x07, 0x78, 0x07, 0x78, 0x0F, 0x70,
  0x0F, 0x70, 0x0F, 0x70, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x70, 0x1E, 0x78,
  0x3C, 0x7C, 0x78, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xC1, 0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1C, 0x07, 0x8E, 0x07, 0x8F, 0x07, 0xC7, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0x1E, 0x1E, 0x0F, 0x3C, 0x0F, 0x38, 0x07, 0x78, 0x07,
  0x78, 0x07, 0x78, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x0E,
  0xF0, 0x0E, 0xF0, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x78, 0x78, 0x3F, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10,
  0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x07,
  0x1E, 0x07, 0x1E, 0x0F, 0x1C, 0x0F, 0x1C, 0x0E, 0x3C, 0x3E, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF0, 0x38, 0x70, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x38, 0x70, 0x3C, 0x70, 0x3C, 0x70, 0x3C, 0x03, 0xF0, 0x1F, 0xF0,
  0x7F, 0xF0, 0xF1, 0xE3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x1E,
  0x70, 0x1C, 0xE0, 0x79, 0xE0, 0xF3, 0xE3, 0xC3, 0xFF, 0x83, 0xFE, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x07, 0x8E, 0x03, 0x87, 0x01, 0xC7,
  0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x78, 0x0E,
  0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x01, 0xC3, 0x80, 0xE3, 0xC0,
  0x71, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1C, 0x1E, 0x1E, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0xFC, 0x00, 0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x70, 0xF0,
  0x71, 0xE0, 0x71, 0xE0, 0x79, 0xC0, 0x7B, 0xC0, 0x7B, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0xE0, 0x70, 0x7F, 0x07, 0x83, 0xF8, 0x3C, 0x1D, 0xC1, 0xE1, 0xEE, 0x1F,
  0x0F, 0x70, 0xF8, 0x73, 0x87, 0xC7, 0x9C, 0x7E, 0x3C, 0xE3, 0xB1, 0xC7,
  0x1D, 0x9E, 0x39, 0xCC, 0xF1, 0xCE, 0x67, 0x0E, 0xE3, 0x38, 0x77, 0x1B,
  0xC3, 0xB8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x0F, 0x03,
  0xE1, 0xE0, 0x78, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x1E,
  0x00, 0xF7, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x79, 0xC0,
  0x0F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0x70, 0x1E, 0x0F, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x00, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF3, 0x83, 0xC7, 0x07,
  0x0E, 0x1E, 0x1E, 0x78, 0x1C, 0xF0, 0x3B, 0xC0, 0x77, 0x00, 0xFE, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xC0, 0x0F, 0xC3, 0xE0, 0xF8,
  0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07,
  0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x00, 0xE3, 0x8E,
  0x3C, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x1E, 0x78, 0xE3, 0x8E, 0x38, 0xE3,
  0xCF, 0x1C, 0x71, 0xC7, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0,
  0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x01, 0xC1, 0xF0, 0x7C, 0x3F, 0x00, 0x07, 0x01, 0xC0, 0xF8, 0x3E, 0x1F,
  0x87, 0x63, 0x98, 0xE6, 0x71, 0xDC, 0x7E, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF1, 0xE3, 0x8E, 0x1C, 0x03, 0xE0, 0x7F, 0x87, 0xFC, 0x78, 0xF3,
  0xC7, 0x80, 0x3C, 0x01, 0xE1, 0xFF, 0x1F, 0xF1, 0xE3, 0x9E, 0x1C, 0xE1,
  0xE7, 0x0F, 0x38, 0xF9, 0xFF, 0x8F, 0xFC, 0x1E, 0xF0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xDF, 0x07, 0xFE, 0x1F,
  0xF8, 0xF8, 0xF3, 0xC3, 0xCF, 0x0F, 0x38, 0x3C, 0xE0, 0xF3, 0x83, 0xDE,
  0x0E, 0x78, 0x39, 0xE0, 0xE7, 0x87, 0x9E, 0x3C, 0x7F, 0xF3, 0xFF, 0x8E,
  0x7C, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0x8F, 0x70, 0x77, 0x07, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0xE0, 0xEF, 0x1E, 0x7F,
  0xC7, 0xF8, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x83, 0xCE, 0x0F, 0xDC, 0x3F, 0xF8, 0xF1, 0xF1, 0xC1,
  0xE3, 0x83, 0xCF, 0x07, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xE0, 0xF1,
  0xC1, 0xE3, 0x83, 0x87, 0x8F, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0x38, 0x00,
  0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x8F, 0x78, 0x77, 0x07, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xF0, 0x4F, 0x0C, 0x7F, 0xE3, 0xFC,
  0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x3C, 0x1F, 0xE3,
  0xFC, 0x7F, 0x83, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x9C,
  0x1F, 0xB8, 0x7F, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x9E, 0x0E, 0x3C,
  0x1C, 0x78, 0x38, 0xE0, 0xF1, 0xC1, 0xE3, 0x83, 0xC7, 0x87, 0x0F, 0x1E,
  0x0F, 0xFC, 0x1F, 0xF8, 0x1E, 0xF0, 0x01, 0xE0, 0x03, 0x83, 0x0F, 0x0F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x77, 0x83, 0xFE, 0x1F, 0xF9, 0xE3, 0xCF, 0x0E,
  0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0x9C,
  0x1C, 0xE0, 0xE7, 0x0F, 0x78, 0x7B, 0xC3, 0xC0, 0x0E, 0x0E, 0x0E, 0x0E,
  0x00, 0x00, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x0F, 0x0F, 0xC3, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x0F, 0x0E, 0x3E, 0x1C,
  0xF8, 0x79, 0xE0, 0xF7, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xF3, 0x81, 0xC7, 0x83, 0x8F, 0x07, 0x0E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E,
  0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70,
  0x70, 0x70, 0xF0, 0x1D, 0xF1, 0xE0, 0xFF, 0x9F, 0x87, 0xFF, 0xFE, 0x78,
  0xF8, 0xF3, 0xC3, 0xC7, 0x9E, 0x1C, 0x3C, 0xE0, 0xE1, 0xE7, 0x0F, 0x0F,
  0x38, 0x78, 0x7B, 0xC3, 0xC3, 0x9E, 0x1C, 0x1C, 0xF0, 0xE0, 0xE7, 0x07,
  0x0F, 0x38, 0x78, 0x79, 0xC3, 0xC3, 0xDE, 0x1E, 0x1C, 0xF0, 0xE0, 0xE0,
  0x1D, 0xE0, 0xFF, 0xCF, 0xFE, 0x7C, 0xF3, 0xC3, 0x9C, 0x1C, 0xE0, 0xE7,
  0x07, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xE0, 0xE7, 0x07, 0x38, 0x3B, 0xC3,
  0xDE, 0x1E, 0xF0, 0xF0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x70, 0xE7, 0x87,
  0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEF,
  0x0F, 0x78, 0xF1, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x0E, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0xF8, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E, 0x0F, 0x1C,
  0x1E, 0x78, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x8F, 0x1F, 0xFE,
  0x3F, 0xF8, 0x7B, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x38, 0xFD, 0xCF, 0xFE, 0xF1, 0xF7, 0x07,
  0xB8, 0x3B, 0xC1, 0xDE, 0x0E, 0xE0, 0xF7, 0x07, 0xB8, 0x3D, 0xC1, 0xCE,
  0x0E, 0x78, 0xF3, 0xFF, 0x8F, 0xFC, 0x3D, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x1D, 0xC7, 0xF1, 0xFC, 0xFF, 0x3C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x07,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0xC7,
  0x9C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xEF,
  0x0F, 0x38, 0x71, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x1E, 0x1E, 0x1C, 0xFF,
  0xFF, 0xFF, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70,
  0x70, 0x7C, 0x7C, 0x3C, 0x38, 0x39, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7, 0x87,
  0xB8, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xF7, 0x87, 0xBC, 0x3D, 0xE1, 0xCF,
  0x0E, 0x78, 0xF3, 0xFF, 0x8F, 0xFC, 0x3D, 0xE0, 0xE0, 0xFE, 0x0E, 0xE1,
  0xEE, 0x1C, 0xE1, 0xCF, 0x3C, 0xF3, 0x87, 0x78, 0x77, 0x07, 0x70, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x03, 0x80, 0x38, 0x00, 0xE1, 0xC3,
  0xF8, 0x70, 0xEE, 0x1C, 0x3B, 0x8F, 0x1E, 0xE3, 0xC7, 0x39, 0xF1, 0xCE,
  0x7E, 0xF3, 0x9B, 0xB8, 0xEE, 0xEE, 0x3B, 0xBF, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xF8, 0xF8, 0x1E, 0x3E, 0x07, 0x87, 0x81, 0xC1, 0xC0, 0x70, 0x70,
  0x00, 0x1E, 0x1E, 0x3C, 0x78, 0x38, 0xE0, 0x73, 0xC0, 0xFF, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7F, 0x01,
  0xEE, 0x07, 0x9C, 0x0E, 0x3C, 0x3C, 0x78, 0xF0, 0x70, 0x1C, 0x1E, 0x38,
  0x38, 0x70, 0xF0, 0xE1, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0xBC, 0x07, 0x78,
  0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xCF, 0xFE, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x03, 0x80, 0x3C, 0x03, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x00, 0x81, 0xC1,
  0xE1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x87,
  0xC3, 0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x0E, 0x07, 0x00, 0x80, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x83,
  0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87,
  0x0E, 0x18, 0x30, 0x60, 0xC0, 0x0C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x0E, 0x0F, 0x0F,
  0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x1E, 0x1E,
  0x0E, 0x04, 0x00, 0x1E, 0x0E, 0x7E, 0x1D, 0xFE, 0x33, 0x9C, 0xE6, 0x1F,
  0xDC, 0x3F, 0x00, 0x1C, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 22, 8, 1, -22 },
  { 21, 9, 8, 10, 2, -23 },
  { 30, 15, 22, 16, 1, -22 },
  { 72, 14, 28, 15, 1, -25 },
  { 121, 14, 22, 19, 3, -22 },
  { 160, 15, 22, 17, 1, -22 },
  { 202, 4, 8, 5, 2, -23 },
  { 206, 10, 32, 10, 1, -25 },
  { 246, 9, 32, 10, -1, -25 },
  { 282, 12, 13, 13, 2, -22 },
  { 302, 13, 16, 15, 1, -18 },
  { 328, 6, 9, 7, -2, -4 },
  { 335, 7, 3, 9, 1, -11 },
  { 338, 4, 4, 8, 1, -4 },
  { 340, 14, 24, 11, -2, -22 },
  { 382, 13, 22, 15, 1, -22 },
  { 418, 9, 22, 15, 3, -22 },
  { 443, 14, 22, 15, 0, -22 },
  { 482, 13, 22, 15, 1, -22 },
  { 518, 14, 22, 15, 0, -22 },
  { 557, 14, 22, 15, 1, -22 },
  { 596, 13, 22, 15, 1, -22 },
  { 632, 14, 22, 15, 2, -22 },
  { 671, 13, 22, 15, 1, -22 },
  { 707, 12, 22, 15, 2, -22 },
  { 740, 6, 17, 8, 1, -17 },
  { 753, 8, 22, 7, -1, -17 },
  { 775, 12, 14, 13, 1, -17 },
  { 796, 13, 10, 15, 1, -15 },
  { 813, 12, 15, 14, 1, -17 },
  { 836, 11, 22, 13, 2, -22 },
  { 867, 21, 29, 23, 1, -22 },
  { 944, 17, 22, 18, -1, -22 },
  { 991, 16, 22, 17, 0, -22 },
  { 1035, 16, 22, 17, 1, -22 },
  { 1079, 16, 22, 17, 0, -22 },
  { 1123, 16, 22, 15, 0, -22 },
  { 1167, 16, 22, 14, 0, -22 },
  { 1211, 16, 22, 18, 1, -22 },
  { 1255, 19, 22, 19, 0, -22 },
  { 1308, 7, 22, 8, 1, -22 },
  { 1328, 15, 22, 15, 0, -22 },
  { 1370, 19, 22, 17, 0, -22 },
  { 1423, 12, 22, 14, 0, -22 },
  { 1456, 23, 22, 23, 0, -22 },
  { 1520, 19, 22, 19, 0, -22 },
  { 1573, 16, 22, 18, 1, -22 },
  { 1617, 17, 22, 17, 0, -22 },
  { 1664, 16, 26, 18, 1, -22 },
  { 1716, 16, 22, 16, 0, -22 },
  { 1760, 15, 22, 16, 1, -22 },
  { 1802, 14, 22, 16, 3, -22 },
  { 1841, 17, 22, 17, 1, -22 },
  { 1888, 16, 22, 17, 3, -22 },
  { 1932, 21, 22, 23, 3, -22 },
  { 1990, 19, 22, 17, -1, -22 },
  { 2043, 15, 22, 16, 3, -22 },
  { 2085, 17, 22, 16, 0, -22 },
  { 2132, 10, 30, 8, 0, -25 },
  { 2170, 6, 24, 11, 3, -22 },
  { 2188, 10, 30, 8, -2, -25 },
  { 2226, 10, 11, 11, 1, -22 },
  { 2240, 12, 3, 12, -2, 0 },
  { 2245, 6, 5, 10, 3, -24 },
  { 2249, 13, 17, 14, 0, -17 },
  { 2277, 14, 23, 15, 0, -23 },
  { 2318, 12, 17, 14, 1, -17 },
  { 2344, 15, 23, 15, 1, -23 },
  { 2388, 12, 17, 14, 1, -17 },
  { 2414, 11, 23, 10, 1, -23 },
  { 2446, 15, 23, 15, 0, -17 },
  { 2490, 13, 23, 15, 0, -23 },
  { 2528, 8, 23, 7, 0, -23 },
  { 2551, 10, 29, 7, -3, -23 },
  { 2588, 15, 23, 14, 0, -23 },
  { 2632, 8, 23, 7, 0, -23 },
  { 2655, 21, 17, 22, 0, -17 },
  { 2700, 13, 17, 15, 0, -17 },
  { 2728, 13, 17, 15, 1, -17 },
  { 2756, 15, 23, 15, -1, -17 },
  { 2800, 13, 23, 15, 1, -17 },
  { 2838, 10, 17, 10, 0, -17 },
  { 2860, 13, 17, 14, 0, -17 },
  { 2888, 8, 20, 9, 1, -20 },
  { 2908, 13, 17, 15, 1, -17 },
  { 2936, 12, 17, 13, 2, -17 },
  { 2962, 18, 17, 19, 2, -17 },
  { 3001, 15, 17, 13, -1, -17 },
  { 3033, 15, 23, 13, -1, -17 },
  { 3077, 13, 17, 13, 0, -17 },
  { 3105, 9, 29, 9, 1, -24 },
  { 3138, 7, 26, 8, 0, -22 },
  { 3161, 9, 30, 9, -1, -24 },
  { 3195, 15, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_MediumItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC31PT7B_H_
