#ifndef _ROBOTOCONDENSED_MEDIUMITALIC63PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF1, 0xF1, 0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E,
  0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xC1, 0xE1,
  0xE0, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x07, 0x80, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0,
  0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x07, 0x1F, 0x03, 0xE0, 0x3C, 0xF8, 0x1F, 0x03, 0xE7,
  0xC0, 0xF8, 0x3F, 0x3E, 0x07, 0xC1, 0xF1, 0xF0, 0x3E, 0x1F, 0x0F, 0x81,
  0xF1, 0xF0, 0x7C, 0x0F, 0x0F, 0x83, 0xE0, 0xF8, 0xF8, 0x1F, 0x07, 0xCF,
  0x80, 0xFC, 0x7C, 0x7C, 0x03, 0xFF, 0xE7, 0xC0, 0x1F, 0xFE, 0x7C, 0x00,
  0x7F, 0xE3, 0xE0, 0x01, 0xFE, 0x3E, 0x00, 0x01, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0xF9, 0xFF, 0xC0, 0x0F, 0x9F, 0xFE,
  0x00, 0x7C, 0xFF, 0xF8, 0x07, 0xCF, 0xC7, 0xC0, 0x7C, 0x7C, 0x1F, 0x03,
  0xE7, 0xC0, 0xF8, 0x3E, 0x3E, 0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x1F, 0x0F,
  0x81, 0xF1, 0xF0, 0x7C, 0x0F, 0x9F, 0x03, 0xE0, 0x7C, 0xF8, 0x1F, 0x07,
  0xCF, 0x80, 0xF8, 0x3E, 0x78, 0x07, 0xC1, 0xF0, 0xC0, 0x3F, 0x1F, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x01, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC1, 0xFC, 0x3F,
  0xFF, 0x83, 0xF0, 0xFF, 0x7F, 0x87, 0xE3, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0,
  0xFF, 0x1F, 0x9F, 0xE0, 0xFE, 0x7E, 0x3F, 0x81, 0xFE, 0xFC, 0x7F, 0x01,
  0xFF, 0xF8, 0xFE, 0x03, 0xFF, 0xE1, 0xFC, 0x03, 0xFF, 0xC7, 0xF8, 0x07,
  0xFF, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F,
  0xF0, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x7F,
  0x80, 0x7F, 0xF0, 0x7F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1F,
  0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x80, 0x3C, 0x02, 0x3C, 0x0F, 0x03, 0x9F, 0xC7,
  0xC7, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xC7,
  0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x1E,
  0x01, 0xF0, 0x03, 0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0x80, 0x18, 0x00, 0x7F, 0xFE, 0xFF,
  0xFD, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x1E, 0x1F, 0x9F,
  0xEF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x08, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xEF, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0x83,
  0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F,
  0xC7, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80,
  0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x3F, 0xBF, 0xC0, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F,
  0x81, 0xFC, 0x1F, 0xE0, 0x7F, 0xDF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xC7, 0xF3, 0xC1, 0xFC, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0xC0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xDF, 0xC0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF3,
  0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F,
  0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xBF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0x0F, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x3F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0xFF, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x1F, 0xE0, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0xC0,
  0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF3, 0xF8,
  0x03, 0xF9, 0xFC, 0x03, 0xFC, 0xFF, 0x03, 0xFE, 0x7F, 0x83, 0xFE, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x3F, 0xEF, 0xE0, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0xFE, 0x07, 0xF8, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x01, 0xF0,
  0x02, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x20, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xE0, 0xFE, 0xFF, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xC0,
  0xFC, 0x03, 0xFF, 0x80, 0x78, 0x1F, 0x00, 0xFF, 0xF8, 0x0F, 0x07, 0xE0,
  0x3F, 0xFF, 0x81, 0xE0, 0xF8, 0x0F, 0xFF, 0xF0, 0x3C, 0x3F, 0x01, 0xF8,
  0x3E, 0x07, 0x87, 0xC0, 0x7E, 0x07, 0xC0, 0xF0, 0xF8, 0x1F, 0x81, 0xF0,
  0x1E, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC7, 0xC0, 0xFC, 0x07, 0xC0, 0x78,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xE7, 0xC0,
  0xFC, 0x07, 0xC0, 0x3C, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0x9F, 0x03, 0xE0,
  0x1F, 0x01, 0xF7, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0xF8, 0x1F, 0x80, 0xF8,
  0x07, 0xDF, 0x03, 0xF0, 0x1F, 0x00, 0xF3, 0xE0, 0x7C, 0x03, 0xE0, 0x1E,
  0x7C, 0x0F, 0x80, 0xFC, 0x07, 0xCF, 0x81, 0xF0, 0x1F, 0x00, 0xF1, 0xF0,
  0x7E, 0x03, 0xE0, 0x1E, 0x3C, 0x0F, 0xC0, 0x7C, 0x07, 0xC7, 0x81, 0xF8,
  0x1F, 0x80, 0xF1, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x1E, 0x03, 0xF0, 0xFE,
  0x07, 0x83, 0xC0, 0x7F, 0x3F, 0xC1, 0xF0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0x81, 0xFF, 0xCF, 0xFF, 0x01, 0xF0, 0x1F, 0xF1, 0xFF, 0xC0, 0x3E,
  0x01, 0xFC, 0x1F, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x20, 0x00, 0x00,
  0x7F, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x1F, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFE,
  0x1F, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0xC0,
  0x7F, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x7F,
  0x00, 0xFF, 0xFC, 0x7F, 0x00, 0xFF, 0xFC, 0xFF, 0x01, 0xFF, 0xFC, 0xFF,
  0x01, 0xFF, 0xFC, 0xFE, 0x01, 0xFF, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x00,
  0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0xFE,
  0x07, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x1F, 0xC3, 0xFE, 0x00, 0x00, 0xFE, 0x3F,
  0xE0, 0x00, 0x07, 0xF3, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x7F, 0x00, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x01, 0xFF, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0x7C, 0x00, 0x3F, 0x7E, 0x01, 0xFD,
  0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xF7, 0xE0, 0x07, 0xEF, 0xE0, 0x1F, 0x9F,
  0x80, 0x3F, 0xBF, 0x80, 0xFE, 0x7E, 0x00, 0xFC, 0xFE, 0x03, 0xF9, 0xF8,
  0x07, 0xF7, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x9F, 0x80,
  0xFE, 0x7F, 0x00, 0xFE, 0x3E, 0x03, 0xF1, 0xFC, 0x03, 0xF8, 0xF8, 0x0F,
  0xC7, 0xF0, 0x1F, 0xC3, 0xF0, 0x7E, 0x3F, 0xC0, 0x7F, 0x0F, 0xC1, 0xF8,
  0xFE, 0x01, 0xFC, 0x3F, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x3F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xC7, 0xE1, 0xFE,
  0x03, 0xFC, 0x1F, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0x7C, 0xFC, 0x1F, 0xC0,
  0x3F, 0x81, 0xF7, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x03,
  0xF8, 0x1F, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFF, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0xF0, 0x00, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xFE, 0x00,
  0x7F, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xC0, 0x7F,
  0xFC, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xDF, 0x80, 0x7F,
  0x80, 0xFE, 0x7C, 0x03, 0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xC0, 0x3F, 0x9F,
  0x80, 0xFE, 0x03, 0xFC, 0xFC, 0x07, 0xF0, 0x1F, 0xE3, 0xE0, 0x7F, 0x80,
  0xFE, 0x1F, 0x83, 0xFC, 0x07, 0xF0, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xE0,
  0xFE, 0x01, 0xFC, 0x1F, 0x87, 0xF0, 0x1F, 0xE0, 0xFC, 0x3F, 0x80, 0xFF,
  0x07, 0xE3, 0xFC, 0x07, 0xF0, 0x1F, 0x9F, 0xE0, 0x3F, 0x80, 0xFC, 0xFE,
  0x01, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0xE0, 0x1F, 0x3F, 0x80, 0xFF, 0x00,
  0xFD, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xFF, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x3F,
  0xFC, 0x07, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x07, 0xFF, 0x01, 0xFC,
  0x00, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F,
  0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8,
  0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x0D, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFC,
  0x07, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x0F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xFC, 0x0F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80,
  0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xE0,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x03,
  0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFB, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xF8,
  0x03, 0xF9, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xE0, 0x0F,
  0xE7, 0xF0, 0x07, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0x1F,
  0xC0, 0x3F, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFF, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xFF,
  0x03, 0xF8, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0xFC, 0x0F,
  0xE0, 0xFE, 0x0F, 0xDF, 0x83, 0xF8, 0x1F, 0xC1, 0xFB, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0x7E, 0x0F, 0xE0, 0x7F, 0x0F, 0xC7, 0xC3, 0xF8, 0x0F, 0xE1,
  0xF8, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x1F, 0x0F, 0xE0, 0x3F, 0x8F, 0xC3,
  0xE1, 0xF8, 0x03, 0xF1, 0xF8, 0x7C, 0x7F, 0x00, 0x7E, 0x3F, 0x0F, 0x8F,
  0xE0, 0x0F, 0xCF, 0xC1, 0xF1, 0xF8, 0x01, 0xF9, 0xF8, 0x3E, 0x7F, 0x00,
  0x3F, 0x3E, 0x07, 0xCF, 0xE0, 0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x00, 0xFD,
  0xF8, 0x1F, 0xFF, 0x00, 0x1F, 0xBE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0x80, 0x07,
  0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x3F,
  0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0,
  0x3E, 0x7C, 0x07, 0xE3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E,
  0x1F, 0x83, 0xE1, 0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x7E, 0x03,
  0xF7, 0xE0, 0x1F, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x7F, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFE, 0x1F,
  0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC7, 0xFC, 0x0F, 0xE7, 0xF8, 0x07, 0xF3, 0xFC, 0x07, 0xF1, 0xFC, 0x03,
  0xF9, 0xFE, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80,
  0x7F, 0x9F, 0xE0, 0x7F, 0x8F, 0xFD, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFD, 0xFC, 0x07, 0xFC, 0xFF, 0x00,
  0x20, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x81, 0x00, 0x03, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0,
  0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F,
  0xE0, 0x7F, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xE0, 0x7E, 0x7F, 0xFC, 0x07, 0xE3, 0xFF, 0x80, 0xFE, 0x1F, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xE7,
  0xFC, 0x3F, 0xC0, 0xFE, 0x3F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0,
  0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xFE, 0xFF, 0x83, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF8,
  0xFE, 0x00, 0xFF, 0xF3, 0xF8, 0x07, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xBF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xF7, 0xF0, 0x00, 0xFF, 0x9F,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x08, 0x3F, 0xC0, 0x0C, 0x0F, 0xF0, 0x1F, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFC, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xFF, 0x87, 0xF0, 0x07, 0xFF, 0x1F, 0x80, 0x7F, 0xFE, 0x7E, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFE, 0x07,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F,
  0xF9, 0xFC, 0x00, 0x02, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x02, 0x00, 0x1F, 0xE0, 0x0E, 0x00, 0xFF,
  0x00, 0x7C, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x78, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0xC0,
  0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0x80, 0x7F,
  0x07, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC7,
  0xF8, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF9, 0xFF, 0x00, 0x0F, 0xEF, 0xF8,
  0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xC0, 0x03, 0xFE,
  0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC,
  0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x7F,
  0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xDF, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xFF,
  0xC7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFE,
  0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x3F, 0xE0, 0x0F, 0xDF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xC0, 0xFF, 0x07,
  0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF1,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x07, 0xF3,
  0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF1, 0xFE, 0x00, 0x0F, 0xDF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFF,
  0x00, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xFE, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xF7, 0xFF, 0xC0, 0x1F, 0xCF, 0xFE,
  0x00, 0xFE, 0x1F, 0xF0, 0x03, 0xF8, 0x0C, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0xFC, 0x0F, 0xFF, 0x1F, 0x83, 0xFF, 0xF7, 0xF0, 0xFF, 0xFE, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF8, 0x7F, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xFC, 0x01, 0xFF, 0x3F,
  0x80, 0x02, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xDF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xE3,
  0xFC, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x7F,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x80, 0x00, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F,
  0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xEF, 0xC0, 0x0F,
  0xF9, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xBF, 0x80, 0x3F,
  0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07,
  0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x9F, 0xC0, 0x0F,
  0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00,
  0xFD, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xC0, 0x3F, 0xBF,
  0x80, 0xFE, 0x01, 0xFD, 0xFC, 0x07, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x80,
  0xFE, 0x7F, 0x03, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xE0, 0x7F, 0x1F, 0xC1,
  0xFF, 0x03, 0xF8, 0xFE, 0x0F, 0xF8, 0x1F, 0x87, 0xF0, 0xFF, 0xC1, 0xFC,
  0x3F, 0x87, 0xFE, 0x0F, 0xC1, 0xFC, 0x3F, 0xF0, 0xFE, 0x0F, 0xE3, 0xFF,
  0xC7, 0xF0, 0x3F, 0x1F, 0x7E, 0x3F, 0x01, 0xF9, 0xFB, 0xF3, 0xF8, 0x0F,
  0xCF, 0xDF, 0x9F, 0x80, 0x7E, 0xFC, 0xFC, 0xFC, 0x03, 0xF7, 0xE3, 0xEF,
  0xE0, 0x1F, 0xBE, 0x1F, 0x7E, 0x00, 0xFF, 0xF0, 0xFB, 0xF0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0xC0,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F,
  0x03, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x7F, 0x80, 0x01, 0xFD, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFF, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00,
  0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x7E, 0x0F, 0xE0,
  0x01, 0xF8, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xC7, 0xFF, 0x80, 0x3E, 0x3F,
  0xFE, 0x03, 0xF3, 0xFF, 0xF8, 0x1F, 0xBF, 0xFF, 0xC1, 0xF9, 0xFC, 0xFF,
  0x9F, 0xCF, 0xC1, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFE,
  0x3E, 0x00, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 46, 16, 1, -45 },
  { 88, 17, 16, 20, 5, -47 },
  { 122, 31, 45, 33, 2, -45 },
  { 297, 28, 60, 31, 2, -53 },
  { 507, 29, 47, 39, 6, -46 },
  { 678, 31, 47, 34, 1, -46 },
  { 861, 8, 16, 10, 4, -47 },
  { 877, 19, 64, 19, 3, -50 },
  { 1029, 19, 64, 20, -3, -50 },
  { 1181, 26, 27, 27, 3, -45 },
  { 1269, 26, 32, 30, 2, -37 },
  { 1373, 13, 17, 14, -4, -7 },
  { 1401, 15, 6, 19, 2, -22 },
  { 1413, 9, 9, 17, 1, -8 },
  { 1424, 29, 49, 21, -4, -45 },
  { 1602, 26, 47, 31, 3, -46 },
  { 1755, 18, 45, 31, 7, -45 },
  { 1857, 29, 46, 31, 0, -46 },
  { 2024, 28, 47, 31, 1, -46 },
  { 2189, 28, 45, 31, 1, -45 },
  { 2347, 29, 46, 31, 2, -45 },
  { 2514, 25, 46, 31, 3, -45 },
  { 2658, 29, 45, 31, 3, -45 },
  { 2822, 27, 47, 31, 2, -46 },
  { 2981, 25, 46, 31, 4, -46 },
  { 3125, 13, 35, 16, 1, -34 },
  { 3182, 17, 44, 14, -3, -34 },
  { 3276, 24, 29, 27, 2, -34 },
  { 3363, 25, 19, 30, 3, -30 },
  { 3423, 25, 29, 28, 1, -34 },
  { 3514, 22, 47, 27, 5, -46 },
  { 3644, 43, 58, 47, 1, -44 },
  { 3956, 34, 45, 36, -2, -45 },
  { 4148, 32, 45, 34, 1, -45 },
  { 4328, 32, 47, 35, 3, -46 },
  { 4516, 32, 45, 35, 1, -45 },
  { 4696, 32, 45, 30, 1, -45 },
  { 4876, 31, 45, 29, 1, -45 },
  { 5051, 32, 47, 36, 3, -46 },
  { 5239, 37, 45, 38, 1, -45 },
  { 5448, 15, 45, 16, 1, -45 },
  { 5533, 31, 46, 30, 0, -45 },
  { 5712, 37, 45, 34, 1, -45 },
  { 5921, 24, 45, 29, 1, -45 },
  { 6056, 46, 45, 46, 1, -45 },
  { 6315, 37, 45, 38, 1, -45 },
  { 6524, 32, 47, 37, 3, -46 },
  { 6712, 33, 45, 34, 1, -45 },
  { 6898, 32, 54, 37, 3, -46 },
  { 7114, 32, 45, 33, 1, -45 },
  { 7294, 32, 47, 32, 1, -46 },
  { 7482, 31, 45, 33, 5, -45 },
  { 7657, 34, 46, 35, 2, -45 },
  { 7853, 33, 45, 35, 5, -45 },
  { 8039, 43, 45, 46, 6, -45 },
  { 8281, 39, 45, 34, -2, -45 },
  { 8501, 32, 45, 33, 5, -45 },
  { 8681, 35, 45, 32, -1, -45 },
  { 8878, 21, 62, 16, -1, -52 },
  { 9041, 13, 49, 23, 6, -45 },
  { 9121, 21, 62, 16, -4, -52 },
  { 9284, 20, 22, 23, 2, -45 },
  { 9339, 25, 6, 25, -4, 0 },
  { 9358, 13, 9, 20, 6, -47 },
  { 9373, 25, 35, 29, 1, -34 },
  { 9483, 28, 48, 30, 0, -47 },
  { 9651, 25, 35, 28, 2, -34 },
  { 9761, 30, 48, 30, 2, -47 },
  { 9941, 25, 35, 29, 2, -34 },
  { 10051, 22, 48, 20, 2, -48 },
  { 10183, 30, 47, 30, 0, -34 },
  { 10360, 27, 47, 30, 0, -47 },
  { 10519, 14, 46, 15, 1, -46 },
  { 10600, 21, 59, 14, -6, -46 },
  { 10755, 30, 47, 28, 0, -47 },
  { 10932, 15, 47, 15, 1, -47 },
  { 11021, 43, 34, 46, 0, -34 },
  { 11204, 27, 34, 30, 0, -34 },
  { 11319, 26, 35, 31, 2, -34 },
  { 11433, 30, 47, 30, -2, -34 },
  { 11610, 27, 47, 30, 2, -34 },
  { 11769, 21, 34, 19, 0, -34 },
  { 11859, 25, 35, 28, 1, -34 },
  { 11969, 17, 42, 18, 2, -41 },
  { 12059, 27, 34, 30, 2, -33 },
  { 12174, 25, 33, 27, 3, -33 },
  { 12278, 37, 33, 39, 4, -33 },
  { 12431, 30, 33, 27, -2, -33 },
  { 12555, 30, 46, 26, -2, -33 },
  { 12728, 28, 33, 27, -1, -33 },
  { 12844, 19, 60, 18, 2, -49 },
  { 12987, 13, 53, 15, 1, -45 },
  { 13074, 20, 60, 18, -3, -49 },
  { 13224, 29, 13, 35, 3, -25 },
};

const GFXfont RobotoCondensed_MediumItalic63pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic63pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic63pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC63PT7B_H_
