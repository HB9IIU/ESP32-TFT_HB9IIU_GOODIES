#ifndef _ROBOTOCONDENSED_MEDIUMITALIC67PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x38, 0x00, 0x1F, 0x0F, 0xC7,
  0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0xC3, 0xE3, 0xE1,
  0xF8, 0xF8, 0x7E, 0x7E, 0x1F, 0x1F, 0x87, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x07,
  0xF0, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xE1, 0xFC,
  0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x1C, 0x3E, 0x07, 0xC0, 0x3C, 0x7C, 0x0F, 0x80, 0xF9,
  0xF8, 0x1F, 0x03, 0xF3, 0xE0, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x1F, 0x0F,
  0x80, 0xF8, 0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x3E, 0x07, 0xE3, 0xE0, 0x7C,
  0x0F, 0x8F, 0xC0, 0x7C, 0x3F, 0x1F, 0x00, 0xFF, 0xFE, 0x7C, 0x01, 0xFF,
  0xF9, 0xF8, 0x01, 0xFF, 0xE3, 0xE0, 0x01, 0xFF, 0x8F, 0x80, 0x01, 0xFE,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x07, 0xC7, 0xFE, 0x00, 0x1F, 0x9F,
  0xFE, 0x00, 0x3E, 0x7F, 0xFE, 0x00, 0xF8, 0xFF, 0xFC, 0x03, 0xF3, 0xF0,
  0xFC, 0x07, 0xC7, 0xC0, 0xF8, 0x1F, 0x1F, 0x81, 0xF0, 0x7E, 0x3F, 0x03,
  0xE1, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0xF8, 0x0F, 0x8F, 0xC1, 0xF0, 0x1F,
  0x3F, 0x03, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0xFD, 0xF8, 0x0F, 0x81, 0xF1,
  0xE0, 0x1F, 0x87, 0xE1, 0x80, 0x1F, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0xFE, 0x07, 0xE0, 0xFF,
  0xFF, 0x83, 0xF0, 0xFF, 0xBF, 0xC3, 0xF8, 0x7F, 0x8F, 0xF1, 0xFC, 0x7F,
  0x87, 0xF8, 0xFE, 0x3F, 0x81, 0xFE, 0x7E, 0x3F, 0xC0, 0xFF, 0x7F, 0x1F,
  0xE0, 0x3F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0x87, 0xF0, 0x07, 0xFF, 0xC3,
  0xF8, 0x03, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xE3, 0xFC, 0x01, 0xFF, 0xC1,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x3C, 0x07, 0x80, 0xE3, 0xF0, 0xF8, 0x7E, 0x7F, 0xCF, 0x9F, 0xE7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFE,
  0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF0, 0x0F, 0x80, 0x06, 0x00, 0x70, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0xFE, 0x01, 0xE0, 0x02, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x3E, 0x3F, 0xBF, 0xDF, 0xEF, 0xFF, 0xFB,
  0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x0F, 0xF3, 0xF8, 0x00, 0xFE,
  0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF0,
  0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x1F,
  0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xF7, 0xFB, 0xE1, 0xFC, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x03,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x87, 0xF0,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFE,
  0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFE,
  0x07, 0xF0, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFC,
  0x7F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x0E, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xC0, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x07, 0xF7, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3,
  0xFF, 0x9F, 0xF9, 0xFF, 0x81, 0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F,
  0xF7, 0xF8, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xDF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x80,
  0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE,
  0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x03,
  0xFC, 0x1F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8,
  0x3F, 0x80, 0x3F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x81, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x00,
  0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xFC,
  0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF0, 0xFF,
  0x00, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F,
  0x83, 0xFC, 0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xE7, 0xF8, 0x03, 0xF9,
  0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03,
  0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0,
  0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xEF,
  0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x7F,
  0xC7, 0xFC, 0x7F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFB, 0xF8, 0x03, 0xF1, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x1C, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x04, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xC1,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x78, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0xFF, 0xE0,
  0x1F, 0x07, 0xE0, 0x0F, 0xFF, 0x80, 0xF8, 0x3E, 0x00, 0xFF, 0xFE, 0x07,
  0xC3, 0xF0, 0x0F, 0xFF, 0xF0, 0x1E, 0x1F, 0x00, 0xFE, 0x0F, 0x80, 0xF1,
  0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0x8F, 0xC0, 0x7E, 0x07, 0xE0, 0x3C, 0x7C,
  0x07, 0xE0, 0x3E, 0x01, 0xE7, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xF9, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xDF, 0x81, 0xF8,
  0x07, 0xE0, 0x3E, 0xFC, 0x0F, 0xC0, 0x3E, 0x01, 0xF7, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0xBE, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xF0, 0x3F, 0x00, 0xFC,
  0x03, 0xDF, 0x81, 0xF8, 0x07, 0xC0, 0x1E, 0xF8, 0x0F, 0xC0, 0x3E, 0x01,
  0xF7, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xBE, 0x07, 0xF0, 0x1F, 0x80, 0x7D,
  0xF0, 0x3F, 0x00, 0xF8, 0x03, 0xCF, 0x81, 0xF8, 0x07, 0xC0, 0x3E, 0x7C,
  0x0F, 0xC0, 0x7E, 0x01, 0xF3, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x1F, 0x03,
  0xF0, 0x3F, 0x80, 0xF8, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0x87, 0xC0, 0x7E,
  0x1F, 0xE0, 0x7C, 0x3E, 0x03, 0xFF, 0xFF, 0x0F, 0xC1, 0xF0, 0x1F, 0xFE,
  0xFF, 0xFC, 0x0F, 0x80, 0xFF, 0xF7, 0xFF, 0xC0, 0x7C, 0x03, 0xFF, 0x1F,
  0xFC, 0x03, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x03, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0x80, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xF1,
  0xFE, 0x01, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xFF, 0x3F, 0xC0, 0x3F, 0xFF,
  0xCF, 0xF0, 0x0F, 0xFF, 0xF3, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x01,
  0xFF, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0x83,
  0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xE7,
  0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xEF, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xE0, 0x00, 0x07, 0xFE, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFB, 0xF8, 0x07, 0xF3, 0xF0, 0x01, 0xFD, 0xFC, 0x03, 0xF9, 0xF8, 0x00,
  0xFC, 0xFE, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0x7E, 0x00,
  0x7F, 0x7F, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0x80,
  0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF0,
  0x1F, 0xCF, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xC7, 0xF8, 0x07, 0xF0, 0xFC,
  0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7E, 0x07, 0xE1, 0xFC, 0x03, 0xFC, 0x3F,
  0x07, 0xF1, 0xFE, 0x01, 0xFE, 0x1F, 0x83, 0xF0, 0xFF, 0x00, 0xFF, 0x0F,
  0xC3, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xE1, 0xF8, 0x3F, 0x80, 0x3F, 0x83,
  0xF1, 0xFC, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0,
  0x7E, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x7E, 0x07, 0xF8, 0x07, 0xF8,
  0x1F, 0xBF, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xFF, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFE,
  0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x03,
  0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xF8, 0x07, 0xFB, 0xF0,
  0x07, 0xF8, 0x07, 0xFB, 0xF8, 0x07, 0xF8, 0x07, 0xF9, 0xF8, 0x07, 0xF8,
  0x07, 0xF9, 0xF8, 0x07, 0xF0, 0x07, 0xF9, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7E, 0x0F, 0xE0, 0x0F,
  0xF0, 0x7E, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x1F, 0xC0,
  0x1F, 0xE0, 0x1F, 0x9F, 0xC0, 0x1F, 0xE0, 0x1F, 0xBF, 0xC0, 0x1F, 0xC0,
  0x1F, 0xBF, 0xC0, 0x3F, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x07, 0xF3, 0xFC,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF,
  0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8,
  0x0F, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03, 0xFE, 0x7F,
  0x80, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x87, 0xF8, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xCF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0x87,
  0xF0, 0x0F, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xF8, 0x07, 0xF0, 0x7F,
  0x01, 0xFF, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x07, 0xF0,
  0x1F, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0x03,
  0xF7, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xDF, 0x81, 0xFC, 0x07, 0xF0, 0x7F,
  0x7E, 0x0F, 0xF0, 0x1F, 0xC1, 0xF9, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xE7,
  0xE0, 0xFE, 0x01, 0xFC, 0x3F, 0x9F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x7E,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF1, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0x87, 0xE1,
  0xFC, 0x01, 0xFC, 0x7E, 0x1F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x7E, 0x3F,
  0x80, 0x1F, 0xCF, 0xC1, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x03, 0xE7, 0xF0,
  0x01, 0xFD, 0xFC, 0x0F, 0x9F, 0xC0, 0x07, 0xF7, 0xE0, 0x3F, 0x7F, 0x00,
  0x1F, 0xDF, 0x80, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x00, 0x03, 0xFB, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x3F,
  0xE7, 0xF0, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xBE, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x1F,
  0x01, 0xF8, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFC, 0x07, 0xE7, 0xF0, 0x0F, 0x9F, 0x80,
  0x3F, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0x9F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x3F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0x83,
  0xF8, 0x7F, 0xC0, 0x7F, 0x1F, 0xE0, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F,
  0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0x8F, 0xF0, 0x0F, 0xF1, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFB, 0xFC,
  0x07, 0xFE, 0x3F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xC3, 0xC0, 0x00, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00,
  0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0,
  0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F,
  0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFE, 0x01, 0xFE,
  0x1F, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07,
  0xF7, 0xFF, 0xF8, 0x1F, 0xCF, 0xFF, 0xC0, 0x7F, 0x3F, 0xFE, 0x03, 0xF8,
  0x7F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFE, 0x1F, 0xE0,
  0x1F, 0xC7, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7,
  0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8,
  0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0x03, 0xF8,
  0x00, 0xFF, 0xC3, 0xF8, 0x01, 0xFF, 0xE7, 0xF8, 0x03, 0xFF, 0xF7, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFE, 0xFE, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00,
  0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x04, 0x07, 0xF8,
  0x01, 0xC0, 0xFF, 0x80, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0xFC, 0x01, 0xFF,
  0xF3, 0xF8, 0x07, 0xFF, 0xF7, 0xF0, 0x1F, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x07,
  0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x03, 0xC3,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x60, 0x01, 0xFE, 0x00, 0xF0, 0x07, 0xFC,
  0x03, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x7F,
  0xBF, 0xF0, 0x03, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x7F,
  0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE,
  0x1F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC, 0x3F,
  0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00,
  0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x10, 0x00, 0xF8, 0x03, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xFE,
  0x03, 0xF8, 0x0F, 0xFC, 0x03, 0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x1F, 0xF0,
  0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80,
  0x07, 0xF1, 0xFF, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x07, 0xF3, 0xFE, 0x00,
  0x0F, 0xF7, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x3F, 0x81, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0xCF,
  0xFC, 0x07, 0xFE, 0x00, 0xFE, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xCF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xE0, 0x1F,
  0xC1, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x87, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x03,
  0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xE1, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x01,
  0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0xFE,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xFC,
  0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x01, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF0, 0x7F,
  0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x00,
  0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0,
  0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x3F,
  0xC7, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x3F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x7F, 0xE0, 0x00, 0xFE, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xE0,
  0x1F, 0xDF, 0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0x80, 0x3F, 0xC7, 0xFE, 0x00,
  0x3F, 0xC0, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xFE, 0x1F, 0xC0, 0x7F, 0xF8, 0xFE, 0x07, 0xFF, 0xE7, 0xF0, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFE, 0x07,
  0xFE, 0x1F, 0xE0, 0x1F, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC,
  0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF1, 0xFC,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xC7, 0xF8, 0x00,
  0xFE, 0x3F, 0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFC,
  0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFE,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xF9, 0xFC, 0x00, 0x0F, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x1F,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x3F,
  0x80, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F,
  0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x1F, 0xF1, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x1F, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xE0, 0x00,
  0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80,
  0x3F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xF7, 0xF0, 0x03, 0xFF, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xE1, 0xFC, 0x07,
  0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFF, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC,
  0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xF0, 0x07, 0xF7, 0xF0, 0x0F, 0xE0, 0x1F,
  0xEF, 0xE0, 0x1F, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0xC0, 0x7F, 0x3F, 0x80,
  0xFF, 0x81, 0xFE, 0x7F, 0x03, 0xFF, 0x03, 0xF8, 0x7E, 0x07, 0xFE, 0x07,
  0xF0, 0xFC, 0x0F, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0xF8, 0x3F, 0x83, 0xF0,
  0x7F, 0xF0, 0x7F, 0x07, 0xE1, 0xFF, 0xE1, 0xFC, 0x0F, 0xC3, 0xFF, 0xC3,
  0xF8, 0x1F, 0x87, 0xEF, 0x87, 0xE0, 0x3F, 0x1F, 0x9F, 0x1F, 0xC0, 0x7E,
  0x3F, 0x3E, 0x3F, 0x80, 0xFC, 0xFC, 0x7C, 0xFE, 0x01, 0xF9, 0xF8, 0xFD,
  0xFC, 0x03, 0xF7, 0xE1, 0xFB, 0xF0, 0x07, 0xEF, 0xC3, 0xFF, 0xE0, 0x0F,
  0xDF, 0x87, 0xFF, 0xC0, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x1F,
  0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF0,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80,
  0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF8,
  0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x01, 0xFC, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFC, 0x7F, 0x80,
  0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0xFF, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x7C,
  0x3F, 0xFC, 0x00, 0xF8, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFC, 0x07, 0xE7,
  0xFF, 0xF8, 0x1F, 0x9F, 0xFF, 0xF8, 0x3F, 0x3F, 0x87, 0xFF, 0xFE, 0x7E,
  0x07, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xC7, 0xE0,
  0x07, 0xFF, 0x0F, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph RobotoCondensed_MediumItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 49, 16, 2, -48 },
  { 93, 18, 17, 21, 5, -50 },
  { 132, 34, 48, 35, 2, -48 },
  { 336, 29, 63, 33, 2, -56 },
  { 565, 31, 50, 41, 6, -49 },
  { 759, 33, 50, 37, 1, -49 },
  { 966, 8, 17, 11, 5, -50 },
  { 983, 21, 68, 21, 3, -53 },
  { 1162, 21, 68, 21, -3, -53 },
  { 1341, 28, 28, 29, 3, -48 },
  { 1439, 28, 34, 32, 2, -39 },
  { 1558, 13, 19, 14, -4, -8 },
  { 1589, 16, 6, 20, 2, -23 },
  { 1601, 9, 9, 18, 2, -8 },
  { 1612, 30, 52, 23, -4, -48 },
  { 1807, 28, 50, 33, 3, -49 },
  { 1982, 18, 48, 33, 8, -48 },
  { 2090, 31, 49, 33, 0, -49 },
  { 2280, 30, 50, 33, 1, -49 },
  { 2468, 30, 48, 33, 1, -48 },
  { 2648, 30, 49, 33, 3, -48 },
  { 2832, 26, 49, 33, 3, -48 },
  { 2992, 31, 48, 33, 3, -48 },
  { 3178, 29, 50, 33, 2, -49 },
  { 3360, 26, 49, 33, 5, -49 },
  { 3520, 14, 37, 17, 1, -36 },
  { 3585, 18, 47, 15, -3, -36 },
  { 3691, 26, 30, 29, 2, -36 },
  { 3789, 27, 21, 32, 3, -32 },
  { 3860, 26, 31, 30, 2, -36 },
  { 3961, 24, 50, 28, 5, -49 },
  { 4111, 45, 62, 50, 2, -47 },
  { 4460, 37, 48, 38, -3, -48 },
  { 4682, 34, 48, 36, 1, -48 },
  { 4886, 34, 50, 37, 3, -49 },
  { 5099, 34, 48, 37, 1, -48 },
  { 5303, 34, 48, 32, 1, -48 },
  { 5507, 33, 48, 31, 1, -48 },
  { 5705, 34, 50, 38, 3, -49 },
  { 5918, 40, 48, 40, 1, -48 },
  { 6158, 16, 48, 17, 1, -48 },
  { 6254, 32, 49, 32, 0, -48 },
  { 6450, 39, 48, 36, 1, -48 },
  { 6684, 26, 48, 31, 1, -48 },
  { 6840, 49, 48, 49, 1, -48 },
  { 7134, 40, 48, 40, 1, -48 },
  { 7374, 34, 50, 39, 3, -49 },
  { 7587, 36, 48, 37, 1, -48 },
  { 7803, 34, 57, 39, 3, -49 },
  { 8046, 34, 48, 35, 1, -48 },
  { 8250, 34, 50, 34, 1, -49 },
  { 8463, 33, 48, 35, 5, -48 },
  { 8661, 36, 49, 37, 2, -48 },
  { 8882, 36, 48, 37, 5, -48 },
  { 9098, 46, 48, 49, 6, -48 },
  { 9374, 41, 48, 36, -2, -48 },
  { 9620, 33, 48, 35, 6, -48 },
  { 9818, 37, 48, 34, -1, -48 },
  { 10040, 22, 66, 17, -1, -55 },
  { 10222, 14, 52, 24, 6, -48 },
  { 10313, 22, 66, 17, -4, -55 },
  { 10495, 22, 24, 25, 2, -48 },
  { 10561, 26, 6, 26, -4, 0 },
  { 10581, 13, 10, 21, 7, -50 },
  { 10598, 27, 37, 31, 1, -36 },
  { 10723, 30, 51, 32, 0, -50 },
  { 10915, 27, 37, 30, 2, -36 },
  { 11040, 32, 51, 32, 2, -50 },
  { 11244, 27, 37, 31, 2, -36 },
  { 11369, 22, 51, 21, 3, -51 },
  { 11510, 31, 50, 32, 0, -36 },
  { 11704, 29, 50, 32, 0, -50 },
  { 11886, 15, 49, 16, 1, -49 },
  { 11978, 23, 63, 15, -7, -49 },
  { 12160, 32, 50, 30, 0, -50 },
  { 12360, 16, 50, 16, 1, -50 },
  { 12460, 45, 36, 49, 0, -36 },
  { 12663, 29, 36, 32, 0, -36 },
  { 12794, 28, 37, 32, 2, -36 },
  { 12924, 32, 50, 32, -2, -36 },
  { 13124, 29, 50, 32, 2, -36 },
  { 13306, 22, 36, 21, 0, -36 },
  { 13405, 27, 37, 30, 1, -36 },
  { 13530, 18, 45, 20, 2, -44 },
  { 13632, 29, 36, 32, 2, -35 },
  { 13763, 26, 35, 29, 4, -35 },
  { 13877, 39, 35, 42, 4, -35 },
  { 14048, 32, 35, 29, -2, -35 },
  { 14188, 32, 49, 28, -2, -35 },
  { 14384, 30, 35, 29, -1, -35 },
  { 14516, 20, 64, 20, 2, -52 },
  { 14676, 14, 57, 16, 1, -48 },
  { 14776, 21, 64, 20, -3, -52 },
  { 14944, 31, 14, 37, 3, -27 },
};

const GFXfont RobotoCondensed_MediumItalic67pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic67pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic67pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC67PT7B_H_
