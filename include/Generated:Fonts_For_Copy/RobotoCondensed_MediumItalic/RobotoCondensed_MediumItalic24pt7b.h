#ifndef _ROBOTOCONDENSED_MEDIUMITALIC24PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0xCE, 0x73, 0x19, 0xCE, 0x73, 0x18, 0xC0, 0x03, 0x1C, 0xC0,
  0x6D, 0xBC, 0xF3, 0xCB, 0x60, 0x03, 0x60, 0x66, 0x06, 0x60, 0x6C, 0x0C,
  0xC3, 0xFF, 0x3F, 0xF1, 0x98, 0x19, 0x81, 0xB0, 0xFF, 0xCF, 0xFC, 0x36,
  0x06, 0x60, 0x66, 0x06, 0xC0, 0xCC, 0x00, 0x03, 0x00, 0xC0, 0x30, 0x3C,
  0x1F, 0x8E, 0xF3, 0x9C, 0xC3, 0x30, 0xCE, 0x03, 0xC0, 0x7C, 0x07, 0x00,
  0xE0, 0x3B, 0x0E, 0xE3, 0xBD, 0xC7, 0xF0, 0xF0, 0x18, 0x04, 0x00, 0x38,
  0x0F, 0x83, 0x31, 0x66, 0x6C, 0xCD, 0x9B, 0x1F, 0xC3, 0xF0, 0x06, 0x01,
  0xB8, 0x6F, 0x8F, 0x33, 0x66, 0xCC, 0xD1, 0x98, 0x3F, 0x03, 0xC0, 0x07,
  0x80, 0xFC, 0x1E, 0xC1, 0xCC, 0x18, 0xC1, 0xDC, 0x1F, 0x80, 0xF0, 0x1E,
  0x03, 0xF3, 0x77, 0x77, 0x3E, 0x63, 0xE6, 0x1C, 0x73, 0xC7, 0xFE, 0x1E,
  0xE0, 0x7F, 0x6D, 0x80, 0x02, 0x0C, 0x38, 0xE1, 0x87, 0x0C, 0x38, 0x70,
  0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x0C,
  0x08, 0x08, 0x30, 0x30, 0x60, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x61, 0xC3, 0x0C, 0x30, 0x40, 0x06, 0x01,
  0x80, 0x41, 0x97, 0xFF, 0xC7, 0x81, 0xE0, 0xD8, 0x63, 0x00, 0x80, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0C, 0x3F, 0xFF, 0xFF, 0xFE, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x00, 0x33, 0x77, 0x6E, 0xC0, 0xFF, 0xC0, 0xFF, 0x00,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x0F,
  0x07, 0xE3, 0x9C, 0xC7, 0x70, 0xDC, 0x76, 0x1D, 0x87, 0xE1, 0xF8, 0x7E,
  0x1B, 0x86, 0xE3, 0xB8, 0xEF, 0x71, 0xF8, 0x3C, 0x00, 0x04, 0xFF, 0xFF,
  0x9C, 0x71, 0x86, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x70, 0x07, 0x83,
  0xF8, 0x77, 0x9C, 0x73, 0x8E, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xF0,
  0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0x83,
  0xF8, 0x77, 0x9C, 0x73, 0x8E, 0x01, 0xC0, 0x70, 0x7C, 0x0F, 0x80, 0x38,
  0x07, 0x00, 0xE6, 0x1C, 0xC3, 0x9C, 0xE3, 0xF8, 0x1E, 0x00, 0x00, 0xE0,
  0x3C, 0x0F, 0x81, 0xE0, 0x6C, 0x1F, 0x83, 0x70, 0xCE, 0x39, 0xC6, 0x31,
  0x86, 0x7F, 0xFF, 0xFC, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x1F, 0xE3,
  0xFC, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1F, 0xC3, 0xFC, 0x73, 0x80, 0x30,
  0x06, 0x00, 0xCE, 0x19, 0xC7, 0x3D, 0xC3, 0xF8, 0x3C, 0x00, 0x03, 0x83,
  0xE1, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0xF1, 0xFE, 0xF3, 0xB8, 0x6E, 0x1B,
  0x86, 0xE1, 0xB8, 0xE7, 0x71, 0xFC, 0x3C, 0x00, 0x7F, 0xEF, 0xFC, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x00, 0x0F, 0x07, 0xE3, 0x9C,
  0xC7, 0x71, 0xCC, 0x73, 0xB8, 0x7C, 0x3F, 0x1C, 0xEE, 0x3B, 0x8E, 0xC3,
  0xB8, 0xEF, 0x71, 0xFC, 0x3C, 0x00, 0x1E, 0x1F, 0x9D, 0xDC, 0x7E, 0x3E,
  0x1F, 0x0F, 0xC7, 0xE7, 0xFF, 0x9F, 0xC0, 0xE0, 0x60, 0x70, 0xF1, 0xF0,
  0xE0, 0x00, 0x37, 0x30, 0x00, 0x00, 0x00, 0xEE, 0xC0, 0x1C, 0x71, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x31, 0xC6, 0x38, 0x40, 0x00, 0x81,
  0xC3, 0xC7, 0xCF, 0x87, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0x00, 0x80, 0x7F,
  0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x40, 0x38, 0x1F, 0x03, 0xE0,
  0x78, 0x1C, 0x3E, 0xFC, 0xF8, 0x70, 0x20, 0x00, 0x3C, 0x7F, 0xF7, 0xE7,
  0xE7, 0x07, 0x0E, 0x1E, 0x1C, 0x38, 0x30, 0x70, 0x00, 0x00, 0x60, 0xE0,
  0x60, 0x01, 0xF0, 0x07, 0xFC, 0x0E, 0x0E, 0x18, 0x06, 0x38, 0x02, 0x31,
  0xE3, 0x63, 0xF3, 0x67, 0x33, 0xC6, 0x33, 0xCE, 0x63, 0xCC, 0x63, 0xCC,
  0x63, 0xCC, 0x62, 0x8C, 0xC6, 0x8C, 0xC4, 0x8F, 0x7C, 0xC7, 0x78, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xB8, 0x1D, 0xC0, 0xCE, 0x0E, 0x70,
  0x61, 0x87, 0x0C, 0x3F, 0xE3, 0xFF, 0x1C, 0x1D, 0xC0, 0xEE, 0x07, 0xE0,
  0x38, 0x1F, 0xC1, 0xFF, 0x1C, 0xF1, 0x83, 0x38, 0x33, 0x87, 0x38, 0xF3,
  0xFC, 0x3F, 0xC3, 0x0E, 0x70, 0x67, 0x06, 0x70, 0xE7, 0x0E, 0x73, 0xE7,
  0xFC, 0xFF, 0x00, 0x07, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x70, 0x77, 0x07,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0xE0, 0xEE, 0x1C,
  0x73, 0xC7, 0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0x3C, 0x30, 0xE3,
  0x83, 0x1C, 0x1C, 0xE0, 0xE7, 0x06, 0x38, 0x71, 0x83, 0x9C, 0x1C, 0xE0,
  0xE7, 0x0E, 0x38, 0x71, 0xCF, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xF1, 0xFF,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x3F, 0xC3, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFC, 0xFF, 0xC0, 0x1F,
  0xF1, 0xFF, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3F,
  0xC3, 0xFC, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x00, 0x07, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x70, 0x37, 0x00, 0x70, 0x06,
  0x00, 0xE3, 0xFE, 0x3E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0x7B, 0xE7,
  0xFC, 0x1F, 0x00, 0x1C, 0x0C, 0x38, 0x18, 0x70, 0x70, 0xC0, 0xE3, 0x81,
  0xC7, 0x03, 0x8E, 0x06, 0x1F, 0xFC, 0x3F, 0xF8, 0x60, 0x71, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x0E, 0x0E, 0x1C, 0x1C, 0x30, 0x38, 0xE0, 0x70, 0x1C,
  0x71, 0xC7, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x1C, 0x71, 0xC7, 0x18, 0x60,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0xE1, 0x8E, 0x38, 0x77, 0x87, 0xF0,
  0x3E, 0x00, 0x1C, 0x3C, 0x70, 0xE1, 0xC7, 0x06, 0x38, 0x39, 0xE0, 0xEF,
  0x03, 0xB8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x07, 0xB8, 0x1C, 0xE0, 0x71,
  0xC1, 0xC7, 0x07, 0x0E, 0x18, 0x38, 0xE0, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xFF, 0xFF, 0x80, 0x1E, 0x03, 0xC7, 0x81, 0xF1, 0xE0,
  0x78, 0x78, 0x1E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xF1, 0xF8, 0xFC, 0x6E,
  0x33, 0x3B, 0x0C, 0xCD, 0xC7, 0x37, 0x71, 0xCD, 0x9C, 0x73, 0xE7, 0x1C,
  0xF1, 0x87, 0x3C, 0x61, 0x8E, 0x38, 0xE1, 0x8E, 0x00, 0x1C, 0x0C, 0x38,
  0x38, 0x78, 0x70, 0xF0, 0xE3, 0xE1, 0xC7, 0xE3, 0x8E, 0xC6, 0x1D, 0x9C,
  0x3B, 0xB8, 0x63, 0x71, 0xC6, 0xE3, 0x8D, 0xC7, 0x0F, 0x0E, 0x1E, 0x1C,
  0x3C, 0x30, 0x78, 0xE0, 0x70, 0x07, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x70,
  0x37, 0x03, 0x70, 0x36, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0,
  0xEE, 0x0E, 0x7B, 0xC7, 0xF8, 0x1F, 0x00, 0x1F, 0xE0, 0xFF, 0x87, 0x1E,
  0x30, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x38, 0xF1, 0xFF, 0x1F,
  0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x00, 0x07,
  0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x70, 0x77, 0x03, 0x70, 0x76, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE, 0x0E, 0x7B, 0xC7, 0xF8, 0x1F,
  0x80, 0x3C, 0x01, 0xC0, 0x08, 0x1F, 0xC0, 0xFF, 0x87, 0x3C, 0x30, 0x61,
  0x83, 0x9C, 0x18, 0xE1, 0xC7, 0x3E, 0x3F, 0xE1, 0xFC, 0x1C, 0x60, 0xE3,
  0x87, 0x1C, 0x38, 0xE1, 0xC3, 0x0C, 0x1C, 0xE0, 0xE0, 0x07, 0xC0, 0xFE,
  0x1E, 0xF1, 0x87, 0x38, 0x33, 0x80, 0x1C, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x00, 0xE0, 0x0E, 0x60, 0xE7, 0x0E, 0x79, 0xC3, 0xFC, 0x1F, 0x00, 0xFF,
  0xEF, 0xFE, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x00, 0x38, 0x39, 0xC1, 0x8C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1,
  0xCE, 0x0C, 0x60, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0C, 0x70, 0xE3,
  0xCF, 0x0F, 0xF0, 0x3E, 0x00, 0xE0, 0x77, 0x03, 0xB8, 0x39, 0xC1, 0xC6,
  0x0E, 0x30, 0xE1, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0x98, 0x1D, 0xC0, 0x6C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00, 0xE1, 0xC3, 0x70,
  0xE3, 0xB8, 0xF1, 0xDC, 0x78, 0xCE, 0x3C, 0xE7, 0x3E, 0x73, 0x9B, 0x31,
  0xCD, 0xB8, 0xEC, 0xDC, 0x76, 0x6C, 0x1B, 0x36, 0x0F, 0x1F, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xC3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x00, 0x1E, 0x1E,
  0x1C, 0x38, 0x38, 0xE0, 0x71, 0xC0, 0x77, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x76, 0x01, 0xCE, 0x03, 0x9C,
  0x0E, 0x38, 0x3C, 0x38, 0x70, 0x70, 0xE0, 0x7E, 0x0E, 0x61, 0xE7, 0x1C,
  0x73, 0x87, 0x38, 0x37, 0x03, 0x70, 0x3E, 0x03, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x00, 0x1F, 0xF9, 0xFF, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x1E, 0x1E, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0,
  0xE7, 0x38, 0xC6, 0x31, 0xCE, 0x73, 0x8C, 0x63, 0x1C, 0xE7, 0x38, 0xC0,
  0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0xF0, 0xF0,
  0x0C, 0x38, 0x70, 0xF3, 0x66, 0xD9, 0xB3, 0xC6, 0xFF, 0xFF, 0xC0, 0x73,
  0x8C, 0x30, 0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x01, 0xC7, 0xF3, 0xFD, 0xC6,
  0x61, 0xB8, 0xE7, 0x79, 0xFE, 0x3B, 0x80, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x7F, 0x0F, 0xF1, 0xEE, 0x30, 0xE6, 0x1D, 0xC3, 0xB8, 0x67,
  0x0C, 0xE3, 0x98, 0x73, 0xDC, 0xFF, 0x9D, 0xE0, 0x1E, 0x1F, 0x9C, 0xEC,
  0x3E, 0x1F, 0x03, 0x01, 0x80, 0xC0, 0x61, 0xB9, 0xCF, 0xC3, 0xC0, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x3B, 0x9F, 0xF3, 0x9E, 0xE1, 0xDC,
  0x33, 0x86, 0x61, 0xCC, 0x39, 0x87, 0x30, 0xE7, 0x38, 0xFF, 0x0F, 0x60,
  0x1F, 0x1F, 0xDC, 0xEC, 0x3E, 0x1F, 0xFF, 0xFF, 0x80, 0xC0, 0x70, 0x3D,
  0xCF, 0xE3, 0xC0, 0x07, 0x1F, 0x1C, 0x38, 0x38, 0xFE, 0xFE, 0x30, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0x0E, 0x67, 0xFC,
  0xE7, 0xB8, 0x77, 0x0E, 0xE1, 0x98, 0x33, 0x0E, 0x61, 0xCC, 0x39, 0xEF,
  0x3F, 0xC3, 0xD8, 0x07, 0x00, 0xE2, 0x38, 0xFF, 0x0F, 0x80, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0F, 0xE3, 0xFC, 0xE7, 0x30, 0xCC, 0x37, 0x1D,
  0xC7, 0x71, 0xDC, 0x76, 0x1B, 0x86, 0xE3, 0xB8, 0xE0, 0x1C, 0x71, 0x80,
  0x00, 0xE3, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x80, 0x06,
  0x07, 0x06, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x70, 0xF0, 0xE0, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x03, 0x80, 0x71, 0xCE, 0x71, 0xDC, 0x37, 0x07, 0xE1,
  0xF8, 0x3F, 0x07, 0xE0, 0xEE, 0x19, 0xC3, 0x1C, 0xE3, 0x9C, 0x70, 0x1C,
  0x71, 0xC6, 0x18, 0xE3, 0x8E, 0x38, 0xC3, 0x1C, 0x71, 0xC7, 0x18, 0x63,
  0x80, 0x3F, 0x9E, 0x3F, 0xFF, 0x39, 0xF7, 0x30, 0xE3, 0x30, 0xC3, 0x71,
  0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x61, 0x86, 0x61, 0x86, 0xE3,
  0x8E, 0xE3, 0x8E, 0x3F, 0x8F, 0xF3, 0x9C, 0xC3, 0x70, 0xDC, 0x77, 0x1D,
  0xC7, 0x71, 0xD8, 0x6E, 0x1B, 0x8E, 0xE3, 0x80, 0x1F, 0x0F, 0xE7, 0x39,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x06, 0xC1, 0xB8, 0xEE, 0x71, 0xFC, 0x3C,
  0x00, 0x1F, 0xC1, 0xFE, 0x1E, 0xE1, 0x87, 0x18, 0x73, 0x87, 0x38, 0x63,
  0x86, 0x38, 0xE3, 0x0E, 0x39, 0xC7, 0xFC, 0x77, 0x87, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0xDF, 0xF7, 0x3F, 0x87, 0xE1, 0xB8, 0x6C,
  0x3B, 0x0E, 0xC3, 0xB0, 0xEE, 0x73, 0xFC, 0x7F, 0x01, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0x3F, 0x3F, 0x3F, 0x38, 0x30, 0x70, 0x70, 0x70, 0x70,
  0x60, 0x60, 0xE0, 0xE0, 0x0F, 0x07, 0xE3, 0x9C, 0xC7, 0x30, 0x0F, 0x01,
  0xF0, 0x1E, 0x03, 0xB8, 0xE6, 0x39, 0xFC, 0x3E, 0x00, 0x38, 0xE3, 0xBF,
  0xFD, 0xC7, 0x1C, 0x71, 0x86, 0x38, 0xE3, 0x87, 0x1C, 0x71, 0xDC, 0x77,
  0x1D, 0x86, 0x61, 0xB8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB8, 0xCE, 0x73, 0xFC,
  0x7F, 0x00, 0xE1, 0xF8, 0xE6, 0x39, 0x8C, 0x67, 0x19, 0x86, 0xE1, 0xF8,
  0x7C, 0x1F, 0x03, 0x80, 0xE0, 0x30, 0x00, 0x63, 0x0D, 0x8C, 0x76, 0x79,
  0xD9, 0xE6, 0x67, 0xB9, 0xB6, 0xC6, 0xDB, 0x1F, 0x7C, 0x79, 0xE1, 0xE7,
  0x87, 0x1C, 0x1C, 0x70, 0x61, 0xC0, 0x18, 0xE1, 0xCE, 0x1D, 0xC0, 0xDC,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xB8, 0x3B, 0x87, 0x18,
  0x71, 0xC0, 0x38, 0x73, 0x8E, 0x18, 0xE1, 0x9C, 0x19, 0xC1, 0x98, 0x1B,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0xF0, 0x0E, 0x00, 0x3F, 0xCF, 0xF0, 0x1C, 0x0E, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0xFE, 0xFF, 0x00, 0x02, 0x1C,
  0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x61, 0xC7, 0x0E, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0E, 0x0C, 0x00, 0x18, 0xC6, 0x31, 0x8C, 0x46,
  0x31, 0x8C, 0x62, 0x31, 0x8C, 0x63, 0x19, 0x80, 0x08, 0x38, 0x30, 0x60,
  0xE1, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x71, 0xC3, 0x06, 0x1C, 0x38, 0x70,
  0xC1, 0x87, 0x1C, 0x30, 0x00, 0x38, 0x6F, 0x8D, 0xBB, 0xE3, 0xEC, 0x38,
};

const GFXglyph RobotoCondensed_MediumItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 17, 6, 1, -17 },
  { 12, 6, 6, 7, 2, -18 },
  { 17, 12, 17, 13, 1, -17 },
  { 43, 10, 22, 12, 1, -20 },
  { 71, 11, 17, 15, 2, -17 },
  { 95, 12, 17, 13, 0, -17 },
  { 121, 3, 6, 4, 2, -18 },
  { 124, 7, 24, 7, 1, -19 },
  { 145, 7, 24, 7, -1, -19 },
  { 166, 10, 10, 10, 1, -17 },
  { 179, 10, 13, 11, 1, -15 },
  { 196, 4, 7, 5, -1, -3 },
  { 200, 5, 2, 7, 1, -8 },
  { 202, 3, 3, 6, 1, -3 },
  { 204, 10, 18, 8, -1, -17 },
  { 227, 10, 17, 12, 1, -17 },
  { 249, 6, 17, 12, 3, -17 },
  { 262, 11, 17, 12, 0, -17 },
  { 286, 11, 17, 12, 0, -17 },
  { 310, 11, 17, 12, 0, -17 },
  { 334, 11, 17, 12, 1, -17 },
  { 358, 10, 17, 12, 1, -17 },
  { 380, 11, 17, 12, 1, -17 },
  { 404, 10, 17, 12, 1, -17 },
  { 426, 9, 17, 12, 2, -17 },
  { 446, 4, 13, 6, 1, -13 },
  { 453, 6, 17, 5, -1, -13 },
  { 466, 9, 11, 10, 1, -13 },
  { 479, 10, 6, 11, 1, -11 },
  { 487, 9, 11, 11, 1, -13 },
  { 500, 8, 17, 10, 2, -17 },
  { 517, 16, 22, 18, 1, -17 },
  { 561, 13, 17, 14, -1, -17 },
  { 589, 12, 17, 13, 0, -17 },
  { 615, 12, 17, 13, 1, -17 },
  { 641, 13, 17, 13, 0, -17 },
  { 669, 12, 17, 12, 0, -17 },
  { 695, 12, 17, 11, 0, -17 },
  { 721, 12, 17, 14, 1, -17 },
  { 747, 15, 17, 14, 0, -17 },
  { 779, 6, 17, 6, 0, -17 },
  { 792, 12, 17, 11, 0, -17 },
  { 818, 14, 17, 13, 0, -17 },
  { 848, 10, 17, 11, 0, -17 },
  { 870, 18, 17, 18, 0, -17 },
  { 909, 15, 17, 14, 0, -17 },
  { 941, 12, 17, 14, 1, -17 },
  { 967, 13, 17, 13, 0, -17 },
  { 995, 12, 20, 14, 1, -17 },
  { 1025, 13, 17, 13, 0, -17 },
  { 1053, 12, 17, 12, 0, -17 },
  { 1079, 12, 17, 12, 2, -17 },
  { 1105, 13, 17, 13, 1, -17 },
  { 1133, 13, 17, 13, 2, -17 },
  { 1161, 17, 17, 18, 2, -17 },
  { 1198, 15, 17, 13, -1, -17 },
  { 1230, 12, 17, 12, 2, -17 },
  { 1256, 13, 17, 12, 0, -17 },
  { 1284, 8, 24, 6, 0, -20 },
  { 1308, 5, 18, 9, 2, -17 },
  { 1320, 8, 24, 6, -1, -20 },
  { 1344, 7, 9, 9, 1, -17 },
  { 1352, 9, 2, 9, -1, 0 },
  { 1355, 5, 4, 7, 2, -18 },
  { 1358, 10, 13, 11, 0, -13 },
  { 1375, 11, 18, 12, 0, -18 },
  { 1400, 9, 13, 11, 1, -13 },
  { 1415, 11, 18, 12, 1, -18 },
  { 1440, 9, 13, 11, 1, -13 },
  { 1455, 8, 18, 8, 1, -18 },
  { 1473, 11, 18, 12, 0, -13 },
  { 1498, 10, 18, 11, 0, -18 },
  { 1521, 6, 18, 6, 0, -18 },
  { 1535, 8, 23, 5, -2, -18 },
  { 1558, 11, 18, 11, 0, -18 },
  { 1583, 6, 18, 6, 0, -18 },
  { 1597, 16, 13, 17, 0, -13 },
  { 1623, 10, 13, 11, 0, -13 },
  { 1640, 10, 13, 12, 1, -13 },
  { 1657, 12, 18, 12, -1, -13 },
  { 1684, 10, 18, 12, 1, -13 },
  { 1707, 8, 13, 7, 0, -13 },
  { 1720, 10, 13, 11, 0, -13 },
  { 1737, 6, 16, 7, 1, -16 },
  { 1749, 10, 13, 11, 1, -13 },
  { 1766, 10, 13, 10, 1, -13 },
  { 1783, 14, 13, 15, 1, -13 },
  { 1806, 12, 13, 10, -1, -13 },
  { 1826, 12, 18, 10, -1, -13 },
  { 1853, 10, 13, 10, 0, -13 },
  { 1870, 7, 23, 7, 1, -19 },
  { 1891, 5, 20, 6, 0, -17 },
  { 1904, 7, 23, 7, -1, -19 },
  { 1925, 11, 5, 13, 1, -10 },
};

const GFXfont RobotoCondensed_MediumItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC24PT7B_H_
