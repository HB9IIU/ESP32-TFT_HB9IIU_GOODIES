#ifndef _ROBOTOCONDENSED_MEDIUMITALIC26PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0xE3, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x61, 0x80,
  0x00, 0xC3, 0x8C, 0x00, 0x66, 0xCD, 0xB3, 0x6C, 0xD9, 0xB3, 0x00, 0x03,
  0x30, 0x19, 0x80, 0xCC, 0x0C, 0xC0, 0x66, 0x1F, 0xFC, 0xFF, 0xE1, 0x98,
  0x0C, 0xC0, 0xCC, 0x06, 0x60, 0x33, 0x0F, 0xFE, 0x7F, 0xF0, 0xCC, 0x06,
  0xE0, 0x66, 0x03, 0x30, 0x19, 0x80, 0x01, 0x80, 0x30, 0x04, 0x03, 0xC1,
  0xFC, 0x3F, 0xCE, 0x39, 0xC7, 0x38, 0xE7, 0x00, 0xE0, 0x0F, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0xE1, 0xDC, 0x3B, 0x8F, 0x7F, 0xC7, 0xF0, 0x7C,
  0x06, 0x00, 0xC0, 0x3C, 0x07, 0xE0, 0x66, 0x26, 0x67, 0xC6, 0x6C, 0x6C,
  0xEF, 0xC7, 0xD8, 0x3B, 0x00, 0x60, 0x06, 0xE0, 0xDF, 0x1B, 0x31, 0xB3,
  0x33, 0x36, 0x33, 0x63, 0x30, 0x3E, 0x01, 0xC0, 0x07, 0x80, 0xFC, 0x1F,
  0xC1, 0x8C, 0x38, 0xC3, 0x9C, 0x3B, 0xC1, 0xF8, 0x1E, 0x03, 0xE0, 0x7E,
  0x7F, 0x77, 0xE7, 0x7E, 0x3E, 0xE3, 0xEE, 0x1C, 0xF7, 0xC7, 0xFE, 0x3E,
  0xE0, 0x6F, 0xFD, 0xB0, 0x01, 0x03, 0x06, 0x0E, 0x1C, 0x18, 0x38, 0x38,
  0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x60, 0x60, 0x60, 0x60, 0x30, 0x30, 0x10, 0x08, 0x0C, 0x0C, 0x06, 0x06,
  0x06, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E,
  0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x70, 0xE0, 0xC0, 0x80, 0x07, 0x00,
  0xC0, 0x18, 0x33, 0x37, 0xFE, 0x7F, 0x83, 0x80, 0xF0, 0x33, 0x0E, 0x70,
  0x84, 0x00, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF7,
  0xFE, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x31, 0x9C,
  0xE6, 0x73, 0x00, 0xFF, 0xF0, 0xFF, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x00,
  0x07, 0x83, 0xF8, 0x77, 0x9C, 0x73, 0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70,
  0xEC, 0x1F, 0x83, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x1C, 0x77, 0x8F,
  0xE0, 0xF8, 0x00, 0x02, 0x3D, 0xFF, 0xFC, 0xE3, 0x87, 0x0E, 0x1C, 0x38,
  0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0xE1, 0xC0, 0x07, 0xC0, 0xFE, 0x1E,
  0xF1, 0xC7, 0x38, 0x73, 0x87, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0xFE, 0xFF,
  0xE0, 0x0F, 0x83, 0xF8, 0xFF, 0x3C, 0x77, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x07, 0xC1, 0xE0, 0x7E, 0x01, 0xC0, 0x1C, 0x03, 0xB0, 0x77, 0x1C, 0xF7,
  0x8F, 0xE0, 0xF8, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x7E, 0x06, 0xE0, 0xEE, 0x1C, 0xE1, 0x9C, 0x39, 0xC7, 0x1C, 0x71, 0xCF,
  0xFE, 0xFF, 0xE0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1F, 0xF1, 0xFE,
  0x1F, 0xE1, 0x80, 0x38, 0x03, 0x80, 0x37, 0x07, 0xF8, 0x7B, 0xC1, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0xE1, 0xCE, 0x3C, 0x7F, 0x87, 0xF0,
  0x3E, 0x00, 0x01, 0xC1, 0xF0, 0xFC, 0x70, 0x38, 0x0E, 0x07, 0x71, 0xFE,
  0x7B, 0xDC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x8F, 0x7F, 0x8F,
  0xC1, 0xE0, 0x3F, 0xF7, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x00, 0x07, 0x83, 0xF8, 0xFF, 0x9C,
  0x73, 0x8E, 0x71, 0xCE, 0x39, 0xFE, 0x1F, 0x87, 0xF1, 0xCE, 0x70, 0xEE,
  0x1D, 0xC3, 0xB8, 0x77, 0x1C, 0xF7, 0x8F, 0xE0, 0xF8, 0x00, 0x1F, 0x0F,
  0xE7, 0xF9, 0xC6, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xEF, 0x79,
  0xFE, 0x3B, 0x81, 0xC0, 0x70, 0x38, 0x7C, 0x3E, 0x0F, 0x00, 0x3B, 0xCC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xCE, 0x70, 0x1E, 0x3C, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x86, 0x1C, 0x38, 0xE0, 0x80, 0x00,
  0x40, 0x60, 0x78, 0x7E, 0x7C, 0x3C, 0x0E, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x70, 0x04, 0x3F, 0xEF, 0xF9, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF7,
  0xFC, 0xFF, 0x80, 0x20, 0x1C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xF0, 0x7C,
  0x7E, 0x7E, 0x3E, 0x0E, 0x02, 0x00, 0x1E, 0x3F, 0x9F, 0xFC, 0x7E, 0x38,
  0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x38, 0x18, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80,
  0x61, 0x80, 0x19, 0xC7, 0x8C, 0xC7, 0xE6, 0xC7, 0x31, 0x63, 0x18, 0xB3,
  0x18, 0xF1, 0x8C, 0x79, 0xC6, 0x3C, 0xE3, 0x1E, 0x63, 0x8F, 0x31, 0x8D,
  0x9D, 0xC6, 0xCF, 0xBE, 0x63, 0x9E, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x82, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x0E, 0xC0, 0x3B, 0x01, 0xCE, 0x07, 0x38, 0x38,
  0xE0, 0xE3, 0x83, 0x8E, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x8E, 0x07, 0x70,
  0x1D, 0xC0, 0x7E, 0x01, 0xC0, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x38, 0x71,
  0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x1E, 0x3F, 0xE1, 0xFF, 0x0E, 0x1C, 0x70,
  0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCE, 0x1E, 0x7F, 0xE3, 0xFE, 0x3F, 0xE0,
  0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83, 0xB8, 0x1D, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x3B, 0x81,
  0xCE, 0x1C, 0x7F, 0xE1, 0xFE, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0xC1, 0xFF,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0x63, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE0,
  0xE3, 0x83, 0x8E, 0x0E, 0x70, 0x39, 0xC1, 0xC7, 0x07, 0x1C, 0x38, 0x7F,
  0xE1, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x70,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xE3, 0xFF, 0x3F, 0xF0,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0xFE,
  0x78, 0x73, 0x83, 0xB8, 0x1D, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x7F, 0xC3, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xCE, 0x0E, 0x7F, 0xF1, 0xFF,
  0x07, 0xE0, 0x1C, 0x07, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x1C, 0x0E,
  0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x38, 0x1C, 0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38,
  0x70, 0x38, 0xE0, 0x38, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x70, 0xE3, 0x87, 0x1E, 0x38, 0x7F,
  0x83, 0xF8, 0x0F, 0x80, 0x1C, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x1C, 0x78,
  0x1C, 0xF0, 0x1C, 0xE0, 0x39, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3D, 0xC0, 0x79, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x70, 0xE0,
  0x70, 0xF0, 0x70, 0x70, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x7F, 0xDF, 0xFF, 0xFC, 0x1E, 0x01, 0xE3, 0xE0, 0x3C, 0x7C,
  0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x36, 0x0F, 0x8E, 0xC3, 0xF1, 0xD8,
  0x7E, 0x3B, 0x0D, 0xC7, 0x63, 0xB8, 0xEE, 0x67, 0x1D, 0xDD, 0xC7, 0x3B,
  0x38, 0xE3, 0xE7, 0x1C, 0x78, 0xE3, 0x8F, 0x1C, 0x71, 0xC3, 0x8E, 0x38,
  0xE3, 0x87, 0x1C, 0x00, 0x1E, 0x07, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x0E,
  0x1F, 0x0E, 0x1F, 0x0E, 0x3B, 0x0E, 0x3B, 0x9C, 0x39, 0x9C, 0x39, 0x9C,
  0x39, 0xDC, 0x39, 0xDC, 0x70, 0xDC, 0x70, 0xF8, 0x70, 0xF8, 0x70, 0x78,
  0x70, 0x78, 0x70, 0x78, 0xE0, 0x78, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F,
  0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x39, 0xC0, 0xEE,
  0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x07, 0x1C, 0x38, 0x7F, 0xE0,
  0xFF, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0x07, 0x1C,
  0x1C, 0x70, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xFF, 0xE3, 0xFF, 0x0F,
  0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x78, 0x73, 0x83, 0xB8, 0x1D,
  0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x3B, 0x81, 0xCE, 0x1C, 0x7F, 0xE1, 0xFE, 0x07, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x20, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0x0E, 0x1C, 0x1C, 0x70,
  0x73, 0x83, 0x8E, 0x0E, 0x38, 0x78, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x71,
  0xC1, 0xC7, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xCE, 0x07, 0x00,
  0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x38, 0x77, 0x07, 0x38, 0x03, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E,
  0xFF, 0xC7, 0xF8, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E, 0x38, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x71, 0xC1, 0xC7, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x0E, 0x38, 0x38, 0x7F, 0xC1, 0xFE, 0x01, 0xF0, 0x00, 0xE0, 0x3F,
  0x80, 0xEF, 0x07, 0x9C, 0x1C, 0x70, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x78,
  0x71, 0xC1, 0xC7, 0x07, 0x38, 0x0C, 0xE0, 0x37, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0xE1, 0xF8, 0x78,
  0x7E, 0x1E, 0x39, 0x87, 0x8E, 0x63, 0xE3, 0x98, 0xF9, 0xC6, 0x3E, 0x71,
  0x9D, 0x9C, 0x67, 0x66, 0x19, 0x9B, 0x86, 0xE6, 0xE1, 0xB1, 0xB0, 0x6C,
  0x7C, 0x1F, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x1C,
  0x07, 0x07, 0x00, 0x0E, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x07, 0x1C, 0x07,
  0x38, 0x07, 0x78, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0x70, 0x1C, 0x70, 0x38,
  0x70, 0x78, 0x78, 0x70, 0x38, 0xF0, 0x7B, 0x83, 0x9C, 0x3C, 0xE1, 0xC7,
  0x1E, 0x18, 0xE0, 0xEE, 0x07, 0x70, 0x3F, 0x00, 0xF8, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x00, 0x0F, 0x1F,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30,
  0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0xE1,
  0x86, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0xC3, 0x0E, 0x38, 0xE3, 0x8E, 0x18,
  0x61, 0xC7, 0x1C, 0x1F, 0x1F, 0x07, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x30, 0xF0, 0xF0, 0x0E, 0x0E, 0x1E, 0x1E, 0x3E, 0x37, 0x73, 0x63,
  0xE3, 0xFF, 0xBF, 0xE0, 0xE3, 0x9C, 0x60, 0x07, 0x83, 0xF8, 0xF7, 0x9C,
  0x70, 0x0E, 0x01, 0xC3, 0xF1, 0xFE, 0x71, 0xCE, 0x3B, 0x87, 0x3B, 0xE7,
  0xFC, 0x7B, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x3B, 0xC3, 0xFE, 0x3F, 0xE3, 0x8E, 0x38, 0x73, 0x07, 0x70, 0x67, 0x0E,
  0x70, 0xE7, 0x0E, 0x70, 0xE7, 0xFC, 0xEF, 0xCE, 0xF0, 0x1F, 0x0F, 0xE7,
  0xBD, 0xC7, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0xEE, 0x3B, 0xDC,
  0x7F, 0x0F, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x1E, 0xE3, 0xFE, 0x7F, 0xE7, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C,
  0xE1, 0xCE, 0x18, 0xE3, 0x8F, 0xF8, 0xFF, 0x83, 0xB8, 0x0F, 0x0F, 0xE7,
  0xBD, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x13, 0xFE,
  0x7F, 0x8F, 0x80, 0x07, 0x87, 0xC7, 0xE3, 0x81, 0xC1, 0xC1, 0xF9, 0xFC,
  0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38,
  0x1C, 0x00, 0x0F, 0x71, 0xFF, 0x3F, 0xF3, 0x8F, 0x70, 0x67, 0x0E, 0x70,
  0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x71, 0xC7, 0xFC, 0x3F, 0xC1, 0xDC, 0x01,
  0xC0, 0x38, 0xF7, 0x8F, 0xF0, 0x3E, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0xF1, 0xFF, 0x3F, 0xE7, 0x1C, 0xE3, 0xB8, 0x77,
  0x0E, 0xE1, 0xDC, 0x3B, 0x8E, 0x71, 0xDC, 0x3B, 0x87, 0x70, 0xE0, 0x1C,
  0x70, 0xC0, 0x00, 0x63, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x71,
  0x8E, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03,
  0x81, 0xC3, 0xC3, 0xE1, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0xF3, 0x8E, 0x39, 0xC3, 0xB8, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xF0, 0x7F, 0x07, 0x38, 0x73, 0x86, 0x38, 0xE1, 0xCE, 0x1C, 0x0C,
  0x38, 0x70, 0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0x87, 0x00, 0x3B, 0xCF, 0x0F, 0xFF, 0xE3, 0xDF, 0xF8,
  0xE3, 0xC7, 0x38, 0xE1, 0xCC, 0x38, 0x67, 0x0E, 0x39, 0xC3, 0x8E, 0x70,
  0xC3, 0x9C, 0x70, 0xE7, 0x1C, 0x39, 0x87, 0x0C, 0xE1, 0xC7, 0x38, 0x71,
  0xC0, 0x3B, 0xC7, 0xFC, 0xFF, 0x9C, 0x73, 0x8E, 0xE1, 0xDC, 0x3B, 0x87,
  0x70, 0xEE, 0x39, 0xC7, 0x70, 0xEE, 0x1D, 0xC3, 0x80, 0x0F, 0x07, 0xF1,
  0xEF, 0x38, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x06, 0xE1, 0xDC, 0x3B, 0x8F,
  0x7B, 0xC7, 0xF0, 0x7C, 0x00, 0x1D, 0xE0, 0xFF, 0x87, 0xFC, 0x38, 0xE1,
  0xC3, 0x8C, 0x18, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x3C, 0xFB,
  0xC7, 0xFC, 0x3B, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00,
  0x1E, 0xE7, 0xFD, 0xEF, 0xB8, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0E, 0xE1,
  0xDC, 0x33, 0x8E, 0x7B, 0xCF, 0xF8, 0x77, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x00, 0x3B, 0x9F, 0x8F, 0xC7, 0x83, 0x81, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x00, 0x0F, 0x83, 0xF8, 0xF7, 0x1C,
  0x73, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3B, 0x87, 0x39, 0xC7,
  0xF8, 0x3C, 0x00, 0x1C, 0x70, 0xE7, 0xFF, 0xE7, 0x0C, 0x38, 0x70, 0xE1,
  0xC3, 0x86, 0x1C, 0x3E, 0x3C, 0x78, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0xE7,
  0x1C, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x73, 0x8E, 0x7F, 0xCF, 0xF8,
  0xF7, 0x00, 0xE1, 0xCC, 0x39, 0xC7, 0x39, 0xC7, 0x38, 0xE6, 0x1D, 0xC3,
  0xB0, 0x7E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x00, 0xC3, 0x0F,
  0x8E, 0x3B, 0x1C, 0x76, 0x38, 0xCC, 0xF3, 0x99, 0xF7, 0x37, 0xEC, 0x6D,
  0xF8, 0xD9, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0E, 0x1C, 0x1C, 0x38,
  0x00, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1E,
  0x01, 0xE0, 0x0F, 0x80, 0xFC, 0x0F, 0x60, 0x73, 0x87, 0x1C, 0x38, 0xE0,
  0x38, 0x70, 0xE3, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x0E, 0xE0, 0x77, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0xF8, 0x07, 0x80, 0x38, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x01,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0F,
  0xF9, 0xFF, 0x00, 0x02, 0x07, 0x0E, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38,
  0x38, 0x38, 0x70, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60,
  0x60, 0x70, 0x30, 0x10, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x18, 0xC3,
  0x0C, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x18, 0x63, 0x80, 0x08, 0x1C, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x0F, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0xE0, 0xC0, 0x3C, 0x37,
  0xE3, 0x7F, 0xFE, 0x7E, 0xC1, 0xC0,
};

const GFXglyph RobotoCondensed_MediumItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 19, 6, 1, -19 },
  { 16, 7, 7, 8, 2, -20 },
  { 23, 13, 19, 14, 1, -19 },
  { 54, 11, 24, 13, 1, -22 },
  { 87, 12, 19, 16, 2, -19 },
  { 116, 12, 19, 14, 1, -19 },
  { 145, 3, 7, 4, 2, -20 },
  { 148, 8, 27, 8, 1, -21 },
  { 175, 8, 27, 8, -1, -21 },
  { 202, 11, 11, 11, 1, -19 },
  { 218, 11, 14, 12, 1, -15 },
  { 238, 5, 7, 6, -1, -3 },
  { 243, 6, 2, 8, 1, -9 },
  { 245, 3, 3, 7, 1, -3 },
  { 247, 11, 21, 9, -1, -19 },
  { 276, 11, 19, 13, 1, -19 },
  { 303, 7, 19, 13, 3, -19 },
  { 320, 12, 19, 13, 0, -19 },
  { 349, 11, 19, 13, 1, -19 },
  { 376, 12, 19, 13, 0, -19 },
  { 405, 12, 19, 13, 1, -19 },
  { 434, 10, 19, 13, 1, -19 },
  { 458, 12, 19, 13, 1, -19 },
  { 487, 11, 19, 13, 1, -19 },
  { 514, 10, 19, 13, 2, -19 },
  { 538, 5, 14, 7, 1, -14 },
  { 547, 7, 18, 6, -1, -14 },
  { 563, 10, 12, 11, 1, -14 },
  { 578, 11, 9, 12, 1, -13 },
  { 591, 10, 12, 12, 1, -14 },
  { 606, 9, 19, 11, 2, -19 },
  { 628, 17, 24, 19, 1, -18 },
  { 679, 14, 19, 15, -1, -19 },
  { 713, 13, 19, 14, 0, -19 },
  { 744, 13, 19, 14, 1, -19 },
  { 775, 14, 19, 14, 0, -19 },
  { 809, 13, 19, 12, 0, -19 },
  { 840, 13, 19, 12, 0, -19 },
  { 871, 13, 19, 15, 1, -19 },
  { 902, 16, 19, 16, 0, -19 },
  { 940, 7, 19, 7, 0, -19 },
  { 957, 13, 19, 12, 0, -19 },
  { 988, 16, 19, 14, 0, -19 },
  { 1026, 10, 19, 12, 0, -19 },
  { 1050, 19, 19, 19, 0, -19 },
  { 1096, 16, 19, 16, 0, -19 },
  { 1134, 14, 19, 15, 1, -19 },
  { 1168, 14, 19, 14, 0, -19 },
  { 1202, 13, 22, 15, 1, -19 },
  { 1238, 14, 19, 14, 0, -19 },
  { 1272, 12, 19, 13, 1, -19 },
  { 1301, 13, 19, 13, 2, -19 },
  { 1332, 14, 19, 14, 1, -19 },
  { 1366, 14, 19, 14, 2, -19 },
  { 1400, 18, 19, 19, 2, -19 },
  { 1443, 16, 19, 14, -1, -19 },
  { 1481, 13, 19, 13, 2, -19 },
  { 1512, 14, 19, 13, 0, -19 },
  { 1546, 8, 25, 7, 0, -21 },
  { 1571, 6, 21, 9, 2, -19 },
  { 1587, 8, 25, 7, -1, -21 },
  { 1612, 8, 9, 10, 1, -19 },
  { 1621, 10, 2, 10, -1, 0 },
  { 1624, 5, 4, 8, 3, -20 },
  { 1627, 11, 14, 12, 0, -14 },
  { 1647, 12, 20, 12, 0, -20 },
  { 1677, 10, 14, 12, 1, -14 },
  { 1695, 12, 20, 13, 1, -20 },
  { 1725, 10, 14, 12, 1, -14 },
  { 1743, 9, 20, 8, 1, -20 },
  { 1766, 12, 19, 13, 0, -14 },
  { 1795, 11, 20, 12, 0, -20 },
  { 1823, 6, 19, 6, 0, -19 },
  { 1838, 9, 24, 6, -3, -19 },
  { 1865, 12, 20, 12, 0, -20 },
  { 1895, 7, 20, 6, 0, -20 },
  { 1913, 18, 14, 19, 0, -14 },
  { 1945, 11, 14, 12, 0, -14 },
  { 1965, 11, 14, 13, 1, -14 },
  { 1985, 13, 19, 12, -1, -14 },
  { 2016, 11, 19, 13, 1, -14 },
  { 2043, 9, 14, 8, 0, -14 },
  { 2059, 11, 14, 11, 0, -14 },
  { 2079, 7, 17, 8, 1, -17 },
  { 2094, 11, 14, 12, 1, -14 },
  { 2114, 11, 14, 11, 1, -14 },
  { 2134, 15, 14, 16, 2, -14 },
  { 2161, 13, 14, 11, -1, -14 },
  { 2184, 13, 19, 11, -1, -14 },
  { 2215, 11, 14, 11, 0, -14 },
  { 2235, 8, 25, 8, 1, -20 },
  { 2260, 6, 22, 6, 0, -19 },
  { 2277, 8, 25, 8, -1, -20 },
  { 2302, 12, 5, 14, 1, -10 },
};

const GFXfont RobotoCondensed_MediumItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC26PT7B_H_
