#ifndef _ROBOTOCONDENSED_MEDIUMITALIC69PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x38, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x87, 0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7C,
  0x3E, 0x0F, 0x87, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x78, 0x3E, 0x1F, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFF, 0x03,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE,
  0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80,
  0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F,
  0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3E,
  0x0F, 0xC0, 0x30, 0x7E, 0x0F, 0xC0, 0x3C, 0x7C, 0x07, 0xC0, 0x7E, 0x7C,
  0x07, 0xC0, 0xFC, 0x7C, 0x07, 0xC0, 0xF8, 0xFC, 0x07, 0xC1, 0xF8, 0xFC,
  0x0F, 0xC3, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0xFC,
  0x0F, 0x8F, 0xC0, 0x7C, 0x1F, 0x8F, 0x80, 0x7C, 0x3F, 0x9F, 0x80, 0x7F,
  0xFF, 0x3F, 0x00, 0x3F, 0xFE, 0x3E, 0x00, 0x3F, 0xFE, 0x7C, 0x00, 0x1F,
  0xFC, 0xFC, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x1F, 0xF8, 0x00,
  0x3F, 0x3F, 0xFC, 0x00, 0x7E, 0x7F, 0xFE, 0x00, 0x7C, 0xFF, 0xFE, 0x00,
  0xFC, 0xFC, 0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0x01, 0xF1, 0xF8, 0x1F, 0x03,
  0xF1, 0xF0, 0x1F, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC1, 0xF0, 0x1F, 0x0F,
  0x81, 0xF0, 0x1F, 0x1F, 0x81, 0xF0, 0x1F, 0x1F, 0x03, 0xF0, 0x3F, 0x3E,
  0x01, 0xF0, 0x3F, 0x7E, 0x01, 0xF0, 0x3E, 0x3C, 0x01, 0xF0, 0x7E, 0x08,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF8, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0x07, 0xFF,
  0xF8, 0x1F, 0x83, 0xFF, 0xFF, 0x07, 0xE1, 0xFF, 0x3F, 0xC3, 0xF8, 0xFF,
  0x8F, 0xF8, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x9F, 0xF0, 0x7F, 0xDF, 0xC7,
  0xF8, 0x0F, 0xF7, 0xF1, 0xFE, 0x01, 0xFF, 0xFC, 0x7F, 0x80, 0x7F, 0xFE,
  0x1F, 0xE0, 0x0F, 0xFF, 0x87, 0xF8, 0x03, 0xFF, 0xC1, 0xFE, 0x00, 0x7F,
  0xF0, 0x7F, 0x80, 0x1F, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF7, 0xF8, 0x07,
  0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0x87, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x01, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x18, 0x07, 0xC0, 0x31, 0xF0, 0x3E, 0x0F, 0x8F, 0xF1,
  0xF3, 0xFC, 0xFF, 0xEF, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F,
  0xBF, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF8, 0x1F,
  0x80, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xC0, 0x1F, 0x00,
  0x0C, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFE, 0x01, 0xE0,
  0x06, 0x00, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7E, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE3,
  0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xCF, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3,
  0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x03,
  0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xC3, 0xFC,
  0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFE, 0xFE,
  0x7E, 0x1F, 0xCF, 0x03, 0xF9, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0x80, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x3F,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xF0, 0x3F, 0xCF, 0xFC, 0x07,
  0xFD, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0xFE,
  0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFE,
  0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xC1, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x1F, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1,
  0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xC1, 0xFE, 0x1F, 0xE0,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFD, 0xFE, 0x00, 0x7F, 0x7F,
  0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x9F, 0xE0, 0x3F, 0xE7, 0xF8, 0x1F, 0xF9,
  0xFF, 0x9F, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F,
  0x9F, 0xE0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xFF, 0x00,
  0x3C, 0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x78, 0x1F, 0x00, 0x7F, 0xFF, 0x80,
  0xF0, 0x7E, 0x01, 0xFF, 0xFF, 0x81, 0xF0, 0xF8, 0x07, 0xF8, 0x7E, 0x03,
  0xE3, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0x81, 0xF8, 0x0F,
  0x8F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF3,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xE7, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xCF,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x9F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x7D, 0xF8,
  0x1F, 0x80, 0x7E, 0x00, 0xF3, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE7, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x9F, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x7C, 0x07,
  0xE0, 0x3F, 0x00, 0xF0, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xE1, 0xF0, 0x1F,
  0x83, 0xFC, 0x0F, 0x83, 0xE0, 0x3F, 0x8F, 0xF8, 0x1F, 0x07, 0xC0, 0x7F,
  0xFF, 0xF0, 0xFC, 0x0F, 0x80, 0xFF, 0xFB, 0xFF, 0xF0, 0x1F, 0x00, 0xFF,
  0xE7, 0xFF, 0xE0, 0x3E, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7E, 0x01, 0xFE,
  0x07, 0xFC, 0x00, 0xFC, 0x00, 0x70, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFE,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC,
  0x0F, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F,
  0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0xF1, 0xFE, 0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F,
  0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x1F, 0xE0,
  0x1F, 0xFF, 0xE7, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF8, 0x7F,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x01,
  0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x03,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0xFF, 0xC0,
  0x00, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0x07,
  0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xBF, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x01,
  0xFF, 0xFC, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x7F, 0xBF, 0x80, 0x1F, 0xCF, 0xE0, 0x1F, 0xEF, 0xE0,
  0x07, 0xF7, 0xF8, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFE, 0x01, 0xFC, 0x7E,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x3F, 0xC7,
  0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xF1, 0xF8, 0x07, 0xE3, 0xFC, 0x03, 0xFC,
  0x7E, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF8, 0x07,
  0xF8, 0x3F, 0x0F, 0xE1, 0xFE, 0x01, 0xFE, 0x0F, 0xC3, 0xF8, 0x7F, 0x80,
  0x7F, 0x83, 0xF1, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFC, 0x7F, 0x07, 0xF8,
  0x07, 0xF8, 0x3F, 0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xCF, 0xE0, 0xFF,
  0x00, 0xFF, 0x03, 0xFB, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x01, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xE0,
  0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xFF,
  0xF0, 0x07, 0xF8, 0x03, 0xFD, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0xFC, 0x01,
  0xFE, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x1F, 0x80, 0xFF, 0x00,
  0x7F, 0x8F, 0xC0, 0x7F, 0x80, 0x3F, 0xC7, 0xF0, 0x3F, 0xC0, 0x1F, 0xE1,
  0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x0F, 0xC3, 0xFC, 0x01,
  0xFE, 0x07, 0xE1, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x00,
  0xFC, 0x7F, 0x80, 0x7F, 0x80, 0x7E, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xBF,
  0xC0, 0x1F, 0xE0, 0x0F, 0xDF, 0xE0, 0x0F, 0xF0, 0x07, 0xEF, 0xF0, 0x0F,
  0xF0, 0x03, 0xF7, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x3F,
  0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00,
  0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xFC,
  0x03, 0xFC, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F,
  0xC0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x7F,
  0x80, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x07, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0xFF,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x03,
  0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x03, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xF1,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xE0, 0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x03,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x87,
  0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00,
  0xFE, 0x3F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x80,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x3F,
  0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x3F,
  0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFF,
  0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFB,
  0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xFB, 0xF0, 0x3F, 0xC0, 0x7F, 0x03, 0xFB,
  0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF3, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF3,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xE3, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xE3,
  0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xE3, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xC3,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xC3, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC3,
  0xF1, 0xFE, 0x00, 0x7F, 0x1F, 0x83, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x83,
  0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x83, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x03,
  0xF3, 0xF8, 0x00, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7E, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x0F, 0xF9, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x0F, 0xF9, 0xFE, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF0, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x1F, 0xE0, 0x3F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x07, 0xFC,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8,
  0x07, 0xE7, 0xC0, 0x3F, 0x3E, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0xFE, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x03, 0xE3,
  0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xF8, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x83,
  0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFC, 0x1F, 0xC3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x3F, 0xC7,
  0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x03, 0xF8, 0xFF, 0x00,
  0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF8,
  0xFF, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0x81, 0xFF, 0xE7, 0xF8, 0x07, 0xFC, 0x7F,
  0x80, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x0F, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x07, 0xFB,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0x03, 0xFE, 0x01,
  0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x1F,
  0xE0, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xFE,
  0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0x7F,
  0xFF, 0x80, 0xFE, 0x7F, 0xFF, 0x01, 0xFC, 0x7F, 0xF8, 0x07, 0xF8, 0x7F,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x1F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x03,
  0xF8, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x07,
  0xF0, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x07,
  0xF8, 0x00, 0x7F, 0xE3, 0xFC, 0x00, 0xFF, 0xF9, 0xFE, 0x00, 0xFF, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xDF,
  0xC0, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0x81, 0xFE, 0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x0F,
  0xE3, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x0C, 0x07, 0xF8, 0x01, 0xE0, 0x7F, 0xC0, 0x7E, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x7F, 0xFC, 0x7F, 0x00, 0xFF, 0xFE, 0x7F,
  0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC,
  0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8,
  0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xE0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xDF, 0xC0, 0x01, 0xFF, 0x9F, 0xC0,
  0x00, 0x3C, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x10, 0x00, 0x7F, 0x80, 0x38, 0x00, 0xFF, 0x80,
  0x3C, 0x01, 0xFF, 0x00, 0x7F, 0xCF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0x03, 0xFC, 0xFF, 0xC0,
  0x0F, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0x81, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F,
  0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0xC1,
  0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0x00,
  0x38, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x81,
  0xFF, 0x80, 0x3F, 0x81, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0,
  0xFF, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x03, 0xFC,
  0xFF, 0x80, 0x01, 0xFC, 0xFF, 0x80, 0x00, 0xFE, 0x7F, 0xC0, 0x00, 0xFF,
  0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xDF, 0xE0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x7F, 0xC3, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x07, 0xF0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xF9, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xC3, 0xFE, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xC1, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x83,
  0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF3, 0xFF, 0x00, 0x3F, 0xDF, 0xFE, 0x00,
  0xFE, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x03,
  0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87,
  0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC,
  0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x1F,
  0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0,
  0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F,
  0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F,
  0x80, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF, 0x00,
  0x0F, 0xE7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x03, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x9F, 0xF8, 0x00, 0x3F, 0xDF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F,
  0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xF3, 0xFF,
  0xF0, 0x03, 0xF8, 0xFF, 0xF0, 0x03, 0xFC, 0x3F, 0xF0, 0x01, 0xFE, 0x03,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xFF, 0x87, 0xF0, 0x1F, 0xFF, 0x1F, 0xC0, 0xFF, 0xFE, 0xFF, 0x07,
  0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFE,
  0x0F, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFC, 0x00,
  0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0xFF,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xFE, 0x01, 0xFE,
  0x07, 0xFC, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFE, 0xFF, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x03,
  0xF9, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xFE, 0x7F, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01,
  0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F,
  0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFE,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x3F,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFB,
  0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xCF, 0xF0, 0x07, 0xF9, 0xFE, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x8F, 0xF0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x01,
  0xFC, 0x7F, 0x03, 0xFE, 0x03, 0xFC, 0x7F, 0x03, 0xFF, 0x03, 0xF8, 0x7F,
  0x03, 0xFF, 0x03, 0xF8, 0x7F, 0x07, 0xFF, 0x07, 0xF8, 0x7F, 0x07, 0xFF,
  0x07, 0xF0, 0x7F, 0x0F, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xFF, 0x0F, 0xE0,
  0x7F, 0x0F, 0xFF, 0x0F, 0xE0, 0x7F, 0x1F, 0xBF, 0x0F, 0xE0, 0x7F, 0x1F,
  0xBF, 0x1F, 0xC0, 0x7F, 0x3F, 0xBF, 0x1F, 0xC0, 0x7F, 0x3F, 0x3F, 0x1F,
  0x80, 0x7F, 0x7F, 0x3F, 0x3F, 0x80, 0x7F, 0x7E, 0x1F, 0x3F, 0x80, 0x7F,
  0x7E, 0x1F, 0x7F, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x7F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xE0,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xF8, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F,
  0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0x0F, 0xFF, 0x00, 0x3F, 0x1F, 0xFF, 0x80, 0x3F,
  0x1F, 0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xE0, 0x7E, 0x3F, 0xFF, 0xF0, 0xFE,
  0x7F, 0x0F, 0xFF, 0xFE, 0x7E, 0x07, 0xFF, 0xFC, 0xFE, 0x03, 0xFF, 0xFC,
  0xFC, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0x80,
};

const GFXglyph RobotoCondensed_MediumItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 50, 17, 2, -49 },
  { 101, 19, 18, 21, 5, -52 },
  { 144, 35, 49, 36, 2, -49 },
  { 359, 30, 64, 33, 2, -57 },
  { 599, 32, 51, 43, 6, -50 },
  { 803, 34, 51, 38, 1, -50 },
  { 1020, 9, 17, 11, 5, -52 },
  { 1040, 21, 71, 21, 3, -55 },
  { 1227, 21, 71, 22, -3, -55 },
  { 1414, 29, 29, 30, 3, -49 },
  { 1520, 29, 36, 32, 2, -41 },
  { 1651, 13, 19, 15, -4, -8 },
  { 1682, 16, 7, 21, 2, -25 },
  { 1696, 9, 9, 19, 2, -8 },
  { 1707, 31, 53, 23, -4, -49 },
  { 1913, 29, 51, 33, 3, -50 },
  { 2098, 19, 49, 33, 8, -49 },
  { 2215, 32, 50, 33, 0, -50 },
  { 2415, 31, 51, 33, 1, -50 },
  { 2613, 31, 49, 33, 1, -49 },
  { 2803, 31, 50, 33, 3, -49 },
  { 2997, 27, 50, 33, 3, -49 },
  { 3166, 31, 49, 33, 4, -49 },
  { 3356, 30, 51, 33, 2, -50 },
  { 3548, 26, 50, 33, 5, -50 },
  { 3711, 14, 38, 17, 2, -37 },
  { 3778, 18, 48, 16, -3, -37 },
  { 3886, 26, 31, 30, 2, -37 },
  { 3987, 28, 21, 33, 3, -33 },
  { 4061, 27, 32, 31, 2, -37 },
  { 4169, 25, 51, 29, 5, -50 },
  { 4329, 47, 63, 51, 2, -48 },
  { 4700, 38, 49, 39, -3, -49 },
  { 4933, 35, 49, 37, 1, -49 },
  { 5148, 35, 51, 38, 3, -50 },
  { 5372, 35, 49, 38, 1, -49 },
  { 5587, 35, 49, 33, 1, -49 },
  { 5802, 34, 49, 32, 1, -49 },
  { 6011, 35, 51, 39, 3, -50 },
  { 6235, 41, 49, 41, 1, -49 },
  { 6487, 17, 49, 17, 1, -49 },
  { 6592, 33, 50, 33, 0, -49 },
  { 6799, 40, 49, 37, 1, -49 },
  { 7044, 27, 49, 32, 1, -49 },
  { 7210, 50, 49, 51, 1, -49 },
  { 7517, 41, 49, 41, 1, -49 },
  { 7769, 36, 51, 40, 3, -50 },
  { 7999, 37, 49, 38, 1, -49 },
  { 8226, 35, 59, 40, 3, -50 },
  { 8485, 35, 49, 36, 1, -49 },
  { 8700, 35, 51, 35, 1, -50 },
  { 8924, 33, 49, 36, 6, -49 },
  { 9127, 36, 50, 38, 3, -49 },
  { 9352, 36, 49, 38, 6, -49 },
  { 9573, 48, 49, 51, 6, -49 },
  { 9867, 42, 49, 37, -2, -49 },
  { 10125, 34, 49, 36, 6, -49 },
  { 10334, 38, 49, 35, -1, -49 },
  { 10567, 23, 68, 17, -1, -57 },
  { 10763, 15, 53, 25, 6, -49 },
  { 10863, 23, 68, 17, -4, -57 },
  { 11059, 21, 25, 26, 3, -49 },
  { 11125, 27, 6, 27, -4, 0 },
  { 11146, 13, 10, 22, 7, -52 },
  { 11163, 28, 38, 32, 1, -37 },
  { 11296, 31, 53, 33, 0, -52 },
  { 11502, 28, 38, 31, 2, -37 },
  { 11635, 33, 53, 33, 2, -52 },
  { 11854, 28, 38, 32, 2, -37 },
  { 11987, 23, 53, 22, 3, -53 },
  { 12140, 32, 51, 33, 0, -37 },
  { 12344, 30, 52, 33, 0, -52 },
  { 12539, 16, 50, 16, 1, -50 },
  { 12639, 24, 64, 16, -7, -50 },
  { 12831, 33, 52, 31, 0, -52 },
  { 13046, 16, 52, 16, 1, -52 },
  { 13150, 47, 37, 50, 0, -37 },
  { 13368, 30, 37, 33, 0, -37 },
  { 13507, 29, 38, 33, 2, -37 },
  { 13645, 33, 51, 33, -2, -37 },
  { 13856, 30, 51, 33, 2, -37 },
  { 14048, 23, 37, 21, 0, -37 },
  { 14155, 28, 38, 30, 1, -37 },
  { 14288, 19, 46, 20, 2, -45 },
  { 14398, 30, 37, 33, 2, -36 },
  { 14537, 27, 36, 29, 4, -36 },
  { 14659, 40, 36, 43, 4, -36 },
  { 14839, 33, 36, 30, -2, -36 },
  { 14988, 33, 50, 29, -2, -36 },
  { 15195, 31, 36, 30, -1, -36 },
  { 15335, 21, 66, 20, 2, -54 },
  { 15509, 15, 58, 17, 1, -49 },
  { 15618, 22, 66, 20, -3, -54 },
  { 15800, 32, 14, 38, 3, -27 },
};

const GFXfont RobotoCondensed_MediumItalic69pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic69pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic69pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC69PT7B_H_
