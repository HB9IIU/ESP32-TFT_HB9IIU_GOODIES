#ifndef _ROBOTOCONDENSED_MEDIUMITALIC19PT7B_H_
#define _ROBOTOCONDENSED_MEDIUMITALIC19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-MediumItalic.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_MediumItalic19pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCC, 0x63, 0x18, 0xC4, 0x63, 0x00, 0x06, 0x30, 0x69, 0xA4,
  0x96, 0x58, 0x0D, 0x84, 0x82, 0x43, 0x61, 0x23, 0xFC, 0xD8, 0x68, 0x24,
  0x7F, 0x9B, 0x09, 0x05, 0x86, 0xC0, 0x04, 0x04, 0x1E, 0x3E, 0x73, 0x63,
  0x60, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0xC6, 0xCE, 0xFC, 0x78, 0x20, 0x20,
  0x70, 0x68, 0x26, 0xD2, 0x4B, 0x67, 0x60, 0x20, 0x30, 0x37, 0x16, 0x9A,
  0x79, 0x20, 0xB0, 0x70, 0x0E, 0x07, 0xC1, 0xB0, 0xCC, 0x33, 0x07, 0x81,
  0xC0, 0xF2, 0x6D, 0x99, 0xEE, 0x79, 0x8C, 0x7F, 0x0F, 0x60, 0x6D, 0x2C,
  0x04, 0x61, 0x8C, 0x21, 0x86, 0x10, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x41, 0x82, 0x00, 0x10, 0x60, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC6,
  0x18, 0x63, 0x0C, 0x63, 0x08, 0x00, 0x08, 0x08, 0x5B, 0xFF, 0x18, 0x28,
  0x6C, 0x44, 0x18, 0x18, 0x18, 0x18, 0xFE, 0xFE, 0x30, 0x30, 0x30, 0x30,
  0x26, 0x66, 0xC0, 0xFF, 0x5D, 0x80, 0x03, 0x03, 0x02, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x1C, 0x3E, 0x63,
  0x63, 0x63, 0xC3, 0xC7, 0xC6, 0xC6, 0xC6, 0xC6, 0xCC, 0xFC, 0x78, 0x09,
  0xFF, 0x31, 0x8C, 0xC6, 0x31, 0x8C, 0xE6, 0x30, 0x0E, 0x1F, 0x8C, 0xEE,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0F, 0xF7, 0xF8,
  0x0E, 0x1F, 0x8C, 0xE6, 0x30, 0x38, 0x18, 0x78, 0x3C, 0x03, 0x01, 0xB8,
  0xCC, 0xE7, 0xE1, 0xE0, 0x03, 0x81, 0x81, 0xC1, 0xE0, 0xB0, 0xD8, 0xCC,
  0x6C, 0x66, 0x7F, 0xBF, 0xC0, 0xC0, 0x60, 0x60, 0x3F, 0x3F, 0x30, 0x60,
  0x60, 0x7C, 0x7E, 0x06, 0x06, 0x06, 0xC6, 0xCE, 0xFC, 0x78, 0x0E, 0x3C,
  0xC3, 0x86, 0x0F, 0xBF, 0xF3, 0xC7, 0x8F, 0x1E, 0x77, 0xCF, 0x00, 0x7F,
  0xBF, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0E,
  0x06, 0x07, 0x00, 0x1C, 0x3E, 0x73, 0x63, 0x63, 0x66, 0x3E, 0x7C, 0xC6,
  0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x1C, 0x3E, 0x66, 0x63, 0xE3, 0xC7, 0xE6,
  0x7E, 0x3E, 0x06, 0x0C, 0x1C, 0x78, 0x60, 0x03, 0x30, 0x00, 0x00, 0x4E,
  0x60, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x01, 0x88, 0xC6, 0x60, 0x02, 0x1D,
  0xF7, 0x0E, 0x0F, 0x07, 0x04, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x20,
  0x30, 0x3C, 0x0F, 0x07, 0x1E, 0x78, 0x60, 0x80, 0x3C, 0xFD, 0x9F, 0x30,
  0x61, 0x87, 0x1C, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x03, 0xE0, 0x71,
  0x86, 0x06, 0x20, 0x13, 0x3C, 0x93, 0xA5, 0x93, 0x29, 0x99, 0x4C, 0x8A,
  0x64, 0x72, 0x67, 0x9F, 0x64, 0xEE, 0x20, 0x01, 0x80, 0x07, 0x60, 0x1F,
  0x00, 0x01, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x19, 0x03, 0x30, 0xC6,
  0x18, 0xC7, 0xF8, 0xFF, 0x38, 0x66, 0x0C, 0xC1, 0x80, 0x1F, 0x0F, 0xE3,
  0x1C, 0xC3, 0x31, 0xCC, 0x63, 0xF9, 0xFC, 0x61, 0x98, 0x66, 0x19, 0x8E,
  0x7F, 0x3F, 0x80, 0x1F, 0x1F, 0xDC, 0x6C, 0x36, 0x1F, 0x03, 0x01, 0x80,
  0xC0, 0x61, 0xB0, 0xD8, 0xE7, 0xE1, 0xE0, 0x1F, 0x0F, 0xE3, 0x18, 0xC3,
  0x30, 0xCC, 0x33, 0x0D, 0xC7, 0x61, 0x98, 0x66, 0x19, 0x8C, 0x7F, 0x3F,
  0x00, 0x1F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xF1, 0xFC, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x7F, 0x3F, 0xC0, 0x1F, 0xCF, 0xE3, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0xF1, 0xFC, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x86, 0x60, 0x38, 0x0C, 0x03, 0x1E, 0xC7,
  0xB0, 0xEC, 0x3B, 0x8C, 0x7F, 0x0F, 0x80, 0x18, 0x63, 0x86, 0x30, 0x63,
  0x06, 0x30, 0x63, 0x0E, 0x3F, 0xC7, 0xFC, 0x60, 0xC6, 0x0C, 0x60, 0xC6,
  0x1C, 0x61, 0x8E, 0x18, 0x19, 0xCC, 0x63, 0x18, 0xCE, 0x63, 0x18, 0xC6,
  0x70, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0xB1, 0x9C, 0xC7, 0xC1, 0xC0, 0x18, 0xE7, 0x38, 0xC6, 0x19, 0xC3, 0x70,
  0x7C, 0x0F, 0x03, 0xF0, 0x76, 0x0C, 0xC1, 0x9C, 0x31, 0x86, 0x39, 0xC7,
  0x00, 0x18, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60,
  0x60, 0x7F, 0xFE, 0x18, 0x1C, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x78,
  0xF1, 0xE3, 0xCD, 0x9B, 0x36, 0x65, 0x99, 0x96, 0xE6, 0x73, 0x19, 0xCC,
  0x67, 0x33, 0x98, 0xC0, 0x18, 0x63, 0x86, 0x38, 0x63, 0xC6, 0x3C, 0x63,
  0x4E, 0x36, 0xC7, 0x6C, 0x66, 0xC6, 0x2C, 0x63, 0xC6, 0x3C, 0x61, 0x8E,
  0x18, 0x1F, 0x0F, 0xE7, 0x19, 0x86, 0x61, 0xF8, 0x7C, 0x1B, 0x06, 0xC1,
  0xB0, 0x6C, 0x3B, 0x8C, 0x7E, 0x0F, 0x00, 0x1F, 0x8F, 0xF3, 0x0C, 0xC3,
  0x30, 0xCC, 0x33, 0x1D, 0xFE, 0x7F, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x00, 0x1F, 0x0F, 0xE7, 0x19, 0x86, 0x61, 0xF8, 0x6C, 0x1B, 0x06, 0xC1,
  0xB0, 0x6C, 0x33, 0x8C, 0x7E, 0x0F, 0x80, 0x70, 0x08, 0x1F, 0x0F, 0xE3,
  0x1C, 0xC3, 0x30, 0xCC, 0x73, 0x19, 0xFE, 0x7E, 0x19, 0xC6, 0x31, 0x8C,
  0x63, 0x38, 0xE0, 0x0F, 0x07, 0xE3, 0x9C, 0xC3, 0x30, 0x0E, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0xEE, 0x39, 0x8C, 0x7F, 0x0F, 0x80, 0xFF, 0xFF, 0x86,
  0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03,
  0x00, 0x70, 0xD8, 0x76, 0x19, 0x86, 0x61, 0x98, 0x6E, 0x1B, 0x0E, 0xC3,
  0x30, 0xCC, 0x33, 0x1C, 0xFE, 0x1F, 0x00, 0xC1, 0xB0, 0xEC, 0x33, 0x0C,
  0xC7, 0x31, 0x8C, 0xE1, 0xB0, 0x6C, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x00, 0xC6, 0x3E, 0x31, 0xB3, 0x8D, 0x9C, 0xEC, 0xE6, 0x6D, 0x33, 0x69,
  0x9B, 0x58, 0xF2, 0xC7, 0x9E, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x61, 0x80,
  0x30, 0xE7, 0x18, 0x67, 0x0D, 0xC1, 0xB0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x07, 0xC0, 0xCC, 0x39, 0x8E, 0x31, 0x87, 0x00, 0xC3, 0xE1, 0xB1, 0xDC,
  0xC6, 0xC3, 0x61, 0xE0, 0xF0, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x00,
  0x3F, 0xCF, 0xF0, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0C,
  0x07, 0x01, 0x80, 0xFF, 0x3F, 0xC0, 0x1C, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0x61, 0x86, 0x18, 0x61, 0x8E, 0x30, 0xC3, 0x8E, 0x00, 0xCC, 0xCC, 0xCC,
  0x66, 0x66, 0x66, 0x63, 0x30, 0x1C, 0x70, 0xC7, 0x18, 0x61, 0x86, 0x18,
  0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x33, 0x8E, 0x00, 0x18, 0xE3, 0x9A, 0x6B,
  0x2C, 0xC0, 0xFF, 0xFC, 0xC6, 0x20, 0x1E, 0x3F, 0x73, 0x03, 0x3F, 0x76,
  0xE6, 0xE6, 0x7E, 0x76, 0x38, 0x30, 0x30, 0x30, 0x3E, 0x3F, 0x73, 0x63,
  0x63, 0x63, 0x63, 0x67, 0xFE, 0xDC, 0x1E, 0x3F, 0x63, 0x63, 0x60, 0x60,
  0x66, 0x66, 0x7E, 0x3C, 0x01, 0x80, 0x60, 0x18, 0x06, 0x1D, 0x8F, 0xE6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x9C, 0x7E, 0x0F, 0x80, 0x3C, 0xFF,
  0x9E, 0x3F, 0xFF, 0xF0, 0x62, 0xFC, 0xF0, 0x1C, 0xF3, 0x0C, 0xFB, 0xE6,
  0x18, 0x61, 0x8C, 0x30, 0xC3, 0x00, 0x1D, 0x9F, 0xDC, 0xCC, 0x66, 0x33,
  0x19, 0x8C, 0xCE, 0x7E, 0x1F, 0x01, 0x80, 0xCF, 0xC3, 0xC0, 0x38, 0x30,
  0x30, 0x30, 0x3E, 0x3F, 0x73, 0x63, 0x63, 0x63, 0x67, 0xE6, 0xC6, 0xC6,
  0x39, 0x80, 0x63, 0x19, 0x8C, 0x63, 0x19, 0xCC, 0x00, 0x0E, 0x18, 0x00,
  0x60, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x78, 0xE0,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x39, 0xB9, 0xF8, 0xF8, 0x78, 0x3E, 0x1B,
  0x0D, 0xCC, 0x66, 0x30, 0x19, 0xCC, 0x63, 0x18, 0xCC, 0x63, 0x18, 0xCE,
  0x60, 0x3E, 0x71, 0xFF, 0xDC, 0xC6, 0xC6, 0x36, 0x31, 0xB1, 0x9D, 0x9C,
  0xCC, 0xC6, 0xC6, 0x36, 0x31, 0x80, 0x3E, 0x3F, 0x73, 0x63, 0x63, 0x63,
  0x67, 0xE6, 0xC6, 0xC6, 0x3C, 0x7E, 0xE6, 0xC6, 0xC6, 0xC6, 0xC6, 0xCE,
  0xFC, 0x78, 0x1F, 0x0F, 0xCE, 0x66, 0x33, 0x19, 0x8C, 0xC6, 0x67, 0x7F,
  0x37, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1D, 0x9F, 0xD8, 0xCC, 0x66, 0x33,
  0x19, 0x8C, 0xCE, 0x7E, 0x1F, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x3C, 0xF7,
  0x18, 0x61, 0x86, 0x18, 0xC3, 0x00, 0x1E, 0x3F, 0x63, 0x70, 0x38, 0x1E,
  0x06, 0xC6, 0x7E, 0x3C, 0x33, 0x99, 0xFF, 0x31, 0x9C, 0xC6, 0x31, 0xC6,
  0x00, 0x63, 0x66, 0xC6, 0xC6, 0xC6, 0xC6, 0xCE, 0xCC, 0xFC, 0xFC, 0xC7,
  0x8F, 0x36, 0x64, 0xCF, 0x1E, 0x38, 0x70, 0xC0, 0xC4, 0x79, 0xCF, 0x3B,
  0x6F, 0x6D, 0xE9, 0xAF, 0x3D, 0xE3, 0x38, 0x67, 0x0C, 0x40, 0x39, 0x86,
  0xE1, 0xB0, 0x78, 0x0E, 0x07, 0x01, 0xE0, 0xD8, 0x76, 0x18, 0xC0, 0x31,
  0x8C, 0x63, 0x30, 0xCC, 0x16, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xC0, 0x70, 0x38, 0x00, 0x3F, 0x7F, 0x06, 0x0C, 0x1C, 0x38, 0x30,
  0x60, 0xFE, 0xFE, 0x04, 0x31, 0x86, 0x18, 0x63, 0x0C, 0x61, 0x86, 0x08,
  0x61, 0x86, 0x18, 0x30, 0x40, 0x11, 0x33, 0x32, 0x22, 0x26, 0x66, 0x44,
  0x44, 0xC0, 0x10, 0x61, 0x86, 0x18, 0x61, 0x86, 0x0C, 0x31, 0x8C, 0x30,
  0xC3, 0x18, 0x63, 0x00, 0x71, 0xFC, 0xB3, 0xD8, 0xC0,
};

const GFXglyph RobotoCondensed_MediumItalic19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 6, 1, -14 },
  { 14, 9, 14, 10, 1, -14 },
  { 30, 8, 18, 9, 1, -16 },
  { 48, 9, 14, 12, 2, -14 },
  { 64, 10, 14, 10, 0, -14 },
  { 82, 3, 5, 3, 1, -14 },
  { 84, 6, 19, 6, 1, -15 },
  { 99, 6, 19, 6, -1, -15 },
  { 114, 8, 8, 8, 1, -14 },
  { 122, 8, 10, 9, 1, -11 },
  { 132, 4, 5, 4, -1, -2 },
  { 135, 4, 2, 6, 1, -7 },
  { 136, 3, 3, 5, 0, -3 },
  { 138, 8, 15, 6, -1, -14 },
  { 153, 8, 14, 9, 1, -14 },
  { 167, 5, 14, 9, 2, -14 },
  { 176, 9, 14, 9, 0, -14 },
  { 192, 9, 14, 9, 0, -14 },
  { 208, 9, 14, 9, 0, -14 },
  { 224, 8, 14, 9, 1, -14 },
  { 238, 7, 14, 9, 1, -14 },
  { 251, 9, 14, 9, 1, -14 },
  { 267, 8, 14, 9, 1, -14 },
  { 281, 8, 14, 9, 1, -14 },
  { 295, 4, 11, 5, 0, -11 },
  { 301, 5, 14, 4, -1, -11 },
  { 310, 7, 8, 8, 1, -10 },
  { 317, 7, 6, 9, 1, -9 },
  { 323, 8, 9, 8, 0, -10 },
  { 332, 7, 14, 8, 1, -14 },
  { 345, 13, 17, 14, 0, -13 },
  { 373, 11, 14, 11, -1, -14 },
  { 393, 10, 14, 10, 0, -14 },
  { 411, 9, 14, 10, 1, -14 },
  { 427, 10, 14, 10, 0, -14 },
  { 445, 10, 14, 9, 0, -14 },
  { 463, 10, 14, 9, 0, -14 },
  { 481, 10, 14, 11, 1, -14 },
  { 499, 12, 14, 11, 0, -14 },
  { 520, 5, 14, 5, 0, -14 },
  { 529, 9, 14, 9, 0, -14 },
  { 545, 11, 14, 10, 0, -14 },
  { 565, 8, 14, 9, 0, -14 },
  { 579, 14, 14, 14, 0, -14 },
  { 604, 12, 14, 11, 0, -14 },
  { 625, 10, 14, 11, 1, -14 },
  { 643, 10, 14, 10, 0, -14 },
  { 661, 10, 16, 11, 1, -14 },
  { 681, 10, 14, 10, 0, -14 },
  { 699, 10, 14, 10, 0, -14 },
  { 717, 9, 14, 10, 2, -14 },
  { 733, 10, 14, 10, 1, -14 },
  { 751, 10, 14, 11, 2, -14 },
  { 769, 13, 14, 14, 2, -14 },
  { 792, 11, 14, 10, 0, -14 },
  { 812, 9, 14, 10, 2, -14 },
  { 828, 10, 14, 10, 0, -14 },
  { 846, 6, 19, 5, 0, -16 },
  { 861, 4, 15, 7, 2, -14 },
  { 869, 6, 19, 5, -1, -16 },
  { 884, 6, 7, 7, 1, -14 },
  { 890, 7, 2, 7, -1, 0 },
  { 892, 4, 3, 6, 2, -14 },
  { 894, 8, 10, 9, 0, -10 },
  { 904, 8, 14, 9, 0, -14 },
  { 918, 8, 10, 9, 0, -10 },
  { 928, 10, 14, 9, 0, -14 },
  { 946, 7, 10, 9, 1, -10 },
  { 955, 6, 14, 6, 1, -14 },
  { 966, 9, 14, 9, 0, -10 },
  { 982, 8, 14, 9, 0, -14 },
  { 996, 5, 13, 4, 0, -13 },
  { 1005, 7, 17, 4, -2, -13 },
  { 1020, 9, 14, 9, 0, -14 },
  { 1036, 5, 14, 4, 0, -14 },
  { 1045, 13, 10, 14, 0, -10 },
  { 1062, 8, 10, 9, 0, -10 },
  { 1072, 8, 10, 9, 1, -10 },
  { 1082, 9, 14, 9, -1, -10 },
  { 1098, 9, 14, 9, 0, -10 },
  { 1114, 6, 10, 6, 0, -10 },
  { 1122, 8, 10, 8, 0, -10 },
  { 1132, 5, 13, 6, 1, -13 },
  { 1141, 8, 10, 9, 1, -10 },
  { 1151, 7, 10, 8, 1, -10 },
  { 1160, 11, 10, 12, 1, -10 },
  { 1174, 10, 10, 8, -1, -10 },
  { 1187, 10, 14, 8, -1, -10 },
  { 1205, 8, 10, 8, 0, -10 },
  { 1215, 6, 18, 6, 0, -15 },
  { 1229, 4, 17, 5, 0, -14 },
  { 1238, 6, 18, 6, -1, -15 },
  { 1252, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_MediumItalic19pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_MediumItalic19pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_MediumItalic19pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOCONDENSED_MEDIUMITALIC19PT7B_H_
