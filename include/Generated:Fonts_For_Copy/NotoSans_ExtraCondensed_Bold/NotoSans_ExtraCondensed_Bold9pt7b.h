#ifndef _NOTOSANS_EXTRACONDENSED_BOLD9PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xF6, 0x5F, 0x5F, 0x66, 0x27, 0xC6, 0x3B, 0x62, 0x41,
  0x52, 0xC5, 0xE5, 0xA5, 0x4B, 0x00, 0x23, 0x98, 0xCF, 0xC9, 0xE0, 0xD0,
  0x69, 0x64, 0x98, 0xD5, 0x5C, 0x6F, 0x6F, 0x2F, 0x22, 0x60, 0xE0, 0xC0,
  0x32, 0x44, 0x48, 0x26, 0xDD, 0xDD, 0x60, 0x7C, 0x92, 0x40, 0x4F, 0x32,
  0x64, 0xF0, 0x4F, 0x36, 0x31, 0xE0, 0x26, 0x6A, 0xF2, 0x64, 0xE1, 0x3E,
  0x27, 0xCF, 0x9D, 0x60, 0xF3, 0x22, 0x64, 0x2F, 0xD6, 0xF9, 0x60, 0x4F,
  0x9F, 0x53, 0x60, 0xD0, 0xC0, 0xD0, 0x70, 0x3C, 0x61, 0xF0, 0xF0, 0xC3,
  0x68, 0x5C, 0xB4, 0x10, 0x11, 0xA5, 0xEB, 0xAE, 0xF4, 0x0E, 0x62, 0x94,
  0xED, 0x4C, 0xF7, 0xDB, 0xC0, 0x27, 0x4C, 0xC4, 0x70, 0xEB, 0xBB, 0xAE,
  0xEE, 0xB0, 0xEE, 0xA0, 0x1B, 0x91, 0xBD, 0xAD, 0xE0, 0xBB, 0xFB, 0xBB,
  0xE9, 0x25, 0xC0, 0x55, 0x56, 0xBE, 0xCE, 0xAB, 0x92, 0x49, 0xC0, 0xDE,
  0xF7, 0xBA, 0xD4, 0x9D, 0xDB, 0xBB, 0x23, 0x93, 0x9C, 0xAD, 0xC0, 0xF6,
  0xE9, 0x00, 0x23, 0x93, 0x9C, 0xAD, 0xC2, 0x18, 0xEA, 0xEC, 0xAB, 0x3E,
  0xC6, 0x2B, 0xE0, 0xF6, 0x66, 0x66, 0xBB, 0xBB, 0xBE, 0x9E, 0x94, 0xA6,
  0x30, 0x97, 0x6B, 0xD3, 0x66, 0xCD, 0x80, 0xF6, 0x66, 0x7D, 0xD7, 0x66,
  0x22, 0xF2, 0x64, 0xCF, 0xEA, 0xAC, 0x84, 0x42, 0x23, 0xD5, 0x5C, 0x22,
  0x95, 0x30, 0xF0, 0xD0, 0x61, 0x7B, 0xF0, 0xCC, 0xFD, 0xDD, 0xF0, 0x7B,
  0x66, 0x11, 0x7D, 0xDD, 0x70, 0x6D, 0xFC, 0x70, 0x6B, 0xA4, 0x90, 0x7D,
  0xDD, 0x71, 0x70, 0xCC, 0xFD, 0xDD, 0xD0, 0xCF, 0xFC, 0xCF, 0xFF, 0xC0,
  0x92, 0xED, 0xE8, 0xFF, 0xFC, 0xFF, 0x5D, 0x75, 0xD4, 0xFD, 0xDD, 0xD0,
  0x6D, 0xDD, 0x70, 0xFD, 0xDD, 0xFC, 0xC0, 0x7D, 0xDD, 0x71, 0x10, 0xBB,
  0x6C, 0x71, 0x9E, 0x5D, 0x24, 0xC0, 0xDD, 0xDD, 0x70, 0x9F, 0x66, 0x60,
  0xB7, 0xD7, 0xDE, 0x68, 0xB6, 0x66, 0xB0, 0x9F, 0x66, 0x64, 0xC0, 0xED,
  0x2E, 0x69, 0x44, 0x98, 0xFF, 0xFF, 0xC0, 0xC9, 0x14, 0xB0, 0xFA,
};

const GFXglyph NotoSans_ExtraCondensed_Bold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 4, 6, 5, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 7, 7, 7, 0, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 2, 2, 2, 0, -6 },
  { 24, 3, 7, 3, 0, -6 },
  { 27, 2, 7, 3, 0, -6 },
  { 29, 4, 4, 4, 0, -7 },
  { 31, 4, 4, 4, 0, -5 },
  { 33, 2, 2, 2, 0, -1 },
  { 34, 3, 1, 3, 0, -3 },
  { 35, 2, 1, 2, 0, -1 },
  { 36, 4, 6, 4, 0, -6 },
  { 39, 4, 7, 4, 0, -7 },
  { 43, 3, 6, 4, 0, -6 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 4, 6, 4, 0, -6 },
  { 57, 4, 6, 4, 0, -6 },
  { 60, 4, 7, 4, 0, -7 },
  { 64, 4, 6, 4, 0, -6 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 4, 7, 4, 0, -7 },
  { 75, 2, 5, 2, 0, -5 },
  { 77, 2, 6, 2, 0, -5 },
  { 79, 4, 4, 4, 0, -5 },
  { 81, 4, 3, 4, 0, -5 },
  { 83, 4, 4, 4, 0, -5 },
  { 85, 3, 7, 3, 0, -7 },
  { 88, 6, 8, 7, 0, -7 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 3, 6, 5, 1, -6 },
  { 101, 4, 7, 4, 0, -7 },
  { 105, 4, 6, 5, 1, -6 },
  { 108, 2, 6, 4, 1, -6 },
  { 110, 2, 6, 4, 1, -6 },
  { 112, 5, 7, 5, 0, -7 },
  { 117, 4, 6, 5, 1, -6 },
  { 120, 3, 6, 3, 0, -6 },
  { 123, 2, 8, 2, 0, -6 },
  { 125, 4, 6, 5, 1, -6 },
  { 128, 3, 6, 4, 1, -6 },
  { 131, 5, 6, 7, 1, -6 },
  { 135, 4, 6, 6, 1, -6 },
  { 138, 5, 7, 5, 0, -7 },
  { 143, 3, 6, 4, 1, -6 },
  { 146, 5, 9, 5, 0, -7 },
  { 152, 4, 6, 5, 1, -6 },
  { 155, 4, 7, 4, 0, -7 },
  { 159, 4, 6, 4, 0, -6 },
  { 162, 4, 6, 5, 1, -6 },
  { 165, 5, 6, 5, 0, -6 },
  { 169, 7, 6, 7, 0, -6 },
  { 175, 4, 6, 4, 0, -6 },
  { 178, 4, 6, 4, 0, -6 },
  { 181, 4, 6, 4, 0, -6 },
  { 184, 2, 7, 3, 1, -6 },
  { 186, 4, 6, 4, 0, -6 },
  { 189, 2, 7, 3, 0, -6 },
  { 191, 5, 4, 5, 0, -6 },
  { 194, 4, 1, 4, 0, 1 },
  { 195, 2, 2, 3, 0, -7 },
  { 196, 4, 5, 4, 0, -5 },
  { 199, 4, 7, 5, 0, -7 },
  { 203, 3, 5, 4, 0, -5 },
  { 205, 4, 7, 5, 0, -7 },
  { 209, 4, 5, 4, 0, -5 },
  { 212, 3, 7, 3, 0, -7 },
  { 215, 4, 7, 5, 0, -5 },
  { 219, 4, 7, 5, 0, -7 },
  { 223, 2, 7, 2, 0, -7 },
  { 225, 2, 9, 2, 0, -7 },
  { 228, 3, 7, 4, 1, -7 },
  { 231, 2, 7, 2, 0, -7 },
  { 233, 6, 5, 7, 0, -5 },
  { 237, 4, 5, 5, 0, -5 },
  { 240, 4, 5, 4, 0, -5 },
  { 243, 4, 7, 5, 0, -5 },
  { 247, 4, 7, 5, 0, -5 },
  { 251, 3, 5, 3, 0, -5 },
  { 253, 3, 5, 3, 0, -5 },
  { 255, 3, 6, 3, 0, -6 },
  { 258, 4, 5, 5, 0, -5 },
  { 261, 4, 5, 4, 0, -5 },
  { 264, 6, 5, 6, 0, -5 },
  { 268, 4, 5, 4, 0, -5 },
  { 271, 4, 7, 4, 0, -5 },
  { 275, 3, 5, 3, 0, -5 },
  { 277, 3, 7, 3, 0, -6 },
  { 280, 2, 9, 4, 1, -7 },
  { 283, 3, 7, 3, 0, -6 },
  { 286, 4, 2, 4, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Bold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD9PT7B_H_
