#ifndef _NOTOSANS_EXTRACONDENSED_BOLD52PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold52pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x10, 0xFF, 0x1F, 0xEF, 0xE3, 0xFD, 0xFC, 0x7F, 0x3F, 0x8F,
  0xE7, 0xF0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF1,
  0xF0, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xE3, 0xE0, 0x03, 0xE3,
  0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x87, 0xC0, 0x0F, 0x8F,
  0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x8F,
  0x80, 0x0F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x07,
  0xFF, 0x80, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xF7, 0x3C, 0xFE, 0x70, 0x4F, 0xE7, 0x00, 0xFE, 0x70, 0x0F, 0xE7, 0x00,
  0x7F, 0x70, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0x7F, 0x00, 0x73, 0xF0, 0x07, 0x3F, 0x80,
  0x73, 0xFE, 0x07, 0x7F, 0xF8, 0x77, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x7C, 0x00, 0x7E, 0x7C, 0x03,
  0xE0, 0x03, 0xE3, 0xF0, 0x3F, 0x00, 0x1F, 0x0F, 0x81, 0xF0, 0x00, 0xF8,
  0x7C, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0xF8, 0x00, 0x3E, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC3, 0xE0, 0x00, 0x7C, 0x3E,
  0x1F, 0x00, 0x03, 0xE1, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0x8F, 0x83, 0xC0,
  0xF8, 0x7C, 0x7C, 0x7F, 0x87, 0xC7, 0xE7, 0xC7, 0xFE, 0x1F, 0x3E, 0x3E,
  0x7F, 0xF8, 0xFF, 0xF3, 0xF3, 0xFF, 0xC7, 0xFF, 0x1F, 0x1F, 0x3F, 0x1F,
  0xF8, 0xF9, 0xF8, 0xF8, 0x7F, 0x8F, 0x8F, 0x87, 0xC0, 0x60, 0x7C, 0x7C,
  0x3E, 0x00, 0x07, 0xE3, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x0F, 0xC0, 0x01,
  0xF0, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x3E, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0xF8, 0x00, 0x7C, 0x0F, 0x87, 0xC0, 0x03, 0xE0,
  0x7C, 0x3E, 0x00, 0x3F, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0x0F, 0xDF, 0x00,
  0x0F, 0x80, 0x7F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x07,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87,
  0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x0F,
  0xE1, 0xFF, 0xE0, 0xFE, 0x1F, 0xFE, 0x0F, 0xE3, 0xFF, 0xF1, 0xFC, 0x7F,
  0xFF, 0x9F, 0xC7, 0xF3, 0xF9, 0xFC, 0x7F, 0x1F, 0xDF, 0xCF, 0xE1, 0xFF,
  0xF8, 0xFE, 0x0F, 0xFF, 0x8F, 0xE0, 0x7F, 0xF0, 0xFE, 0x03, 0xFF, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0x9F, 0xE0, 0x7F, 0xE0, 0xFF, 0x00, 0x60, 0x00, 0x00, 0xFF,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x20, 0x7C,
  0x09, 0xE3, 0xE3, 0xCF, 0xFF, 0x7E, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC,
  0x01, 0xFB, 0xF0, 0x1F, 0xDF, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xF0, 0x1E,
  0x0F, 0x00, 0x20, 0x20, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x3F, 0x9F, 0xDF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0xFE,
  0x7E, 0x3F, 0x1F, 0x8F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF0, 0xFE, 0x7F, 0x0F,
  0xE7, 0xE0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xE7, 0xE0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x60, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F, 0xBF,
  0xFF, 0x3F, 0x3E, 0x3F, 0x1C, 0x7F, 0x08, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xE0, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x7F, 0xE7,
  0x80, 0xFE, 0x30, 0x0F, 0xE2, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7E, 0x7F, 0xE3, 0x00,
  0xFE, 0x20, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01,
  0xFE, 0xFE, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1E,
  0xFE, 0x00, 0xFB, 0xF8, 0x03, 0xEF, 0xE0, 0x1F, 0x3F, 0x80, 0x7C, 0xFE,
  0x03, 0xE3, 0xF8, 0x0F, 0x8F, 0xE0, 0x7C, 0x3F, 0x81, 0xF0, 0xFE, 0x0F,
  0x83, 0xF8, 0x3E, 0x0F, 0xE1, 0xF0, 0x3F, 0x87, 0xC0, 0xFE, 0x3E, 0x03,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xEF, 0x00,
  0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xC7, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF8, 0x00, 0xFE, 0xE0, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x1F, 0xF8, 0x43, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x7E, 0x0F, 0xCF, 0xF8, 0xFD, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x1F, 0xCF, 0xE0,
  0x7E, 0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0x7E, 0x07, 0xE3,
  0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x3F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF1, 0xFE, 0x7F, 0x07, 0xFB, 0xF8, 0x1F,
  0xDF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFD, 0xF8,
  0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0x87, 0xFB, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x20, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0xFF, 0x7F, 0x8F, 0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x1F, 0x9F, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xE1,
  0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFE, 0xFC, 0x7F, 0xF7, 0xE1,
  0xFF, 0x3F, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x30,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10,
  0x1E, 0x1F, 0x9F, 0xCF, 0xF7, 0xFB, 0xFD, 0xFC, 0x7E, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x3F, 0x9F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC,
  0xFC, 0x7E, 0x3F, 0x1F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x03,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xF7, 0xFC, 0xE0,
  0x7F, 0x20, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x1F, 0xC1, 0xF0, 0xF8, 0x1F,
  0xFC, 0x7C, 0x3E, 0x0F, 0xFF, 0x0F, 0x9F, 0x07, 0xFF, 0xC3, 0xE7, 0xC3,
  0xF9, 0xF0, 0xF9, 0xF0, 0xFC, 0x7C, 0x3E, 0x7C, 0x3E, 0x1F, 0x0F, 0xBE,
  0x1F, 0x87, 0xC1, 0xEF, 0x87, 0xC1, 0xF0, 0x7F, 0xE1, 0xF0, 0x7C, 0x1F,
  0xF8, 0x7C, 0x1F, 0x07, 0xBE, 0x1F, 0x07, 0xC3, 0xEF, 0x87, 0xC1, 0xF0,
  0xFB, 0xE1, 0xF0, 0x7C, 0x3E, 0xF8, 0x7C, 0x3F, 0x0F, 0xBE, 0x1F, 0x0F,
  0xC3, 0xEF, 0x87, 0xE3, 0xF0, 0xF3, 0xE0, 0xF9, 0xFE, 0x7C, 0x7C, 0x3F,
  0xF7, 0xFE, 0x1F, 0x07, 0xFD, 0xFF, 0x87, 0xC1, 0xFE, 0x3F, 0xC1, 0xF8,
  0x1F, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xC0,
  0x01, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xF8, 0x03, 0xF8,
  0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xF3, 0xFC, 0x00, 0xFE, 0x7F, 0x80,
  0x1F, 0xCF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xBF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE,
  0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xF8, 0x1F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0x0C, 0x3F, 0xC0, 0x10, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x8F, 0xFC,
  0x0E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFE, 0x0F, 0xF8, 0xFE, 0x07, 0xFC, 0xFE, 0x03, 0xFC,
  0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE,
  0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xFC,
  0xFE, 0x07, 0xFC, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0x7E, 0x1F, 0xF0, 0x0E, 0x3F, 0xE0, 0x02, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00,
  0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x7F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x06,
  0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x7F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF8, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xFB, 0x3F, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xF3,
  0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFB, 0xF8,
  0x0F, 0xF7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC1, 0xFE, 0x3F, 0x83,
  0xF8, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF9, 0xFE,
  0x07, 0xF3, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xDF, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0,
  0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03,
  0xFC, 0xFE, 0x07, 0xF9, 0xFC, 0x07, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x0F,
  0xEF, 0xE0, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xBE, 0x01, 0xF7,
  0xFF, 0xDF, 0x01, 0xFB, 0xFF, 0xEF, 0xC0, 0xFD, 0xFF, 0xF7, 0xE0, 0x7E,
  0xFF, 0xF9, 0xF0, 0x3E, 0x7F, 0xFC, 0xF8, 0x3F, 0x3F, 0xFE, 0x7E, 0x1F,
  0x9F, 0xFF, 0x3F, 0x0F, 0x8F, 0xFF, 0x8F, 0x87, 0xC7, 0xFF, 0xC7, 0xC7,
  0xE3, 0xFF, 0xE3, 0xF3, 0xF1, 0xFF, 0xF1, 0xF9, 0xF0, 0xFF, 0xF8, 0x7D,
  0xF8, 0x7F, 0xFC, 0x3E, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0xE0,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFC,
  0x0F, 0xF0, 0x3F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0x0F, 0xFF,
  0x80, 0xFC, 0x07, 0xFF, 0xC0, 0x7C, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xDF, 0x81,
  0xFF, 0xEF, 0xE0, 0xFF, 0xF7, 0xF0, 0x7F, 0xF9, 0xFC, 0x3F, 0xFC, 0xFE,
  0x1F, 0xFE, 0x3F, 0x0F, 0xFF, 0x1F, 0xC7, 0xFF, 0x87, 0xE3, 0xFF, 0xC3,
  0xF9, 0xFF, 0xE1, 0xFC, 0xFF, 0xF0, 0x7F, 0x7F, 0xF8, 0x3F, 0xBF, 0xFC,
  0x0F, 0xDF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF0,
  0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xE7, 0xF0, 0x01, 0xFC,
  0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0x00,
  0x1F, 0xDF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF7, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F,
  0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x1F,
  0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xF8, 0x3F, 0xDF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xF7, 0xF0, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0x7F,
  0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xE7, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFE,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00,
  0x7F, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F,
  0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF,
  0x00, 0x70, 0x01, 0xFF, 0x81, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFC, 0x1E, 0xFE, 0x01, 0xBF, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F,
  0xFE, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0xDF, 0xE0, 0x7F, 0xBF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x1F,
  0x9F, 0xC0, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x80,
  0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0x7E, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x80, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x3F, 0x00,
  0x07, 0xEF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x7F, 0x00,
  0xFF, 0x00, 0xFE, 0x3F, 0x00, 0xFF, 0x80, 0xFE, 0x3F, 0x80, 0xFF, 0x80,
  0xFE, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x3F,
  0x81, 0xFF, 0x81, 0xFC, 0x1F, 0x81, 0xF7, 0xC1, 0xFC, 0x1F, 0xC1, 0xF7,
  0xC1, 0xFC, 0x1F, 0xC1, 0xF7, 0xC1, 0xFC, 0x1F, 0xC3, 0xF7, 0xC1, 0xFC,
  0x1F, 0xC3, 0xF7, 0xC3, 0xF8, 0x0F, 0xC3, 0xF7, 0xE3, 0xF8, 0x0F, 0xC3,
  0xE7, 0xE3, 0xF8, 0x0F, 0xE3, 0xE7, 0xE3, 0xF8, 0x0F, 0xE7, 0xE3, 0xE3,
  0xF8, 0x0F, 0xE7, 0xE3, 0xE3, 0xF0, 0x07, 0xE7, 0xE3, 0xF7, 0xF0, 0x07,
  0xE7, 0xE3, 0xF7, 0xF0, 0x07, 0xE7, 0xC3, 0xF7, 0xF0, 0x07, 0xE7, 0xC1,
  0xF7, 0xF0, 0x07, 0xFF, 0xC1, 0xF7, 0xE0, 0x03, 0xFF, 0xC1, 0xF7, 0xE0,
  0x03, 0xFF, 0xC1, 0xF7, 0xE0, 0x03, 0xFF, 0x81, 0xF7, 0xE0, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F, 0x87,
  0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x0F, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xFD, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0x7F,
  0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xEF, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0xBF, 0x80, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0xFE, 0x00,
  0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7E,
  0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC6, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0xF0, 0xFF, 0xFE,
  0x7F, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xCF, 0x9F, 0xF1, 0xF1,
  0xFC, 0x3E, 0x0C, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x3C,
  0x0F, 0xE7, 0xF8, 0x7F, 0x7F, 0xE3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF7, 0xFC, 0x7F, 0xBF, 0xC1, 0xFD, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xBF, 0xE3,
  0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7E, 0xFF, 0xE3, 0xF3, 0xFF, 0x1F,
  0x8F, 0xE0, 0x00, 0x08, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xC7, 0xF8, 0x31, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x09, 0xFF, 0x1E, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xC7, 0xF0, 0xFF, 0x3F, 0x8F,
  0xFD, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFC, 0x7F,
  0xDF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x3F, 0xDF, 0xE3, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x8F, 0xFE, 0xFC, 0x7F, 0xE7, 0xE0, 0xFE, 0x1F, 0x01, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC3, 0xFD, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xFF,
  0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x27, 0xF8,
  0x1E, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0x80, 0x01, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x84, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7F, 0x8F, 0xC7, 0xFE,
  0x7E, 0x7F, 0xFB, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFE, 0x3F, 0xEF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x83, 0xFD, 0xFC, 0x1F, 0xEF, 0xF3, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF,
  0xEF, 0xC7, 0xFF, 0xFE, 0x3F, 0xF7, 0xF0, 0x7F, 0x3F, 0x80, 0x41, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x98, 0x01,
  0xFC, 0xFE, 0x7F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE3, 0xE0, 0xFE,
  0xFF, 0x8F, 0xDF, 0xFC, 0xFD, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x11, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x01, 0xF8, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xEF,
  0xF7, 0xFE, 0xFF, 0xDF, 0xF3, 0xFC, 0x7F, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0,
  0x7F, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8,
  0x3F, 0x8F, 0xE0, 0xFE, 0x7F, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F,
  0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0xFF, 0xBF, 0x03, 0xFC, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F, 0x87, 0xF0,
  0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE,
  0x07, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x01,
  0xF0, 0x7C, 0x7F, 0xC3, 0xFE, 0x3F, 0x7F, 0xF3, 0xFF, 0x9F, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xF1, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0x03,
  0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x03, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF,
  0x81, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xFF,
  0xF0, 0x3F, 0x81, 0xFF, 0xF8, 0x1F, 0xC0, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F,
  0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0x81, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x3E, 0x0F,
  0x8F, 0xF8, 0xFD, 0xFF, 0xCF, 0xDF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC7, 0xF8, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFB, 0xF8, 0x07,
  0xEF, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0xFE, 0x01, 0xFB, 0xF8, 0x07, 0xEF,
  0xE0, 0x3F, 0xBF, 0x80, 0xFE, 0x7E, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0,
  0x7F, 0x0F, 0xE3, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x07,
  0xE3, 0xFC, 0x3F, 0x3F, 0xF1, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFB, 0xFE, 0x3F, 0xDF, 0xE0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFB, 0xFC, 0x1F, 0xDF, 0xF9, 0xFE,
  0xFF, 0xFF, 0xF7, 0xEF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFD, 0xFF, 0x8F, 0xE7,
  0xF0, 0x7F, 0x06, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x8F, 0xC7, 0xFE, 0x7E, 0x7F, 0xFB, 0xF3, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFE, 0x3F, 0xEF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFD, 0xFC, 0x1F, 0xEF, 0xF1, 0xFF,
  0x7F, 0xFF, 0xF9, 0xFF, 0xEF, 0xC7, 0xFF, 0xFE, 0x3F, 0xF7, 0xF0, 0x7F,
  0x3F, 0x80, 0x41, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0,
  0xFF, 0xF3, 0xF7, 0xEF, 0xEF, 0xDF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xE2,
  0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xF8, 0x19, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03,
  0xFC, 0x01, 0xFD, 0x80, 0xFE, 0xF9, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x08, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x63, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8,
  0x03, 0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xBF, 0x3F, 0xF3, 0xF1, 0xFE, 0x1F,
  0x03, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3,
  0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F,
  0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE,
  0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xF7,
  0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7E,
  0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x03, 0xFC, 0x0F, 0xEF, 0xC0, 0xFF, 0x81, 0xFD, 0xFC, 0x1F, 0xF0,
  0x3F, 0x3F, 0x83, 0xFE, 0x07, 0xE7, 0xF0, 0x7F, 0xC1, 0xFC, 0x7E, 0x0F,
  0xFC, 0x3F, 0x8F, 0xC1, 0xEF, 0x87, 0xF1, 0xFC, 0x7D, 0xF0, 0xFC, 0x3F,
  0x8F, 0xBE, 0x1F, 0x87, 0xF1, 0xF7, 0xC7, 0xF0, 0x7E, 0x3E, 0x78, 0xFE,
  0x0F, 0xC7, 0x8F, 0x9F, 0x81, 0xFC, 0xF1, 0xF3, 0xF0, 0x3F, 0xBE, 0x3E,
  0x7E, 0x03, 0xF7, 0xC7, 0xDF, 0xC0, 0x7E, 0xF8, 0x7B, 0xF0, 0x0F, 0xDF,
  0x0F, 0x7E, 0x01, 0xFB, 0xC1, 0xEF, 0xC0, 0x3F, 0x78, 0x3D, 0xF8, 0x03,
  0xEF, 0x07, 0xBF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x80, 0xFC, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xCF,
  0xC0, 0x7F, 0x3F, 0x81, 0xF8, 0xFE, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1,
  0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x00, 0xFE, 0xFE,
  0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE3, 0xF0, 0x1F, 0xC7, 0xF0,
  0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x87,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E, 0x01, 0xFC, 0xFC,
  0x03, 0xF9, 0xF8, 0x03, 0xF7, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x81, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0xC0,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xF8, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0x04, 0x00, 0x04, 0xFF, 0x80, 0x17, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x07, 0xFC, 0x80,
  0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 8, 38, 13, 3, -37 },
  { 39, 19, 13, 23, 2, -37 },
  { 70, 24, 37, 26, 1, -37 },
  { 181, 20, 42, 24, 2, -39 },
  { 286, 37, 38, 40, 2, -38 },
  { 462, 28, 39, 29, 1, -38 },
  { 599, 8, 13, 12, 2, -37 },
  { 612, 14, 45, 16, 2, -37 },
  { 691, 13, 45, 16, 1, -37 },
  { 765, 21, 21, 23, 1, -40 },
  { 821, 22, 25, 24, 1, -31 },
  { 890, 9, 13, 13, 2, -6 },
  { 905, 13, 6, 16, 1, -17 },
  { 915, 8, 9, 13, 3, -8 },
  { 924, 21, 37, 21, 0, -37 },
  { 1022, 20, 39, 24, 2, -38 },
  { 1120, 16, 37, 24, 2, -37 },
  { 1194, 20, 38, 24, 2, -38 },
  { 1289, 20, 39, 24, 2, -38 },
  { 1387, 22, 37, 24, 1, -37 },
  { 1489, 20, 38, 24, 2, -37 },
  { 1584, 20, 39, 24, 2, -38 },
  { 1682, 21, 37, 24, 1, -37 },
  { 1780, 21, 39, 24, 1, -38 },
  { 1883, 21, 39, 24, 1, -38 },
  { 1986, 8, 30, 14, 3, -29 },
  { 2016, 9, 36, 13, 2, -29 },
  { 2057, 22, 25, 24, 1, -31 },
  { 2126, 22, 16, 24, 1, -26 },
  { 2170, 22, 25, 24, 1, -31 },
  { 2239, 18, 39, 19, 0, -38 },
  { 2327, 34, 42, 38, 2, -38 },
  { 2506, 27, 37, 27, 0, -37 },
  { 2631, 22, 37, 27, 3, -37 },
  { 2733, 22, 39, 25, 2, -38 },
  { 2841, 24, 37, 29, 3, -37 },
  { 2952, 16, 37, 23, 4, -37 },
  { 3026, 16, 37, 22, 4, -37 },
  { 3100, 24, 39, 29, 2, -38 },
  { 3217, 23, 37, 31, 4, -37 },
  { 3324, 14, 37, 16, 1, -37 },
  { 3389, 14, 48, 14, -3, -37 },
  { 3473, 23, 37, 27, 4, -37 },
  { 3580, 17, 37, 21, 3, -37 },
  { 3659, 33, 37, 40, 4, -37 },
  { 3812, 25, 37, 33, 4, -37 },
  { 3928, 27, 39, 31, 2, -38 },
  { 4060, 21, 37, 25, 3, -37 },
  { 4158, 27, 47, 31, 2, -38 },
  { 4317, 24, 37, 27, 3, -37 },
  { 4428, 18, 39, 22, 2, -38 },
  { 4516, 21, 37, 22, 1, -37 },
  { 4614, 23, 38, 30, 3, -37 },
  { 4724, 26, 37, 26, 0, -37 },
  { 4845, 40, 37, 39, -1, -37 },
  { 5030, 25, 37, 25, 0, -37 },
  { 5146, 25, 37, 25, 0, -37 },
  { 5262, 20, 37, 21, 1, -37 },
  { 5355, 12, 45, 16, 3, -37 },
  { 5423, 21, 37, 21, 0, -37 },
  { 5521, 12, 45, 16, 1, -37 },
  { 5589, 25, 23, 28, 1, -37 },
  { 5661, 21, 3, 21, 0, 5 },
  { 5669, 12, 8, 16, 2, -40 },
  { 5681, 19, 30, 24, 2, -29 },
  { 5753, 21, 41, 26, 3, -40 },
  { 5861, 18, 30, 21, 2, -29 },
  { 5929, 21, 41, 26, 2, -40 },
  { 6037, 20, 30, 24, 2, -29 },
  { 6112, 17, 40, 16, 0, -40 },
  { 6197, 21, 41, 26, 2, -29 },
  { 6305, 20, 40, 26, 3, -40 },
  { 6405, 7, 40, 13, 3, -40 },
  { 6440, 11, 52, 13, -1, -40 },
  { 6512, 22, 40, 25, 3, -40 },
  { 6622, 7, 40, 13, 3, -40 },
  { 6657, 33, 29, 39, 3, -29 },
  { 6777, 20, 29, 26, 3, -29 },
  { 6850, 22, 30, 25, 2, -29 },
  { 6933, 21, 41, 26, 3, -29 },
  { 7041, 21, 41, 26, 2, -29 },
  { 7149, 15, 29, 18, 3, -29 },
  { 7204, 17, 30, 19, 1, -29 },
  { 7268, 15, 35, 17, 1, -34 },
  { 7334, 20, 29, 26, 3, -28 },
  { 7407, 23, 28, 23, 0, -28 },
  { 7488, 35, 28, 35, 0, -28 },
  { 7611, 22, 28, 22, 0, -28 },
  { 7688, 23, 40, 23, 0, -28 },
  { 7803, 17, 28, 19, 1, -28 },
  { 7863, 15, 45, 18, 1, -37 },
  { 7948, 6, 52, 23, 8, -40 },
  { 7987, 16, 45, 18, 2, -37 },
  { 8077, 22, 9, 24, 1, -23 },
};

const GFXfont NotoSans_ExtraCondensed_Bold52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD52PT7B_H_
