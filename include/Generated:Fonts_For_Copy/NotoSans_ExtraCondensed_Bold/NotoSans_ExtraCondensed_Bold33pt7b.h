#ifndef _NOTOSANS_EXTRACONDENSED_BOLD33PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x00,
  0x01, 0xEF, 0xFF, 0xFE, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xE0, 0x07, 0x38, 0x0E, 0x70, 0x3C, 0xE0, 0x71,
  0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC,
  0x79, 0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFC, 0x79, 0xC0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x03, 0x00, 0x18, 0x01, 0xE0, 0x3F, 0xE3, 0xFF, 0xBF, 0xF9,
  0xEC, 0xCF, 0x60, 0x7B, 0x03, 0xD8, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0x78, 0x1B, 0xE0, 0xDF, 0xC7, 0xFF, 0xFF,
  0x7F, 0xF1, 0xFF, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0x7E, 0x07, 0x01, 0xFC, 0x0E, 0x03, 0xBC, 0x3C, 0x0F, 0x38, 0x70,
  0x1C, 0x70, 0xE0, 0x38, 0xE3, 0xC0, 0x71, 0xC7, 0x00, 0xE3, 0x9E, 0x01,
  0xC7, 0x38, 0x43, 0xCE, 0x73, 0xE3, 0xBD, 0xEF, 0xE7, 0xF3, 0x9F, 0xE7,
  0xE7, 0x79, 0xC7, 0x1C, 0xF3, 0x80, 0x39, 0xC7, 0x00, 0xF3, 0x8E, 0x01,
  0xC7, 0x1C, 0x03, 0x8E, 0x38, 0x0F, 0x1E, 0x70, 0x1C, 0x1C, 0xE0, 0x78,
  0x3F, 0xC0, 0xE0, 0x7F, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x0F, 0xF0, 0x0F,
  0xFC, 0x07, 0xFE, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xF3, 0xC0, 0x79, 0xE0,
  0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0xFB, 0xFE,
  0x7B, 0xEF, 0x3D, 0xE3, 0xFE, 0xF1, 0xFE, 0x78, 0x7F, 0x3C, 0x1F, 0x9F,
  0x0F, 0x8F, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFC, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x0F, 0x0F, 0x0F, 0x80, 0x0F, 0x00, 0x38, 0x01, 0xC1, 0x8E, 0x2F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F, 0xC1, 0xEF, 0x1F, 0x7C, 0x71,
  0xC1, 0x0C, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80,
  0xFE, 0x0F, 0xF8, 0xFF, 0xE7, 0xCF, 0x3C, 0x79, 0xE3, 0xFF, 0x1F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC7, 0xDE, 0x3C, 0xF1, 0xE7, 0xFF, 0x1F, 0xF0, 0xFF, 0x81,
  0xF8, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xDF, 0xFF, 0xFF, 0xDF, 0x67,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x81, 0xFE, 0x1F, 0xF9,
  0xFF, 0xE7, 0x1F, 0x10, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x83,
  0xFF, 0x3F, 0xFC, 0xFF, 0xE6, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x07, 0xF8, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x01, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0x8F,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFC, 0x03, 0xF8, 0x0E, 0xF0, 0x1D, 0xE0, 0x73, 0xC0, 0xE7, 0x83,
  0x8F, 0x07, 0x1E, 0x1E, 0x3C, 0x38, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0xF8, 0xFF, 0xCF, 0xFE, 0xFF, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF8, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0x03, 0xF0,
  0x7F, 0x87, 0xFC, 0x7F, 0xE3, 0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x9F, 0x3D, 0xFD, 0xFF, 0xEF, 0xDF, 0xFC, 0x7F, 0xE1, 0xFE, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x1E, 0xF1, 0xF7, 0xFF, 0x1F, 0xF8, 0xFF, 0x81,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xE7, 0x8F,
  0xFC, 0x3D, 0xE3, 0xEF, 0x1E, 0x7C, 0xF1, 0xFF, 0x8F, 0xF8, 0x3F, 0x83,
  0xFC, 0x3F, 0xF9, 0xF7, 0xDF, 0x1F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x8F, 0xBF, 0xF8, 0xFF, 0x83, 0xF8, 0x0F, 0x01, 0xFE, 0x1F, 0xF8,
  0xFF, 0xEF, 0x9F, 0x7C, 0x7B, 0xC3, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x3F, 0xF1, 0xF7, 0xFF, 0xBF, 0xFC, 0xFD, 0xE3, 0xCF, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x03, 0xE4, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0xE0, 0xF7, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3B, 0xFF, 0xFF, 0x80, 0x79, 0xF7,
  0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xDF, 0x7D, 0xE7,
  0x9E, 0xF3, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x7F, 0x8F,
  0xF1, 0xFC, 0x1F, 0x80, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0x80, 0x7C, 0x00, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x03,
  0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFC, 0x0F, 0xE1, 0xFE, 0x1F, 0xE0, 0xFE, 0x03, 0xE0, 0x0E, 0x00,
  0x20, 0x00, 0x1F, 0x07, 0xFC, 0xFF, 0xE7, 0xFE, 0x61, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x03, 0xC0,
  0xF8, 0x1E, 0x00, 0xF0, 0xF0, 0x01, 0xC3, 0x83, 0xC7, 0x9E, 0x3F, 0xCE,
  0x71, 0xFF, 0x39, 0xC7, 0x3C, 0xE7, 0x3C, 0xF3, 0xBC, 0xE3, 0xCF, 0xF3,
  0x8F, 0x3F, 0x8E, 0x3C, 0xEE, 0x38, 0xF3, 0xB8, 0xE3, 0x8E, 0xF3, 0x8F,
  0x39, 0xCF, 0x7D, 0xC7, 0x1F, 0xBF, 0x1C, 0x3C, 0x78, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x08, 0x07, 0xC0, 0xE0, 0x0F, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x7C,
  0x07, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xE0, 0xF1, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x9F, 0x07, 0xCF, 0x81, 0xE7,
  0xC0, 0xFB, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFE, 0xF8, 0xFB, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7B,
  0xE3, 0xEF, 0xFF, 0x3F, 0xF0, 0xFF, 0xF3, 0xFF, 0xEF, 0x87, 0xFE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0x3F, 0xF0, 0x03, 0xF0, 0x1F, 0xF1, 0xFF, 0xC7, 0xFE, 0x3F, 0x18, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F,
  0x81, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0x81, 0xFE, 0xFE, 0x01, 0xFF, 0xC3,
  0xFF, 0xC7, 0xFF, 0xCF, 0x9F, 0x9F, 0x0F, 0xBE, 0x1F, 0x7C, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC7, 0xCF, 0xFF, 0x9F,
  0xFE, 0x3F, 0xF8, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF,
  0xBE, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x03,
  0xF0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xE0, 0xCF, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x8F, 0xFF, 0x1F, 0xFE,
  0x3F, 0xFC, 0x7F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFB, 0xE1,
  0xF7, 0xFF, 0xE7, 0xFF, 0xC7, 0xFF, 0x87, 0xFC, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xE7, 0xFB, 0xFF, 0xFF, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC7, 0xDF, 0xEF, 0xF7, 0xF3, 0xE0, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1,
  0xF7, 0xC3, 0xCF, 0x8F, 0x9F, 0x3E, 0x3E, 0x7C, 0x7D, 0xF0, 0xFB, 0xE1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x7C,
  0xF0, 0xF9, 0xF1, 0xF1, 0xE3, 0xE3, 0xE7, 0xC7, 0xCF, 0x87, 0xDF, 0x0F,
  0xBE, 0x0F, 0xFC, 0x1F, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFE, 0xE0, 0xFF, 0xF7, 0x07,
  0x7F, 0xBC, 0x3B, 0xFD, 0xE3, 0xDF, 0xE7, 0x1E, 0xFF, 0x38, 0xE7, 0xF9,
  0xE7, 0x3F, 0xCF, 0x79, 0xFE, 0x3B, 0xCF, 0xF1, 0xDC, 0x7F, 0x8F, 0xE3,
  0xFC, 0x7F, 0x1F, 0xE1, 0xF0, 0xFF, 0x0F, 0x87, 0xF8, 0x7C, 0x3F, 0xC3,
  0xE1, 0xFE, 0x0E, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xF7, 0x8F, 0xFB,
  0xC7, 0xFC, 0xF3, 0xFE, 0x79, 0xFF, 0x3E, 0xFF, 0x8F, 0x7F, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF0, 0xF7, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0x03, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0x87, 0xFF, 0xC3, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x3C, 0xF8, 0x1F,
  0x78, 0x0F, 0xBC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7D, 0xE0, 0x3E, 0xF0, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xC7,
  0xC3, 0xE3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0xFC, 0x07,
  0xFE, 0x3F, 0xFD, 0xFF, 0xEF, 0x9F, 0xFC, 0x7F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC7, 0xFE, 0x3F, 0xF3, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xE3, 0xF3,
  0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7D, 0xE0, 0x3E, 0xF0, 0x1F, 0x7C,
  0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xC7, 0xC3, 0xE3, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0xFC, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF,
  0xCF, 0x9F, 0x9F, 0x1F, 0x3E, 0x1E, 0x7C, 0x3C, 0xF8, 0x79, 0xF1, 0xF3,
  0xE3, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7D, 0xF0, 0xF9,
  0xE1, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0xCF, 0x8F, 0x9F, 0x0F, 0xBE, 0x1F,
  0x7C, 0x1F, 0x0F, 0x83, 0xFF, 0x7F, 0xF7, 0xFE, 0xFC, 0xEF, 0x82, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xFF, 0xEF, 0xFE, 0xFF,
  0xC7, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xE7, 0xFF, 0xCF,
  0xFF, 0x8F, 0xFE, 0x0F, 0xF0, 0xF0, 0x0F, 0xF8, 0x07, 0x9E, 0x03, 0xCF,
  0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x1E, 0x1E, 0x0F, 0x0F, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xC0, 0x79,
  0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xB8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0xF8,
  0x1E, 0x07, 0xFC, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xEF, 0x83, 0xE0, 0xF3,
  0xC3, 0xF0, 0x79, 0xE1, 0xF8, 0x7C, 0xF0, 0xFE, 0x3E, 0x78, 0x7F, 0x1E,
  0x3E, 0x3B, 0x8F, 0x0F, 0x3D, 0xC7, 0x87, 0x9E, 0xE7, 0xC3, 0xCF, 0x7B,
  0xE1, 0xE7, 0x3D, 0xE0, 0xF3, 0x9E, 0xF0, 0x3F, 0xC7, 0x78, 0x1F, 0xE3,
  0xBC, 0x0F, 0xF1, 0xDE, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFC,
  0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0xF8,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x3C, 0x7C, 0x3E, 0x78, 0x1E, 0x78, 0x1E,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E, 0xF8, 0x3E,
  0x78, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C, 0x3C, 0x78, 0x3E, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3E,
  0x78, 0x1E, 0x78, 0x1E, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x3C, 0x78, 0x3C,
  0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x3C,
  0x3E, 0x1E, 0x0F, 0x1F, 0xC3, 0xFF, 0x0F, 0xFC, 0x63, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xE3, 0xFF, 0x7F, 0xFB, 0xFF, 0xFE, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0x7F, 0x79, 0xF3, 0xC0, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x7C, 0xF7, 0xF7,
  0xFF, 0xBF, 0x7F, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x8F, 0xFE, 0xFF, 0xFF, 0xDF, 0xFE,
  0xE7, 0xE0, 0x0F, 0xE7, 0xFC, 0xFF, 0xBF, 0x77, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x5F, 0xBB, 0xFF,
  0x3F, 0xE3, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC7, 0xDF, 0x3F, 0xFD, 0xFF, 0xF7, 0xDF, 0xDE, 0x1F,
  0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0x78, 0x7D, 0xF3, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x3C, 0x1F,
  0xC1, 0xFF, 0x0F, 0xFC, 0xF9, 0xE7, 0x87, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0xC7,
  0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xE0,
  0x7C, 0x0F, 0x83, 0xFE, 0xFF, 0xDF, 0xF8, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF, 0xDF, 0x3F, 0x78,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7D, 0xE1, 0xF7, 0xDF, 0xDF, 0xFF, 0x3F, 0xFC, 0x7D, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x79, 0x03, 0xE7, 0xFF, 0x9F, 0xFC, 0x7F, 0xE0,
  0x7E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0xFC, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xF1, 0xFF, 0x8F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF8, 0xFF, 0xFF, 0x60, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0xF0,
  0xC0, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0xFF, 0xFE,
  0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x1F, 0xF0, 0xFB, 0xC3, 0xCF, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3,
  0xDE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xBE, 0x3C, 0x78,
  0xF1, 0xF3, 0xC3, 0xCF, 0x0F, 0xBC, 0x1E, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xE3,
  0xE7, 0xFF, 0xBF, 0xBF, 0xFF, 0xFD, 0xFB, 0xFF, 0xFF, 0x8F, 0x8F, 0xF8,
  0x7C, 0x7F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83,
  0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3F, 0xC3,
  0xC1, 0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xC0, 0xE7, 0xE7,
  0xFF, 0xBF, 0xFD, 0xFB, 0xEF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xC0, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x1F, 0x3E, 0x78,
  0x7B, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xFE,
  0x1F, 0x78, 0x7D, 0xE1, 0xE7, 0xCF, 0x8F, 0xFC, 0x1F, 0xF0, 0x3F, 0x00,
  0xE7, 0xE7, 0xBF, 0xBF, 0xFD, 0xFB, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x7F, 0xF7,
  0xFF, 0xFE, 0xF7, 0xF7, 0x9F, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1F, 0x3C, 0xFE, 0xF7, 0xFF,
  0xDF, 0x7F, 0x78, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7D, 0xE1, 0xF7, 0xCF, 0xDF, 0xFF, 0x3F,
  0xFC, 0x7D, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0xE3, 0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x00, 0x3F, 0x9F, 0xFF, 0xFF, 0xC6, 0xF0, 0x3C, 0x0F, 0xC1, 0xF8,
  0x7F, 0x8F, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF,
  0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3F, 0xFF, 0xFF, 0xFC, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xF4, 0xFF, 0x1F, 0xC3, 0xF0, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1,
  0xFF, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x79, 0xF3, 0xC0, 0xF8,
  0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE7, 0xC7, 0x87, 0x8F, 0x0F, 0x1E,
  0x1E, 0x7C, 0x3C, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x7C, 0x3D,
  0xE3, 0xF0, 0xF7, 0x8F, 0xC3, 0xDE, 0x3F, 0x1E, 0x78, 0xFC, 0x79, 0xF3,
  0xB9, 0xE3, 0xCE, 0xE7, 0x8F, 0x73, 0xBE, 0x3D, 0xCE, 0xF0, 0xF7, 0x3B,
  0xC3, 0xDC, 0x6F, 0x07, 0x71, 0xBC, 0x1F, 0xC7, 0xE0, 0x7F, 0x1F, 0x81,
  0xF8, 0x7E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7D, 0xE3, 0xE7, 0xCF, 0x8F, 0x3C, 0x3F, 0xF0, 0x7F, 0x81, 0xFE, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0xF7, 0xC3,
  0xCF, 0x1F, 0x3E, 0x78, 0x7B, 0xE1, 0xF0, 0xF8, 0x3E, 0xF0, 0x79, 0xE0,
  0xF3, 0xC3, 0xE7, 0xC7, 0x87, 0x8F, 0x0F, 0x1E, 0x1E, 0x7C, 0x1E, 0xF0,
  0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x41, 0xF0, 0xFC, 0x3F,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x3F,
  0x8F, 0xC3, 0xF0, 0xFE, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x80, 0x3E, 0x0F, 0xC3, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xF0, 0x7C, 0x3F, 0x1F, 0xC7, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x8F, 0xC3, 0xF0,
  0xF8, 0x00, 0x7E, 0x07, 0xFF, 0x7F, 0xFF, 0xF1, 0xFE, 0x81, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 24, 8, 2, -24 },
  { 16, 11, 9, 15, 2, -24 },
  { 29, 15, 24, 17, 1, -24 },
  { 74, 13, 27, 15, 1, -25 },
  { 118, 23, 24, 25, 1, -24 },
  { 187, 17, 24, 18, 1, -24 },
  { 238, 4, 9, 8, 2, -24 },
  { 243, 8, 29, 10, 2, -24 },
  { 272, 9, 29, 10, 0, -24 },
  { 305, 13, 13, 15, 1, -25 },
  { 327, 13, 16, 15, 1, -20 },
  { 353, 6, 8, 8, 1, -4 },
  { 359, 8, 4, 10, 1, -11 },
  { 363, 5, 5, 8, 2, -5 },
  { 367, 13, 24, 13, 0, -24 },
  { 406, 13, 24, 15, 1, -24 },
  { 445, 10, 24, 15, 2, -24 },
  { 475, 13, 24, 15, 1, -24 },
  { 514, 13, 24, 15, 1, -24 },
  { 553, 15, 24, 15, 0, -24 },
  { 598, 12, 24, 15, 2, -24 },
  { 634, 13, 24, 15, 1, -24 },
  { 673, 13, 24, 15, 1, -24 },
  { 712, 13, 24, 15, 1, -24 },
  { 751, 13, 24, 15, 1, -24 },
  { 790, 5, 18, 9, 2, -18 },
  { 802, 6, 22, 9, 1, -18 },
  { 819, 13, 16, 15, 1, -20 },
  { 845, 13, 10, 15, 1, -17 },
  { 862, 14, 16, 15, 1, -20 },
  { 890, 12, 24, 12, 0, -24 },
  { 926, 22, 27, 24, 1, -24 },
  { 1001, 17, 24, 17, 0, -24 },
  { 1052, 14, 24, 17, 2, -24 },
  { 1094, 14, 24, 16, 1, -24 },
  { 1136, 15, 24, 18, 2, -24 },
  { 1181, 11, 24, 14, 2, -24 },
  { 1214, 11, 24, 14, 2, -24 },
  { 1247, 15, 24, 19, 2, -24 },
  { 1292, 15, 24, 19, 2, -24 },
  { 1337, 9, 24, 10, 1, -24 },
  { 1364, 9, 31, 9, -2, -24 },
  { 1399, 15, 24, 17, 2, -24 },
  { 1444, 11, 24, 13, 2, -24 },
  { 1477, 21, 24, 25, 2, -24 },
  { 1540, 17, 24, 21, 2, -24 },
  { 1591, 17, 24, 20, 1, -24 },
  { 1642, 13, 24, 16, 2, -24 },
  { 1681, 17, 30, 20, 1, -24 },
  { 1745, 15, 24, 17, 2, -24 },
  { 1790, 12, 24, 14, 1, -24 },
  { 1826, 14, 24, 14, 0, -24 },
  { 1868, 15, 24, 19, 2, -24 },
  { 1913, 17, 24, 17, 0, -24 },
  { 1964, 25, 24, 25, 0, -24 },
  { 2039, 16, 24, 16, 0, -24 },
  { 2087, 16, 24, 16, 0, -24 },
  { 2135, 13, 24, 14, 0, -24 },
  { 2174, 8, 29, 10, 2, -24 },
  { 2203, 13, 24, 13, 0, -24 },
  { 2242, 7, 29, 10, 1, -24 },
  { 2268, 16, 15, 18, 1, -24 },
  { 2298, 14, 2, 13, 0, 3 },
  { 2302, 8, 5, 10, 1, -25 },
  { 2307, 13, 18, 15, 1, -18 },
  { 2337, 13, 25, 17, 2, -25 },
  { 2378, 11, 18, 13, 1, -18 },
  { 2403, 14, 25, 17, 1, -25 },
  { 2447, 13, 18, 15, 1, -18 },
  { 2477, 11, 25, 10, 0, -25 },
  { 2512, 14, 26, 17, 1, -18 },
  { 2558, 13, 25, 17, 2, -25 },
  { 2599, 4, 25, 8, 2, -25 },
  { 2612, 7, 33, 8, -1, -25 },
  { 2641, 14, 25, 16, 2, -25 },
  { 2685, 4, 25, 8, 2, -25 },
  { 2698, 21, 18, 25, 2, -18 },
  { 2746, 13, 18, 17, 2, -18 },
  { 2776, 14, 18, 16, 1, -18 },
  { 2808, 13, 26, 17, 2, -18 },
  { 2851, 14, 26, 17, 1, -18 },
  { 2897, 9, 18, 11, 2, -18 },
  { 2918, 10, 18, 12, 1, -18 },
  { 2941, 10, 22, 11, 0, -22 },
  { 2969, 13, 18, 17, 2, -18 },
  { 2999, 15, 18, 15, 0, -18 },
  { 3033, 22, 18, 22, 0, -18 },
  { 3083, 14, 18, 14, 0, -18 },
  { 3115, 15, 26, 15, 0, -18 },
  { 3164, 10, 18, 12, 1, -18 },
  { 3187, 10, 29, 11, 0, -24 },
  { 3224, 4, 33, 14, 5, -25 },
  { 3241, 10, 29, 11, 1, -24 },
  { 3278, 14, 5, 15, 1, -14 },
};

const GFXfont NotoSans_ExtraCondensed_Bold33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold33pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD33PT7B_H_
