#ifndef _NOTOSANS_EXTRACONDENSED_BOLD40PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0xFC,
  0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x87, 0xBE,
  0x1E, 0xF8, 0x79, 0xE1, 0xE7, 0x87, 0x80, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x38, 0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x1E,
  0x78, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x0F, 0x1E,
  0x03, 0xC7, 0x00, 0xF1, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0x9E, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x1C, 0x78, 0x07, 0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0,
  0x00, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x7F, 0xC3, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFF, 0x7E, 0x8E, 0xF9, 0x01, 0xF2, 0x03, 0xE4, 0x07, 0xE8, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x05,
  0xF0, 0x0B, 0xF0, 0x13, 0xE0, 0x27, 0xE0, 0x4F, 0xF0, 0xBE, 0xFF, 0xFD,
  0xFF, 0xF3, 0xFF, 0xC0, 0xFE, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x0F, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xC0, 0x0F, 0xF0, 0x1E, 0x00,
  0xFF, 0xC0, 0xF0, 0x07, 0x9E, 0x0F, 0x00, 0x7C, 0xF0, 0x78, 0x03, 0xC7,
  0x83, 0xC0, 0x1E, 0x3C, 0x3C, 0x00, 0xF1, 0xF1, 0xE0, 0x07, 0x8F, 0x9E,
  0x00, 0x3C, 0x7C, 0xF0, 0x01, 0xE3, 0xC7, 0x86, 0x07, 0x9E, 0x78, 0xFC,
  0x3C, 0xF3, 0xCF, 0xF1, 0xFF, 0xBC, 0xFF, 0xC7, 0xF9, 0xE7, 0x9E, 0x3F,
  0x8F, 0x3C, 0xF0, 0x78, 0xF3, 0xE7, 0x80, 0x07, 0x9E, 0x3E, 0x00, 0x3C,
  0xF1, 0xF0, 0x03, 0xC7, 0x8F, 0x80, 0x1E, 0x3C, 0x7C, 0x01, 0xE1, 0xE3,
  0xE0, 0x0F, 0x07, 0x9E, 0x00, 0x78, 0x3C, 0xF0, 0x07, 0x81, 0xFF, 0x80,
  0x3C, 0x07, 0xF8, 0x03, 0xC0, 0x3F, 0xC0, 0x1E, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xF7, 0xE0,
  0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF3,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x87, 0xE7, 0xFE, 0x3E, 0x7F, 0xF1, 0xF3, 0xEF, 0xDF, 0xBF, 0x3F,
  0xF9, 0xF0, 0xFF, 0xCF, 0x87, 0xFE, 0x7C, 0x1F, 0xE3, 0xF0, 0x7F, 0x1F,
  0x83, 0xF0, 0xFF, 0x7F, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE0, 0xFF, 0x1F, 0x80, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7,
  0x80, 0x07, 0xC1, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E,
  0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x78, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1F, 0x07, 0x83, 0xE0,
  0xF0, 0x7C, 0x1E, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x43,
  0xC2, 0x73, 0xCE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x3E, 0xF8, 0x7E, 0x7E, 0x3C, 0x7C, 0x1C, 0x30, 0x04,
  0x20, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x3E, 0x7C, 0xFB, 0xF7, 0xCF, 0x9F, 0x3C, 0x79, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3F, 0x7C, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F,
  0x7C, 0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x3E, 0x7E, 0x3E, 0x3F, 0x7E,
  0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0xF0, 0x1F, 0x03,
  0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF, 0xFD, 0xF7, 0x9F, 0x31,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFC,
  0x7F, 0xFE, 0x78, 0x7E, 0x30, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE,
  0x30, 0x7E, 0x20, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x7F, 0xF0, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xBE, 0x03, 0xDF, 0x03,
  0xCF, 0x81, 0xE7, 0xC1, 0xE3, 0xE0, 0xF1, 0xF0, 0xF0, 0xF8, 0x78, 0x7C,
  0x78, 0x3E, 0x3C, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x39, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0xF1,
  0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0xFE, 0x03,
  0xFE, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x60, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x7E, 0x7E, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x3E, 0x7E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x7C, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3F, 0xFC, 0x7F,
  0xFE, 0x7C, 0x7E, 0xFC, 0x3E, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xDF, 0x0F, 0x9F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7C, 0x41, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7B, 0xFF, 0xFF, 0xFD, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xF0, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xF9, 0xF3,
  0xEF, 0xDF, 0x3E, 0x7C, 0xF3, 0xE0, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x7F, 0xFC, 0xC3, 0xF4,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x01, 0xFE, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0x7C, 0x78, 0x00, 0x1E, 0x78, 0x3F, 0xCF, 0x3C, 0x3F, 0xE3, 0xFC,
  0x3F, 0xF1, 0xFE, 0x3E, 0x78, 0xFF, 0x1E, 0x3C, 0x7F, 0x8F, 0x1E, 0x3F,
  0xCF, 0x0F, 0x1F, 0xC7, 0x87, 0x8F, 0xE3, 0xC3, 0xC7, 0xF1, 0xE1, 0xE3,
  0xF8, 0xF0, 0xF1, 0xFE, 0x7C, 0x78, 0xFF, 0x1E, 0x7C, 0x77, 0x8F, 0xF7,
  0xFB, 0xC3, 0xFB, 0xF9, 0xF0, 0xF8, 0xF8, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x02, 0x01, 0xFC, 0x0F, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xEF, 0x00,
  0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF7,
  0xC0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03,
  0xF1, 0xF8, 0x1F, 0x07, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xF8, 0x0F, 0x8F, 0xC0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0x80, 0xFF, 0x80, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8,
  0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFE, 0xF8, 0xFE, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x01,
  0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0x06, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0x3F,
  0xDF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0xFE, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x3F, 0xCF, 0x83,
  0xF3, 0xE0, 0x7E, 0xF8, 0x1F, 0xBE, 0x07, 0xEF, 0x80, 0xFB, 0xE0, 0x3E,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0xBE, 0x07, 0xEF, 0x83,
  0xF3, 0xE1, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0x8F, 0xE0, 0x67, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0x7D, 0xF8,
  0x1F, 0x3F, 0x8F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x0F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0xFC, 0x3F, 0xBF, 0xFF, 0xEF, 0xFB, 0xFC, 0xFE, 0x00, 0xF8, 0x0F,
  0xFE, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F,
  0x8F, 0xC3, 0xE3, 0xF0, 0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0xBF, 0x03, 0xEF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x1F, 0x8F,
  0x87, 0xE3, 0xE0, 0xF8, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0,
  0x7E, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x7B, 0xFF, 0x78, 0x3D, 0xFF, 0xBC, 0x3E, 0xFF, 0xDE, 0x1E, 0x7F,
  0xEF, 0x8F, 0x3F, 0xF3, 0xC7, 0x9F, 0xF9, 0xE7, 0xCF, 0xFC, 0xF3, 0xC7,
  0xFE, 0x7D, 0xE3, 0xFF, 0x1E, 0xF1, 0xFF, 0x8F, 0xF8, 0xFF, 0xC7, 0xF8,
  0x7F, 0xE3, 0xFC, 0x3F, 0xF0, 0xFE, 0x1F, 0xF8, 0x7E, 0x0F, 0xFC, 0x3F,
  0x07, 0xFE, 0x1F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x83, 0xC0, 0xF8, 0xFC,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFD, 0xF1, 0xFF, 0xBE, 0x3F, 0xF3, 0xE7, 0xFE, 0x7C, 0xFF, 0xCF,
  0xDF, 0xF8, 0xFB, 0xFF, 0x1F, 0x3F, 0xE1, 0xF7, 0xFC, 0x3E, 0xFF, 0x83,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0, 0xFC, 0x7E,
  0x07, 0xE7, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xE7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFF,
  0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0xFF, 0xDF, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x1F, 0xFF,
  0xFF, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF0, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x7E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE7, 0xC0, 0x7E, 0x7E,
  0x07, 0xE7, 0xE0, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xC7, 0xF3, 0xE1,
  0xF9, 0xF0, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF,
  0x87, 0xE7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8,
  0x3E, 0x7C, 0x1F, 0x3F, 0x0F, 0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0,
  0xFC, 0xF8, 0x3E, 0x7C, 0x1F, 0xBE, 0x0F, 0xDF, 0x03, 0xFF, 0x81, 0xF8,
  0x07, 0xE0, 0x3F, 0xF8, 0xFF, 0xF9, 0xFF, 0xE7, 0xFF, 0xCF, 0xC3, 0x9F,
  0x02, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xE7, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFF, 0x7F, 0xBF, 0xFF,
  0x9F, 0xFF, 0x87, 0xFF, 0x80, 0xFF, 0x80, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE3, 0xE0, 0x3C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0,
  0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF0, 0x0F,
  0x9F, 0x00, 0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xDE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0x80, 0x7F,
  0xE0, 0x3E, 0x01, 0xFF, 0x80, 0xFC, 0x0F, 0xFE, 0x03, 0xF0, 0x3F, 0xFC,
  0x0F, 0xC0, 0xFD, 0xF0, 0x3F, 0x03, 0xE7, 0xC1, 0xFC, 0x0F, 0x9F, 0x07,
  0xF8, 0x3E, 0x7C, 0x1F, 0xE1, 0xF9, 0xF0, 0x7F, 0x87, 0xE3, 0xE1, 0xFE,
  0x1F, 0x0F, 0x8F, 0xF8, 0x7C, 0x3E, 0x3D, 0xF1, 0xF0, 0xF8, 0xF3, 0xCF,
  0xC3, 0xE3, 0xCF, 0x3F, 0x0F, 0xCF, 0x3C, 0xF8, 0x1F, 0x7C, 0xF3, 0xE0,
  0x7D, 0xF3, 0xEF, 0x81, 0xF7, 0x8F, 0xBE, 0x07, 0xDE, 0x1E, 0xF8, 0x1F,
  0x78, 0x7F, 0xC0, 0x3D, 0xE1, 0xFF, 0x00, 0xF7, 0x87, 0xFC, 0x03, 0xFC,
  0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x7C, 0x0F, 0xCF,
  0xC1, 0xF9, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xF1, 0xF8, 0x3E, 0x3E, 0x07,
  0xCF, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3F,
  0x7E, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3F, 0x1F, 0x87, 0xC1, 0xF1, 0xF8,
  0x3F, 0x3E, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0,
  0x1F, 0x3F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC7, 0xE0, 0xF8,
  0xF8, 0x1F, 0x1F, 0x03, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xBE, 0x01, 0xF3, 0xC0, 0x7C, 0x7C, 0x0F, 0x87,
  0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x01, 0xF3, 0xE0, 0x3E, 0x78, 0x03,
  0xFF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x1F,
  0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF,
  0xF1, 0x87, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x01, 0xFE, 0x3F, 0xFC,
  0xFF, 0xFB, 0xFF, 0xF7, 0xE3, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF8, 0xFD, 0xFF, 0xFB, 0xFE, 0xF7, 0xFD, 0xE7, 0xF3, 0xC0, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0xF8, 0x7D, 0xFE, 0x3E, 0xFF, 0x9F, 0xFF,
  0xCF, 0xE7, 0xF7, 0xE1, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xF0, 0x7D,
  0xF8, 0x3E, 0xFC, 0x3F, 0x7F, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xBF,
  0xC7, 0xCF, 0xC0, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x3F, 0x19,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x05, 0xFC, 0x33, 0xFF,
  0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F,
  0x8F, 0x8F, 0xF7, 0xCF, 0xFB, 0xE7, 0xFF, 0xF7, 0xF7, 0xFB, 0xF0, 0xFD,
  0xF0, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x1F, 0xBF,
  0x1F, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1, 0xFE, 0xF8, 0x7E, 0x7C, 0x07, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x1E, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x06, 0x3F, 0xFE,
  0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x00, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F,
  0xF1, 0xFF, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0x9F, 0xFD,
  0xFF, 0xEF, 0xFF, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xCF, 0x8F,
  0xF7, 0xCF, 0xFB, 0xE7, 0xFF, 0xF7, 0xF3, 0xFB, 0xF0, 0xFD, 0xF0, 0x7E,
  0xF8, 0x3F, 0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x1F, 0xBF, 0x1F, 0xCF,
  0xFF, 0xE7, 0xFD, 0xF1, 0xFE, 0xF8, 0x7E, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x20, 0x0F, 0x9C, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x02, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF8, 0xFB,
  0xFC, 0xFB, 0xFE, 0xFF, 0xFE, 0xFF, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0xFB,
  0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB,
  0xEF, 0xBE, 0xFB, 0xE0, 0x0F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xDF, 0xEF, 0xF7, 0xF3, 0xF0,
  0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0xBF, 0x07, 0xCF,
  0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x7C, 0x3F, 0x3F, 0x0F, 0xCF, 0x83, 0xF7,
  0xC0, 0xFB, 0xF0, 0x3E, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xBE, 0x0F, 0xCF, 0xC3, 0xF1, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0x8F,
  0xC3, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0xBF, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xF8, 0x7E, 0x3E, 0xFF, 0x3F, 0xCF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0xDF, 0xBF, 0x0F, 0xC3, 0xFF,
  0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3F, 0xFC, 0x3F, 0x0F, 0xFE, 0x0F, 0xC3,
  0xFF, 0xC3, 0xF0, 0xFF, 0xE0, 0xFC, 0x3F, 0xF8, 0x3F, 0x0F, 0xFE, 0x0F,
  0xC3, 0xFF, 0x83, 0xF0, 0xFF, 0xE0, 0xFC, 0x3F, 0xF8, 0x3F, 0x0F, 0xFE,
  0x0F, 0xC3, 0xFF, 0x83, 0xF0, 0xFF, 0xE0, 0xFC, 0x3F, 0xF8, 0x3F, 0x0F,
  0xFE, 0x0F, 0xC3, 0xF0, 0xF1, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xF3, 0xF3, 0xF0,
  0xF9, 0xF0, 0x7E, 0xF8, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3F, 0x7E, 0x1F,
  0x1F, 0x1F, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0xF9,
  0xF8, 0x7D, 0xFE, 0x3E, 0xFF, 0x9F, 0xFF, 0xCF, 0xE3, 0xF7, 0xE1, 0xFB,
  0xF0, 0x7D, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xFF, 0x81, 0xFF, 0xE0, 0xFB, 0xF0, 0x7D, 0xF8, 0x3E, 0xFC, 0x3F, 0x7F,
  0x1F, 0xBF, 0xFF, 0x9F, 0x7F, 0xCF, 0xBF, 0xC7, 0xCF, 0xC3, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0xCF, 0x8F, 0xF7, 0xCF,
  0xFB, 0xE7, 0xFF, 0xF7, 0xF7, 0xFB, 0xF0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3F,
  0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xE0,
  0xFD, 0xF0, 0x7E, 0xF8, 0x3F, 0x7E, 0x1F, 0xBF, 0x1F, 0xCF, 0xFF, 0xE7,
  0xFD, 0xF1, 0xFE, 0xF8, 0x7E, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0xFF, 0x9E, 0xFB, 0xEF, 0xFE, 0xFF, 0xEF, 0xF2,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x1F, 0xE1, 0xFF, 0xDF, 0xFD, 0xFF, 0xEF, 0xC7, 0x7C, 0x03, 0xE0, 0x1F,
  0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFF, 0x0F, 0xFF, 0xFD, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF1, 0x1F, 0xF1, 0xFF,
  0x0F, 0xF0, 0x7F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0x8F, 0xFC,
  0x0F, 0xFF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x7E, 0x7C, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x07, 0xCF, 0x81, 0xF3, 0xE0,
  0x7C, 0xF8, 0x1F, 0x7C, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xF8, 0x1F, 0x83, 0xFF, 0x87, 0xF0, 0x7D, 0xF0, 0xFE, 0x1F, 0x3E,
  0x1F, 0xC3, 0xE7, 0xC3, 0xF8, 0x7C, 0xF8, 0x77, 0x0F, 0x8F, 0x8E, 0xF1,
  0xF1, 0xF3, 0xDE, 0x7C, 0x3E, 0x7B, 0xCF, 0x87, 0xCF, 0x39, 0xF0, 0xF9,
  0xC7, 0x3E, 0x0F, 0xB8, 0xE7, 0x81, 0xF7, 0x1F, 0xF0, 0x3F, 0xE3, 0xFE,
  0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0xBE, 0x1F, 0x9F, 0x8F, 0xC7, 0xC7,
  0xC3, 0xF7, 0xE0, 0xFB, 0xE0, 0x7D, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0x3F, 0x0F, 0x8F, 0x8F, 0xC7, 0xE7, 0xC1,
  0xF7, 0xE0, 0xFC, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0, 0x7E,
  0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1F, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x0F, 0x7C, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x00, 0xE0, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x01,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC,
  0x0F, 0x81, 0xF8, 0xFF, 0x8F, 0xE0, 0xFE, 0x0F, 0xF8, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7F, 0x07, 0xF0, 0x7F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x0F, 0xC1,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x7F, 0x00, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF4, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 29, 10, 2, -29 },
  { 23, 14, 11, 18, 2, -29 },
  { 43, 18, 29, 20, 1, -29 },
  { 109, 15, 32, 19, 2, -30 },
  { 169, 29, 29, 31, 1, -29 },
  { 275, 21, 29, 22, 1, -29 },
  { 352, 6, 11, 9, 2, -29 },
  { 361, 10, 35, 13, 2, -29 },
  { 405, 10, 35, 13, 1, -29 },
  { 449, 16, 16, 18, 1, -30 },
  { 481, 16, 19, 19, 1, -24 },
  { 519, 7, 10, 10, 1, -5 },
  { 528, 10, 5, 12, 1, -13 },
  { 535, 6, 6, 10, 2, -6 },
  { 540, 16, 29, 16, 0, -29 },
  { 598, 16, 29, 18, 1, -29 },
  { 656, 12, 29, 18, 2, -29 },
  { 700, 16, 29, 18, 1, -29 },
  { 758, 16, 29, 18, 1, -29 },
  { 816, 17, 29, 18, 1, -29 },
  { 878, 15, 29, 18, 2, -29 },
  { 933, 16, 29, 18, 1, -29 },
  { 991, 16, 29, 18, 1, -29 },
  { 1049, 16, 29, 18, 1, -29 },
  { 1107, 16, 29, 18, 1, -29 },
  { 1165, 6, 22, 10, 2, -22 },
  { 1182, 7, 27, 10, 1, -22 },
  { 1206, 16, 19, 19, 1, -24 },
  { 1244, 16, 12, 19, 1, -20 },
  { 1268, 17, 19, 19, 1, -24 },
  { 1309, 14, 29, 15, 0, -29 },
  { 1360, 25, 32, 29, 2, -29 },
  { 1460, 21, 29, 21, 0, -29 },
  { 1537, 16, 29, 21, 3, -29 },
  { 1595, 16, 29, 19, 2, -29 },
  { 1653, 18, 29, 22, 3, -29 },
  { 1719, 12, 29, 17, 3, -29 },
  { 1763, 12, 29, 17, 3, -29 },
  { 1807, 18, 29, 23, 2, -29 },
  { 1873, 18, 29, 24, 3, -29 },
  { 1939, 11, 29, 13, 1, -29 },
  { 1979, 10, 37, 11, -2, -29 },
  { 2026, 18, 29, 21, 3, -29 },
  { 2092, 13, 29, 16, 3, -29 },
  { 2140, 25, 29, 31, 3, -29 },
  { 2231, 19, 29, 25, 3, -29 },
  { 2300, 20, 29, 24, 2, -29 },
  { 2373, 15, 29, 20, 3, -29 },
  { 2428, 20, 36, 24, 2, -29 },
  { 2518, 17, 29, 20, 3, -29 },
  { 2580, 15, 29, 17, 1, -29 },
  { 2635, 16, 29, 17, 1, -29 },
  { 2693, 17, 29, 23, 3, -29 },
  { 2755, 20, 29, 20, 0, -29 },
  { 2828, 30, 29, 30, 0, -29 },
  { 2937, 19, 29, 19, 0, -29 },
  { 3006, 19, 29, 19, 0, -29 },
  { 3075, 15, 29, 16, 1, -29 },
  { 3130, 10, 35, 12, 2, -29 },
  { 3174, 16, 29, 16, 0, -29 },
  { 3232, 9, 35, 12, 1, -29 },
  { 3272, 19, 18, 21, 1, -29 },
  { 3315, 16, 3, 16, 0, 3 },
  { 3321, 9, 7, 12, 2, -31 },
  { 3329, 15, 22, 19, 1, -22 },
  { 3371, 17, 30, 20, 2, -30 },
  { 3435, 14, 22, 16, 1, -22 },
  { 3474, 17, 30, 20, 1, -30 },
  { 3538, 16, 22, 18, 1, -22 },
  { 3582, 13, 31, 12, 0, -31 },
  { 3633, 17, 32, 20, 1, -22 },
  { 3701, 16, 30, 20, 2, -30 },
  { 3761, 6, 30, 10, 2, -30 },
  { 3784, 9, 40, 10, -1, -30 },
  { 3829, 18, 30, 19, 2, -30 },
  { 3897, 5, 30, 10, 2, -30 },
  { 3916, 26, 22, 30, 2, -22 },
  { 3988, 16, 22, 20, 2, -22 },
  { 4032, 17, 22, 20, 1, -22 },
  { 4079, 17, 32, 20, 2, -22 },
  { 4147, 17, 32, 20, 1, -22 },
  { 4215, 12, 22, 14, 2, -22 },
  { 4248, 13, 22, 15, 1, -22 },
  { 4284, 12, 26, 13, 0, -26 },
  { 4323, 16, 22, 20, 2, -22 },
  { 4367, 18, 22, 18, 0, -22 },
  { 4417, 27, 22, 27, 0, -22 },
  { 4492, 17, 22, 17, 0, -22 },
  { 4539, 18, 32, 18, 0, -22 },
  { 4611, 13, 22, 14, 1, -22 },
  { 4647, 12, 35, 14, 0, -29 },
  { 4700, 4, 40, 18, 7, -31 },
  { 4720, 12, 35, 14, 1, -29 },
  { 4773, 17, 6, 19, 1, -17 },
};

const GFXfont NotoSans_ExtraCondensed_Bold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD40PT7B_H_
