#ifndef _NOTOSANS_EXTRACONDENSED_BOLD26PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x70, 0x07, 0xFF, 0x70, 0xF3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x3B, 0x9D, 0xCE, 0x0C, 0xC1, 0xCC, 0x1D, 0xC1,
  0xDC, 0x19, 0xC1, 0x9C, 0xFF, 0xFF, 0xFF, 0x39, 0x83, 0xB8, 0x3B, 0x8F,
  0xFE, 0xFF, 0xEF, 0xFE, 0x33, 0x07, 0x30, 0x73, 0x07, 0x70, 0x77, 0x00,
  0x04, 0x01, 0x01, 0xF0, 0xFF, 0x7F, 0xBD, 0x2E, 0x43, 0xD0, 0x7C, 0x1F,
  0x01, 0xF0, 0x3E, 0x07, 0xC1, 0x78, 0x5F, 0x1F, 0xFF, 0xBF, 0xE1, 0xE0,
  0x10, 0x04, 0x01, 0x00, 0x38, 0x1C, 0x1F, 0x06, 0x0F, 0xE3, 0x83, 0xB8,
  0xE0, 0xEE, 0x30, 0x33, 0x9C, 0x0C, 0xE7, 0x03, 0x39, 0x80, 0xEE, 0xEF,
  0xBF, 0xB3, 0xF7, 0xDD, 0xDC, 0xE7, 0x77, 0x01, 0x9C, 0xC0, 0xE7, 0x30,
  0x31, 0xCC, 0x1C, 0x77, 0x07, 0x1D, 0xC1, 0x83, 0xE0, 0xE0, 0x78, 0x1E,
  0x01, 0xF8, 0x1F, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xDE, 0x07, 0xE0,
  0x3E, 0x03, 0xF3, 0xDF, 0x9F, 0xFE, 0xFE, 0x7F, 0x71, 0xFB, 0x8F, 0x9E,
  0x3C, 0xFF, 0xF3, 0xFF, 0x8F, 0xDE, 0xFF, 0xFF, 0xF7, 0x70, 0x0E, 0x38,
  0x71, 0xC3, 0x8E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x1C, 0x3C, 0x38,
  0x70, 0xE1, 0xE1, 0xC3, 0x83, 0x83, 0x80, 0xE0, 0xE0, 0xE1, 0xC1, 0xC3,
  0x87, 0x0E, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0x38, 0x71,
  0xC3, 0x8E, 0x3C, 0x00, 0x1C, 0x07, 0x01, 0xC3, 0xB7, 0xFF, 0xFF, 0xF1,
  0xE0, 0xFC, 0xF7, 0x9C, 0xC2, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x77, 0xFF, 0xEE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0x01, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x0F, 0x00, 0x1E, 0x0F, 0xC7, 0xF9, 0xCE, 0xF3, 0xFC,
  0xFE, 0x3F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0xFF, 0x3D,
  0xCE, 0x7F, 0x9F, 0xC3, 0xF0, 0x07, 0x0F, 0x1F, 0x3F, 0x7F, 0xF7, 0x67,
  0x27, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x1E, 0x1F, 0xCF, 0xFB, 0x9E, 0x43, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x78, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3E, 0x3F, 0xCF, 0xF9, 0x9F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x3F, 0x0F,
  0x83, 0xF8, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0xFF, 0xBF, 0xEF, 0xE0,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xDC, 0x1F, 0xC1, 0xBC,
  0x3B, 0xC3, 0xBC, 0x73, 0xC7, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x70, 0x1C,
  0x07, 0x01, 0xF8, 0xFF, 0xBF, 0xE4, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x0F, 0xFF, 0xBF, 0xCF, 0xE0, 0x07, 0x87, 0xE3, 0xF9, 0xF0, 0x70, 0x3C,
  0x0E, 0x03, 0xBC, 0xFF, 0xBF, 0xFF, 0x3F, 0x87, 0xE1, 0xF8, 0x7F, 0x1F,
  0xCF, 0x7F, 0x9F, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0xF0, 0x3C, 0x0E, 0x07, 0x80, 0x1E, 0x1F, 0xE7, 0xFB, 0xCF, 0xE1, 0xFC,
  0xFF, 0x3D, 0xFE, 0x3F, 0x0F, 0x87, 0xFB, 0xDE, 0xE3, 0xF8, 0x7E, 0x1F,
  0x87, 0xFF, 0xDF, 0xE3, 0xF0, 0x1C, 0x1F, 0xC7, 0xFB, 0xDE, 0xE3, 0xF8,
  0xFE, 0x1F, 0x87, 0xE3, 0xFD, 0xFF, 0xFD, 0xF7, 0x11, 0xC0, 0xF0, 0x38,
  0x1E, 0x7F, 0x1F, 0xC7, 0xC0, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x7F, 0xF7,
  0x7F, 0x77, 0x00, 0x00, 0x00, 0x07, 0x77, 0xFE, 0xE0, 0x00, 0x40, 0x30,
  0x3C, 0x3F, 0x3F, 0x3F, 0x0F, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x3C, 0x03,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x30, 0x0F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3C, 0x1F, 0x1F, 0xBF,
  0x8F, 0x83, 0x80, 0x80, 0x00, 0x3E, 0x7F, 0xBF, 0xEC, 0xF0, 0x38, 0x1C,
  0x1E, 0x0F, 0x0F, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x38, 0x3C,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC3,
  0x00, 0x73, 0x8F, 0x99, 0x8F, 0xCD, 0xCE, 0x67, 0xE6, 0x33, 0xF7, 0x39,
  0xFB, 0x9C, 0xFD, 0xCE, 0x7E, 0xE7, 0x37, 0x33, 0x9B, 0x9F, 0x7C, 0xC7,
  0x3C, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x06, 0x03, 0xFF, 0x00, 0x7F, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x77, 0x01, 0xDE,
  0x07, 0x38, 0x1C, 0xE0, 0xF3, 0x83, 0xCF, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC7, 0xFF, 0x9E, 0x1E, 0x70, 0x7B, 0xC0, 0xEF, 0x03, 0xC0, 0xF8, 0x1F,
  0xF3, 0xFF, 0x73, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x1E, 0xFF, 0x9F, 0xE3,
  0xFF, 0x71, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1E, 0xFF, 0xDF, 0xF3, 0xFC,
  0x00, 0x07, 0x83, 0xFC, 0xFF, 0xBE, 0x67, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC1, 0x3F,
  0xC7, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0xE3, 0xFE, 0x7F, 0xEE, 0x3F, 0xC3,
  0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0xC3, 0xF8,
  0x7F, 0x1E, 0xFF, 0xDF, 0xF3, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0xC1, 0xFF,
  0x3F, 0xF3, 0xE2, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF0, 0x77, 0x07, 0x78, 0x77, 0x87, 0x3F, 0xF3, 0xFF,
  0x0F, 0xE0, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xF0, 0xFF, 0xFF, 0xF3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7D, 0xFF, 0xF8,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x3F, 0xFF, 0xBE, 0xE0, 0xFE, 0x1E, 0xE3, 0xCE, 0x3C,
  0xE7, 0x8E, 0x78, 0xEF, 0x0E, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0x70,
  0xE7, 0x8E, 0x78, 0xE3, 0xCE, 0x3C, 0xE1, 0xCE, 0x1E, 0xE1, 0xF0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xEC, 0x37, 0xEE, 0x77,
  0xEE, 0x77, 0xEE, 0x77, 0xE6, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7,
  0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0x87, 0xF0, 0x7F, 0x83, 0xFE,
  0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x3F, 0xF9, 0xFD, 0xCF, 0xEE, 0x7F, 0x7B,
  0xF9, 0xDF, 0xCF, 0xFE, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF,
  0x07, 0xF8, 0x3E, 0x07, 0x80, 0xFF, 0x0F, 0xFC, 0xFB, 0xE7, 0x87, 0xB8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07,
  0xF8, 0x3D, 0xE1, 0xEF, 0x1E, 0x3F, 0xF1, 0xFF, 0x03, 0xF0, 0xFC, 0x3F,
  0xCF, 0xFB, 0xBF, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xFF, 0xEF, 0xFB,
  0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x07, 0x80,
  0xFF, 0x0F, 0xFC, 0xFB, 0xE7, 0x87, 0xB8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x3D, 0xE1, 0xEF, 0x1E,
  0x3F, 0xF1, 0xFF, 0x03, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0,
  0xF8, 0x1F, 0xE3, 0xFE, 0x77, 0xEE, 0x3D, 0xC7, 0xB8, 0xF7, 0x1E, 0xE7,
  0xDF, 0xF3, 0xFC, 0x7F, 0x8E, 0x71, 0xCF, 0x39, 0xE7, 0x1E, 0xE3, 0xDC,
  0x3F, 0x87, 0x80, 0x1E, 0x3F, 0xDF, 0xFF, 0xFF, 0x07, 0x03, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x8F, 0xFF, 0xFF, 0xBF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x7F, 0x8F, 0xFF, 0xEF, 0xF8, 0xFE, 0x00, 0xE0, 0x3F, 0x81, 0xDC, 0x1E,
  0xE0, 0xE7, 0x07, 0x38, 0x38, 0xE3, 0xC7, 0x1C, 0x38, 0xE1, 0xC7, 0x0F,
  0x38, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xF0, 0xF0, 0xEF, 0x0F, 0x0E,
  0xF1, 0xF1, 0xE7, 0x1F, 0x1E, 0x71, 0xF1, 0xE7, 0x1B, 0x9C, 0x79, 0xB9,
  0xC7, 0xBB, 0x9C, 0x3B, 0xBB, 0xC3, 0xB9, 0xBC, 0x3B, 0x9B, 0x83, 0xB1,
  0xF8, 0x3B, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x1E,
  0x0F, 0x00, 0xF0, 0xF7, 0x0E, 0x79, 0xE3, 0x9E, 0x39, 0xC3, 0xFC, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x83, 0xFC, 0x3D,
  0xC3, 0x9E, 0x78, 0xE7, 0x0F, 0xF0, 0xF0, 0xF0, 0x7F, 0x0F, 0x70, 0xF7,
  0x8E, 0x39, 0xE3, 0x9C, 0x3D, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0F, 0x03,
  0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0,
  0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xC0,
  0x06, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x39, 0xC3, 0x9C,
  0x70, 0xE7, 0x0E, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0xF1, 0xE3, 0x87,
  0x7F, 0x1F, 0xE6, 0x78, 0x0F, 0x03, 0xC7, 0xF7, 0xFF, 0xEF, 0xE3, 0xF8,
  0xFE, 0x3F, 0xDF, 0xFD, 0xDE, 0x70, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3D, 0xE7, 0xFE, 0xFF, 0xDE, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x8F, 0xF1, 0xFF, 0xFB, 0xFF, 0x73, 0xC0, 0x3F, 0xBF,
  0x9E, 0xDE, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x2F, 0xF7,
  0xF9, 0xF8, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xCF, 0x7B,
  0xFF, 0x7F, 0xFE, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x8F,
  0xF1, 0xEF, 0xFD, 0xFF, 0x9E, 0x70, 0x3F, 0x1F, 0xE7, 0x3B, 0xC7, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x0F, 0x05, 0xFE, 0x7F, 0x8F, 0xE0,
  0x0F, 0x8F, 0x8F, 0xC7, 0x83, 0x81, 0xC1, 0xFD, 0xFE, 0xFF, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x3D,
  0xEF, 0xFD, 0xFF, 0xF8, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE,
  0x3F, 0xC7, 0xBF, 0xF7, 0xFE, 0x7B, 0xC0, 0x70, 0x0E, 0x81, 0xCF, 0xF9,
  0xFE, 0x3F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F,
  0xE7, 0xFE, 0xFF, 0xDE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF0, 0x6F, 0xF7, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0xF3, 0xC7, 0x00, 0x03, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFB,
  0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0xF7, 0x1C,
  0xE7, 0x9D, 0xE3, 0xB8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0x38, 0xE7,
  0x9C, 0x73, 0x8F, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0x9F, 0x77, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xFF,
  0x1E, 0x3F, 0x8E, 0x1F, 0xC7, 0x0F, 0xE3, 0x87, 0xF1, 0xC3, 0xF8, 0xE1,
  0xFC, 0x70, 0xFE, 0x38, 0x7F, 0x1C, 0x3F, 0x8E, 0x1C, 0xEF, 0x9D, 0xFB,
  0xFF, 0x78, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xC0, 0x3F, 0x0F, 0xF1, 0xEF, 0x78, 0xEF, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3B, 0xC7, 0x3F, 0xE3, 0xF8, 0x3E,
  0x00, 0xE7, 0x9F, 0xFB, 0xFF, 0x78, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x3F, 0xC7, 0xFF, 0xEF, 0xFD, 0xEF, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x00, 0x3D, 0xEF, 0xFD, 0xFF, 0xF8, 0xFF, 0x1F,
  0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xC7, 0xBF, 0xF7, 0xFE, 0x7B,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0xE7, 0xEF, 0xFF,
  0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x7F,
  0xFF, 0xF6, 0xE0, 0xF0, 0xF8, 0x7E, 0x3E, 0x0F, 0x07, 0x87, 0xFF, 0xFE,
  0xFC, 0x18, 0x38, 0x38, 0x7F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xBF, 0xF7, 0xEE,
  0x79, 0xC0, 0xF0, 0xEE, 0x1D, 0xC7, 0xB8, 0xE7, 0x9C, 0x73, 0x8E, 0xF1,
  0xDC, 0x3B, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0xF1, 0xE3,
  0xDC, 0x78, 0xE7, 0x3E, 0x39, 0xCF, 0x9E, 0x73, 0x77, 0x1E, 0xDD, 0xC3,
  0xB3, 0x70, 0xEC, 0xDC, 0x3F, 0x37, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x78,
  0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x00, 0xF1, 0xEF, 0x79, 0xEF, 0x1D, 0xC3,
  0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xF0, 0xEE, 0x3D, 0xE7, 0x1D,
  0xE3, 0xC0, 0xF0, 0xEE, 0x1D, 0xC7, 0xBC, 0xE7, 0x9C, 0x73, 0x8E, 0xF1,
  0xDC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70,
  0x1E, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0x1E, 0x1E, 0x1C,
  0x3C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0x01, 0x0F, 0x1F, 0x1E,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFC, 0xF0, 0xF8, 0x3C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0xF0, 0xF8, 0x78, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x3F, 0x0F, 0x1F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0xF8, 0xF8, 0xF0, 0xF8, 0x7F, 0xFF, 0xFE, 0x1E,
};

const GFXglyph NotoSans_ExtraCondensed_Bold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 19, 7, 1, -19 },
  { 11, 9, 7, 12, 1, -19 },
  { 19, 12, 19, 13, 1, -19 },
  { 48, 10, 22, 12, 1, -20 },
  { 76, 18, 19, 20, 1, -19 },
  { 119, 13, 19, 14, 1, -19 },
  { 150, 4, 7, 6, 1, -19 },
  { 154, 7, 23, 8, 1, -19 },
  { 175, 7, 23, 8, 0, -19 },
  { 196, 10, 11, 12, 1, -20 },
  { 210, 10, 12, 12, 1, -15 },
  { 225, 4, 6, 6, 1, -3 },
  { 228, 6, 4, 8, 1, -9 },
  { 231, 4, 4, 7, 1, -4 },
  { 233, 10, 19, 11, 0, -19 },
  { 257, 10, 19, 12, 1, -19 },
  { 281, 8, 19, 12, 1, -19 },
  { 300, 10, 19, 12, 1, -19 },
  { 324, 10, 19, 12, 1, -19 },
  { 348, 12, 19, 12, 0, -19 },
  { 377, 10, 19, 12, 1, -19 },
  { 401, 10, 19, 12, 1, -19 },
  { 425, 10, 19, 12, 1, -19 },
  { 449, 10, 19, 12, 1, -19 },
  { 473, 10, 19, 12, 1, -19 },
  { 497, 4, 14, 7, 1, -14 },
  { 504, 4, 17, 7, 1, -14 },
  { 513, 10, 13, 12, 1, -16 },
  { 530, 10, 8, 12, 1, -13 },
  { 540, 10, 13, 12, 1, -16 },
  { 557, 9, 19, 10, 0, -19 },
  { 579, 17, 21, 19, 1, -19 },
  { 624, 14, 19, 14, 0, -19 },
  { 658, 11, 19, 14, 2, -19 },
  { 685, 11, 19, 13, 1, -19 },
  { 712, 11, 19, 15, 2, -19 },
  { 739, 8, 19, 11, 2, -19 },
  { 758, 8, 19, 11, 2, -19 },
  { 777, 12, 19, 15, 1, -19 },
  { 806, 12, 19, 15, 2, -19 },
  { 835, 7, 19, 8, 1, -19 },
  { 852, 6, 24, 7, -1, -19 },
  { 870, 12, 19, 13, 2, -19 },
  { 899, 8, 19, 11, 2, -19 },
  { 918, 16, 19, 20, 2, -19 },
  { 956, 13, 19, 16, 2, -19 },
  { 987, 13, 19, 15, 1, -19 },
  { 1018, 10, 19, 13, 2, -19 },
  { 1042, 13, 23, 15, 1, -19 },
  { 1080, 11, 19, 13, 2, -19 },
  { 1107, 9, 19, 11, 1, -19 },
  { 1129, 11, 19, 11, 0, -19 },
  { 1156, 11, 19, 15, 2, -19 },
  { 1183, 13, 19, 13, 0, -19 },
  { 1214, 20, 19, 19, 0, -19 },
  { 1262, 12, 19, 12, 0, -19 },
  { 1291, 12, 19, 12, 0, -19 },
  { 1320, 10, 19, 11, 0, -19 },
  { 1344, 6, 23, 8, 1, -19 },
  { 1362, 10, 19, 11, 0, -19 },
  { 1386, 6, 23, 8, 1, -19 },
  { 1404, 12, 12, 14, 1, -19 },
  { 1422, 11, 2, 11, 0, 2 },
  { 1425, 6, 4, 8, 1, -20 },
  { 1428, 10, 14, 12, 1, -14 },
  { 1446, 11, 20, 13, 1, -20 },
  { 1474, 9, 14, 10, 1, -14 },
  { 1490, 11, 20, 13, 1, -20 },
  { 1518, 10, 14, 12, 1, -14 },
  { 1536, 9, 20, 8, 0, -20 },
  { 1559, 11, 20, 13, 1, -14 },
  { 1587, 11, 20, 13, 1, -20 },
  { 1615, 4, 20, 6, 1, -20 },
  { 1625, 6, 26, 6, -1, -20 },
  { 1645, 11, 20, 13, 2, -20 },
  { 1673, 4, 20, 6, 1, -20 },
  { 1683, 17, 14, 19, 1, -14 },
  { 1713, 11, 14, 13, 1, -14 },
  { 1733, 11, 14, 13, 1, -14 },
  { 1753, 11, 20, 13, 1, -14 },
  { 1781, 11, 20, 13, 1, -14 },
  { 1809, 8, 14, 9, 1, -14 },
  { 1823, 8, 14, 10, 1, -14 },
  { 1837, 8, 17, 9, 0, -17 },
  { 1854, 11, 14, 13, 1, -14 },
  { 1874, 11, 14, 12, 0, -14 },
  { 1894, 18, 14, 18, 0, -14 },
  { 1926, 11, 14, 11, 0, -14 },
  { 1946, 11, 20, 12, 0, -14 },
  { 1974, 8, 14, 9, 1, -14 },
  { 1988, 8, 23, 9, 0, -19 },
  { 2011, 3, 26, 11, 4, -20 },
  { 2021, 8, 23, 9, 1, -19 },
  { 2044, 10, 4, 12, 1, -11 },
};

const GFXfont NotoSans_ExtraCondensed_Bold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD26PT7B_H_
