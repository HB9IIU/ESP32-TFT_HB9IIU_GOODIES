#ifndef _NOTOSANS_EXTRACONDENSED_BOLD59PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xEF, 0xF7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF,
  0x83, 0x00, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x7E, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x3E, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFC, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x7C, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0x7E, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFE, 0xC7, 0xC7, 0xF9, 0x81, 0x8F, 0xE3, 0x00, 0x1F,
  0xC6, 0x00, 0x3F, 0x8C, 0x00, 0x7F, 0x18, 0x00, 0xFF, 0x30, 0x01, 0xFF,
  0x60, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xBF, 0xC0, 0x03, 0x3F, 0xC0, 0x06, 0x7F,
  0x80, 0x0C, 0x7F, 0x80, 0x18, 0xFF, 0x80, 0x31, 0xFF, 0xC0, 0x67, 0xF7,
  0xE0, 0xDF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xE7, 0xF0, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC7, 0xE0, 0x7C, 0x0F,
  0xC3, 0xF1, 0xF8, 0x7F, 0xC3, 0xF0, 0xFC, 0x7E, 0x3F, 0xF8, 0x7E, 0x7F,
  0x3F, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC7, 0xFF, 0xC3, 0xFF, 0xE3, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0xF8, 0x7E, 0x3F, 0x1F,
  0x83, 0xFC, 0x3F, 0x1F, 0x87, 0xE0, 0x3C, 0x0F, 0xC7, 0xE1, 0xF8, 0x00,
  0x03, 0xE1, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xCF, 0xE0, 0x01, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x01, 0xFE, 0x0F, 0xFF, 0x81, 0xFE, 0x1F, 0xFF, 0xC3, 0xFC, 0x3F,
  0xFF, 0xE3, 0xFC, 0x3F, 0xDF, 0xE3, 0xFC, 0x7F, 0x8F, 0xF3, 0xFC, 0x7F,
  0x8F, 0xFF, 0xF8, 0x7F, 0x87, 0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F,
  0xF3, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xE3, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE,
  0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x30, 0x7E, 0x0E, 0x7E, 0x7E, 0x7E, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE7, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xC3,
  0xF8, 0x07, 0x81, 0xF0, 0x03, 0x81, 0xC0, 0x01, 0x00, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xCF,
  0xF3, 0xFC, 0xFF, 0x3F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x1F, 0xC7, 0xF3,
  0xF8, 0xFE, 0x3F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x7F, 0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xF7, 0xFC, 0x3F, 0xC3, 0xF8, 0xFF, 0x07, 0xF9, 0xFE,
  0x0F, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xBF,
  0x80, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x0F, 0xF1, 0xFE,
  0x3F, 0xC3, 0xFE, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xFF, 0xF7,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xCF, 0x8F, 0xF1, 0xC3, 0xFC, 0x20,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0x87, 0xFC, 0x3C,
  0x07, 0xFC, 0x70, 0x07, 0xF8, 0x40, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x1F, 0x07, 0xFE, 0x38, 0x03, 0xFC, 0x20, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xEF,
  0xC1, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x7F,
  0x00, 0x1F, 0xBF, 0x80, 0x0F, 0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7,
  0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8,
  0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7E,
  0x07, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3,
  0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFA, 0x00, 0x1F, 0xEE, 0x00, 0xFF, 0xBF,
  0x1F, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFE, 0x02, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x81, 0x00, 0xFE, 0x3F, 0xC1, 0xFC,
  0xFF, 0xE3, 0xFB, 0xFF, 0xC7, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xF1, 0xFF, 0x7F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFD,
  0xFE, 0x07, 0xFB, 0xFE, 0x1F, 0xE3, 0xFE, 0x7F, 0xC7, 0xFF, 0xFF, 0x87,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x81,
  0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F,
  0xCF, 0xF0, 0x3F, 0x9F, 0xE0, 0xFF, 0x1F, 0xE3, 0xFC, 0x3F, 0xEF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x7F,
  0x9F, 0xF1, 0xFE, 0x1F, 0xF3, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x02, 0x80, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x3F, 0xE7, 0xFC, 0xFF, 0x87, 0xFD, 0xFE, 0x07, 0xFB, 0xFC,
  0x0F, 0xF7, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x3F, 0xFE, 0xFE, 0x7F, 0xFD, 0xFC, 0x7F, 0xF3, 0xF8,
  0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x82, 0x07, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x08, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0x7F, 0x06, 0x00, 0x06, 0x07, 0xE3, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7,
  0xFC, 0xFF, 0x3F, 0x87, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x3F, 0x9F, 0xE7, 0xF1,
  0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC7, 0xC3, 0xFF, 0x38, 0x07, 0xF9, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x1F,
  0x80, 0xFF, 0xE1, 0xF8, 0xFC, 0x0F, 0xFF, 0xC7, 0xE3, 0xF0, 0x7F, 0xFF,
  0x0F, 0x8F, 0x81, 0xFF, 0xFC, 0x3F, 0x7E, 0x0F, 0xE3, 0xF0, 0xFD, 0xF8,
  0x3F, 0x0F, 0xC3, 0xF7, 0xE1, 0xF8, 0x3F, 0x07, 0xDF, 0x07, 0xE0, 0xFC,
  0x1F, 0x7C, 0x1F, 0x83, 0xF0, 0x7F, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xC3,
  0xF0, 0x3F, 0x07, 0xFF, 0x0F, 0xC0, 0xFC, 0x1F, 0xFC, 0x3F, 0x03, 0xF0,
  0x7F, 0xF0, 0xFC, 0x0F, 0xC3, 0xFF, 0xC3, 0xF0, 0x7E, 0x0F, 0xFF, 0x0F,
  0xC1, 0xF8, 0x3F, 0xFC, 0x3F, 0x07, 0xE0, 0xFB, 0xF0, 0x7E, 0x1F, 0xC3,
  0xE7, 0xC1, 0xF8, 0xFF, 0x1F, 0x9F, 0x87, 0xFF, 0xFF, 0xFC, 0x7E, 0x0F,
  0xFE, 0xFF, 0xF1, 0xF8, 0x3F, 0xF9, 0xFF, 0x87, 0xE0, 0x7F, 0xC7, 0xFC,
  0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x04, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x00,
  0x7F, 0xCF, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFC, 0x7F, 0xF9, 0xFE, 0x07, 0xFE, 0xFF, 0x01,
  0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF,
  0x07, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFE, 0x1F, 0xFC,
  0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFC, 0x7C, 0x3F, 0xF0, 0x0C,
  0x3F, 0xE0, 0x04, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x02, 0x3F, 0xF0, 0x0E, 0x1F, 0xFE, 0xFE,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFC, 0x1F, 0xFC, 0xFF,
  0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x01, 0xFE,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x07, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0xCF,
  0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7C, 0x1F, 0xF8, 0x01, 0x87, 0xFE, 0x00, 0x10, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xEF, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0x7F, 0x9F, 0xF8, 0x0F, 0xF1,
  0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x1F,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x3F, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFB, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x1F, 0xF1,
  0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x87, 0xF8, 0x1F, 0xE0, 0xFF, 0x07,
  0xFC, 0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F, 0x8F, 0xF8, 0x0F,
  0xF1, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x3F, 0xDF, 0xF8, 0x07, 0xFB, 0xFE,
  0x00, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFB, 0xFC, 0x03, 0xFE,
  0x7F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xE0,
  0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1,
  0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFE, 0xFF, 0x00,
  0x7F, 0xDF, 0xE0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFD, 0xF8, 0x03, 0xFF, 0xFF, 0xEF, 0xC0, 0x1F, 0xBF, 0xFF, 0x7F, 0x00,
  0xFD, 0xFF, 0xFB, 0xF8, 0x07, 0xEF, 0xFF, 0xCF, 0xC0, 0x7F, 0x7F, 0xFE,
  0x7E, 0x03, 0xF3, 0xFF, 0xF3, 0xF8, 0x1F, 0x9F, 0xFF, 0x9F, 0xC1, 0xFC,
  0xFF, 0xFE, 0x7E, 0x0F, 0xE7, 0xFF, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x9F,
  0x83, 0xF1, 0xFF, 0xFC, 0xFE, 0x3F, 0x8F, 0xFF, 0xE3, 0xF1, 0xF8, 0x7F,
  0xFF, 0x1F, 0x8F, 0xC3, 0xFF, 0xF8, 0xFC, 0x7E, 0x1F, 0xFF, 0xC7, 0xF7,
  0xF0, 0xFF, 0xFE, 0x1F, 0xBF, 0x07, 0xFF, 0xF0, 0xFD, 0xF8, 0x3F, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F,
  0x80, 0x7F, 0xFF, 0x01, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0x7F, 0x01, 0xFF, 0xFB, 0xFC, 0x0F, 0xFF, 0xCF, 0xE0, 0x7F, 0xFE, 0x7F,
  0x83, 0xFF, 0xF3, 0xFC, 0x1F, 0xFF, 0x8F, 0xE0, 0xFF, 0xFC, 0x7F, 0x87,
  0xFF, 0xE1, 0xFC, 0x3F, 0xFF, 0x0F, 0xF1, 0xFF, 0xFC, 0x3F, 0x8F, 0xFF,
  0xE1, 0xFE, 0x7F, 0xFF, 0x0F, 0xF3, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF, 0xC1,
  0xFE, 0xFF, 0xFE, 0x07, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0x1F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x07,
  0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0xC0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF3, 0xFE, 0x00, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0x83, 0xFE,
  0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF7, 0xF8, 0x7F, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x3F, 0xE3, 0xFE,
  0x00, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0x80,
  0x0F, 0xF3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFC, 0x1F, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0,
  0xFF, 0x8F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xCF, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8,
  0xFF, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03,
  0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xC1, 0xE7, 0xFC, 0x01, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE3, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xC3, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x1F, 0xFE, 0x03, 0xF8,
  0x1F, 0xC0, 0x7F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFF, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x3F, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0xFC, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF3, 0xF0, 0xFF, 0x00, 0xFE,
  0x0F, 0xCF, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x3F, 0x0F, 0xF0, 0x0F, 0xF1,
  0xFC, 0xFC, 0x3F, 0xC0, 0x1F, 0xC7, 0xF3, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0xCF, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x1F, 0x9F, 0xE0, 0x07, 0xF1, 0xF8,
  0x7E, 0x7F, 0x80, 0x1F, 0xEF, 0xE1, 0xF9, 0xFE, 0x00, 0x3F, 0xBF, 0x87,
  0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF0, 0x3F,
  0x7F, 0x00, 0x0F, 0xEF, 0xC0, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x03, 0xFF,
  0xF0, 0x00, 0x7E, 0xFC, 0x0F, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xE3, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF1, 0xFE,
  0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x3F, 0xBF, 0xC0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xFC, 0x03,
  0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF7,
  0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xC0,
  0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x3F, 0xDF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0x7F, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x81,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xF8, 0xFF, 0x83, 0x01, 0xFF,
  0x08, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xCF, 0xCF, 0xFE, 0x3F, 0x1F, 0xF0, 0xFC, 0x04, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x07, 0x80, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xF0, 0xFF, 0x7F, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE,
  0xFF, 0x81, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFE, 0x7F, 0xF8, 0xFE, 0x3F, 0xF0,
  0xFE, 0x1F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFE, 0x0C, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x03, 0x7F,
  0xE0, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xF0, 0x7F, 0x07, 0xFC,
  0x7F, 0x0F, 0xFE, 0x7F, 0x1F, 0xFF, 0x7F, 0x1F, 0xFF, 0x7F, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x81,
  0xFF, 0x7F, 0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x1F, 0xFF, 0x7F, 0x0F, 0xFE, 0x3F, 0x03, 0xFC, 0x3F, 0x00, 0x40,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x1F, 0xC1, 0xFE,
  0x7F, 0x81, 0xFC, 0xFE, 0x03, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x08, 0xFF, 0x80, 0x71, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x80, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x0F, 0xFE, 0x7F, 0x1F,
  0xFF, 0x7F, 0x1F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F,
  0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC3, 0xFF, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0x1F, 0xFE, 0x7F, 0x0F,
  0xFE, 0x7F, 0x03, 0xF8, 0x7F, 0x00, 0x40, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x40, 0x01, 0xFE, 0x38,
  0x03, 0xFE, 0x3F, 0xBF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xF8,
  0x1F, 0xE7, 0xFC, 0x3F, 0xDF, 0xFE, 0x7F, 0xBF, 0xFC, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xE0, 0x3C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x07, 0xFB, 0xF8, 0x07, 0xF9, 0xFC, 0x07, 0xFC, 0xFE, 0x03, 0xFC, 0x7F,
  0x03, 0xFC, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE1, 0xFE, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0xFF, 0x00, 0xFE, 0x7F, 0x00,
  0x7F, 0x7F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x9F,
  0xC0, 0x7F, 0x8F, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x7F, 0x07, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0xFE,
  0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0xDF, 0xC0, 0x1F, 0xEF,
  0xE0, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xC0, 0x1F, 0x03, 0xF8, 0xFF, 0xC1, 0xFF, 0x0F, 0xE7, 0xFF,
  0x8F, 0xFE, 0x3F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF0, 0xFF,
  0xE3, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xFF,
  0xF8, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF,
  0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF,
  0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80,
  0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x7F, 0xE3, 0xF9, 0xFF, 0xE7, 0xF7, 0xFF,
  0xCF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0x83,
  0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF, 0xE0,
  0x1F, 0xEF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xFB, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xF7, 0xF8, 0x03, 0xF9, 0xFC, 0x03, 0xFC,
  0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F, 0xF0, 0xFE, 0x7F, 0xF8, 0xFE,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0xE3, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x7F, 0xF8, 0xFF, 0x3F, 0xF0, 0xFF,
  0x1F, 0xE0, 0xFF, 0x03, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xFC, 0x7F, 0x0F, 0xFE, 0x7F, 0x1F, 0xFF, 0x7F, 0x1F, 0xFF, 0x7F, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x81, 0xFF, 0x7F, 0xC3, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0x7F, 0x1F, 0xFE, 0x7F, 0x0F, 0xFE, 0x7F, 0x03, 0xF8, 0x7F, 0x00,
  0x40, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xF1,
  0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xF9, 0xFB, 0xF8, 0x0C, 0xFE, 0x01,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0x60, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x8F, 0xFF, 0xC7, 0xFF, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x00, 0x60, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0xFF, 0x9F,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xCF,
  0xC7, 0xFF, 0x1F, 0x87, 0xFC, 0x3F, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x3F,
  0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x80,
  0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x1F,
  0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x87, 0xF8,
  0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7,
  0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xCF, 0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x7F, 0x01,
  0xFF, 0x80, 0xFE, 0x7F, 0x01, 0xFF, 0x80, 0xFE, 0x7F, 0x81, 0xFF, 0x80,
  0xFE, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x3F,
  0x83, 0xFF, 0xC1, 0xFC, 0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x3F, 0xC3, 0xFF,
  0xC3, 0xFC, 0x3F, 0xC3, 0xE7, 0xC3, 0xFC, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8,
  0x1F, 0xC3, 0xE7, 0xC3, 0xF8, 0x1F, 0xE7, 0xE7, 0xE3, 0xF8, 0x1F, 0xE7,
  0xE3, 0xE7, 0xF8, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0, 0x0F, 0xE7, 0xC3, 0xE7,
  0xF0, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0, 0x0F,
  0xE7, 0xC3, 0xE7, 0xF0, 0x07, 0xEF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xEF, 0xF0, 0x07, 0xF7,
  0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC3, 0xFC, 0x1F, 0xE3, 0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFD, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0,
  0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x0F,
  0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFF,
  0x1F, 0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0xC1,
  0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F,
  0xF0, 0x0F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x8F, 0xF8, 0x00, 0x5F, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xC0, 0x0F, 0xFE, 0x40, 0x00, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 9, 43, 15, 3, -42 },
  { 50, 20, 15, 26, 3, -42 },
  { 88, 28, 42, 30, 1, -42 },
  { 235, 23, 48, 28, 2, -45 },
  { 373, 42, 43, 45, 2, -43 },
  { 599, 32, 44, 33, 1, -43 },
  { 775, 8, 15, 14, 3, -42 },
  { 790, 15, 51, 19, 3, -42 },
  { 886, 15, 51, 19, 1, -42 },
  { 982, 24, 24, 26, 1, -45 },
  { 1054, 24, 28, 27, 2, -35 },
  { 1138, 10, 15, 15, 2, -7 },
  { 1157, 14, 8, 18, 2, -20 },
  { 1171, 9, 10, 15, 3, -9 },
  { 1183, 22, 43, 24, 1, -43 },
  { 1302, 23, 44, 27, 2, -43 },
  { 1429, 18, 42, 27, 3, -42 },
  { 1524, 23, 43, 27, 2, -43 },
  { 1648, 23, 44, 27, 2, -43 },
  { 1775, 25, 42, 27, 1, -42 },
  { 1907, 22, 43, 27, 3, -42 },
  { 2026, 23, 44, 27, 2, -43 },
  { 2153, 24, 42, 27, 1, -42 },
  { 2279, 23, 44, 27, 2, -43 },
  { 2406, 23, 44, 27, 2, -43 },
  { 2533, 9, 34, 15, 3, -33 },
  { 2572, 10, 41, 15, 2, -33 },
  { 2624, 25, 28, 27, 1, -35 },
  { 2712, 24, 18, 27, 2, -30 },
  { 2766, 24, 28, 27, 2, -35 },
  { 2850, 21, 44, 22, 0, -43 },
  { 2966, 38, 48, 43, 2, -43 },
  { 3194, 31, 42, 31, 0, -42 },
  { 3357, 25, 42, 31, 4, -42 },
  { 3489, 24, 44, 29, 3, -43 },
  { 3621, 26, 42, 33, 4, -42 },
  { 3758, 19, 42, 26, 4, -42 },
  { 3858, 19, 42, 25, 4, -42 },
  { 3958, 27, 44, 33, 3, -43 },
  { 4107, 27, 42, 35, 4, -42 },
  { 4249, 16, 42, 19, 1, -42 },
  { 4333, 15, 54, 16, -3, -42 },
  { 4435, 27, 42, 30, 4, -42 },
  { 4577, 19, 42, 24, 4, -42 },
  { 4677, 37, 42, 46, 4, -42 },
  { 4872, 29, 42, 37, 4, -42 },
  { 5025, 29, 44, 35, 3, -43 },
  { 5185, 23, 42, 29, 4, -42 },
  { 5306, 29, 53, 35, 3, -43 },
  { 5499, 26, 42, 30, 4, -42 },
  { 5636, 21, 44, 25, 2, -43 },
  { 5752, 23, 42, 25, 1, -42 },
  { 5873, 26, 43, 34, 4, -42 },
  { 6013, 30, 42, 30, 0, -42 },
  { 6171, 46, 42, 44, -1, -42 },
  { 6413, 28, 42, 28, 0, -42 },
  { 6560, 28, 42, 28, 0, -42 },
  { 6707, 22, 42, 24, 1, -42 },
  { 6823, 14, 51, 18, 3, -42 },
  { 6913, 23, 43, 24, 0, -43 },
  { 7037, 14, 51, 18, 1, -42 },
  { 7127, 29, 26, 31, 1, -42 },
  { 7222, 24, 4, 24, 0, 5 },
  { 7234, 14, 9, 18, 2, -45 },
  { 7250, 22, 34, 27, 2, -33 },
  { 7344, 24, 46, 30, 3, -45 },
  { 7482, 20, 34, 24, 2, -33 },
  { 7567, 24, 46, 30, 2, -45 },
  { 7705, 23, 34, 27, 2, -33 },
  { 7803, 19, 45, 18, 1, -45 },
  { 7910, 24, 47, 30, 2, -33 },
  { 8051, 23, 45, 30, 3, -45 },
  { 8181, 8, 45, 14, 3, -45 },
  { 8226, 13, 59, 14, -2, -45 },
  { 8322, 25, 45, 29, 4, -45 },
  { 8463, 8, 45, 14, 3, -45 },
  { 8508, 38, 33, 44, 3, -33 },
  { 8665, 23, 33, 30, 3, -33 },
  { 8760, 25, 34, 29, 2, -33 },
  { 8867, 24, 47, 30, 3, -33 },
  { 9008, 24, 47, 30, 2, -33 },
  { 9149, 17, 33, 20, 3, -33 },
  { 9220, 18, 34, 22, 2, -33 },
  { 9297, 17, 40, 19, 1, -39 },
  { 9382, 23, 33, 30, 3, -32 },
  { 9477, 26, 32, 26, 0, -32 },
  { 9581, 40, 32, 40, 0, -32 },
  { 9741, 25, 32, 25, 0, -32 },
  { 9841, 26, 46, 26, 0, -32 },
  { 9991, 19, 32, 21, 1, -32 },
  { 10067, 17, 51, 20, 1, -42 },
  { 10176, 6, 59, 26, 10, -45 },
  { 10221, 18, 51, 20, 2, -42 },
  { 10336, 25, 10, 27, 1, -26 },
};

const GFXfont NotoSans_ExtraCondensed_Bold59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD59PT7B_H_
