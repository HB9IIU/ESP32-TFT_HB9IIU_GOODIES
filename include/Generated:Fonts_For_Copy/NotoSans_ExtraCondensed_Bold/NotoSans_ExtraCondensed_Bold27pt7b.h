#ifndef _NOTOSANS_EXTRACONDENSED_BOLD27PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x0E, 0xF7,
  0xDC, 0xF3, 0xFC, 0xFF, 0x3D, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x0C, 0xE1,
  0xCC, 0x1C, 0xC1, 0xCC, 0x1D, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0x83,
  0x98, 0x39, 0x8F, 0xFE, 0xFF, 0xEF, 0xFE, 0x33, 0x83, 0x30, 0x73, 0x07,
  0x30, 0x77, 0x00, 0x04, 0x01, 0x00, 0x60, 0xFF, 0x7F, 0xFF, 0x7F, 0x43,
  0xD0, 0xF4, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xF0, 0x5E, 0x17, 0xC5,
  0xFF, 0xFF, 0xF8, 0x78, 0x04, 0x01, 0x00, 0x40, 0x10, 0x00, 0x0F, 0x83,
  0x81, 0xF8, 0x70, 0x77, 0x0C, 0x0E, 0x63, 0x81, 0xCC, 0x70, 0x39, 0x8C,
  0x07, 0x33, 0x80, 0xE6, 0x63, 0x9D, 0xDD, 0xF9, 0xFB, 0xBF, 0x3E, 0x66,
  0x71, 0x1D, 0xCE, 0x03, 0xB9, 0xC0, 0xE7, 0x38, 0x1C, 0xE7, 0x03, 0x0C,
  0xE0, 0xE1, 0xDC, 0x1C, 0x3F, 0x07, 0x03, 0xC0, 0x04, 0x00, 0xFE, 0x03,
  0xF8, 0x1E, 0xF0, 0x73, 0xC1, 0xCF, 0x07, 0xB8, 0x1F, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xE3, 0xFF, 0xCE, 0xF7, 0xFB, 0x9F, 0xEE, 0x3F, 0x38, 0x7C,
  0xF1, 0xE3, 0xFF, 0xC7, 0xFF, 0x8F, 0xCF, 0xFF, 0xF7, 0x77, 0x70, 0x0E,
  0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0x38, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x38, 0x70, 0xE1, 0xE1, 0xC3, 0xC3, 0x83, 0x80, 0xF0, 0xF0, 0xE1, 0xE1,
  0xC3, 0x87, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x1E, 0x38,
  0x71, 0xE3, 0x8F, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0xC3, 0x33, 0xFF, 0xFF,
  0xF1, 0xE0, 0xFC, 0x7F, 0x9C, 0xF3, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x7B, 0x9D, 0xEE, 0x73, 0x80, 0xFF, 0xFF, 0xC0, 0x77, 0xBE, 0xE0,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0xC0, 0x00, 0x04, 0x07, 0xE1, 0xFE, 0x3F, 0xC7, 0x3D, 0xE3, 0xBC,
  0x77, 0x8E, 0xF1, 0xDC, 0x3B, 0x87, 0xF0, 0xEF, 0x1D, 0xE3, 0xBC, 0x77,
  0x9E, 0x73, 0xCF, 0xF0, 0xFE, 0x0F, 0x80, 0x07, 0x87, 0xC7, 0xE7, 0xF7,
  0xFF, 0xBC, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x04, 0x1F, 0xCF, 0xFB, 0xFF, 0x43, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x03, 0xC1,
  0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x08, 0x1F, 0xCF, 0xF9, 0xFF, 0x43,
  0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0x8F, 0xC3, 0xF0, 0xFF, 0x03, 0xC0, 0x70,
  0x1C, 0x0F, 0x83, 0xFF, 0xFF, 0xFB, 0xFC, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0xDC, 0x1D, 0xC1, 0x9C, 0x39, 0xC3, 0x9C, 0x71, 0xC7,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFC, 0xFF, 0x9F,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x3E, 0x0F, 0xFF, 0xFF, 0xEF, 0xF0,
  0x01, 0x03, 0xF8, 0xFF, 0x1F, 0xE7, 0x80, 0xE0, 0x3C, 0x07, 0x10, 0xEF,
  0x9F, 0xFB, 0xFF, 0x78, 0xEE, 0x1F, 0xC3, 0xFC, 0x7F, 0x8E, 0xF3, 0xCF,
  0xF8, 0xFE, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x00, 0x04, 0x07, 0xE1, 0xFE, 0x79,
  0xEF, 0x1D, 0xE3, 0xBC, 0x73, 0xDE, 0x7F, 0x87, 0xE0, 0xFC, 0x3F, 0xCF,
  0x3D, 0xC3, 0xB8, 0x7F, 0x0F, 0xF1, 0xFF, 0xF9, 0xFE, 0x1F, 0x80, 0x08,
  0x07, 0xE1, 0xFE, 0x7F, 0xEF, 0x3D, 0xC3, 0xB8, 0x77, 0x0F, 0xE1, 0xFE,
  0x7F, 0xFF, 0xBF, 0xE3, 0xDC, 0x03, 0x80, 0x70, 0x1E, 0x07, 0x8F, 0xF1,
  0xFC, 0x3F, 0x00, 0x73, 0xBE, 0xE2, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFD,
  0xC0, 0x73, 0xDE, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x07, 0xB9, 0xDE, 0xF7,
  0x38, 0x00, 0x20, 0x1C, 0x1F, 0x8F, 0xE7, 0xF1, 0xF8, 0x3C, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x0F, 0x80, 0x70, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x1C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x7E, 0x3F, 0x1F, 0x83, 0xC0, 0x60,
  0x08, 0x00, 0x08, 0x1F, 0xCF, 0xF9, 0xFE, 0x43, 0x80, 0xF0, 0x38, 0x1E,
  0x07, 0x83, 0xC1, 0xE0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x0F,
  0x03, 0xC0, 0x70, 0x00, 0x40, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0x81, 0xC3,
  0x80, 0x73, 0x82, 0x1D, 0xC7, 0xEE, 0xC7, 0xF3, 0xE7, 0x39, 0xF3, 0x9C,
  0xF9, 0x8E, 0x7C, 0xC7, 0x3E, 0x63, 0x9F, 0x31, 0x8F, 0x9D, 0xEF, 0xCF,
  0xBE, 0x73, 0x8E, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x81, 0x81, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x7B,
  0x81, 0xCE, 0x07, 0x38, 0x1C, 0xF0, 0xF3, 0xC3, 0xC7, 0x0F, 0xFC, 0x3F,
  0xF9, 0xFF, 0xE7, 0x87, 0x9E, 0x0E, 0x78, 0x3F, 0xC0, 0xFF, 0x03, 0xC0,
  0xFF, 0x9F, 0xFB, 0xFF, 0x70, 0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0x3E, 0xFF,
  0x9F, 0xF3, 0x9F, 0x70, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xFF, 0xDF,
  0xFB, 0xFC, 0x00, 0x01, 0x01, 0xFC, 0x7F, 0x9F, 0xF7, 0xC2, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x7C, 0x27, 0xFC, 0x7F, 0x87, 0xE0, 0xFF, 0x0F, 0xF8, 0xFF, 0xCE,
  0x3E, 0xE1, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1E, 0xE1, 0xEE, 0x7E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x01, 0x80, 0x7F, 0xC7, 0xFC, 0x7F, 0xE7, 0xC1, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x07, 0xF8,
  0x3D, 0xC1, 0xEF, 0x0F, 0x7C, 0x79, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xF0, 0xFF, 0xFD, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7D, 0xFF, 0xF8, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1F, 0xFF, 0xFE, 0xE0, 0xF0, 0xFF, 0x1E, 0xF3, 0xEF, 0x3C, 0xF7, 0x8F,
  0x78, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xF7, 0x8F,
  0x3C, 0xF3, 0xCF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF0, 0xF0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE1, 0xDF, 0xB8, 0xEF, 0xDC, 0x77,
  0xEE, 0x37, 0xF7, 0x3B, 0xF9, 0xDD, 0xFC, 0xEE, 0xFE, 0x7E, 0x7F, 0x3F,
  0x3F, 0x8F, 0x9F, 0xC7, 0xCF, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0x71, 0xE0,
  0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xFF, 0x1F, 0xB8, 0xFD,
  0xC7, 0xEF, 0x3F, 0x39, 0xF9, 0xEF, 0xC7, 0x7E, 0x3F, 0xF0, 0xFF, 0x87,
  0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1E, 0x03, 0x00, 0x7F, 0x83, 0xFF,
  0x0F, 0xFC, 0x78, 0x79, 0xE1, 0xEF, 0x03, 0xBC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x7C,
  0xF8, 0xFF, 0xC1, 0xFF, 0x03, 0xF0, 0xFF, 0x3F, 0xEF, 0xFF, 0x8F, 0xE1,
  0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xFF, 0xFF, 0xFB, 0xFC, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x0F,
  0xFC, 0x78, 0x79, 0xE1, 0xEF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xF7, 0x03, 0x9E, 0x1E, 0x7C, 0xF8,
  0xFF, 0xC1, 0xFE, 0x03, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0xFF, 0x0F, 0xF8, 0xFF, 0xCE, 0x3C, 0xE1, 0xEE, 0x1E, 0xE1,
  0xCE, 0x3C, 0xEF, 0xCF, 0xF8, 0xFF, 0x0E, 0x70, 0xE7, 0x8E, 0x78, 0xE3,
  0xCE, 0x3C, 0xE1, 0xEE, 0x1E, 0xE0, 0xF0, 0x0C, 0x0F, 0xF7, 0xFB, 0xFE,
  0xF0, 0xBC, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80,
  0xE0, 0x3E, 0x0F, 0xC7, 0xBF, 0xEF, 0xF1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x00, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x1E, 0xFF,
  0xE7, 0xFC, 0x3F, 0x80, 0xF0, 0x3F, 0xC0, 0xE7, 0x03, 0x9C, 0x1E, 0x78,
  0x71, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x38, 0xE0, 0xF3, 0x81, 0xCE, 0x07,
  0x38, 0x1D, 0xC0, 0x77, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00,
  0x78, 0x00, 0xE0, 0xF0, 0x7F, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0x70, 0xF8, 0xF7, 0x1F, 0x8E, 0x71, 0xF8, 0xE7, 0x9F, 0x9E, 0x79, 0xF9,
  0xE3, 0x99, 0xDE, 0x3B, 0x9D, 0xC3, 0xB9, 0xDC, 0x3B, 0x9D, 0xC3, 0xF9,
  0xFC, 0x1F, 0x8F, 0xC1, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x80, 0xF0, 0xF3, 0xC7, 0x8E, 0x78, 0x7B, 0xC3, 0xDC, 0x0F, 0xE0,
  0x7F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xFC, 0x1E,
  0xE0, 0xF7, 0x87, 0x3C, 0x78, 0xF3, 0xC7, 0xBC, 0x1E, 0xF0, 0x7B, 0x87,
  0x9E, 0x3C, 0xF1, 0xC3, 0x9E, 0x1E, 0xF0, 0x77, 0x03, 0xF8, 0x1F, 0x80,
  0x7C, 0x03, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07,
  0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF,
  0xC0, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x06, 0x00,
  0x78, 0x03, 0xC0, 0x3F, 0x01, 0xF8, 0x1E, 0xE0, 0xE7, 0x07, 0x1C, 0x70,
  0xE3, 0x83, 0xB8, 0x1D, 0xC0, 0xF0, 0xFF, 0xFF, 0xFC, 0xF1, 0xE3, 0x87,
  0x0C, 0x3F, 0x1F, 0xE7, 0xFC, 0x8F, 0x03, 0xC0, 0x73, 0xFD, 0xFF, 0xF1,
  0xF8, 0x7E, 0x3F, 0x8F, 0xFF, 0xFF, 0xF7, 0xDC, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xC7, 0xFC, 0xFF, 0xDE, 0x7B, 0x87, 0x70,
  0xEE, 0x1D, 0xC3, 0xF8, 0x7F, 0x0E, 0xE1, 0xDE, 0x7B, 0xFF, 0x7F, 0xCE,
  0xF0, 0x1F, 0x1F, 0xDF, 0xEF, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x17, 0xFB, 0xFC, 0xFC, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xCF, 0x3B, 0xF7, 0x7F, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3D, 0xFF, 0xBF, 0x73, 0xEE, 0x1F,
  0x0F, 0xE7, 0xFD, 0xC7, 0xF1, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x03, 0xC1, 0x7F, 0xCF, 0xF1, 0xF8, 0x06, 0x0F, 0xCF, 0xE7, 0xA3, 0x81,
  0xC1, 0xFD, 0xFE, 0xFF, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x3C, 0xEF, 0xDD, 0xFF, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7, 0xFE,
  0xFD, 0xCF, 0x78, 0x0F, 0x01, 0xF0, 0x3D, 0xFF, 0x3F, 0xE7, 0xF8, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0xF3, 0xFE, 0xFF, 0xFC, 0xFE,
  0x3F, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xC0, 0x2F, 0xF7, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x70, 0x08, 0xF3, 0xC7, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCF, 0xFF, 0xFF, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x7F, 0x1E, 0xE3, 0x9C, 0xF3,
  0xBC, 0x77, 0x0F, 0xE1, 0xFC, 0x3F, 0xC7, 0xB8, 0xE7, 0x9C, 0x73, 0x8F,
  0x70, 0xEE, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xCF,
  0x1E, 0x7F, 0xDF, 0xBF, 0xFF, 0xDE, 0x7C, 0xFE, 0x3C, 0x7F, 0x1E, 0x3F,
  0x8F, 0x1F, 0xC7, 0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xFC, 0x78,
  0xFE, 0x3C, 0x7F, 0x1E, 0x3F, 0x8F, 0x1E, 0xCF, 0x3F, 0xEF, 0xFF, 0xCF,
  0xE3, 0xF8, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1C, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC7, 0xB8, 0xF7, 0xFC, 0x7F, 0x87, 0xC0, 0xCF,
  0x1F, 0xF3, 0xFF, 0x79, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x0F, 0xE1, 0xFC,
  0x3B, 0x87, 0x79, 0xEF, 0xFD, 0xFF, 0x3B, 0xC7, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0x3C, 0xEF, 0xDD, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3,
  0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xF7, 0xFE, 0xFD, 0xCF,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0xCF, 0x9F, 0xFF,
  0xFF, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00, 0x3E,
  0x7F, 0xFF, 0xE1, 0xE0, 0xF0, 0xFC, 0x7E, 0x3F, 0x0F, 0x07, 0x87, 0xFF,
  0xFF, 0xFE, 0x18, 0x18, 0x38, 0x3F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x3F, 0x1F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xB8,
  0xF7, 0xFE, 0xFD, 0xCF, 0xB8, 0xF0, 0xFF, 0x0F, 0x70, 0xE7, 0x0E, 0x79,
  0xE7, 0x9C, 0x39, 0xC3, 0x9C, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F,
  0x80, 0xF0, 0x0F, 0x00, 0xF1, 0xE1, 0xFC, 0x78, 0x77, 0x1F, 0x3D, 0xC7,
  0xCE, 0x7B, 0xF3, 0x9E, 0xEC, 0xE3, 0xBB, 0x78, 0xEC, 0xDE, 0x3B, 0x3F,
  0x0E, 0xCF, 0xC3, 0xB3, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0x81,
  0xE1, 0xE0, 0xF1, 0xEE, 0x3D, 0xE7, 0x1D, 0xE3, 0xF8, 0x3F, 0x07, 0xC0,
  0x78, 0x1F, 0x03, 0xF0, 0xFE, 0x1D, 0xE7, 0x9C, 0xE3, 0xFC, 0x78, 0xF0,
  0xFF, 0x0F, 0x70, 0xE7, 0x8E, 0x79, 0xE3, 0x9C, 0x39, 0xC3, 0xDC, 0x3F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x7E, 0x07, 0xC0, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0x1E,
  0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0x1F,
  0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFC, 0xF0, 0xFC, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xF8, 0xF8, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x1F, 0x0F, 0x1F, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xF0, 0x30, 0x3F, 0xCF, 0xFF, 0xC7,
  0xF8, 0x18,
};

const GFXglyph NotoSans_ExtraCondensed_Bold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 10, 7, 12, 1, -19 },
  { 22, 12, 19, 14, 1, -19 },
  { 51, 10, 23, 13, 1, -21 },
  { 80, 19, 20, 21, 1, -20 },
  { 128, 14, 20, 15, 1, -20 },
  { 163, 4, 7, 6, 1, -19 },
  { 167, 7, 23, 9, 1, -19 },
  { 188, 7, 23, 9, 0, -19 },
  { 209, 10, 11, 12, 1, -21 },
  { 223, 11, 13, 13, 1, -16 },
  { 241, 5, 7, 7, 1, -3 },
  { 246, 6, 3, 8, 1, -9 },
  { 249, 5, 4, 7, 1, -4 },
  { 252, 11, 19, 11, 0, -19 },
  { 279, 11, 20, 12, 1, -20 },
  { 307, 9, 19, 12, 1, -19 },
  { 329, 10, 20, 12, 1, -20 },
  { 354, 10, 20, 12, 1, -20 },
  { 379, 12, 19, 12, 0, -19 },
  { 408, 10, 19, 12, 1, -19 },
  { 432, 11, 20, 12, 1, -20 },
  { 460, 11, 19, 12, 1, -19 },
  { 487, 11, 20, 12, 1, -20 },
  { 515, 11, 20, 12, 1, -20 },
  { 543, 5, 15, 7, 1, -15 },
  { 553, 5, 19, 7, 1, -15 },
  { 565, 11, 13, 13, 1, -16 },
  { 583, 11, 9, 13, 1, -14 },
  { 596, 11, 13, 13, 1, -16 },
  { 614, 10, 20, 10, 0, -20 },
  { 639, 17, 22, 20, 1, -20 },
  { 686, 14, 19, 14, 0, -19 },
  { 720, 11, 19, 14, 2, -19 },
  { 747, 11, 20, 13, 1, -20 },
  { 775, 12, 19, 15, 2, -19 },
  { 804, 8, 19, 12, 2, -19 },
  { 823, 8, 19, 12, 2, -19 },
  { 842, 13, 20, 15, 1, -20 },
  { 875, 12, 19, 16, 2, -19 },
  { 904, 7, 19, 9, 1, -19 },
  { 921, 6, 25, 7, -1, -19 },
  { 940, 12, 19, 14, 2, -19 },
  { 969, 9, 19, 11, 2, -19 },
  { 991, 17, 19, 21, 2, -19 },
  { 1032, 13, 19, 17, 2, -19 },
  { 1063, 14, 20, 16, 1, -20 },
  { 1098, 10, 19, 13, 2, -19 },
  { 1122, 14, 25, 16, 1, -20 },
  { 1166, 12, 19, 14, 2, -19 },
  { 1195, 10, 20, 11, 1, -20 },
  { 1220, 11, 19, 12, 0, -19 },
  { 1247, 12, 19, 15, 2, -19 },
  { 1276, 14, 19, 14, 0, -19 },
  { 1310, 20, 19, 20, 0, -19 },
  { 1358, 13, 19, 13, 0, -19 },
  { 1389, 13, 19, 13, 0, -19 },
  { 1420, 11, 19, 11, 0, -19 },
  { 1447, 6, 23, 8, 2, -19 },
  { 1465, 11, 19, 11, 0, -19 },
  { 1492, 6, 23, 8, 1, -19 },
  { 1510, 13, 12, 14, 1, -19 },
  { 1530, 11, 2, 11, 0, 2 },
  { 1533, 6, 5, 8, 1, -21 },
  { 1537, 10, 15, 13, 1, -15 },
  { 1556, 11, 21, 14, 2, -21 },
  { 1585, 9, 15, 11, 1, -15 },
  { 1602, 11, 21, 14, 1, -21 },
  { 1631, 10, 15, 12, 1, -15 },
  { 1650, 9, 21, 8, 0, -21 },
  { 1674, 11, 21, 14, 1, -15 },
  { 1703, 10, 21, 14, 2, -21 },
  { 1730, 4, 21, 7, 1, -21 },
  { 1741, 6, 27, 7, -1, -21 },
  { 1762, 11, 21, 13, 2, -21 },
  { 1791, 3, 21, 7, 2, -21 },
  { 1799, 17, 15, 20, 2, -15 },
  { 1831, 10, 15, 14, 2, -15 },
  { 1850, 11, 15, 13, 1, -15 },
  { 1871, 11, 21, 14, 2, -15 },
  { 1900, 11, 21, 14, 1, -15 },
  { 1929, 7, 15, 9, 2, -15 },
  { 1943, 8, 15, 10, 1, -15 },
  { 1958, 8, 18, 9, 0, -18 },
  { 1976, 11, 15, 14, 1, -15 },
  { 1997, 12, 15, 12, 0, -15 },
  { 2020, 18, 15, 18, 0, -15 },
  { 2054, 11, 15, 11, 0, -15 },
  { 2075, 12, 21, 12, 0, -15 },
  { 2107, 8, 15, 10, 1, -15 },
  { 2122, 8, 23, 9, 0, -19 },
  { 2145, 3, 27, 12, 4, -21 },
  { 2156, 8, 23, 9, 1, -19 },
  { 2179, 11, 5, 13, 1, -12 },
};

const GFXfont NotoSans_ExtraCondensed_Bold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD27PT7B_H_
