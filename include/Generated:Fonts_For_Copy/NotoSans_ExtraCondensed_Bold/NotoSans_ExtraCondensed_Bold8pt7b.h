#ifndef _NOTOSANS_EXTRACONDENSED_BOLD8PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x30, 0xF4, 0x56, 0xF6, 0xF6, 0x5D, 0x1A, 0x80, 0x4A, 0xCB,
  0x9B, 0x2C, 0xB0, 0x66, 0x6F, 0xBF, 0xE0, 0x5A, 0x94, 0x95, 0x5C, 0x5F,
  0x80, 0x4B, 0xA0, 0x60, 0xC0, 0xC0, 0x25, 0x25, 0x00, 0x76, 0xDA, 0xC0,
  0x3C, 0x92, 0x40, 0x74, 0x95, 0xC0, 0x74, 0xB3, 0xC0, 0x26, 0x6A, 0xF2,
  0x6B, 0x93, 0xC0, 0x6B, 0xDA, 0xC0, 0xE4, 0x94, 0x80, 0x75, 0xBB, 0xC0,
  0x76, 0xB3, 0xC0, 0xC3, 0xC1, 0x80, 0x2F, 0x10, 0xFF, 0x86, 0x78, 0xD5,
  0xA0, 0x80, 0x32, 0x6F, 0x7A, 0xA0, 0xC0, 0x66, 0x65, 0xF9, 0xD7, 0xFB,
  0x80, 0x74, 0xC8, 0x47, 0xD6, 0xDB, 0x80, 0xEB, 0xB0, 0xEB, 0xA0, 0x34,
  0xCF, 0x57, 0xB6, 0xFB, 0x40, 0xD5, 0x70, 0x55, 0x5E, 0xBB, 0x6D, 0x40,
  0xAA, 0xB0, 0x9C, 0xFB, 0xDE, 0xF4, 0xB7, 0xFB, 0x40, 0x65, 0xD9, 0x57,
  0xDE, 0xE9, 0x00, 0x65, 0xD9, 0x57, 0x10, 0xDE, 0xED, 0x40, 0x77, 0x33,
  0xC0, 0xE9, 0x24, 0x80, 0xB6, 0xDB, 0xC0, 0x99, 0x66, 0x66, 0xA6, 0xDB,
  0x5E, 0x79, 0x20, 0xB6, 0x66, 0x6B, 0x9E, 0x66, 0x44, 0xE5, 0x29, 0xC0,
  0xEA, 0xAC, 0x91, 0x22, 0x40, 0xD5, 0x5C, 0x26, 0x69, 0xE0, 0xC0, 0xEE,
  0xF0, 0x88, 0xF9, 0xDE, 0x72, 0x30, 0x11, 0xF9, 0xB7, 0xFE, 0x30, 0x6B,
  0x24, 0x80, 0xF9, 0xB5, 0x2E, 0x88, 0xF9, 0x99, 0xCF, 0xF0, 0xCF, 0xFA,
  0xCD, 0xEA, 0xED, 0xFC, 0xFA, 0xFB, 0xEF, 0xF9, 0x99, 0x69, 0x96, 0xF9,
  0xDA, 0x88, 0xF9, 0xB5, 0x11, 0xFB, 0x60, 0xF8, 0xF0, 0x75, 0x40, 0x99,
  0xB7, 0xB6, 0x64, 0xAD, 0xD6, 0xB0, 0xE9, 0xD0, 0xB6, 0x64, 0x4C, 0xE9,
  0x70, 0x57, 0x54, 0xFF, 0xC9, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 3, 2, 4, 0, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 3, 6, 4, 0, -6 },
  { 10, 6, 6, 6, 0, -6 },
  { 15, 4, 6, 4, 0, -6 },
  { 18, 2, 2, 2, 0, -6 },
  { 19, 2, 7, 3, 0, -6 },
  { 21, 2, 7, 3, 0, -6 },
  { 23, 3, 3, 4, 0, -6 },
  { 25, 3, 4, 4, 0, -5 },
  { 27, 2, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 2, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 3, 6, 4, 0, -6 },
  { 36, 3, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 0, -6 },
  { 42, 3, 6, 4, 0, -6 },
  { 45, 4, 6, 4, 0, -6 },
  { 48, 3, 6, 4, 0, -6 },
  { 51, 3, 6, 4, 0, -6 },
  { 54, 3, 6, 4, 0, -6 },
  { 57, 3, 6, 4, 0, -6 },
  { 60, 3, 6, 4, 0, -6 },
  { 63, 2, 4, 2, 0, -4 },
  { 64, 2, 5, 2, 0, -4 },
  { 66, 3, 4, 4, 0, -5 },
  { 68, 4, 2, 4, 0, -4 },
  { 69, 4, 4, 4, 0, -5 },
  { 71, 3, 6, 3, 0, -6 },
  { 74, 5, 7, 6, 0, -6 },
  { 79, 4, 6, 4, 0, -6 },
  { 82, 3, 6, 4, 1, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 3, 6, 4, 1, -6 },
  { 91, 2, 6, 3, 1, -6 },
  { 93, 2, 6, 3, 1, -6 },
  { 95, 4, 6, 5, 0, -6 },
  { 98, 3, 6, 5, 1, -6 },
  { 101, 2, 6, 3, 0, -6 },
  { 103, 2, 8, 2, 0, -6 },
  { 105, 3, 6, 4, 1, -6 },
  { 108, 2, 6, 3, 1, -6 },
  { 110, 5, 6, 6, 1, -6 },
  { 114, 3, 6, 5, 1, -6 },
  { 117, 4, 6, 5, 0, -6 },
  { 120, 3, 6, 4, 1, -6 },
  { 123, 4, 7, 5, 0, -6 },
  { 127, 3, 6, 4, 1, -6 },
  { 130, 3, 6, 3, 0, -6 },
  { 133, 3, 6, 3, 0, -6 },
  { 136, 3, 6, 5, 1, -6 },
  { 139, 4, 6, 4, 0, -6 },
  { 142, 6, 6, 6, 0, -6 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 4, 6, 4, 0, -6 },
  { 153, 3, 6, 3, 0, -6 },
  { 156, 2, 7, 3, 0, -6 },
  { 158, 3, 6, 3, 0, -6 },
  { 161, 2, 7, 3, 0, -6 },
  { 163, 4, 4, 4, 0, -6 },
  { 165, 3, 1, 3, 0, 0 },
  { 166, 2, 1, 2, 0, -6 },
  { 167, 3, 4, 4, 0, -4 },
  { 169, 4, 6, 4, 0, -6 },
  { 172, 3, 4, 3, 0, -4 },
  { 174, 4, 6, 4, 0, -6 },
  { 177, 3, 4, 4, 0, -4 },
  { 179, 3, 6, 2, 0, -6 },
  { 182, 4, 6, 4, 0, -4 },
  { 185, 4, 6, 4, 0, -6 },
  { 188, 2, 6, 2, 0, -6 },
  { 190, 2, 8, 2, 0, -6 },
  { 192, 4, 6, 4, 0, -6 },
  { 195, 1, 6, 2, 0, -6 },
  { 196, 6, 4, 6, 0, -4 },
  { 199, 4, 4, 4, 0, -4 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 4, 6, 4, 0, -4 },
  { 206, 4, 6, 4, 0, -4 },
  { 209, 3, 4, 3, 0, -4 },
  { 211, 3, 4, 3, 0, -4 },
  { 213, 2, 5, 3, 0, -5 },
  { 215, 4, 4, 4, 0, -4 },
  { 217, 4, 4, 4, 0, -4 },
  { 219, 5, 4, 5, 0, -4 },
  { 222, 3, 4, 3, 0, -4 },
  { 224, 4, 6, 4, 0, -4 },
  { 227, 3, 4, 3, 0, -4 },
  { 229, 2, 7, 3, 0, -6 },
  { 231, 1, 8, 4, 1, -6 },
  { 232, 3, 7, 3, 0, -6 },
  { 235, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_ExtraCondensed_Bold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD8PT7B_H_
