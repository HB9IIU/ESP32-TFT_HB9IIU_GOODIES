#ifndef _NOTOSANS_EXTRACONDENSED_BOLD46PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00,
  0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0x20, 0xFE, 0x3F, 0xFE, 0x3F, 0xFE,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C,
  0x3F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7C, 0x1E, 0x01, 0xE3, 0xE0, 0x0F, 0x1F,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0xC3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x1E, 0x1E, 0x00, 0xF1,
  0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78, 0x03, 0xE3, 0xC1, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x1F, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x3C, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0x7F, 0xFF, 0x7E, 0x61, 0xBF, 0x30, 0x1F, 0x98, 0x0F,
  0xCC, 0x07, 0xF6, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0x7E, 0x01,
  0x9F, 0x00, 0xCF, 0xC0, 0x67, 0xF0, 0x37, 0xFE, 0x1B, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x0F, 0xC0, 0x07, 0x80, 0x0F,
  0xF0, 0x07, 0xC0, 0x0F, 0xFC, 0x03, 0xC0, 0x0F, 0xFE, 0x03, 0xE0, 0x07,
  0xCF, 0x81, 0xF0, 0x03, 0xE7, 0xC0, 0xF0, 0x01, 0xE1, 0xE0, 0xF8, 0x01,
  0xF0, 0xF0, 0x78, 0x00, 0xF8, 0x78, 0x3C, 0x00, 0x7C, 0x3C, 0x3E, 0x00,
  0x3E, 0x1E, 0x1E, 0x00, 0x1F, 0x0F, 0x1F, 0x00, 0x0F, 0x87, 0x8F, 0x80,
  0x03, 0xC3, 0xC7, 0x87, 0xC1, 0xE3, 0xE7, 0xCF, 0xF8, 0xF9, 0xF3, 0xC7,
  0xFC, 0x3F, 0xF3, 0xE7, 0xFF, 0x1F, 0xF9, 0xF3, 0xEF, 0x87, 0xF8, 0xF3,
  0xE3, 0xE1, 0xF8, 0xF9, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x1F, 0x00, 0x1F,
  0x0F, 0x8F, 0x80, 0x0F, 0x87, 0xC7, 0xC0, 0x07, 0x83, 0xE3, 0xE0, 0x07,
  0xC1, 0xF1, 0xF0, 0x03, 0xC0, 0x7C, 0xF0, 0x03, 0xE0, 0x3F, 0xF8, 0x01,
  0xF0, 0x0F, 0xF8, 0x00, 0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF7,
  0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0x1F, 0xFC, 0x3F, 0x9F, 0xFF, 0x1F, 0x8F,
  0xFF, 0xCF, 0xC7, 0xE7, 0xF7, 0xE7, 0xF1, 0xFF, 0xE3, 0xF0, 0xFF, 0xF1,
  0xF8, 0x3F, 0xF8, 0xFC, 0x0F, 0xF8, 0x7F, 0x07, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFC, 0xFE, 0x0F, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xEF,
  0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x41,
  0xF0, 0x9E, 0x78, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xEF, 0x83, 0xF3, 0xF0,
  0xFC, 0x7E, 0x1E, 0x1E, 0x01, 0x83, 0x00, 0x20, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0xFF,
  0xFF, 0xFF, 0xEF, 0xDF, 0x88, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xCF, 0xC7, 0xE3, 0xF3,
  0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x7E, 0xFC,
  0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB,
  0xF0, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xE7, 0xE3, 0xF9, 0xF8, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF,
  0xFF, 0x7F, 0xFF, 0xFB, 0xF7, 0xCF, 0xCE, 0x3F, 0x10, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0x8F, 0xE3, 0x81,
  0xFC, 0x40, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x78, 0x7F, 0x84, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xFA, 0x00, 0x7F, 0x30, 0x1F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xDF, 0x00, 0x3D, 0xF0, 0x07, 0xDF, 0x00, 0x7B,
  0xF0, 0x0F, 0xBF, 0x00, 0xF3, 0xF0, 0x1F, 0x3F, 0x01, 0xE3, 0xF0, 0x3E,
  0x3F, 0x03, 0xC3, 0xF0, 0x7C, 0x3F, 0x07, 0x83, 0xF0, 0xF8, 0x3F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0xE1,
  0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFF, 0x1C, 0xFF, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9,
  0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xCF, 0xE0,
  0xFB, 0xFE, 0x1F, 0x7F, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xE1, 0xFB,
  0xF8, 0x3F, 0x7F, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC1, 0xF9, 0xFC, 0x3F, 0x1F, 0x8F, 0xE3,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F, 0x1F, 0x8F, 0xC3,
  0xFB, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03,
  0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x9F, 0xC7, 0xE1, 0xFC, 0xFC, 0x1F, 0xBF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBF,
  0x07, 0xE7, 0xFB, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xF3, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF,
  0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF,
  0x83, 0xFB, 0xF0, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x0F,
  0xFB, 0xE0, 0xFE, 0x7C, 0x06, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x83, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x7E, 0xFF, 0xFF,
  0xF7, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF3, 0xF7, 0xFF, 0xFF, 0xBF, 0x7E, 0x10, 0x7E, 0x7E, 0x7E, 0x7F,
  0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC,
  0xF8, 0xF8, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F,
  0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xF0, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFF, 0x38, 0x7F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x01,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x3E, 0x03, 0x81, 0xF1, 0xE0, 0xFF,
  0xC7, 0x9F, 0x0F, 0xFE, 0x3E, 0xF0, 0xFF, 0xF0, 0xF7, 0x87, 0xC7, 0x87,
  0xFC, 0x7C, 0x3C, 0x3F, 0xE3, 0xE1, 0xE1, 0xFE, 0x1F, 0x0F, 0x0F, 0xF0,
  0xF0, 0x78, 0x7F, 0x87, 0x87, 0xC3, 0xFC, 0x3C, 0x3E, 0x1F, 0xE1, 0xE1,
  0xF0, 0xFF, 0x0F, 0x0F, 0x87, 0xF8, 0x78, 0x7C, 0x3F, 0xC3, 0xE3, 0xE3,
  0xFF, 0x1F, 0x3F, 0x1E, 0xF8, 0x7F, 0xFF, 0xF7, 0xC3, 0xFC, 0xFF, 0x1E,
  0x0F, 0xE7, 0xF0, 0xF8, 0x1C, 0x0E, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x40, 0x0F, 0xF0, 0x3E,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xF4, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7,
  0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0x7E, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x7F, 0xBF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xEF,
  0xC1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF3, 0xF1, 0xFF, 0x7E, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1,
  0xFF, 0xFC, 0x7F, 0xC7, 0x8F, 0xE0, 0x13, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0x1F, 0xE0, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xF0, 0x7F, 0x9F, 0x81, 0xFC, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF,
  0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0xFE,
  0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x3F, 0x07, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xEF, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xF8, 0x78, 0xFF, 0x00, 0x47, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7F, 0x01, 0xFB, 0xF8, 0x0F,
  0xCF, 0xE0, 0x7E, 0x7F, 0x83, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0x9F, 0xE1, 0xE0, 0x00,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x1F, 0xCF, 0xC0,
  0xFE, 0x7E, 0x0F, 0xE3, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x7F, 0x07,
  0xE3, 0xF8, 0x3F, 0x3F, 0x81, 0xF9, 0xFC, 0x0F, 0xDF, 0xC0, 0x7E, 0xFE,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xE7, 0xE0, 0x7E, 0x3F, 0x83, 0xF0, 0xFC,
  0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x3F, 0x07, 0xF1, 0xF8,
  0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xDF, 0x80, 0x7E,
  0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x01, 0xF7, 0xFF, 0xF8, 0x0F, 0xBF, 0xFB, 0xE0, 0x7D,
  0xFF, 0xDF, 0x07, 0xDF, 0xFE, 0xF8, 0x3E, 0xFF, 0xF7, 0xC1, 0xF7, 0xFF,
  0x9F, 0x0F, 0xBF, 0xFC, 0xF8, 0xF9, 0xFF, 0xE7, 0xC7, 0xCF, 0xFF, 0x3E,
  0x3E, 0x7F, 0xF8, 0xF9, 0xE3, 0xFF, 0xC7, 0xDF, 0x1F, 0xFE, 0x3E, 0xF8,
  0xFF, 0xF1, 0xF7, 0xC7, 0xFF, 0x87, 0xFC, 0x3F, 0xFC, 0x3F, 0xE1, 0xFF,
  0xE1, 0xFF, 0x0F, 0xFF, 0x0F, 0xF8, 0x7F, 0xF8, 0x3F, 0x83, 0xFF, 0xC1,
  0xFC, 0x1F, 0xFE, 0x0F, 0xE0, 0xFF, 0xF0, 0x7E, 0x07, 0xFF, 0x81, 0xF0,
  0x3F, 0xFC, 0x0F, 0x81, 0xF8, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x87, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F, 0x1F,
  0xFE, 0x7E, 0x3F, 0xFC, 0x7C, 0x7F, 0xF8, 0xFC, 0xFF, 0xF1, 0xF9, 0xFF,
  0xE1, 0xFB, 0xFF, 0xC3, 0xF7, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xE0, 0x7F,
  0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xBF, 0x00,
  0x7F, 0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFE, 0x3F,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC1,
  0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xF8, 0xFF, 0x0F,
  0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F,
  0xBF, 0x00, 0x7F, 0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF1,
  0xFE, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xCF, 0xFC, 0xFC, 0x1F, 0xCF, 0xC1, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC1, 0xFC, 0xFC, 0x3F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFC, 0xFE, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x8F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F,
  0xC1, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFE, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F,
  0xFC, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0x0C, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x0F,
  0xFF, 0x8F, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07,
  0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x8F, 0x80, 0x3F,
  0x1F, 0x80, 0x7C, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x07,
  0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x1F, 0x80, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0x80, 0x7F,
  0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x7E, 0x01, 0xFC,
  0x07, 0xE3, 0xF0, 0x3F, 0xC0, 0x7E, 0x3F, 0x03, 0xFC, 0x0F, 0xE3, 0xF0,
  0x3F, 0xC0, 0xFC, 0x3F, 0x03, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0xE0, 0xFC,
  0x1F, 0x07, 0xFE, 0x0F, 0xC1, 0xF8, 0x7F, 0xE0, 0xFC, 0x1F, 0x87, 0xDE,
  0x1F, 0x81, 0xF8, 0x7D, 0xE1, 0xF8, 0x1F, 0x87, 0x9F, 0x1F, 0x81, 0xF8,
  0xF9, 0xF1, 0xF8, 0x0F, 0xCF, 0x9F, 0x1F, 0x80, 0xFC, 0xF9, 0xF3, 0xF0,
  0x0F, 0xCF, 0x9F, 0x3F, 0x00, 0xFC, 0xF8, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F,
  0xBF, 0x00, 0x7D, 0xF0, 0xFB, 0xF0, 0x07, 0xDF, 0x0F, 0xBF, 0x00, 0x7F,
  0xF0, 0xFB, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x03, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x7E, 0x03, 0xF9, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xE0, 0x7E, 0x3F,
  0x81, 0xF8, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0xC0, 0x1F, 0x7E, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xE1,
  0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x0F, 0xC7, 0xF0, 0x3F, 0x9F, 0x80, 0xFE,
  0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F,
  0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xBE,
  0x00, 0x7C, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xE0, 0x7E, 0x0F, 0x81,
  0xF0, 0x3F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF9, 0xF8, 0x03, 0xE7, 0xC0,
  0x0F, 0xBF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x00, 0xF0, 0x03,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0x8F, 0xE0, 0x81,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFC, 0xFD, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xDF, 0xDF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xDF, 0x3F, 0xE7, 0xC7, 0xF1, 0xF0, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0C, 0x0F, 0xCF, 0xC3, 0xE7, 0xFC, 0xFB,
  0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x87, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFB, 0xFF, 0x3E, 0x7F,
  0x8F, 0x8F, 0xC0, 0x00, 0xC0, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF,
  0xEF, 0xFF, 0x9F, 0xC1, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x17, 0xF0, 0x6F, 0xFF, 0xDF, 0xFF, 0x9F, 0xFF,
  0x1F, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0xC3, 0xF1, 0xFC, 0xFC, 0xFF, 0x9F, 0x3F, 0xF7, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xF7,
  0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xF7, 0xC7, 0xF9, 0xF0, 0xFC, 0x7C, 0x00,
  0x80, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x1F, 0xCF,
  0xC7, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0x1F, 0xF7,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFC,
  0x0F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xF8, 0x87, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF,
  0x3F, 0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x03, 0x00, 0x03, 0xF9, 0xF1, 0xFE, 0x7C, 0xFF,
  0xDF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xDF, 0x1F, 0xEF,
  0xC3, 0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF4,
  0x01, 0xFD, 0xE0, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7, 0xFF, 0xE1, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x0C, 0x0F, 0x9F, 0xE3, 0xEF, 0xFC, 0xFB, 0xFF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFB, 0xF8, 0x7E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x3C,
  0xFF, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x01, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF8, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F,
  0xC3, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF1, 0xFC, 0x7F, 0x9F, 0xBF, 0xEF, 0xFB,
  0xFC, 0xFE, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0xFE, 0x07, 0xEF, 0xC1, 0xF9, 0xF8,
  0x7F, 0x3F, 0x0F, 0xC7, 0xE3, 0xF0, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF7,
  0xE0, 0x7E, 0xFC, 0x0F, 0xBF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFC, 0x1F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x8F, 0xC3,
  0xF1, 0xF8, 0x7F, 0x3F, 0x07, 0xE7, 0xE0, 0xFE, 0xFC, 0x0F, 0xDF, 0x81,
  0xFF, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x07, 0x07, 0x8F,
  0xF0, 0xFE, 0x3E, 0xFF, 0xCF, 0xF9, 0xF7, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xF8, 0xFF, 0x8F, 0xFF, 0x83, 0xF8, 0x7F,
  0xFC, 0x1F, 0xC1, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x07, 0xE0, 0x7F, 0xF8,
  0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x1F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF0, 0x7E,
  0x07, 0xFF, 0x83, 0xF0, 0x3F, 0xFC, 0x1F, 0x81, 0xFF, 0xE0, 0xFC, 0x0F,
  0xFF, 0x07, 0xE0, 0x7F, 0xF8, 0x3F, 0x03, 0xFF, 0xC1, 0xF8, 0x1F, 0xFE,
  0x0F, 0xC0, 0xFF, 0xF0, 0x7E, 0x07, 0xFF, 0x83, 0xF0, 0x3F, 0xFC, 0x1F,
  0x81, 0xFF, 0xE0, 0xFC, 0x0F, 0xC0, 0x00, 0x30, 0x3C, 0x7F, 0x8F, 0xBF,
  0xF3, 0xEF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE1, 0xFB, 0xF0, 0x7E,
  0xFC, 0x1F, 0xBF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x00, 0xC0, 0x00, 0xFF, 0x80, 0x7F, 0xF8,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0x7F, 0x1F, 0x87, 0xF7, 0xF0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x81, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFB,
  0xF0, 0x3F, 0x7F, 0x07, 0xE7, 0xE1, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x3E, 0x3F, 0x0F,
  0x9F, 0xF3, 0xEF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE1, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xEF,
  0xFC, 0xF9, 0xFE, 0x3F, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x03, 0xF9, 0xF1,
  0xFE, 0x7C, 0xFF, 0xDF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF,
  0xDF, 0x1F, 0xE7, 0xC3, 0xF3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x37, 0x87, 0xFE, 0x7D,
  0xF7, 0xEF, 0xBF, 0x7F, 0xFB, 0xFF, 0xDF, 0xE0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x00, 0x01, 0xC0, 0x3F, 0xF0, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xDF,
  0xC7, 0xBF, 0x02, 0x7E, 0x00, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0xFC,
  0x01, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF,
  0xF8, 0xFF, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF1, 0xFF, 0x83, 0xFC, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xDF, 0x83, 0xF7, 0xE0, 0xFD, 0xFC,
  0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0x7C, 0x7F, 0xDF, 0x0F, 0xE3,
  0xC0, 0xFC, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7, 0xE0, 0x7E, 0x7E,
  0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF0, 0xFC, 0x1F, 0x8F, 0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x80, 0xF9, 0xF8,
  0x0F, 0x9F, 0x00, 0xFD, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x7E, 0xF8, 0x1F, 0xC0, 0xFD,
  0xF8, 0x3F, 0x81, 0xF3, 0xF0, 0x7F, 0x87, 0xE7, 0xE1, 0xFF, 0x0F, 0xCF,
  0xC3, 0xFE, 0x1F, 0x8F, 0xC7, 0xBC, 0x3F, 0x1F, 0x8F, 0x78, 0x7C, 0x3F,
  0x1E, 0xF9, 0xF8, 0x7E, 0x3C, 0xF3, 0xF0, 0x7C, 0xF9, 0xE7, 0xE0, 0xFD,
  0xE3, 0xCF, 0x81, 0xFB, 0xC7, 0x9F, 0x03, 0xF7, 0x8F, 0x7E, 0x07, 0xEF,
  0x1E, 0xFC, 0x07, 0xDE, 0x1D, 0xF0, 0x0F, 0xBC, 0x3F, 0xE0, 0x1F, 0x70,
  0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x83,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x0F, 0xEF, 0xC1, 0xF8, 0xFC, 0x3F,
  0x1F, 0x8F, 0xC1, 0xF9, 0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xE0,
  0x7E, 0xFC, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x9F, 0x83, 0xF3,
  0xF0, 0x7F, 0xFE, 0x07, 0xE0, 0xFE, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07,
  0xF7, 0xE0, 0x7E, 0x7F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xF0,
  0xFC, 0x1F, 0x0F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F,
  0x9F, 0x80, 0xFD, 0xF8, 0x0F, 0xDF, 0x00, 0x7D, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x4F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFF,
  0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x7F, 0x8F, 0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xFE,
  0x0F, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7F, 0x80, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x3F, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xF4, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 34, 12, 2, -33 },
  { 31, 16, 12, 20, 2, -33 },
  { 55, 21, 33, 23, 1, -33 },
  { 142, 17, 38, 21, 2, -35 },
  { 223, 33, 33, 35, 1, -33 },
  { 360, 25, 33, 26, 1, -33 },
  { 464, 7, 12, 11, 2, -33 },
  { 475, 12, 40, 14, 2, -33 },
  { 535, 11, 40, 14, 1, -33 },
  { 590, 18, 19, 20, 1, -35 },
  { 633, 19, 22, 21, 1, -27 },
  { 686, 8, 11, 11, 1, -5 },
  { 697, 12, 6, 14, 1, -15 },
  { 706, 7, 8, 12, 2, -7 },
  { 713, 18, 33, 19, 0, -33 },
  { 788, 18, 33, 21, 2, -33 },
  { 863, 14, 33, 21, 2, -33 },
  { 921, 18, 33, 21, 1, -33 },
  { 996, 19, 33, 21, 1, -33 },
  { 1075, 20, 33, 21, 1, -33 },
  { 1158, 17, 33, 21, 2, -33 },
  { 1229, 19, 33, 21, 1, -33 },
  { 1308, 19, 33, 21, 1, -33 },
  { 1387, 19, 33, 21, 1, -33 },
  { 1466, 19, 33, 21, 1, -33 },
  { 1545, 7, 26, 12, 2, -25 },
  { 1568, 8, 31, 12, 2, -25 },
  { 1599, 19, 21, 21, 1, -27 },
  { 1649, 19, 14, 21, 1, -23 },
  { 1683, 19, 21, 21, 1, -27 },
  { 1733, 16, 34, 17, 0, -33 },
  { 1801, 29, 37, 33, 2, -33 },
  { 1936, 24, 33, 24, 0, -33 },
  { 2035, 19, 33, 24, 3, -33 },
  { 2114, 19, 33, 22, 2, -33 },
  { 2193, 21, 33, 26, 3, -33 },
  { 2280, 15, 33, 20, 3, -33 },
  { 2342, 15, 33, 20, 3, -33 },
  { 2404, 21, 33, 26, 2, -33 },
  { 2491, 21, 33, 27, 3, -33 },
  { 2578, 12, 33, 14, 1, -33 },
  { 2628, 11, 43, 13, -2, -33 },
  { 2688, 21, 33, 24, 3, -33 },
  { 2775, 15, 33, 19, 3, -33 },
  { 2837, 29, 33, 36, 3, -33 },
  { 2957, 23, 33, 29, 3, -33 },
  { 3052, 23, 33, 27, 2, -33 },
  { 3147, 18, 33, 23, 3, -33 },
  { 3222, 23, 41, 27, 2, -33 },
  { 3340, 20, 33, 24, 3, -33 },
  { 3423, 17, 33, 19, 1, -33 },
  { 3494, 18, 33, 20, 1, -33 },
  { 3569, 20, 33, 26, 3, -33 },
  { 3652, 23, 33, 23, 0, -33 },
  { 3747, 36, 33, 34, -1, -33 },
  { 3896, 22, 33, 22, 0, -33 },
  { 3987, 22, 33, 22, 0, -33 },
  { 4078, 17, 33, 19, 1, -33 },
  { 4149, 10, 40, 14, 3, -33 },
  { 4199, 18, 33, 19, 0, -33 },
  { 4274, 11, 40, 14, 1, -33 },
  { 4329, 22, 20, 24, 1, -33 },
  { 4384, 19, 3, 19, 0, 4 },
  { 4392, 10, 7, 14, 2, -35 },
  { 4401, 18, 26, 21, 1, -26 },
  { 4460, 18, 35, 23, 3, -35 },
  { 4539, 15, 26, 18, 2, -26 },
  { 4588, 18, 35, 23, 2, -35 },
  { 4667, 18, 26, 21, 2, -26 },
  { 4726, 15, 35, 14, 0, -35 },
  { 4792, 18, 37, 23, 2, -26 },
  { 4876, 18, 35, 23, 3, -35 },
  { 4955, 7, 35, 11, 2, -35 },
  { 4986, 10, 46, 11, -1, -35 },
  { 5044, 19, 35, 22, 3, -35 },
  { 5128, 6, 35, 11, 3, -35 },
  { 5155, 29, 26, 34, 3, -26 },
  { 5250, 18, 26, 23, 3, -26 },
  { 5309, 19, 26, 22, 2, -26 },
  { 5371, 18, 37, 23, 3, -26 },
  { 5455, 18, 37, 23, 2, -26 },
  { 5539, 13, 26, 16, 3, -26 },
  { 5582, 15, 26, 17, 1, -26 },
  { 5631, 13, 30, 15, 1, -30 },
  { 5680, 18, 25, 23, 2, -25 },
  { 5737, 20, 25, 20, 0, -25 },
  { 5800, 31, 25, 31, 0, -25 },
  { 5897, 19, 25, 19, 0, -25 },
  { 5957, 20, 36, 20, 0, -25 },
  { 6047, 15, 25, 17, 1, -25 },
  { 6094, 14, 40, 16, 0, -33 },
  { 6164, 6, 46, 20, 7, -35 },
  { 6199, 14, 40, 16, 2, -33 },
  { 6269, 19, 8, 21, 1, -20 },
};

const GFXfont NotoSans_ExtraCondensed_Bold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD46PT7B_H_
