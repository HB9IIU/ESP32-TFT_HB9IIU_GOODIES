#ifndef _NOTOSANS_EXTRACONDENSED_BOLD44PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x38, 0xFB,
  0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3,
  0xFF, 0xC3, 0xFF, 0x87, 0xDF, 0x0F, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D,
  0xF0, 0xF8, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x8F, 0x00, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x9F, 0x00, 0xF1, 0xE0, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0x1E, 0x01,
  0xF3, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xFF, 0x81, 0xFF, 0xF1, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFD, 0xC6, 0x7E, 0xE0, 0x3E, 0x70, 0x1F, 0xB8, 0x0F, 0xDC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0E, 0xF8, 0x07, 0x7E, 0x03, 0xBF, 0x81,
  0xDF, 0x70, 0xEF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0,
  0x3F, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x3F, 0xE0, 0x1E,
  0x00, 0x7F, 0xF0, 0x1E, 0x00, 0x7D, 0xF0, 0x3E, 0x00, 0x78, 0xF0, 0x3C,
  0x00, 0x78, 0xF8, 0x3C, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x78,
  0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0xF0, 0x00, 0xF8, 0xF8, 0xF0,
  0x00, 0xF8, 0xF9, 0xF0, 0x00, 0x78, 0xF9, 0xE3, 0xF0, 0x78, 0xF3, 0xE7,
  0xF8, 0x7D, 0xF3, 0xC7, 0xFC, 0x3F, 0xF3, 0xCF, 0xFE, 0x3F, 0xE7, 0xCF,
  0x3E, 0x1F, 0xC7, 0x9F, 0x1E, 0x0F, 0x0F, 0x9F, 0x1E, 0x00, 0x0F, 0x1F,
  0x1F, 0x00, 0x0F, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x1E, 0x1F,
  0x1F, 0x00, 0x1E, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x1E, 0x00, 0x3C, 0x1F,
  0x1E, 0x00, 0x7C, 0x0F, 0x3E, 0x00, 0x78, 0x0F, 0xFE, 0x00, 0x78, 0x07,
  0xFC, 0x00, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x00,
  0x3F, 0x1F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7E,
  0x3F, 0xF8, 0xFC, 0x7F, 0xFC, 0xFC, 0x7E, 0xFC, 0xFC, 0xFC, 0x7E, 0xFC,
  0xFC, 0x3F, 0xF8, 0xFC, 0x3F, 0xF8, 0xFC, 0x1F, 0xF0, 0xFC, 0x0F, 0xF0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xC0, 0x03, 0xE0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8,
  0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x1C, 0x78, 0xE7, 0xDF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07,
  0xDF, 0x83, 0xF3, 0xE1, 0xF8, 0xFC, 0x1E, 0x1C, 0x01, 0x06, 0x00, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F,
  0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0xFB, 0xFF, 0xFF, 0xFF,
  0xDF, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFF, 0x0F, 0xEF, 0xC3, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x83,
  0xE7, 0xE0, 0xF9, 0xF0, 0x3F, 0x7C, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C,
  0x0F, 0xDF, 0x03, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87,
  0xE3, 0xF3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F,
  0xF3, 0xFF, 0xDF, 0xBF, 0xFC, 0xFD, 0xE3, 0xF3, 0x0F, 0xC4, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x07,
  0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x9F, 0xE3, 0x81,
  0xF8, 0x40, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x0F,
  0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0x1F, 0xE3, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xEE, 0x03, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xF7, 0xE0, 0x1E, 0xFC, 0x07,
  0x9F, 0x80, 0xF3, 0xF0, 0x3C, 0x7E, 0x07, 0x8F, 0xC1, 0xE1, 0xF8, 0x3C,
  0x3F, 0x0F, 0x07, 0xE1, 0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xFE,
  0x07, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x20, 0xFF, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x80, 0x3F, 0x60, 0x3F, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0,
  0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xF8, 0x23, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x40, 0x7C, 0xFC, 0x1F, 0x7F,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x87, 0xEF, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7E,
  0x0F, 0xDF, 0x83, 0xE7, 0xF1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F,
  0x83, 0xE7, 0xE1, 0xF8, 0xFC, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0xC0, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFC, 0xFE,
  0x7E, 0x1F, 0x9F, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFD, 0xFC, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF,
  0xE0, 0x1F, 0xE0, 0x01, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x3F, 0xFF, 0x1F, 0xCF, 0xC7, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x1F, 0xBF,
  0x03, 0xEF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xFD, 0xF8, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF,
  0x0F, 0xCF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x7C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x71, 0xF7, 0xFF, 0xFF, 0xDF, 0xBE,
  0x3E, 0x3F, 0x7F, 0x7F, 0x3F, 0x3F, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00,
  0x3C, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x3F, 0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x7C, 0xFE,
  0x20, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x3C, 0x03, 0x03, 0xE7,
  0xC1, 0xFF, 0x1E, 0x78, 0x3F, 0xF1, 0xE7, 0x87, 0xFF, 0x1F, 0xF8, 0xF8,
  0xF0, 0xFF, 0x0F, 0x8F, 0x0F, 0xF0, 0xF0, 0xF0, 0xFF, 0x1F, 0x0F, 0x0F,
  0xF1, 0xF0, 0xF0, 0xFF, 0x1F, 0x0F, 0x0F, 0xF1, 0xF0, 0xF0, 0xFF, 0x1F,
  0x1F, 0x0F, 0xF1, 0xF1, 0xF0, 0xFF, 0x1F, 0x1F, 0x1E, 0xF0, 0xF1, 0xF1,
  0xEF, 0x0F, 0xFF, 0xFE, 0xF8, 0xFF, 0xBF, 0xC7, 0x87, 0xF3, 0xF8, 0x78,
  0x1E, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x04, 0x00, 0xFE, 0x07, 0xC0, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80,
  0x1F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xFC, 0xFE, 0x01, 0xF9, 0xF8, 0x03,
  0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC1, 0xFB, 0xF0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFB,
  0xE3, 0xF8, 0x09, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x18,
  0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xC3, 0xFC, 0xFC, 0x1F, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xEF, 0xC0, 0xFC, 0xFC,
  0x1F, 0xCF, 0xC7, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0x3E, 0x3F, 0xC0,
  0x23, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x03, 0xF7, 0xF0, 0x3F,
  0x3F, 0x83, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x1F, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFE, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x3F, 0xC7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFE, 0x3F, 0x7F, 0xEF, 0xFD, 0xFF,
  0x3F, 0xC7, 0xF0, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC1,
  0xFC, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC,
  0xFE, 0x0F, 0xCF, 0xC0, 0xFD, 0xFC, 0x0F, 0xDF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xFC, 0xFC, 0x1F, 0xCF, 0xC0,
  0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFB, 0xC0, 0x7F, 0xFF,
  0xBE, 0x07, 0xFF, 0xFB, 0xE0, 0x7F, 0xFF, 0xBE, 0x07, 0xBF, 0xFD, 0xE0,
  0xFB, 0xFF, 0xDF, 0x0F, 0xBF, 0xFD, 0xF0, 0xF3, 0xFF, 0xDF, 0x1F, 0x3F,
  0xFC, 0xF1, 0xF3, 0xFF, 0xCF, 0x9F, 0x3F, 0xFC, 0xF9, 0xE3, 0xFF, 0xCF,
  0xBE, 0x3F, 0xFC, 0x7B, 0xE3, 0xFF, 0xC7, 0xFE, 0x3F, 0xFC, 0x7F, 0xC3,
  0xFF, 0xC7, 0xFC, 0x3F, 0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xF8, 0x3F, 0xFC,
  0x3F, 0x83, 0xFF, 0xC3, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xF0,
  0x3F, 0xFC, 0x1F, 0x03, 0xF0, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xEF, 0x83, 0xFF, 0xBF, 0x0F, 0xFE,
  0xFC, 0x3F, 0xF9, 0xF8, 0xFF, 0xF7, 0xE3, 0xFF, 0xCF, 0x8F, 0xFF, 0x3F,
  0x3F, 0xFC, 0x7C, 0xFF, 0xF1, 0xFB, 0xFF, 0xC7, 0xEF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x3F, 0xC7,
  0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xDF, 0x80,
  0x7E, 0x7E, 0x01, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF3, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE, 0x7F,
  0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFE, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xDF, 0x80, 0x7E, 0x7E,
  0x01, 0xF9, 0xFC, 0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF8, 0x7F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC3, 0xF9,
  0xF8, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x87,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0xFF, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x1F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7E, 0x06, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0xF8,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x07, 0xE3,
  0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xF0,
  0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7E,
  0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x1F, 0x00, 0x7C, 0xFC, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF0,
  0x0F, 0xDF, 0x80, 0x7C, 0x03, 0xF7, 0xE0, 0x3F, 0x80, 0xFD, 0xF8, 0x0F,
  0xE0, 0x3F, 0x7E, 0x03, 0xF8, 0x1F, 0x8F, 0x80, 0xFE, 0x07, 0xE3, 0xF0,
  0x3F, 0x81, 0xF8, 0xFC, 0x1F, 0xE0, 0x7E, 0x3F, 0x07, 0xFC, 0x1F, 0x8F,
  0xC1, 0xEF, 0x07, 0xC1, 0xF0, 0x7B, 0xC3, 0xF0, 0x7C, 0x3E, 0xF0, 0xFC,
  0x1F, 0x8F, 0xBC, 0x3F, 0x07, 0xE3, 0xEF, 0x8F, 0xC1, 0xF8, 0xFB, 0xE3,
  0xE0, 0x3E, 0x3C, 0xF9, 0xF8, 0x0F, 0x9F, 0x1E, 0x7E, 0x03, 0xE7, 0xC7,
  0x9F, 0x80, 0xFD, 0xF1, 0xF7, 0xE0, 0x3F, 0x7C, 0x7D, 0xF0, 0x07, 0xDF,
  0x1F, 0x7C, 0x01, 0xF7, 0x83, 0xDF, 0x00, 0x7D, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xF3,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0x3E, 0x7E, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x03, 0xF1, 0xF8,
  0x1F, 0x8F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0,
  0x7F, 0x3F, 0x01, 0xFB, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xFB, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFE, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x3F, 0x0F,
  0x81, 0xF0, 0x7C, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0xFE, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x00,
  0x40, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0xF1, 0xFC,
  0x40, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0xFF, 0xE3, 0xFF,
  0xF3, 0xFF, 0xFB, 0xFF, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xF7, 0xE7, 0xFB, 0xFF, 0xFD, 0xFF, 0xBE,
  0x7F, 0xDF, 0x1F, 0x87, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x3F, 0x8F, 0xDF, 0xF3, 0xF7, 0xFC, 0xFF, 0xFF, 0xBF, 0xEF,
  0xEF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0xBF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xF7, 0xFC, 0xF8, 0xFE, 0x00, 0x00, 0xC0, 0x1F, 0xF8,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F, 0x82, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x27, 0xFF, 0xCF,
  0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x02, 0x0F, 0xC7, 0xF3, 0xF3, 0xFE, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xDF, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0x7F, 0x7F,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xBF, 0x1F, 0xC7, 0xC0, 0x0F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xC7, 0xE3, 0xF7, 0xE0, 0xFB, 0xF0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x4F, 0xE1, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F,
  0xF8, 0x00, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xF9,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0xE3, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x02, 0x00, 0x07, 0xF1, 0xF3, 0xFE, 0xFC,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xDF, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF,
  0xF8, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFE, 0xFC, 0xFF, 0xBF, 0x1F,
  0xCF, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x90, 0x07,
  0xE7, 0xCF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x80,
  0x04, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x10, 0x3F, 0x3F,
  0x8F, 0xDF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE1, 0xFB,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x11, 0xFF, 0xFF, 0xFD, 0xF7, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x02, 0x07, 0xC7, 0xE3, 0xF1,
  0xF8, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7F, 0x7F, 0xFF, 0xFF, 0xBF, 0xDF, 0xC6, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0x81, 0xFB, 0xE0,
  0xFC, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF9, 0xF8,
  0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F,
  0xFF, 0x83, 0xFB, 0xF0, 0xFC, 0xFC, 0x3E, 0x1F, 0x8F, 0x87, 0xE3, 0xE0,
  0xFC, 0xF8, 0x3F, 0x3E, 0x07, 0xEF, 0x81, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x10, 0x02, 0x0F, 0x8F, 0xE1, 0xFC, 0xF9, 0xFF, 0x3F,
  0xEF, 0xFF, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xE3, 0xFF, 0xE1, 0xFC, 0x3F, 0xFE, 0x1F, 0xC1, 0xFF, 0xC0, 0xFC,
  0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF,
  0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F,
  0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F,
  0xFC, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xFF, 0xC0,
  0xF8, 0x1F, 0xFC, 0x0F, 0x81, 0xF0, 0x00, 0x10, 0x3E, 0x3F, 0x8F, 0x9F,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE1, 0xFB, 0xF8, 0x3F,
  0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0x00, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xCF, 0xCF, 0xE1, 0xFB, 0xF0, 0x7E, 0xFC, 0x0F, 0xBF,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xEF, 0xC1, 0xF9, 0xF8, 0x7E,
  0x7F, 0x7F, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x10, 0x3E, 0x3F, 0x8F, 0x9F, 0xF3, 0xF7, 0xFC, 0xFF, 0xFF, 0xBF,
  0xEF, 0xEF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x7F, 0xFF, 0xBF, 0xBF,
  0xFF, 0xEF, 0xDF, 0xF3, 0xF7, 0xFC, 0xFC, 0xFE, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x02, 0x00, 0x07,
  0xF1, 0xF3, 0xFE, 0xFC, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xDF, 0xFF, 0xE1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFE,
  0xFC, 0xFF, 0xBF, 0x1F, 0xCF, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x27, 0xC7, 0xFE, 0x7F, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xDF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0x01,
  0x00, 0x7F, 0xC3, 0xFF, 0xDF, 0xFF, 0x7F, 0xFB, 0xF8, 0xEF, 0xC0, 0xBF,
  0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x8F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xB9,
  0xFF, 0xC7, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xF7,
  0xE1, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFD, 0xF3, 0xFE, 0x7C, 0x7F,
  0x1F, 0xFC, 0x07, 0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xE7, 0xE0,
  0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF8, 0x7C, 0x3F, 0x0F, 0x83, 0xE3,
  0xF0, 0x7C, 0x7E, 0x0F, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xEF,
  0x80, 0x7D, 0xF0, 0x07, 0xBE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFD, 0xF0, 0x7F, 0x03, 0xE7, 0xC1, 0xFE, 0x0F, 0x9F, 0x87, 0xF8,
  0x7E, 0x7E, 0x1F, 0xE1, 0xF9, 0xF8, 0x7F, 0x87, 0xC3, 0xE1, 0xFE, 0x1F,
  0x0F, 0x8F, 0x7C, 0xFC, 0x3F, 0x3C, 0xF3, 0xF0, 0xFC, 0xF3, 0xCF, 0xC1,
  0xF3, 0xCF, 0x3E, 0x07, 0xCF, 0x3C, 0xF8, 0x1F, 0x38, 0xF7, 0xE0, 0x7D,
  0xE1, 0xDF, 0x81, 0xFF, 0x87, 0x7C, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xDF, 0x83, 0xF3, 0xE1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x3F, 0x07, 0xEF, 0xC1, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0xC1, 0xF3, 0xF0, 0xFC,
  0x7C, 0x3F, 0x1F, 0x9F, 0x87, 0xE7, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xEF, 0x80, 0xFD, 0xF8, 0x1F, 0xBF, 0x03, 0xE7, 0xE0, 0xFC, 0x7C, 0x1F,
  0x8F, 0xC3, 0xF1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x7F, 0xC3, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0x7F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0xFE, 0x0F, 0xF0,
  0xFF, 0x8F, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x3F, 0x00, 0x5F, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 31, 11, 2, -31 },
  { 29, 15, 11, 19, 2, -31 },
  { 50, 20, 31, 22, 1, -31 },
  { 128, 17, 36, 21, 2, -33 },
  { 205, 32, 32, 34, 1, -32 },
  { 333, 24, 32, 24, 1, -32 },
  { 429, 6, 11, 10, 2, -31 },
  { 438, 11, 39, 14, 2, -32 },
  { 492, 11, 39, 14, 1, -32 },
  { 546, 18, 18, 20, 1, -34 },
  { 587, 18, 21, 20, 1, -26 },
  { 635, 8, 11, 11, 1, -5 },
  { 646, 11, 6, 13, 1, -15 },
  { 655, 7, 7, 11, 2, -7 },
  { 662, 18, 32, 18, 0, -32 },
  { 734, 18, 32, 20, 1, -32 },
  { 806, 14, 31, 20, 2, -31 },
  { 861, 18, 32, 20, 1, -32 },
  { 933, 18, 32, 20, 1, -32 },
  { 1005, 19, 31, 20, 1, -31 },
  { 1079, 17, 31, 20, 2, -31 },
  { 1145, 18, 32, 20, 1, -32 },
  { 1217, 18, 31, 20, 1, -31 },
  { 1287, 18, 32, 20, 1, -32 },
  { 1359, 18, 32, 20, 1, -32 },
  { 1431, 7, 24, 11, 2, -24 },
  { 1452, 8, 30, 11, 1, -24 },
  { 1482, 18, 21, 20, 1, -26 },
  { 1530, 18, 13, 20, 1, -22 },
  { 1560, 18, 21, 20, 1, -26 },
  { 1608, 16, 32, 16, 0, -32 },
  { 1672, 28, 35, 32, 2, -32 },
  { 1795, 23, 31, 23, 0, -31 },
  { 1885, 18, 31, 23, 3, -31 },
  { 1955, 18, 32, 21, 2, -32 },
  { 2027, 20, 31, 25, 3, -31 },
  { 2105, 14, 31, 19, 3, -31 },
  { 2160, 14, 31, 19, 3, -31 },
  { 2215, 20, 32, 25, 2, -32 },
  { 2295, 20, 31, 26, 3, -31 },
  { 2373, 12, 31, 14, 1, -31 },
  { 2420, 11, 40, 12, -2, -31 },
  { 2475, 20, 31, 23, 3, -31 },
  { 2553, 14, 31, 18, 3, -31 },
  { 2608, 28, 31, 34, 3, -31 },
  { 2717, 22, 31, 28, 3, -31 },
  { 2803, 22, 32, 26, 2, -32 },
  { 2891, 17, 31, 22, 3, -31 },
  { 2957, 22, 39, 26, 2, -32 },
  { 3065, 19, 31, 23, 3, -31 },
  { 3139, 16, 32, 19, 1, -32 },
  { 3203, 17, 31, 19, 1, -31 },
  { 3269, 19, 31, 25, 3, -31 },
  { 3343, 22, 31, 22, 0, -31 },
  { 3429, 34, 31, 33, -1, -31 },
  { 3561, 21, 31, 21, 0, -31 },
  { 3643, 21, 31, 21, 0, -31 },
  { 3725, 16, 31, 18, 1, -31 },
  { 3787, 10, 39, 14, 3, -32 },
  { 3836, 17, 32, 18, 0, -32 },
  { 3904, 10, 39, 14, 1, -32 },
  { 3953, 21, 19, 23, 1, -31 },
  { 4003, 18, 3, 18, 0, 4 },
  { 4010, 10, 7, 14, 2, -34 },
  { 4019, 17, 25, 20, 1, -25 },
  { 4073, 18, 33, 22, 2, -33 },
  { 4148, 15, 25, 18, 2, -25 },
  { 4195, 18, 33, 22, 2, -33 },
  { 4270, 17, 24, 20, 2, -24 },
  { 4321, 15, 34, 13, 0, -34 },
  { 4385, 18, 36, 22, 2, -25 },
  { 4466, 18, 33, 22, 2, -33 },
  { 4541, 6, 34, 11, 2, -34 },
  { 4567, 9, 45, 11, -1, -34 },
  { 4618, 18, 33, 21, 3, -33 },
  { 4693, 6, 33, 11, 2, -33 },
  { 4718, 28, 25, 33, 2, -25 },
  { 4806, 18, 25, 22, 2, -25 },
  { 4863, 18, 25, 21, 2, -25 },
  { 4920, 18, 36, 22, 2, -25 },
  { 5001, 18, 36, 22, 2, -25 },
  { 5082, 13, 25, 15, 2, -25 },
  { 5123, 14, 25, 16, 1, -25 },
  { 5167, 13, 29, 15, 1, -29 },
  { 5215, 18, 24, 22, 2, -24 },
  { 5269, 19, 24, 20, 0, -24 },
  { 5326, 30, 24, 30, 0, -24 },
  { 5416, 18, 24, 19, 0, -24 },
  { 5470, 19, 35, 20, 0, -24 },
  { 5554, 14, 24, 16, 1, -24 },
  { 5596, 14, 38, 15, 0, -31 },
  { 5663, 5, 44, 19, 7, -34 },
  { 5691, 13, 38, 15, 2, -31 },
  { 5753, 18, 7, 20, 1, -19 },
};

const GFXfont NotoSans_ExtraCondensed_Bold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD44PT7B_H_
