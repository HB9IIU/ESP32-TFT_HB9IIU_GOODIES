#ifndef _NOTOSANS_EXTRACONDENSED_BOLD50PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xE7, 0xCF, 0x9F, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0x1F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xFE, 0x1F,
  0xFF, 0x87, 0xFF, 0xE1, 0xFD, 0xF8, 0x7F, 0x7E, 0x1F, 0xDF, 0x87, 0xE7,
  0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8,
  0x3E, 0x7E, 0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0xC3,
  0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC1, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81,
  0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x3E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xF0,
  0x1F, 0xFF, 0x87, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xEC, 0xFB,
  0xF9, 0x82, 0x7F, 0x30, 0x0F, 0xC6, 0x01, 0xFC, 0xC0, 0x1F, 0x98, 0x03,
  0xFB, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x6F, 0xE0,
  0x0C, 0xFC, 0x01, 0x9F, 0xC0, 0x33, 0xFC, 0x06, 0x7F, 0xE0, 0xDF, 0xFF,
  0x9F, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0, 0x7F, 0xF0, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3F,
  0xF8, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0x7E, 0xFC, 0x07, 0xC0,
  0x07, 0xC7, 0xC0, 0x7C, 0x00, 0x7C, 0x7C, 0x0F, 0x80, 0x07, 0xC7, 0xC0,
  0xF8, 0x00, 0x7C, 0x7E, 0x1F, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0x00, 0xFC,
  0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x3E, 0x00,
  0x07, 0xC7, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x7C, 0x3E, 0x07, 0xC7, 0xC7,
  0xC7, 0xF8, 0x7C, 0x7C, 0xF8, 0xFF, 0xC3, 0xEF, 0xCF, 0x9F, 0xFC, 0x3F,
  0xF8, 0xF9, 0xFF, 0xE1, 0xFF, 0x9F, 0x1F, 0x3E, 0x1F, 0xF1, 0xF3, 0xE3,
  0xF0, 0x7E, 0x3E, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE1, 0xF0, 0x00, 0x3E,
  0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x1F, 0x00,
  0x0F, 0x83, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE1,
  0xF0, 0x01, 0xF0, 0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xF3, 0xE0, 0x01, 0xF0,
  0x1F, 0x3E, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0xFC, 0x00,
  0x7C, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xF8, 0x7F, 0xF0, 0x7F,
  0x1F, 0xFF, 0x0F, 0xE7, 0xFF, 0xF1, 0xF8, 0xFE, 0xFE, 0x7F, 0x1F, 0xCF,
  0xEF, 0xE7, 0xF0, 0xFF, 0xF8, 0xFE, 0x1F, 0xFF, 0x1F, 0xC1, 0xFF, 0xE3,
  0xF8, 0x1F, 0xF8, 0x7F, 0x03, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x1F, 0xF7, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xE0, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0x0F, 0x8E, 0x7E, 0xF3,
  0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0xDF, 0x81, 0xF9, 0xF8, 0x3F,
  0x8F, 0xC1, 0xF0, 0xF8, 0x0F, 0x07, 0x00, 0x20, 0x40, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x3F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC, 0xFC, 0xF8,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x18, 0x7E, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x3E, 0x08, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x83, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xC7, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xDF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xE7, 0xE0,
  0xFC, 0xFE, 0x3F, 0x9F, 0xEF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3F, 0xFF, 0x7F, 0x7F, 0xFF, 0x7F, 0x7E, 0x7F, 0x3C, 0x7F, 0x08, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFF,
  0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3C,
  0x0F, 0xE1, 0x80, 0xFE, 0x10, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x0F, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8C, 0x07, 0xF1, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xFE, 0x1F, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x3F, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x7E, 0x00, 0xFB, 0xF0, 0x07,
  0xDF, 0x80, 0x7D, 0xFC, 0x03, 0xEF, 0xE0, 0x3E, 0x7F, 0x01, 0xF3, 0xF8,
  0x1F, 0x1F, 0xC0, 0xF8, 0xFE, 0x0F, 0x87, 0xF0, 0x7C, 0x3F, 0x87, 0xC1,
  0xFC, 0x3E, 0x0F, 0xE3, 0xE0, 0x7F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFD, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9,
  0xFF, 0xFF, 0x08, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8,
  0x01, 0xFF, 0x80, 0x3F, 0xBF, 0x1F, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xE0,
  0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x1F, 0x81, 0xFB, 0xFE,
  0x0F, 0xDF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xF7, 0xFD, 0xFE,
  0x0F, 0xEF, 0xF0, 0x7F, 0x7F, 0x01, 0xFB, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFE, 0x07, 0xE7, 0xF0,
  0x7F, 0x1F, 0xC3, 0xF8, 0xFF, 0x7F, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F,
  0xC7, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFC, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE, 0x0F, 0xEF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xCF, 0xF1, 0xFC, 0x3F, 0xCF, 0xC0,
  0xFE, 0x7E, 0x03, 0xF7, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xFC, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xF7, 0xE0, 0x7F, 0x7F, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFB, 0xF1, 0xFF, 0xBF, 0x0F, 0xF3, 0xF0, 0x18, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x20, 0x7F, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x18, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x8F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0x0C,
  0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x7F,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0x7C, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xFF,
  0x87, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0x83, 0xF8,
  0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x3E,
  0x3E, 0x07, 0xFE, 0x3E, 0x7C, 0x1F, 0xFE, 0x1E, 0x7C, 0x1F, 0xFE, 0x1F,
  0x7C, 0x3F, 0x3E, 0x1F, 0x7C, 0x7E, 0x3E, 0x1F, 0xF8, 0x7C, 0x3E, 0x1F,
  0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F,
  0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xF8, 0x3E, 0x1F,
  0xF8, 0xF8, 0x3E, 0x1F, 0xF8, 0xFC, 0x3E, 0x1E, 0xF8, 0x7C, 0x7E, 0x1E,
  0xF8, 0x7C, 0x7E, 0x3E, 0xF8, 0x7F, 0xFF, 0xFC, 0x7C, 0x3F, 0xEF, 0xFC,
  0x7C, 0x1F, 0xE7, 0xF8, 0x7C, 0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x01, 0x80, 0x07, 0xFC, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x3F, 0x00,
  0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x1F,
  0x80, 0x1F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x0F, 0xE7, 0xF8, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xF8, 0x3F, 0xDF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x7F,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0xE0, 0xFF, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0x81, 0x87, 0xF8, 0x04, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x18, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0x87, 0xFC, 0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x1F, 0xDF,
  0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03,
  0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC3, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87,
  0xFC, 0x07, 0x1F, 0xF0, 0x02, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xC0, 0x3F,
  0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x03, 0xF9,
  0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xC7, 0xFE, 0xFF, 0x8F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0x81,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x7F, 0xC0, 0x60, 0x00, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x1F, 0xCF, 0xE0, 0x7F, 0x9F,
  0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x0F, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC,
  0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF0, 0x1F, 0xDF,
  0xE0, 0x3F, 0xBF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE0, 0xFF, 0x1F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFE, 0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xFD, 0xFC, 0x03, 0xFB, 0xF8,
  0x07, 0xF7, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFD, 0xF0, 0x0F, 0xBF, 0xFF, 0xF8, 0x0F, 0xBF, 0xFF, 0xF8,
  0x0F, 0xBF, 0xFE, 0xF8, 0x1F, 0xBF, 0xFE, 0xF8, 0x1F, 0x3F, 0xFE, 0xFC,
  0x1F, 0x3F, 0xFE, 0xFC, 0x3F, 0x3F, 0xFE, 0x7C, 0x3F, 0x3F, 0xFE, 0x7C,
  0x3E, 0x3F, 0xFE, 0x7E, 0x3E, 0x3F, 0xFE, 0x7E, 0x7E, 0x3F, 0xFE, 0x3E,
  0x7C, 0x3F, 0xFE, 0x3E, 0x7C, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xFE, 0x1F, 0xF8, 0x3F, 0xFE, 0x0F, 0xF0, 0x3F, 0xFE, 0x0F,
  0xF0, 0x3F, 0xFE, 0x0F, 0xF0, 0x3F, 0xFE, 0x0F, 0xE0, 0x3F, 0xFE, 0x07,
  0xE0, 0x3F, 0xFE, 0x07, 0xE0, 0x3F, 0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0x03, 0xFF,
  0xDF, 0xC1, 0xFF, 0xF7, 0xE0, 0xFF, 0xFB, 0xF0, 0x7F, 0xFD, 0xFC, 0x3F,
  0xFE, 0x7E, 0x1F, 0xFF, 0x3F, 0x8F, 0xFF, 0x8F, 0xC7, 0xFF, 0xC7, 0xF3,
  0xFF, 0xE1, 0xF9, 0xFF, 0xF0, 0xFE, 0xFF, 0xF8, 0x7F, 0x7F, 0xFC, 0x1F,
  0xBF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFC,
  0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xEF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0xFF, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x1F, 0xEF, 0xE0, 0xFF,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xFC,
  0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x1F, 0xE7, 0xF0, 0x03, 0xF9, 0xFC, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x3F, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0x87, 0xFC, 0x7F, 0x07, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0, 0xFE,
  0x7F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF9,
  0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xF7, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xEF, 0xF0,
  0xF3, 0xF8, 0x0C, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7E,
  0xC0, 0x3F, 0xBC, 0x0F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x01, 0xFD, 0xFC,
  0x0F, 0xF7, 0xFE, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03,
  0xF3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF8, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0x01, 0xFD,
  0xF8, 0x03, 0xF8, 0x03, 0xF3, 0xF8, 0x07, 0xF0, 0x07, 0xE7, 0xF0, 0x0F,
  0xE0, 0x1F, 0xCF, 0xE0, 0x1F, 0xE0, 0x3F, 0x8F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x1F, 0x80, 0xFF, 0x80, 0xFE, 0x3F, 0x81, 0xFF, 0x01, 0xF8, 0x7F, 0x03,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0x7C, 0x1F,
  0xC1, 0xF8, 0x3E, 0xF8, 0x3F, 0x83, 0xF0, 0x7D, 0xF0, 0x7E, 0x07, 0xF0,
  0xFB, 0xE1, 0xFC, 0x0F, 0xE1, 0xF7, 0xC3, 0xF8, 0x0F, 0xC7, 0xEF, 0xC7,
  0xF0, 0x1F, 0x8F, 0xCF, 0x8F, 0xE0, 0x3F, 0x1F, 0x9F, 0x1F, 0x80, 0x7E,
  0x3E, 0x3E, 0x3F, 0x00, 0xFE, 0x7C, 0x7C, 0xFE, 0x00, 0xFD, 0xF8, 0xFD,
  0xFC, 0x01, 0xFB, 0xF0, 0xFB, 0xF8, 0x03, 0xF7, 0xE1, 0xF7, 0xE0, 0x07,
  0xEF, 0x83, 0xEF, 0xC0, 0x0F, 0xDF, 0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x0F,
  0xBF, 0x00, 0x1F, 0xFC, 0x1F, 0x7E, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x01,
  0xFE, 0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x83,
  0xF8, 0x1F, 0xC3, 0xF8, 0x1F, 0xC7, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7,
  0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xEF, 0xE0, 0x0F, 0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0xC3,
  0xF0, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x81,
  0xFC, 0x7F, 0x01, 0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFC, 0x3F, 0x01,
  0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xC3,
  0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xF7, 0xE0, 0x07, 0xE7,
  0xE0, 0x07, 0xE3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0x7F, 0xC3, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFF, 0xF0, 0xFF,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0x3F, 0x7F, 0x07, 0xEF, 0xC0,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7E, 0xFC, 0x1F, 0xDF, 0xC7,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFB, 0xE7, 0xFF, 0x7C, 0xFF, 0xCF, 0x8F, 0xF0,
  0xF0, 0x20, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x3C, 0x0F, 0xCF, 0xF0, 0xFD, 0xFF, 0x8F,
  0xDF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFE, 0xFF,
  0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xDF, 0xFC, 0xFD, 0xFF, 0x8F,
  0x87, 0xF0, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF9, 0xFE, 0x08, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x09, 0xFE, 0x1C, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0x83, 0xF0, 0xFF,
  0x3F, 0x1F, 0xFB, 0xF3, 0xFF, 0xBF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xF7, 0xF0, 0x7F, 0x7F, 0x0F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF,
  0xBF, 0x1F, 0xF9, 0xF0, 0xFE, 0x1F, 0x01, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0x3F, 0x9F,
  0x83, 0xF3, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x9F, 0xE0, 0x71, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F,
  0xFF, 0x01, 0xFF, 0x80, 0x02, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x3F, 0x1F, 0xFB, 0xF3, 0xFF,
  0xBF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x7F, 0x9F,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0xFE,
  0x3F, 0x01, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x40,
  0x07, 0xE7, 0x00, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xF0, 0x7E, 0x7F, 0x8F,
  0xDF, 0xF9, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xC0, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x07,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0x80,
  0x07, 0x81, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F,
  0xEF, 0xFD, 0xFF, 0xBF, 0xE7, 0xFC, 0xFF, 0x1F, 0x80, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0x7E, 0x07, 0xF3, 0xF0, 0x3F,
  0x1F, 0x83, 0xF8, 0xFC, 0x3F, 0x87, 0xE1, 0xF8, 0x3F, 0x1F, 0xC1, 0xF9,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFE, 0xFE, 0x0F, 0xE3,
  0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0xFC, 0x0F, 0xE7,
  0xE0, 0x7F, 0x3F, 0x01, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0xFE, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0xF8, 0xFF,
  0x0F, 0xF8, 0xF9, 0xFF, 0x8F, 0xFC, 0xFF, 0xFF, 0xDF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x1F, 0xF8, 0xFE, 0xFE, 0x0F,
  0xF0, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x3C,
  0x1F, 0x1F, 0xE3, 0xE7, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFC, 0x3F, 0x8F,
  0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x07,
  0xEF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0x80, 0xFD, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F,
  0x3F, 0x83, 0xF1, 0xFE, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0x8F, 0xF0, 0xFD, 0xFF, 0x8F, 0xDF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0x0F, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xF0, 0xFE, 0xFF, 0x9F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xDF, 0xFC, 0xFC, 0xFF, 0x8F, 0xC7, 0xF0, 0xFC, 0x08, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x3F, 0x1F, 0xFB, 0xF3, 0xFF, 0xBF,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x0F, 0xF7, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0xFF, 0x7F, 0x9F, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xBF, 0x1F, 0xF3, 0xF0, 0xFE, 0x3F,
  0x01, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0xE3, 0xFF, 0x8F, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xBF, 0xE0, 0xFF, 0x03, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xFE, 0x3F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7F, 0xBE, 0xFE, 0x06, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFC, 0x3F, 0xF0, 0x01, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF1, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3,
  0xFF, 0x07, 0xFC, 0x02, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xF3, 0xE7, 0xFE, 0x7C, 0x7F, 0x8F, 0x81, 0x00, 0x00,
  0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0x9F, 0xC0, 0xFE, 0x7F,
  0x03, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x87,
  0xF0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xCF, 0xE0,
  0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xDF, 0x81, 0xFE, 0x07, 0xE7,
  0xE0, 0x7F, 0x81, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x7F, 0x0F, 0xFC, 0x3F,
  0x8F, 0xC3, 0xFF, 0x0F, 0xC3, 0xF0, 0xFF, 0xC3, 0xF0, 0xFC, 0x3D, 0xF0,
  0xFC, 0x3F, 0x8F, 0x3C, 0x3F, 0x0F, 0xE3, 0xCF, 0x1F, 0xC1, 0xF9, 0xF3,
  0xE7, 0xE0, 0x7E, 0x7C, 0xF9, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E, 0x07, 0xE7,
  0x87, 0xBF, 0x80, 0xFD, 0xE1, 0xEF, 0xC0, 0x3F, 0x78, 0x7B, 0xF0, 0x0F,
  0xDE, 0x1E, 0xFC, 0x03, 0xFF, 0x87, 0xBF, 0x00, 0xFF, 0xE1, 0xEF, 0x80,
  0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07,
  0xFB, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0x7F, 0x1F, 0xC1, 0xF8, 0xFE, 0x0F,
  0xE7, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xF7, 0xE0,
  0x1F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xE0,
  0xFC, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0xBF, 0x80, 0xFE, 0xFE, 0x01, 0xFD,
  0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0x9F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC,
  0x0F, 0xC3, 0xF8, 0x3F, 0x0F, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F,
  0x81, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00,
  0xFC, 0xFC, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0xE0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x83, 0xFF, 0x0F, 0xFE, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0x0E, 0x00, 0x09, 0xFF,
  0x00, 0x5F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xD0, 0x03, 0xFC, 0x80, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 7, 37, 13, 3, -36 },
  { 34, 18, 13, 22, 2, -36 },
  { 64, 23, 36, 25, 1, -36 },
  { 168, 19, 41, 23, 2, -38 },
  { 266, 36, 36, 39, 1, -36 },
  { 428, 27, 37, 28, 1, -36 },
  { 553, 7, 13, 12, 2, -36 },
  { 565, 13, 44, 16, 2, -36 },
  { 637, 12, 44, 16, 1, -36 },
  { 703, 20, 20, 22, 1, -38 },
  { 753, 21, 24, 23, 1, -30 },
  { 816, 8, 13, 12, 2, -6 },
  { 829, 13, 7, 15, 1, -17 },
  { 841, 8, 9, 13, 2, -8 },
  { 850, 20, 36, 20, 0, -36 },
  { 940, 19, 37, 23, 2, -36 },
  { 1028, 16, 36, 23, 2, -36 },
  { 1100, 20, 36, 23, 1, -36 },
  { 1190, 19, 37, 23, 2, -36 },
  { 1278, 21, 36, 23, 1, -36 },
  { 1373, 19, 37, 23, 2, -36 },
  { 1461, 21, 37, 23, 1, -36 },
  { 1559, 21, 36, 23, 1, -36 },
  { 1654, 21, 37, 23, 1, -36 },
  { 1752, 20, 37, 23, 1, -36 },
  { 1845, 7, 29, 13, 3, -28 },
  { 1871, 8, 35, 13, 2, -28 },
  { 1906, 21, 24, 23, 1, -30 },
  { 1969, 21, 15, 23, 1, -25 },
  { 2009, 21, 24, 23, 1, -30 },
  { 2072, 18, 37, 18, 0, -36 },
  { 2156, 32, 40, 36, 2, -36 },
  { 2316, 26, 36, 26, 0, -36 },
  { 2433, 21, 36, 26, 3, -36 },
  { 2528, 21, 37, 24, 2, -36 },
  { 2626, 23, 36, 28, 3, -36 },
  { 2730, 16, 36, 22, 3, -36 },
  { 2802, 16, 36, 22, 3, -36 },
  { 2874, 23, 37, 28, 2, -36 },
  { 2981, 23, 36, 29, 3, -36 },
  { 3085, 14, 36, 16, 1, -36 },
  { 3148, 13, 47, 14, -3, -36 },
  { 3225, 23, 36, 26, 3, -36 },
  { 3329, 17, 36, 20, 3, -36 },
  { 3406, 32, 36, 39, 3, -36 },
  { 3550, 25, 36, 32, 3, -36 },
  { 3663, 26, 37, 30, 2, -36 },
  { 3784, 20, 36, 25, 3, -36 },
  { 3874, 26, 45, 30, 2, -36 },
  { 4021, 23, 36, 26, 3, -36 },
  { 4125, 18, 37, 21, 2, -36 },
  { 4209, 20, 36, 21, 1, -36 },
  { 4299, 22, 37, 29, 3, -36 },
  { 4401, 25, 36, 25, 0, -36 },
  { 4514, 39, 36, 37, -1, -36 },
  { 4690, 24, 36, 24, 0, -36 },
  { 4798, 24, 36, 24, 0, -36 },
  { 4906, 19, 36, 21, 1, -36 },
  { 4992, 11, 44, 16, 3, -36 },
  { 5053, 20, 36, 20, 0, -36 },
  { 5143, 12, 44, 16, 1, -36 },
  { 5209, 24, 22, 27, 1, -36 },
  { 5275, 21, 4, 20, 0, 4 },
  { 5286, 12, 8, 16, 2, -38 },
  { 5298, 19, 29, 23, 1, -28 },
  { 5367, 20, 39, 25, 3, -38 },
  { 5465, 17, 29, 20, 2, -28 },
  { 5527, 20, 39, 25, 2, -38 },
  { 5625, 19, 29, 23, 2, -28 },
  { 5694, 17, 38, 15, 0, -38 },
  { 5775, 20, 40, 25, 2, -28 },
  { 5875, 19, 38, 25, 3, -38 },
  { 5966, 7, 38, 12, 3, -38 },
  { 6000, 11, 50, 12, -1, -38 },
  { 6069, 21, 38, 24, 3, -38 },
  { 6169, 6, 38, 12, 3, -38 },
  { 6198, 32, 28, 37, 3, -28 },
  { 6310, 19, 28, 25, 3, -28 },
  { 6377, 21, 29, 24, 2, -28 },
  { 6454, 20, 40, 25, 3, -28 },
  { 6554, 20, 40, 25, 2, -28 },
  { 6654, 14, 28, 17, 3, -28 },
  { 6703, 16, 29, 19, 1, -28 },
  { 6761, 14, 34, 17, 1, -33 },
  { 6821, 19, 28, 25, 3, -27 },
  { 6888, 22, 27, 22, 0, -27 },
  { 6963, 34, 27, 34, 0, -27 },
  { 7078, 21, 27, 21, 0, -27 },
  { 7149, 22, 39, 22, 0, -27 },
  { 7257, 16, 27, 18, 1, -27 },
  { 7311, 16, 44, 17, 0, -36 },
  { 7399, 6, 50, 22, 8, -38 },
  { 7437, 15, 44, 17, 2, -36 },
  { 7520, 21, 9, 23, 1, -22 },
};

const GFXfont NotoSans_ExtraCondensed_Bold50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold50pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD50PT7B_H_
