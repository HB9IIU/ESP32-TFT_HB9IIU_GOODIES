#ifndef _NOTOSANS_EXTRACONDENSED_BOLD22PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x60, 0x0E, 0xFE, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE6, 0xE6, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0xC1, 0x98, 0xFF, 0xDF,
  0xF8, 0xD8, 0x1B, 0x03, 0x63, 0xFF, 0x7F, 0xE3, 0x30, 0x66, 0x0D, 0xC1,
  0xB0, 0x08, 0x08, 0x3E, 0x7F, 0xEB, 0xE8, 0xE8, 0xF8, 0x7C, 0x1E, 0x0F,
  0x0F, 0x8B, 0xCF, 0xFE, 0x7C, 0x08, 0x08, 0x70, 0x71, 0xF0, 0xC3, 0x71,
  0x86, 0x66, 0x0C, 0xCC, 0x19, 0xB8, 0x33, 0x66, 0x6E, 0xDE, 0xFB, 0x76,
  0xE6, 0xCC, 0x1D, 0x98, 0x33, 0x30, 0x66, 0x61, 0x8E, 0xC3, 0x0F, 0x8E,
  0x1E, 0x1E, 0x03, 0xF0, 0x3F, 0x83, 0x38, 0x33, 0x83, 0xF0, 0x3F, 0x01,
  0xE0, 0x3E, 0x77, 0xF6, 0x77, 0xEE, 0x3E, 0x71, 0xC7, 0xBC, 0x7F, 0xE3,
  0xF7, 0xFF, 0xFF, 0xC0, 0x1C, 0xE3, 0x1C, 0x71, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x86, 0x1C, 0x70, 0xE1, 0xC0, 0xE1, 0xC3, 0x0E, 0x38, 0x61,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0x8E, 0x31, 0xCE, 0x00, 0x0C, 0x06,
  0x13, 0x2F, 0xFF, 0xF8, 0xF0, 0xFC, 0xE7, 0x12, 0x00, 0x18, 0x0C, 0x06,
  0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x7E, 0xEE, 0xEC,
  0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x30,
  0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0x81, 0xC0, 0x3C, 0x7E,
  0x7E, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF,
  0x7E, 0x3C, 0x0E, 0x3C, 0xFB, 0xFE, 0xE9, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x3C, 0xFE, 0xFF, 0x47, 0x07, 0x07, 0x07, 0x0E,
  0x0E, 0x1C, 0x38, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0x7C, 0xFE, 0xFF, 0x87,
  0x07, 0x07, 0x0E, 0x3C, 0x3E, 0x0F, 0x07, 0x07, 0x07, 0xCF, 0xFE, 0xFC,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xC3, 0x70, 0xDC, 0x77, 0x19,
  0xCF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x70, 0x1C, 0x7E, 0x7E, 0x7E, 0xE0,
  0xE0, 0xE0, 0xFC, 0xFE, 0x7F, 0x07, 0x07, 0x07, 0x07, 0xCF, 0xFE, 0xFC,
  0x1F, 0x3F, 0x7F, 0x70, 0xE0, 0xE0, 0xDE, 0xFF, 0xE7, 0xE7, 0xE3, 0xE3,
  0xE7, 0xF7, 0x7F, 0x3E, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x18, 0x1C,
  0x0E, 0x06, 0x07, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x3C, 0x3F,
  0x3D, 0xDC, 0xEE, 0x77, 0x39, 0xF8, 0x78, 0x7E, 0x7F, 0xB9, 0xD8, 0x7C,
  0x37, 0x3B, 0xFC, 0xFC, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7, 0xC7, 0xE7, 0xE7,
  0xFF, 0x7B, 0x33, 0x07, 0x07, 0x9E, 0xFC, 0xF8, 0xEF, 0xE0, 0x00, 0x00,
  0x0E, 0xFE, 0xEF, 0xE0, 0x00, 0x00, 0x07, 0x6E, 0xEE, 0xC0, 0x01, 0x83,
  0xC7, 0xEF, 0x8F, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xC0, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x80, 0x70, 0x3E, 0x07, 0xC0, 0xF8,
  0x3C, 0xF9, 0xF0, 0xE0, 0x40, 0x00, 0x3C, 0xFE, 0x7F, 0x47, 0x07, 0x07,
  0x0E, 0x1C, 0x38, 0x38, 0x38, 0x00, 0x00, 0x38, 0x38, 0x38, 0x07, 0xC0,
  0x7F, 0x83, 0x83, 0x1C, 0x06, 0x63, 0x9B, 0x9F, 0x3C, 0xCC, 0xF3, 0x33,
  0xCC, 0xCF, 0x33, 0x3C, 0xCC, 0xF3, 0x76, 0xCF, 0x79, 0x80, 0x07, 0x00,
  0x0E, 0x08, 0x1F, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x81, 0xB8, 0x3B, 0x83, 0x98, 0x39, 0xC3, 0x9C, 0x7F, 0xC7, 0xFC,
  0x70, 0xE7, 0x0E, 0xF0, 0xEE, 0x0F, 0xFE, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3,
  0xB8, 0xEE, 0x7B, 0xFC, 0xFF, 0xB8, 0xEE, 0x1F, 0x87, 0xE3, 0xFF, 0xEF,
  0xFB, 0xF8, 0x0F, 0x1F, 0xDF, 0xEE, 0x1F, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1E, 0x07, 0x03, 0xCC, 0xFE, 0x3F, 0xFC, 0x3F, 0xCF, 0xFB,
  0x8F, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3,
  0xFF, 0xEF, 0xF3, 0xF8, 0xFF, 0xFF, 0xFE, 0x0C, 0x18, 0x30, 0x7E, 0xFD,
  0x83, 0x06, 0x0C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0x0C, 0x3F,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0x0F, 0x8F, 0xF3, 0xFD, 0xE1, 0x70,
  0x38, 0x0E, 0x03, 0x9F, 0xE7, 0xF9, 0xFE, 0x1F, 0x87, 0x71, 0xDE, 0x73,
  0xFC, 0x7F, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xFF, 0xDC, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0xFF, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x39, 0xFF, 0xEE, 0x00, 0xC3, 0xE1, 0xF1, 0xD9,
  0xEC, 0xE6, 0xF3, 0x71, 0xF8, 0xFC, 0x7F, 0x33, 0x99, 0xCC, 0x76, 0x3B,
  0x0F, 0x87, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x8F, 0xEC, 0x6F, 0x63, 0x7B, 0x3B, 0xDD, 0xDE, 0x6C, 0xF3, 0x67,
  0x9F, 0x3C, 0xF1, 0xE3, 0x8F, 0x1C, 0x78, 0xE3, 0xE0, 0xF8, 0x3F, 0x0F,
  0xC3, 0xF8, 0xFE, 0x3D, 0xCF, 0x73, 0xCE, 0xF3, 0xBC, 0x6F, 0x1F, 0xC7,
  0xF0, 0xFC, 0x3F, 0x07, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xEF, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x77, 0x1C, 0xF7, 0x8F,
  0xE0, 0xF8, 0xFC, 0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF, 0xFF,
  0x7F, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x1F, 0x07, 0xF1, 0xFF,
  0x38, 0xEF, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x77, 0x1C, 0xF7, 0x8F, 0xE0, 0xF8, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0xFC, 0x3F, 0xCF, 0xFB, 0x8E, 0xE3, 0xB8, 0xEE, 0x3B, 0xFE, 0xFF, 0x3F,
  0x8E, 0x73, 0x9C, 0xE7, 0xB8, 0xEE, 0x3F, 0x87, 0x3C, 0x7F, 0xFE, 0xE2,
  0xE0, 0xE0, 0xF0, 0x78, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xFE, 0xFE, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x71, 0xDE, 0xF7,
  0xF8, 0xFC, 0xE0, 0xFC, 0x1D, 0x83, 0xB8, 0x67, 0x1C, 0xE3, 0x8C, 0x71,
  0x8C, 0x3B, 0x87, 0x70, 0x6E, 0x0D, 0x81, 0xB0, 0x3E, 0x03, 0xC0, 0x70,
  0xE1, 0x83, 0xF0, 0xE3, 0xB8, 0x71, 0xDC, 0x78, 0xE6, 0x3C, 0x73, 0x9E,
  0x39, 0xCF, 0x98, 0xEE, 0xDC, 0x77, 0x6E, 0x1B, 0x37, 0x0D, 0x9B, 0x87,
  0xCF, 0x83, 0xE3, 0xC1, 0xF1, 0xE0, 0x78, 0xF0, 0x38, 0x78, 0xF1, 0xDC,
  0xF7, 0x38, 0xEE, 0x3F, 0x0F, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0xC3, 0xF0,
  0xEC, 0x3B, 0x9C, 0xE7, 0x1F, 0x87, 0xE1, 0xFC, 0x77, 0x1D, 0xCE, 0x3B,
  0x8E, 0xC3, 0xF0, 0x7C, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0xF0, 0xE0, 0x30, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60,
  0x38, 0x0C, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x3F, 0xFF, 0xF0, 0x06, 0x01, 0xC0, 0x3C, 0x07, 0x81, 0xF8, 0x37,
  0x0E, 0x71, 0x8E, 0x70, 0xDC, 0x1C, 0xFF, 0x80, 0xE3, 0x8C, 0x30, 0x7E,
  0x7F, 0x47, 0x07, 0x07, 0x7F, 0xF7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7B, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x7B, 0xFD, 0xEF, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0xCF, 0xFE, 0xEF, 0x00, 0x3E, 0xFF, 0xCF, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xE5, 0xF9, 0xF0, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3B,
  0xDD, 0xFF, 0xEF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x9E, 0xFF,
  0x7B, 0x80, 0x3E, 0x7E, 0xE7, 0xE3, 0xE3, 0xFF, 0xFF, 0xE0, 0xE0, 0xF1,
  0x7F, 0x3F, 0x1E, 0x7C, 0xF9, 0x83, 0x0F, 0xBF, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x7B, 0xBF, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xEF, 0x70, 0x38, 0x1F, 0x1D, 0xFE, 0xFE,
  0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x7B, 0xFD, 0xEF, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x80, 0x7F, 0x81, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x19, 0xCE, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0xFE, 0x3B, 0x9C, 0xEE, 0x3B, 0x0F, 0xC3, 0xF8, 0xF6, 0x39, 0xCE,
  0x73, 0x8E, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xEF,
  0x7B, 0xFF, 0xFF, 0x7D, 0xF8, 0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8,
  0xE7, 0xE3, 0x9F, 0x8E, 0x7E, 0x39, 0xF8, 0xE7, 0xEF, 0x7F, 0xBD, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x70, 0x3E, 0x3F,
  0xBD, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0x9F, 0xC7, 0xC0,
  0xEF, 0x7F, 0xBC, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xFF,
  0xDD, 0xEE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x7B, 0xBF, 0xFD, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xFB, 0xDF, 0xEF, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0xEF, 0xFF, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0x7F, 0xFB, 0x96, 0x0F, 0x1F, 0x1F, 0x0F, 0x0F, 0x3F, 0xF7, 0xC0,
  0x30, 0x60, 0xC3, 0xFF, 0xEE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0xA7,
  0xCF, 0x80, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xFB, 0xDF, 0xEF, 0x70, 0xE1, 0xF8, 0xE7, 0x39, 0xCE, 0x73, 0x0C, 0xC3,
  0x70, 0xFC, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0xE3, 0x8F, 0xC7, 0x19, 0x9F,
  0x33, 0xB6, 0xE7, 0x6D, 0xCE, 0xDB, 0x8D, 0xB6, 0x1B, 0x6C, 0x34, 0x78,
  0x78, 0xF0, 0xF1, 0xC0, 0xE3, 0x80, 0xE3, 0xBB, 0x9D, 0xC7, 0xE3, 0xE0,
  0xF0, 0x78, 0x7C, 0x37, 0x3B, 0x9C, 0xFC, 0x70, 0xE1, 0xD8, 0xE7, 0x39,
  0xCE, 0x73, 0x0D, 0xC3, 0xF0, 0xFC, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x03, 0xC1, 0xE0, 0x70, 0x00, 0x7E, 0x7E, 0x0E, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x70, 0x70, 0xFF, 0xFF, 0x0E, 0x3C, 0x78, 0xC1, 0x83, 0x06,
  0x1C, 0x39, 0xE3, 0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3C, 0x78, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0xCF, 0x1C, 0x71, 0xC7, 0x1C,
  0x38, 0xF3, 0xDE, 0x71, 0xC7, 0x1C, 0x73, 0xCF, 0x20, 0x60, 0xFC, 0xFF,
  0xF1, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 8, 6, 10, 1, -16 },
  { 15, 11, 16, 11, 0, -16 },
  { 37, 8, 18, 10, 1, -17 },
  { 55, 15, 16, 17, 1, -16 },
  { 85, 12, 16, 12, 0, -16 },
  { 109, 3, 6, 5, 1, -16 },
  { 112, 6, 19, 7, 1, -16 },
  { 127, 6, 19, 7, 0, -16 },
  { 142, 9, 9, 10, 0, -17 },
  { 153, 9, 10, 10, 1, -13 },
  { 165, 4, 6, 5, 1, -3 },
  { 168, 5, 2, 7, 1, -7 },
  { 170, 3, 3, 6, 1, -3 },
  { 172, 9, 16, 9, 0, -16 },
  { 190, 8, 16, 10, 1, -16 },
  { 206, 7, 16, 10, 1, -16 },
  { 220, 8, 16, 10, 1, -16 },
  { 236, 8, 16, 10, 1, -16 },
  { 252, 10, 16, 10, 0, -16 },
  { 272, 8, 16, 10, 1, -16 },
  { 288, 8, 16, 10, 1, -16 },
  { 304, 9, 16, 10, 0, -16 },
  { 322, 9, 16, 10, 1, -16 },
  { 340, 8, 16, 10, 1, -16 },
  { 356, 4, 12, 6, 1, -12 },
  { 362, 4, 15, 6, 1, -12 },
  { 370, 9, 10, 10, 1, -13 },
  { 382, 9, 7, 10, 1, -11 },
  { 390, 9, 10, 10, 1, -13 },
  { 402, 8, 16, 8, 0, -16 },
  { 418, 14, 18, 16, 1, -16 },
  { 450, 12, 16, 12, 0, -16 },
  { 474, 10, 16, 12, 1, -16 },
  { 494, 9, 16, 11, 1, -16 },
  { 512, 10, 16, 12, 1, -16 },
  { 532, 7, 16, 10, 2, -16 },
  { 546, 6, 16, 10, 2, -16 },
  { 558, 10, 16, 12, 1, -16 },
  { 578, 9, 16, 13, 2, -16 },
  { 596, 5, 16, 7, 1, -16 },
  { 606, 5, 21, 6, -1, -16 },
  { 620, 9, 16, 11, 2, -16 },
  { 638, 8, 16, 9, 1, -16 },
  { 654, 13, 16, 17, 2, -16 },
  { 680, 10, 16, 14, 2, -16 },
  { 700, 11, 16, 13, 1, -16 },
  { 722, 9, 16, 11, 1, -16 },
  { 740, 11, 20, 13, 1, -16 },
  { 768, 10, 16, 11, 1, -16 },
  { 788, 8, 16, 9, 1, -16 },
  { 804, 9, 16, 9, 0, -16 },
  { 822, 10, 16, 13, 1, -16 },
  { 842, 11, 16, 11, 0, -16 },
  { 864, 17, 16, 16, 0, -16 },
  { 898, 10, 16, 10, 0, -16 },
  { 918, 10, 16, 10, 0, -16 },
  { 938, 9, 16, 9, 0, -16 },
  { 956, 5, 20, 7, 1, -16 },
  { 969, 9, 16, 9, 0, -16 },
  { 987, 5, 20, 7, 1, -16 },
  { 1000, 11, 10, 12, 0, -16 },
  { 1014, 9, 1, 9, 0, 2 },
  { 1016, 5, 4, 7, 1, -17 },
  { 1019, 8, 12, 10, 1, -12 },
  { 1031, 9, 17, 11, 1, -17 },
  { 1051, 7, 12, 9, 1, -12 },
  { 1062, 9, 17, 11, 1, -17 },
  { 1082, 8, 12, 10, 1, -12 },
  { 1094, 7, 17, 7, 0, -17 },
  { 1109, 9, 17, 11, 1, -12 },
  { 1129, 9, 17, 11, 1, -17 },
  { 1149, 3, 17, 5, 1, -17 },
  { 1156, 5, 22, 5, -1, -17 },
  { 1170, 10, 17, 11, 1, -17 },
  { 1192, 3, 17, 5, 1, -17 },
  { 1199, 14, 12, 16, 1, -12 },
  { 1220, 9, 12, 11, 1, -12 },
  { 1234, 9, 12, 11, 1, -12 },
  { 1248, 9, 17, 11, 1, -12 },
  { 1268, 9, 17, 11, 1, -12 },
  { 1288, 6, 12, 8, 1, -12 },
  { 1297, 7, 12, 8, 1, -12 },
  { 1308, 7, 15, 7, 0, -15 },
  { 1322, 9, 12, 11, 1, -12 },
  { 1336, 10, 12, 10, 0, -12 },
  { 1351, 15, 12, 15, 0, -12 },
  { 1374, 9, 12, 9, 0, -12 },
  { 1388, 10, 17, 10, 0, -12 },
  { 1410, 8, 12, 8, 0, -12 },
  { 1422, 7, 20, 8, 0, -16 },
  { 1440, 2, 22, 10, 4, -17 },
  { 1446, 6, 20, 8, 1, -16 },
  { 1461, 9, 4, 10, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Bold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD22PT7B_H_
