#ifndef _NOTOSANS_EXTRACONDENSED_BOLD42PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0xEF, 0xDF, 0xBF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE0, 0x00, 0x00, 0x00, 0x7D, 0xFB,
  0xFF, 0xFF, 0xCF, 0x80, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xEF,
  0xC7, 0xDF, 0x8F, 0xBF, 0x1F, 0x7C, 0x3E, 0x78, 0x7C, 0xF0, 0xF9, 0xE1,
  0xF0, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C,
  0x70, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x79, 0xE0, 0x1E, 0x3C, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x87, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0xF0, 0x1F, 0xFE, 0x3F,
  0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFD, 0x8C, 0xF9, 0x80, 0xF9, 0x80, 0xF9,
  0x80, 0xFD, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07,
  0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xBE, 0x01, 0xBF, 0x01, 0x9F, 0x81,
  0x9F, 0xC1, 0xBE, 0xF9, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F,
  0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x80, 0x1E,
  0x00, 0xFF, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xC0, 0x1F, 0xF8, 0x1F, 0x00,
  0x79, 0xF0, 0x78, 0x01, 0xE3, 0xC1, 0xE0, 0x0F, 0x8F, 0x0F, 0x80, 0x3E,
  0x3C, 0x3C, 0x00, 0xF8, 0xF0, 0xF0, 0x03, 0xE3, 0xC7, 0x80, 0x0F, 0x8F,
  0x1E, 0x00, 0x3E, 0x3C, 0xF8, 0x00, 0x78, 0xF3, 0xC7, 0xE1, 0xE7, 0xCF,
  0x3F, 0xC7, 0xFE, 0x79, 0xFF, 0x8F, 0xF9, 0xE7, 0xFE, 0x3F, 0xCF, 0x9E,
  0x7C, 0x7E, 0x3C, 0xF8, 0xF0, 0x00, 0xF3, 0xE3, 0xC0, 0x07, 0xCF, 0x8F,
  0x00, 0x1E, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0xF0, 0x03, 0xC3, 0xE3, 0xC0,
  0x0F, 0x0F, 0x8F, 0x00, 0x7C, 0x3E, 0x3C, 0x01, 0xE0, 0x79, 0xF0, 0x07,
  0x81, 0xFF, 0x80, 0x3C, 0x03, 0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0,
  0x3E, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xF7, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xCF, 0xFC, 0x3E, 0x7F, 0xF8,
  0xF9, 0xFF, 0xE7, 0xEF, 0xCF, 0xDF, 0xBF, 0x1F, 0xFC, 0xFC, 0x3F, 0xF3,
  0xF0, 0xFF, 0xCF, 0xC1, 0xFE, 0x3F, 0x03, 0xF0, 0xFE, 0x0F, 0xC3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFD, 0xF8, 0x3F, 0xC3,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x79, 0xE7, 0x80, 0x03, 0xE0,
  0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x3E, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0xF8, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E,
  0x0F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF0, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x06, 0x3C, 0x33, 0xDE,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xF0, 0x03, 0xFC, 0x01,
  0xFF, 0x01, 0xF7, 0xC1, 0xF3, 0xF1, 0xF8, 0xF8, 0x38, 0x70, 0x04, 0x10,
  0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x3E, 0x3E, 0x3E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xF1, 0xF9,
  0xF8, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0xDF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xEF, 0x83, 0xF7, 0xC1, 0xFB, 0xE0, 0xF9, 0xF0, 0x7C,
  0xFC, 0x3E, 0x7E, 0x3F, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F,
  0xFC, 0xFF, 0xEF, 0xFF, 0xFD, 0xFB, 0xCF, 0xCC, 0x7E, 0x23, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xC1, 0xF8, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F, 0xFE,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xEF, 0xF1, 0x81, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0xFF, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x3F, 0x7E, 0xFF, 0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0E, 0xF8, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0xF7,
  0xE0, 0x3D, 0xF8, 0x1E, 0x7E, 0x07, 0x9F, 0x83, 0xC7, 0xE0, 0xF1, 0xF8,
  0x78, 0x7E, 0x1E, 0x1F, 0x8F, 0x87, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0xC0, 0x7E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0x31, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0C, 0x0F, 0xBF, 0x8F, 0xFF, 0xE7,
  0xDF, 0xFB, 0xFF, 0xFD, 0xFE, 0x7E, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x81, 0xFF, 0xC0, 0xFB, 0xE0, 0xFD, 0xF0, 0x7E, 0xFC, 0x3F, 0x7E,
  0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xE7, 0xE3, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3F,
  0x0F, 0x8F, 0x8F, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0,
  0x3F, 0xF8, 0x3F, 0xFE, 0x1F, 0xBF, 0x9F, 0x8F, 0xCF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xBF, 0x1F, 0xDF,
  0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xE3, 0xF1, 0xFB, 0xF0, 0x7D, 0xF8,
  0x3E, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFD, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xEF, 0x9F, 0xF7, 0xC7, 0xF3,
  0xE0, 0x63, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x10, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x00,
  0x7C, 0xFB, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x00, 0x3E, 0x3E, 0x7F,
  0x7F, 0x3F, 0x3E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C,
  0xF8, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x38, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xF3, 0xFF,
  0xF3, 0xFF, 0xE7, 0xFF, 0xE4, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1E,
  0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x30, 0x3C, 0x7C, 0x3F, 0xE3, 0xCF, 0x0F,
  0xFC, 0x79, 0xE3, 0xFF, 0x8F, 0x78, 0x78, 0xF1, 0xEF, 0x1F, 0x1E, 0x1F,
  0xE3, 0xC3, 0xC3, 0xFC, 0x78, 0x78, 0x7F, 0x8F, 0x0F, 0x0F, 0xF1, 0xE1,
  0xE1, 0xFE, 0x3C, 0x3C, 0x3B, 0xC7, 0x87, 0x8F, 0x78, 0xF1, 0xF1, 0xEF,
  0x1E, 0x3E, 0x3D, 0xE3, 0xE7, 0xEF, 0x3C, 0x3F, 0xDF, 0xE7, 0xC7, 0xF3,
  0xF8, 0x78, 0x3C, 0x3E, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x80, 0x3F, 0x80, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xC0, 0x7C, 0x7E, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0x9F, 0x80,
  0x7E, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xDF, 0x07, 0xEF, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF, 0x7C, 0x1F, 0xFE, 0x07, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0x80, 0x03,
  0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xF3, 0xFF, 0xF1, 0xFC, 0x19,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x81, 0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF,
  0xF0, 0x1F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF1, 0xF0, 0xFF, 0x3E, 0x07, 0xE7, 0xC0, 0xFE, 0xF8, 0x0F,
  0xDF, 0x01, 0xFB, 0xE0, 0x3F, 0x7C, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F,
  0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x07, 0xE7, 0xC1, 0xFC,
  0xF8, 0x7F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0x01, 0x9F, 0xC0, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB,
  0xF0, 0x3F, 0x3F, 0x07, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF3, 0xF8,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x07, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0xD3, 0xFB, 0xFF, 0x7F,
  0xCF, 0xF9, 0xFE, 0x3F, 0x00, 0xFC, 0x0F, 0xFF, 0x81, 0xFB, 0xF0, 0x7E,
  0x7E, 0x0F, 0xCF, 0xC3, 0xF1, 0xF8, 0xFE, 0x3F, 0x1F, 0x87, 0xE7, 0xF0,
  0xFC, 0xFC, 0x1F, 0xBF, 0x83, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0x03,
  0xFB, 0xF0, 0x7E, 0x7E, 0x0F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0xC7,
  0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x07, 0xEF,
  0xC0, 0xFD, 0xF8, 0x1F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x78, 0x1F, 0xFF, 0xEF, 0x03, 0xDF, 0xFD, 0xF0, 0x7B, 0xFF, 0xBE,
  0x1F, 0x7F, 0xF3, 0xC3, 0xEF, 0xFE, 0x78, 0x79, 0xFF, 0xCF, 0x9F, 0x3F,
  0xF9, 0xF3, 0xE7, 0xFF, 0x1E, 0x78, 0xFF, 0xE3, 0xCF, 0x1F, 0xFC, 0x7F,
  0xE3, 0xFF, 0x8F, 0xFC, 0x7F, 0xF0, 0xFF, 0x0F, 0xFE, 0x1F, 0xE1, 0xFF,
  0xC3, 0xFC, 0x3F, 0xF8, 0x7F, 0x87, 0xFF, 0x07, 0xE0, 0xFF, 0xE0, 0xFC,
  0x1F, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xE0, 0x7F, 0xF0, 0x3C, 0x0F, 0xC0,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0xFE, 0xF8, 0x7F, 0xF7, 0xC3, 0xFF, 0x9F, 0x1F, 0xFC, 0xF8,
  0xFF, 0xE7, 0xE7, 0xFF, 0x1F, 0x3F, 0xF8, 0xFD, 0xFF, 0xC3, 0xEF, 0xFE,
  0x1F, 0x7F, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF1, 0xF8,
  0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7F, 0x07,
  0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFE, 0x3F, 0x83, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x01, 0xF9,
  0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x07, 0xE1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF8, 0xFF, 0xFF, 0x3E, 0x1F, 0xCF, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x1F,
  0xBE, 0x07, 0xEF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x3F, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x9F, 0x83, 0xE3,
  0xF0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xE1, 0xF8, 0xF8, 0x3F,
  0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0xFE, 0x03, 0xF0,
  0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x0C,
  0x7C, 0x04, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0xC0, 0x3E,
  0xF0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0xF8,
  0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xC1,
  0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0xBE,
  0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0xBE, 0x01, 0xF0, 0x0F, 0xDF,
  0x80, 0xFC, 0x07, 0xCF, 0xC0, 0x7E, 0x07, 0xE7, 0xE0, 0x7F, 0x03, 0xF1,
  0xF0, 0x3F, 0x81, 0xF8, 0xF8, 0x1F, 0xC0, 0xFC, 0x7C, 0x0F, 0xF0, 0x7C,
  0x3F, 0x07, 0xF8, 0x3E, 0x1F, 0x87, 0xFC, 0x3F, 0x07, 0xC3, 0xDE, 0x1F,
  0x83, 0xE1, 0xEF, 0x0F, 0xC1, 0xF0, 0xF7, 0xC7, 0xC0, 0xFC, 0x7B, 0xE3,
  0xE0, 0x7E, 0x7D, 0xF3, 0xF0, 0x1F, 0x3E, 0x79, 0xF8, 0x0F, 0x9F, 0x3C,
  0xFC, 0x07, 0xCF, 0x1E, 0x7C, 0x03, 0xEF, 0x8F, 0xBE, 0x01, 0xF7, 0xC7,
  0xDF, 0x00, 0x7F, 0xE1, 0xEF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0,
  0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xE7, 0xE0, 0x7E,
  0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x9F,
  0x00, 0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00,
  0xF9, 0xF0, 0x1F, 0x9F, 0x81, 0xF9, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0xFC,
  0x3E, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03,
  0xF7, 0xC0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x9F, 0x80, 0xF9, 0xF0, 0x0F,
  0x9F, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xDF, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x07, 0x83,
  0xE0, 0x7C, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1,
  0xF0, 0x7C, 0x1E, 0x0F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFE, 0x1C,
  0x3F, 0x10, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7F, 0x9F, 0x7E, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0x7F, 0xFF, 0x7F, 0xFF, 0x3F, 0xCF, 0x1F,
  0x8F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x7E, 0x3F, 0x7F,
  0x9F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFB, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE7,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xE7, 0xF9, 0xF1, 0xF8, 0x0F, 0xF8, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFE, 0x7F, 0x3B, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xFC, 0x03, 0xF0, 0x17, 0xF3, 0x9F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x8F, 0xCF, 0xCF,
  0xF7, 0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF,
  0xCF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0x3E, 0x3F, 0x1F, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFC, 0x7C, 0x7E, 0xFC, 0x3E, 0xF8, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x02, 0x7E, 0x0E,
  0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xF8, 0x1F, 0xF0,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFF, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC1, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x8F, 0x9F, 0xE7, 0xDF, 0xFB, 0xEF, 0xFF,
  0xF7, 0xE7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xEF, 0xFF, 0xF7, 0xFF,
  0xF9, 0xFE, 0xFC, 0x7E, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC8, 0x07, 0xE7, 0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0,
  0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x7E,
  0x3F, 0x7F, 0x9F, 0x7F, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xF8, 0x7F, 0xF8,
  0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0x7B,
  0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x7E, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0xEF, 0x83, 0xF3,
  0xE0, 0xFC, 0xF8, 0x7E, 0x3E, 0x3F, 0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0xF9,
  0xF0, 0x3E, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0xF3, 0xE0, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x81, 0xFB, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x3F, 0x1F, 0x7F, 0xCF, 0xFB, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x0F, 0xFF, 0x07, 0xE1, 0xFF, 0xE0,
  0xFC, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xE0, 0x7F, 0xF0, 0x7C, 0x0F,
  0xFE, 0x0F, 0x81, 0xFF, 0xC1, 0xF0, 0x3F, 0xF8, 0x3E, 0x07, 0xFF, 0x07,
  0xC0, 0xFF, 0xE0, 0xF8, 0x1F, 0xFC, 0x1F, 0x03, 0xFF, 0x83, 0xE0, 0x7F,
  0xF0, 0x7C, 0x0F, 0xFE, 0x0F, 0x81, 0xFF, 0xC1, 0xF0, 0x3F, 0xF8, 0x3E,
  0x07, 0xFF, 0x07, 0xC0, 0xF8, 0xF8, 0xFC, 0x7D, 0xFF, 0x3E, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7E, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x0F, 0xFF, 0xC7, 0xE7, 0xF7, 0xE1, 0xFB, 0xF0, 0x7D, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x7E, 0x1F, 0x9F, 0x9F, 0xCF, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xC0, 0xF8, 0xFC, 0x7C, 0xFF, 0x3E,
  0xFF, 0xDF, 0xFF, 0xEF, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xCF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xEF, 0xF3, 0xF3, 0xF1, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0x9F, 0xE7, 0xDF, 0xFB,
  0xEF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0xE0, 0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0xEF, 0xFF,
  0xF7, 0xFF, 0xF9, 0xFE, 0xFC, 0x7E, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0xFF, 0x9F, 0xFB, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xFC,
  0x33, 0xF0, 0x4F, 0xC0, 0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x03, 0xFF,
  0x1F, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xC7, 0xFC, 0x00, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF3,
  0x1F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F, 0xDF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFE, 0xF9, 0xFF, 0x7C, 0x7F, 0x3E, 0xFC, 0x07, 0xEF, 0x80,
  0xF9, 0xF0, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87,
  0xE1, 0xF0, 0xFC, 0x3F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x81, 0xF7, 0xC1, 0xFC, 0x1F, 0x7C, 0x1F,
  0xC3, 0xF7, 0xC1, 0xFC, 0x3F, 0x7E, 0x3F, 0xC3, 0xE7, 0xE3, 0xFC, 0x3E,
  0x3E, 0x3D, 0xC3, 0xE3, 0xE3, 0xDE, 0x7E, 0x3E, 0x39, 0xE7, 0xC3, 0xF7,
  0x9E, 0x7C, 0x1F, 0x79, 0xE7, 0xC1, 0xF7, 0x8E, 0x7C, 0x1F, 0x78, 0xEF,
  0xC1, 0xF7, 0x8F, 0xF8, 0x1F, 0x70, 0xFF, 0x80, 0xF7, 0x0F, 0xF8, 0x0F,
  0x70, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF0, 0xFC, 0xFC, 0x3F, 0x3E, 0x07,
  0xDF, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0x7E, 0x07, 0xCF, 0x83, 0xF3, 0xF0, 0xF8, 0xFC, 0x7E, 0x1F, 0x1F,
  0x07, 0xEF, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x3F, 0x3F,
  0x07, 0xE7, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE1, 0xF8, 0xFC, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0xDF, 0x00, 0xFB, 0xE0, 0x1F,
  0x7C, 0x03, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3F, 0x01, 0xF8, 0xFF, 0x87, 0xF8, 0x3F, 0x01, 0xFF, 0x0F, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x07, 0xF0,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0x03, 0xF0, 0xFF, 0x1F,
  0xF1, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xE0,
  0x00, 0x3F, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC,
  0x07, 0xFA, 0x00, 0x30,
};

const GFXglyph NotoSans_ExtraCondensed_Bold42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 30, 11, 2, -30 },
  { 28, 15, 11, 19, 2, -30 },
  { 49, 19, 30, 21, 1, -30 },
  { 121, 16, 34, 20, 2, -32 },
  { 189, 30, 30, 32, 1, -30 },
  { 302, 22, 30, 23, 1, -30 },
  { 385, 6, 11, 10, 2, -30 },
  { 394, 11, 37, 13, 2, -30 },
  { 445, 10, 37, 13, 1, -30 },
  { 492, 17, 17, 19, 1, -32 },
  { 529, 17, 20, 19, 1, -25 },
  { 572, 8, 10, 10, 1, -5 },
  { 582, 11, 5, 13, 1, -14 },
  { 589, 7, 6, 11, 2, -6 },
  { 595, 17, 30, 17, 0, -30 },
  { 659, 17, 30, 19, 1, -30 },
  { 723, 13, 30, 19, 2, -30 },
  { 772, 17, 30, 19, 1, -30 },
  { 836, 17, 30, 19, 1, -30 },
  { 900, 18, 30, 19, 1, -30 },
  { 968, 16, 30, 19, 2, -30 },
  { 1028, 17, 30, 19, 1, -30 },
  { 1092, 17, 30, 19, 1, -30 },
  { 1156, 17, 30, 19, 1, -30 },
  { 1220, 17, 30, 19, 1, -30 },
  { 1284, 7, 23, 11, 2, -23 },
  { 1305, 8, 28, 11, 1, -23 },
  { 1333, 17, 20, 19, 1, -25 },
  { 1376, 17, 13, 19, 1, -21 },
  { 1404, 17, 20, 19, 1, -25 },
  { 1447, 15, 30, 16, 0, -30 },
  { 1504, 27, 33, 30, 2, -30 },
  { 1616, 22, 30, 22, 0, -30 },
  { 1699, 17, 30, 22, 3, -30 },
  { 1763, 17, 30, 20, 2, -30 },
  { 1827, 19, 30, 23, 3, -30 },
  { 1899, 13, 30, 18, 3, -30 },
  { 1948, 13, 30, 18, 3, -30 },
  { 1997, 19, 30, 24, 2, -30 },
  { 2069, 19, 30, 25, 3, -30 },
  { 2141, 11, 30, 13, 1, -30 },
  { 2183, 11, 39, 12, -2, -30 },
  { 2237, 19, 30, 22, 3, -30 },
  { 2309, 13, 30, 17, 3, -30 },
  { 2358, 27, 30, 32, 3, -30 },
  { 2460, 21, 30, 26, 3, -30 },
  { 2539, 21, 30, 25, 2, -30 },
  { 2618, 16, 30, 21, 3, -30 },
  { 2678, 21, 37, 25, 2, -30 },
  { 2776, 18, 30, 22, 3, -30 },
  { 2844, 16, 30, 18, 1, -30 },
  { 2904, 16, 30, 18, 1, -30 },
  { 2964, 18, 30, 24, 3, -30 },
  { 3032, 21, 30, 21, 0, -30 },
  { 3111, 33, 30, 31, -1, -30 },
  { 3235, 20, 30, 20, 0, -30 },
  { 3310, 20, 30, 20, 0, -30 },
  { 3385, 16, 30, 17, 1, -30 },
  { 3445, 10, 37, 13, 2, -30 },
  { 3492, 17, 30, 17, 0, -30 },
  { 3556, 10, 37, 13, 1, -30 },
  { 3603, 20, 18, 22, 1, -30 },
  { 3648, 17, 3, 17, 0, 4 },
  { 3655, 9, 7, 13, 2, -32 },
  { 3663, 16, 23, 19, 1, -23 },
  { 3709, 17, 32, 21, 2, -32 },
  { 3777, 14, 23, 17, 2, -23 },
  { 3818, 17, 32, 21, 2, -32 },
  { 3886, 16, 23, 19, 2, -23 },
  { 3932, 14, 32, 13, 0, -32 },
  { 3988, 17, 33, 21, 2, -23 },
  { 4059, 17, 32, 21, 2, -32 },
  { 4127, 6, 32, 10, 2, -32 },
  { 4151, 9, 42, 10, -1, -32 },
  { 4199, 18, 32, 20, 3, -32 },
  { 4271, 6, 32, 10, 2, -32 },
  { 4295, 27, 23, 31, 2, -23 },
  { 4373, 17, 23, 21, 2, -23 },
  { 4422, 17, 23, 21, 2, -23 },
  { 4471, 17, 33, 21, 2, -23 },
  { 4542, 17, 33, 21, 2, -23 },
  { 4613, 12, 23, 15, 2, -23 },
  { 4648, 14, 23, 16, 1, -23 },
  { 4689, 13, 28, 14, 0, -28 },
  { 4735, 17, 23, 21, 2, -23 },
  { 4784, 19, 23, 19, 0, -23 },
  { 4839, 28, 23, 29, 0, -23 },
  { 4920, 18, 23, 18, 0, -23 },
  { 4972, 19, 33, 19, 0, -23 },
  { 5051, 13, 23, 15, 1, -23 },
  { 5089, 13, 37, 15, 0, -30 },
  { 5150, 5, 42, 18, 7, -32 },
  { 5177, 12, 37, 15, 2, -30 },
  { 5233, 17, 7, 19, 1, -18 },
};

const GFXfont NotoSans_ExtraCondensed_Bold42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold42pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD42PT7B_H_
