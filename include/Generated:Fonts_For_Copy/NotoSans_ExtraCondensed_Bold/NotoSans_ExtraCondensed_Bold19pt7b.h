#ifndef _NOTOSANS_EXTRACONDENSED_BOLD19PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0xEF, 0xDB, 0x36, 0x6C, 0xC0,
  0x1B, 0x0D, 0x86, 0xC3, 0x67, 0xFB, 0xFC, 0xC8, 0x6C, 0xFF, 0xFF, 0xCD,
  0x86, 0xC2, 0x63, 0x60, 0x10, 0xFB, 0xFE, 0x9D, 0x1E, 0x1E, 0x1E, 0x1E,
  0x2E, 0x5F, 0xFF, 0x82, 0x04, 0x00, 0x60, 0xC7, 0x84, 0x36, 0x61, 0xB3,
  0x0D, 0xB0, 0x6D, 0x83, 0x6D, 0xDE, 0xDB, 0x66, 0xD8, 0x66, 0xC3, 0x36,
  0x19, 0xB1, 0x8F, 0x8C, 0x38, 0x1C, 0x07, 0xC1, 0xDC, 0x3B, 0x87, 0x60,
  0x7C, 0x0F, 0x03, 0xE6, 0x6F, 0xDC, 0xFB, 0x9E, 0x31, 0xC7, 0xF8, 0x7F,
  0xC0, 0xFF, 0x6C, 0x19, 0x9C, 0xC6, 0x73, 0x18, 0xC6, 0x31, 0x8E, 0x31,
  0x86, 0x38, 0xC3, 0x1C, 0x63, 0x1C, 0x63, 0x18, 0xC6, 0x33, 0x98, 0xCC,
  0xE0, 0x18, 0x59, 0x7F, 0xFF, 0x3C, 0x76, 0x26, 0x30, 0x60, 0xC7, 0xFF,
  0xE6, 0x0C, 0x18, 0x30, 0xFF, 0x60, 0xFF, 0xFF, 0x80, 0x07, 0x06, 0x06,
  0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xE0, 0x38,
  0xFB, 0xF6, 0x7C, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x3F, 0x77, 0xCF, 0x00,
  0x0C, 0x73, 0xDF, 0xDD, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x39,
  0xFB, 0xFC, 0x70, 0xE1, 0xC3, 0x0E, 0x38, 0x61, 0x87, 0x0F, 0xFF, 0xC0,
  0x79, 0xFB, 0x78, 0x70, 0xE1, 0x9E, 0x3E, 0x0E, 0x1C, 0x3C, 0x7F, 0xDF,
  0x00, 0x06, 0x07, 0x03, 0x83, 0xC1, 0x61, 0xB0, 0xD8, 0xCC, 0x66, 0x7F,
  0xFF, 0xE0, 0xC0, 0x60, 0x30, 0xFD, 0xFB, 0xF7, 0x0C, 0x1F, 0x3F, 0x7F,
  0x0E, 0x1C, 0x3C, 0x7F, 0xDF, 0x00, 0x1C, 0xF9, 0xCF, 0x0C, 0x1B, 0xBF,
  0xF7, 0xC7, 0x8F, 0x1F, 0x77, 0xCF, 0x80, 0xFF, 0xFF, 0xFF, 0x07, 0x06,
  0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x38, 0x38, 0x30, 0x38, 0xFB, 0xBE,
  0x3C, 0xFD, 0x9E, 0x3E, 0xEF, 0x8F, 0x1E, 0x3F, 0xEF, 0x80, 0x18, 0x3E,
  0x7E, 0x67, 0xE3, 0x63, 0x67, 0x7F, 0x3B, 0x03, 0x07, 0x0E, 0x7E, 0x7C,
  0x5F, 0xA0, 0x00, 0xFF, 0x80, 0x5F, 0xA0, 0x00, 0x1F, 0xEC, 0x01, 0x07,
  0x1E, 0x78, 0xF0, 0x3C, 0x0F, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x81, 0xC1, 0xE0, 0xF0, 0xE7, 0xBC, 0x60, 0x80, 0x39, 0xF9, 0xF8,
  0x70, 0xE1, 0x87, 0x1C, 0x30, 0x60, 0x01, 0x83, 0x06, 0x00, 0x0F, 0x03,
  0xFC, 0x30, 0xE6, 0x06, 0xCF, 0xBC, 0xDB, 0xD9, 0xBD, 0x9B, 0xD9, 0xBD,
  0xB3, 0xDF, 0xEC, 0xCC, 0x60, 0x07, 0x08, 0x3F, 0x80, 0x40, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3F, 0x0D, 0xC3, 0x30, 0xCC, 0x7F, 0x9F, 0xE7, 0xF9,
  0x86, 0xE1, 0xF8, 0x70, 0xF8, 0xFE, 0xFF, 0xE7, 0xE7, 0xE7, 0xFE, 0xFE,
  0xE7, 0xE3, 0xE3, 0xE7, 0xFF, 0xFC, 0x1C, 0x3F, 0x7E, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x71, 0x7E, 0x3E, 0xF8, 0x7F, 0x3F, 0xDC,
  0xEE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xDD, 0xEF, 0xE7, 0xE0,
  0xFF, 0xFF, 0xF8, 0xE3, 0x8F, 0xFF, 0xE3, 0x8E, 0x38, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xE3, 0x8F, 0xFF, 0xFF, 0x8E, 0x38, 0xE3, 0x80, 0x0E, 0x1F,
  0xDE, 0xCE, 0x0E, 0x07, 0x03, 0xBF, 0xDF, 0xEF, 0xF1, 0xF8, 0xEE, 0x77,
  0xF9, 0xF8, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0xFF, 0xFF, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1C, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x7B, 0xF0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xF7, 0xF7, 0x00, 0xE3, 0xF3, 0xB9, 0xDD, 0xCE, 0xE7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x77, 0x39, 0x9C, 0xEE, 0x77, 0x1C, 0xE3, 0x8E, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xF0, 0xF0, 0x7F, 0x07, 0xF0,
  0xFF, 0x8F, 0xF8, 0xFF, 0x9B, 0xF9, 0xBE, 0xDB, 0xED, 0xBE, 0xF3, 0xEF,
  0x3E, 0x73, 0xE7, 0x3E, 0x63, 0xE1, 0xFC, 0x7F, 0x1F, 0xE7, 0xF9, 0xFE,
  0x7F, 0xDF, 0xB7, 0xEF, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xF0, 0x1C,
  0x3F, 0x9D, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xEE,
  0x77, 0xF1, 0xF0, 0xF8, 0xFE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xFC,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1C, 0x3F, 0x9D, 0xFC, 0x7E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xEE, 0x77, 0xF1, 0xF0, 0x1C, 0x0E, 0x03,
  0x80, 0xF0, 0x7F, 0x3F, 0x9C, 0xEE, 0x77, 0x3B, 0xB9, 0xFC, 0xFC, 0x77,
  0x3B, 0x9C, 0xEE, 0x77, 0x1C, 0x3B, 0xFF, 0xF0, 0xC3, 0x8F, 0x1E, 0x1C,
  0x30, 0xE7, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x67, 0xF1, 0xF0, 0xC1, 0xF8,
  0x66, 0x19, 0x8E, 0x63, 0x9C, 0xC3, 0x30, 0xCC, 0x37, 0x0D, 0x83, 0xE0,
  0x78, 0x1E, 0x07, 0x00, 0xC3, 0x0F, 0x0C, 0x3E, 0x39, 0xF9, 0xE7, 0x67,
  0x9D, 0x9E, 0x66, 0x79, 0x9D, 0xB6, 0x7C, 0xF8, 0xF3, 0xE3, 0xCF, 0x0F,
  0x3C, 0x3C, 0x70, 0xE1, 0xC0, 0xE3, 0xB1, 0x9D, 0xC6, 0xC3, 0x61, 0xF0,
  0x70, 0x38, 0x3E, 0x1B, 0x0D, 0x8E, 0xE6, 0x37, 0x1C, 0xE3, 0xF1, 0xD8,
  0xCE, 0xE3, 0x61, 0xB0, 0xF8, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xFE, 0xFE, 0xFE, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x70,
  0x60, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0,
  0xC0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x18, 0x0C, 0x0C, 0x0E,
  0x06, 0x07, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F,
  0xF8, 0x0C, 0x03, 0x01, 0xE0, 0x78, 0x3F, 0x0C, 0xC7, 0x39, 0x86, 0xE1,
  0xC0, 0xFF, 0xEE, 0x70, 0x11, 0xF9, 0x38, 0x70, 0xFF, 0xFB, 0xE7, 0xCF,
  0xFF, 0xD8, 0xE0, 0xE0, 0xE0, 0xE8, 0xDE, 0xFE, 0xE7, 0xE7, 0xE7, 0xE7,
  0xE7, 0xE7, 0xFE, 0xDC, 0x19, 0xFF, 0xF8, 0xC3, 0x0C, 0x30, 0xE7, 0xF7,
  0xC0, 0x06, 0x0C, 0x19, 0x37, 0xFF, 0xF1, 0xE3, 0xC7, 0x8F, 0x1F, 0x3F,
  0xEE, 0xC0, 0x10, 0xFB, 0xBE, 0x3C, 0x7F, 0xFF, 0xE0, 0xE3, 0xFD, 0xF8,
  0x08, 0xF7, 0xDC, 0x73, 0xFF, 0xDC, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x00,
  0x20, 0xFF, 0xFE, 0x3C, 0x78, 0xF1, 0xE3, 0xE7, 0xFD, 0xD8, 0x30, 0x7F,
  0xFF, 0x18, 0xE1, 0xC3, 0x87, 0x4D, 0xFF, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xC0, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x39, 0xC0, 0x03,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xF7, 0x90, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE7, 0xEE, 0xEC, 0xF8, 0xF8, 0xFC, 0xEC, 0xEE, 0xE6, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x4D, 0xFF, 0xFF, 0xFE, 0x73, 0xE6,
  0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x3E, 0x63, 0xE6, 0x30, 0x09, 0xBF,
  0xFF, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x98, 0x10, 0x7C, 0xFE, 0xC6,
  0xC7, 0xC7, 0xC7, 0xC6, 0xE6, 0x7E, 0x7C, 0x08, 0xDE, 0xFE, 0xE7, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xFC, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x20,
  0xFF, 0xFE, 0x3C, 0x78, 0xF1, 0xE3, 0xE7, 0xFD, 0xD8, 0x30, 0x60, 0xC1,
  0x83, 0x0E, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x33, 0xED, 0xB0, 0xE3,
  0xE3, 0x87, 0x9F, 0xEF, 0x80, 0x30, 0xC7, 0x3F, 0xFD, 0xC7, 0x1C, 0x71,
  0xC7, 0x1F, 0x3C, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xFE, 0xFC,
  0xE3, 0x67, 0x67, 0x66, 0x76, 0x36, 0x3C, 0x3C, 0x3C, 0x1C, 0xE7, 0x3B,
  0x39, 0x99, 0x4C, 0xDB, 0x67, 0xDF, 0x3E, 0xF0, 0xF7, 0x87, 0x3C, 0x38,
  0xE1, 0xC7, 0x00, 0xE7, 0x76, 0x7E, 0x3C, 0x3C, 0x3C, 0x3C, 0x7E, 0x66,
  0xE7, 0xE3, 0x67, 0x67, 0x76, 0x76, 0x3E, 0x3E, 0x3C, 0x1C, 0x1C, 0x18,
  0x18, 0x78, 0x70, 0x60, 0x7C, 0xF8, 0x70, 0xC3, 0x86, 0x1C, 0x30, 0xFF,
  0xFC, 0x0C, 0xF3, 0x8E, 0x38, 0xE3, 0x8C, 0xE3, 0xC3, 0x0E, 0x38, 0xE3,
  0x8F, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x87, 0x38, 0xC6, 0x31, 0x8E,
  0x3B, 0xDC, 0xC6, 0x31, 0x9C, 0xE0, 0x79, 0xFF, 0x87,
};

const GFXglyph NotoSans_ExtraCondensed_Bold19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 7, 5, 8, 1, -14 },
  { 12, 9, 14, 10, 0, -14 },
  { 28, 7, 15, 9, 1, -14 },
  { 42, 13, 14, 15, 1, -14 },
  { 65, 11, 14, 11, 0, -14 },
  { 85, 3, 5, 4, 1, -14 },
  { 87, 5, 17, 6, 1, -14 },
  { 98, 5, 17, 6, 0, -14 },
  { 109, 8, 7, 8, 0, -14 },
  { 116, 7, 9, 9, 1, -11 },
  { 124, 3, 4, 5, 1, -2 },
  { 126, 4, 2, 6, 1, -6 },
  { 127, 3, 3, 5, 1, -3 },
  { 129, 8, 14, 8, 0, -14 },
  { 143, 7, 14, 9, 1, -14 },
  { 156, 6, 14, 9, 1, -14 },
  { 167, 7, 14, 9, 1, -14 },
  { 180, 7, 14, 9, 1, -14 },
  { 193, 9, 14, 9, 0, -14 },
  { 209, 7, 14, 9, 1, -14 },
  { 222, 7, 14, 9, 1, -14 },
  { 235, 8, 14, 9, 0, -14 },
  { 249, 7, 14, 9, 1, -14 },
  { 262, 8, 14, 9, 0, -14 },
  { 276, 3, 11, 5, 1, -11 },
  { 281, 3, 13, 5, 1, -11 },
  { 286, 8, 9, 9, 0, -11 },
  { 295, 8, 6, 9, 0, -10 },
  { 301, 7, 9, 9, 1, -11 },
  { 309, 7, 14, 7, 0, -14 },
  { 322, 12, 16, 14, 1, -14 },
  { 346, 10, 14, 10, 0, -14 },
  { 364, 8, 14, 10, 1, -14 },
  { 378, 8, 14, 9, 1, -14 },
  { 392, 9, 14, 11, 1, -14 },
  { 408, 6, 14, 8, 1, -14 },
  { 419, 6, 14, 8, 1, -14 },
  { 430, 9, 14, 11, 1, -14 },
  { 446, 9, 14, 11, 1, -14 },
  { 462, 6, 14, 6, 0, -14 },
  { 473, 5, 18, 5, -1, -14 },
  { 485, 9, 14, 10, 1, -14 },
  { 501, 6, 14, 8, 1, -14 },
  { 512, 12, 14, 15, 1, -14 },
  { 533, 10, 14, 12, 1, -14 },
  { 551, 9, 14, 11, 1, -14 },
  { 567, 8, 14, 9, 1, -14 },
  { 581, 9, 17, 11, 1, -14 },
  { 601, 9, 14, 10, 1, -14 },
  { 617, 6, 14, 8, 1, -14 },
  { 628, 8, 14, 8, 0, -14 },
  { 642, 9, 14, 11, 1, -14 },
  { 658, 10, 14, 10, 0, -14 },
  { 676, 14, 14, 14, 0, -14 },
  { 701, 9, 14, 9, 0, -14 },
  { 717, 9, 14, 9, 0, -14 },
  { 733, 8, 14, 8, 0, -14 },
  { 747, 4, 17, 6, 1, -14 },
  { 756, 8, 14, 8, 0, -14 },
  { 770, 5, 17, 6, 0, -14 },
  { 781, 10, 9, 10, 0, -14 },
  { 793, 8, 1, 8, 0, 2 },
  { 794, 4, 3, 6, 1, -15 },
  { 796, 7, 11, 9, 1, -11 },
  { 806, 8, 14, 10, 1, -14 },
  { 820, 6, 11, 8, 1, -11 },
  { 829, 7, 14, 10, 1, -14 },
  { 842, 7, 11, 9, 1, -11 },
  { 852, 6, 15, 6, 0, -15 },
  { 864, 7, 16, 10, 1, -11 },
  { 878, 7, 14, 10, 1, -14 },
  { 891, 3, 14, 5, 1, -14 },
  { 897, 5, 19, 5, -1, -14 },
  { 909, 8, 14, 9, 1, -14 },
  { 923, 3, 14, 5, 1, -14 },
  { 929, 12, 11, 14, 1, -11 },
  { 946, 7, 11, 10, 1, -11 },
  { 956, 8, 11, 9, 1, -11 },
  { 967, 8, 16, 10, 1, -11 },
  { 983, 7, 16, 10, 1, -11 },
  { 997, 5, 11, 7, 1, -11 },
  { 1004, 6, 11, 7, 1, -11 },
  { 1013, 6, 13, 6, 0, -13 },
  { 1023, 7, 10, 10, 1, -10 },
  { 1032, 8, 10, 8, 0, -10 },
  { 1042, 13, 10, 13, 0, -10 },
  { 1059, 8, 10, 8, 0, -10 },
  { 1069, 8, 15, 8, 0, -10 },
  { 1084, 7, 10, 7, 0, -10 },
  { 1093, 6, 17, 7, 0, -14 },
  { 1106, 2, 19, 8, 3, -15 },
  { 1111, 5, 17, 7, 1, -14 },
  { 1122, 8, 3, 9, 0, -8 },
};

const GFXfont NotoSans_ExtraCondensed_Bold19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold19pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD19PT7B_H_
