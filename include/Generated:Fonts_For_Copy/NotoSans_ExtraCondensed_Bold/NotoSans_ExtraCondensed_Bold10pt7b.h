#ifndef _NOTOSANS_EXTRACONDENSED_BOLD10PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xD5, 0x32, 0xBE, 0xAF, 0xA9, 0x80, 0x27, 0xF6, 0x33, 0xF2,
  0x20, 0x6D, 0x52, 0xA3, 0xB1, 0x62, 0xC9, 0x80, 0x71, 0x47, 0x1A, 0xFB,
  0x67, 0xC0, 0xD0, 0x69, 0x2C, 0x92, 0x20, 0xC9, 0x36, 0xD2, 0x80, 0x2B,
  0xF7, 0x22, 0xF2, 0x20, 0x70, 0xE0, 0x70, 0x12, 0x26, 0x44, 0x80, 0x75,
  0xDD, 0xD5, 0x70, 0x3F, 0x73, 0x33, 0x30, 0xF9, 0x13, 0x64, 0xF0, 0xF1,
  0x16, 0x11, 0xF0, 0x33, 0x77, 0xFF, 0x30, 0x74, 0x67, 0x19, 0xF0, 0x74,
  0xED, 0xDD, 0x70, 0xF1, 0x32, 0x26, 0x40, 0x7D, 0x76, 0xDD, 0x70, 0x7D,
  0xDF, 0x51, 0x60, 0xCC, 0x50, 0x1C, 0x17, 0xC3, 0x10, 0xF0, 0xF0, 0x86,
  0x16, 0x80, 0xE3, 0x26, 0x44, 0x40, 0x3C, 0x89, 0xED, 0x5A, 0xAA, 0x90,
  0x1C, 0x33, 0x94, 0xA7, 0xEF, 0x20, 0xEB, 0xBE, 0xBB, 0xE0, 0x7A, 0x31,
  0x84, 0x21, 0xC0, 0xEB, 0x99, 0x9B, 0xE0, 0xF2, 0x79, 0x38, 0xF2, 0x79,
  0x20, 0x7A, 0x11, 0xB4, 0xA5, 0xE0, 0x99, 0x9F, 0x99, 0x90, 0xE9, 0x24,
  0xB8, 0x24, 0x92, 0x49, 0xE0, 0xBA, 0xEE, 0xAB, 0x90, 0x92, 0x49, 0x38,
  0xCF, 0x3D, 0xF5, 0xB6, 0xDA, 0x40, 0xDE, 0xF7, 0x7B, 0xDE, 0x60, 0x79,
  0x2C, 0xB3, 0x49, 0x27, 0x80, 0xEB, 0xBE, 0x88, 0x80, 0x79, 0x2C, 0xB3,
  0x49, 0x27, 0x86, 0x08, 0xEB, 0xBE, 0xAA, 0xB0, 0x7C, 0xC6, 0x3B, 0xE0,
  0xF6, 0x66, 0x66, 0x60, 0x99, 0x99, 0x99, 0xF0, 0x8E, 0xD4, 0xA5, 0x28,
  0x80, 0x93, 0xDA, 0xDA, 0x7A, 0x6E, 0x6C, 0x64, 0xDA, 0x98, 0x47, 0x2B,
  0x60, 0xDA, 0x9C, 0xC2, 0x10, 0x80, 0xF3, 0x26, 0x4C, 0xF0, 0xEA, 0xAA,
  0xC0, 0xC4, 0x46, 0x22, 0x10, 0xED, 0xB6, 0xDB, 0xE0, 0x21, 0x95, 0x90,
  0xF0, 0xCC, 0x27, 0x1F, 0xD7, 0x88, 0xAE, 0xBB, 0xBE, 0x27, 0xCC, 0xC7,
  0x11, 0x57, 0xDD, 0xD7, 0x25, 0xDF, 0xC7, 0x6D, 0x74, 0x92, 0x47, 0xDD,
  0xD7, 0x17, 0x92, 0xFB, 0x6D, 0xDF, 0x51, 0x55, 0x70, 0x88, 0x9A, 0xCE,
  0xAB, 0xFF, 0x2B, 0xFA, 0x69, 0xA6, 0x90, 0x3E, 0xDB, 0x40, 0x23, 0xB5,
  0xB5, 0x38, 0x2E, 0xBB, 0xBE, 0x88, 0x47, 0xDD, 0xD7, 0x11, 0x7A, 0xA0,
  0x7F, 0x33, 0xC0, 0x4B, 0xA4, 0x98, 0xB6, 0xDE, 0xD5, 0x76, 0x60, 0xF7,
  0xD9, 0xB3, 0x66, 0xC0, 0xF6, 0x67, 0xD0, 0xD5, 0x76, 0x66, 0xC0, 0xED,
  0x2E, 0x69, 0x2C, 0x93, 0x20, 0xFF, 0xC0, 0xC9, 0x36, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 4, 2, 4, 0, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 7, 7, 8, 0, -7 },
  { 20, 6, 7, 6, 0, -7 },
  { 26, 2, 2, 2, 0, -7 },
  { 27, 3, 9, 3, 0, -7 },
  { 31, 3, 9, 3, 0, -7 },
  { 35, 4, 4, 4, 0, -8 },
  { 37, 4, 5, 5, 0, -6 },
  { 40, 2, 2, 2, 0, -1 },
  { 41, 3, 1, 3, 0, -3 },
  { 42, 2, 2, 3, 0, -2 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 4, 7, 5, 0, -7 },
  { 51, 4, 7, 5, 0, -7 },
  { 55, 4, 7, 5, 0, -7 },
  { 59, 4, 7, 5, 0, -7 },
  { 63, 4, 7, 5, 0, -7 },
  { 67, 4, 7, 5, 0, -7 },
  { 71, 4, 7, 5, 0, -7 },
  { 75, 4, 7, 5, 0, -7 },
  { 79, 4, 7, 5, 0, -7 },
  { 83, 4, 7, 5, 0, -7 },
  { 87, 1, 6, 3, 1, -6 },
  { 88, 2, 7, 3, 0, -6 },
  { 90, 4, 5, 5, 0, -6 },
  { 93, 4, 3, 5, 0, -5 },
  { 95, 4, 5, 5, 0, -6 },
  { 98, 4, 7, 4, 0, -7 },
  { 102, 7, 8, 7, 0, -7 },
  { 109, 5, 7, 5, 0, -7 },
  { 114, 4, 7, 5, 1, -7 },
  { 118, 5, 7, 5, 0, -7 },
  { 123, 4, 7, 6, 1, -7 },
  { 127, 3, 7, 4, 1, -7 },
  { 130, 3, 7, 4, 1, -7 },
  { 133, 5, 7, 6, 0, -7 },
  { 138, 4, 7, 6, 1, -7 },
  { 142, 3, 7, 3, 0, -7 },
  { 145, 3, 9, 3, -1, -7 },
  { 149, 4, 7, 5, 1, -7 },
  { 153, 3, 7, 4, 1, -7 },
  { 156, 6, 7, 8, 1, -7 },
  { 162, 5, 7, 6, 1, -7 },
  { 167, 6, 7, 6, 0, -7 },
  { 173, 4, 7, 5, 1, -7 },
  { 177, 6, 9, 6, 0, -7 },
  { 184, 4, 7, 5, 1, -7 },
  { 188, 4, 7, 4, 0, -7 },
  { 192, 4, 7, 4, 0, -7 },
  { 196, 4, 7, 6, 1, -7 },
  { 200, 5, 7, 5, 0, -7 },
  { 205, 8, 7, 7, 0, -7 },
  { 212, 5, 7, 5, 0, -7 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 4, 7, 4, 0, -7 },
  { 226, 2, 9, 3, 1, -7 },
  { 229, 4, 7, 4, 0, -7 },
  { 233, 3, 9, 3, 0, -7 },
  { 237, 5, 4, 5, 0, -7 },
  { 240, 4, 1, 4, 0, 1 },
  { 241, 3, 2, 3, 0, -8 },
  { 242, 4, 6, 5, 0, -6 },
  { 245, 4, 8, 5, 1, -8 },
  { 249, 4, 6, 4, 0, -6 },
  { 252, 4, 8, 5, 0, -8 },
  { 256, 4, 6, 5, 0, -6 },
  { 259, 3, 8, 3, 0, -8 },
  { 262, 4, 8, 5, 0, -6 },
  { 266, 3, 8, 5, 1, -8 },
  { 269, 1, 8, 2, 1, -8 },
  { 270, 2, 10, 2, 0, -8 },
  { 273, 4, 8, 5, 1, -8 },
  { 277, 1, 8, 2, 1, -8 },
  { 278, 6, 6, 7, 1, -6 },
  { 283, 3, 6, 5, 1, -6 },
  { 286, 5, 6, 5, 0, -6 },
  { 290, 4, 8, 5, 1, -6 },
  { 294, 4, 8, 5, 0, -6 },
  { 298, 2, 6, 3, 1, -6 },
  { 300, 3, 6, 4, 0, -6 },
  { 303, 3, 7, 3, 0, -7 },
  { 306, 3, 5, 5, 1, -5 },
  { 308, 4, 5, 4, 0, -5 },
  { 311, 7, 5, 7, 0, -5 },
  { 316, 4, 5, 4, 0, -5 },
  { 319, 4, 7, 4, 0, -5 },
  { 323, 3, 5, 4, 0, -5 },
  { 325, 3, 9, 3, 0, -7 },
  { 329, 1, 10, 4, 2, -8 },
  { 331, 3, 9, 3, 0, -7 },
  { 335, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraCondensed_Bold10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold10pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD10PT7B_H_
