#ifndef _NOTOSANS_EXTRACONDENSED_BOLD61PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xBF,
  0xEF, 0xFB, 0xFF, 0xFF, 0xBF, 0xE7, 0xF8, 0xFC, 0x0C, 0x00, 0xFF, 0x8F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F,
  0xDF, 0xC1, 0xFE, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xFC,
  0x0F, 0xCF, 0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x03,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x1F,
  0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xDC, 0x7C, 0x7F, 0x9C, 0x08, 0x7F,
  0x1C, 0x00, 0x7F, 0x1C, 0x00, 0x7F, 0x1C, 0x00, 0x7F, 0x9C, 0x00, 0x7F,
  0x9C, 0x00, 0x7F, 0xDC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1D, 0xFE, 0x00, 0x1C, 0xFF, 0x00, 0x1C, 0xFF, 0x00, 0x1C, 0xFF, 0x80,
  0x1C, 0xFF, 0xE0, 0x1C, 0xFE, 0xF8, 0x1C, 0xFE, 0xFF, 0x1F, 0xFE, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x3F, 0x80, 0x07, 0xF1, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF1,
  0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x3F, 0x0F, 0xF8, 0x7F, 0x1F, 0xCF, 0xE3,
  0xFF, 0x87, 0xE3, 0xF1, 0xF8, 0xFF, 0xF8, 0xFE, 0xFE, 0x3F, 0x1F, 0xFF,
  0x0F, 0xFF, 0x8F, 0xC7, 0xFF, 0xF1, 0xFF, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F,
  0xFC, 0x3F, 0x1F, 0x8F, 0xC1, 0xFF, 0x0F, 0xC7, 0xE1, 0xFC, 0x1F, 0xC1,
  0xF8, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3,
  0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC0,
  0x3F, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0x07, 0xFC, 0x3F, 0xFF,
  0x83, 0xFC, 0x3F, 0xFF, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xF3,
  0xFC, 0xFF, 0x8F, 0xF1, 0xFF, 0x7F, 0x87, 0xF8, 0x7F, 0xFF, 0xC3, 0xFC,
  0x1F, 0xFF, 0xE3, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0xF0, 0xFF,
  0x80, 0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xF8, 0x3F,
  0xF0, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB,
  0xFD, 0xFE, 0xFF, 0x7F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x01, 0x01, 0xF8, 0x10, 0xE0, 0xF8, 0x38, 0xFE, 0x7C, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xFC,
  0x7F, 0xC1, 0xFC, 0x1F, 0xC0, 0x3E, 0x0F, 0xC0, 0x0E, 0x03, 0x80, 0x03,
  0x01, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xE7, 0xF8,
  0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC,
  0x3F, 0x8F, 0xE1, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x7F, 0x06, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3F, 0xE7, 0xFC, 0x3F, 0xC3, 0xFC, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0xC3, 0xFE, 0x3F, 0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0xEF, 0xFF, 0xF9,
  0xFE, 0xFE, 0x3F, 0xCF, 0x87, 0xF8, 0xE1, 0xFF, 0x08, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x7F, 0x07, 0xFC, 0x3C, 0x03, 0xFE, 0x18, 0x03, 0xFE, 0x10, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x3E, 0x07, 0xFE, 0x18, 0x03, 0xFE, 0x10, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0xE0, 0x07, 0xFE, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x3E, 0xFF, 0x00, 0x1F, 0xBF, 0xC0, 0x07, 0xCF, 0xF0, 0x03, 0xF3,
  0xFC, 0x00, 0xFC, 0xFF, 0x00, 0x7E, 0x3F, 0xC0, 0x1F, 0x8F, 0xF0, 0x0F,
  0xC3, 0xFC, 0x03, 0xF0, 0xFF, 0x01, 0xF8, 0x3F, 0xC0, 0x7E, 0x0F, 0xF0,
  0x3F, 0x03, 0xFC, 0x0F, 0xC0, 0xFF, 0x07, 0xE0, 0x3F, 0xC1, 0xF8, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x7C, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1E,
  0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF4, 0x00, 0x3F,
  0xEE, 0x00, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F, 0xF0, 0xFE, 0x7F, 0xF8,
  0xFE, 0xFF, 0xFC, 0xFE, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x81, 0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE,
  0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC3, 0xFC,
  0x3F, 0xE7, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xEF, 0xFC, 0x7F, 0xC7, 0xFE, 0x7F, 0x83, 0xFE,
  0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xC7, 0xFC, 0xFF, 0x83, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFE, 0xFF, 0x1F, 0xFE, 0xFF,
  0x0F, 0xFC, 0xFF, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x30, 0x7F, 0xF0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFE, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC7, 0xF9, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F, 0x8F,
  0xC0, 0xC0, 0x07, 0x03, 0xF0, 0xFF, 0x1F, 0xE7, 0xFE, 0xFF, 0xDF, 0xF9,
  0xFE, 0x3F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF3, 0xFE, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFE, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0x83, 0xFE,
  0x38, 0x07, 0xF8, 0x40, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x0F, 0x00, 0xFC, 0x1F, 0x80, 0xFF, 0xF0, 0xFC, 0x3F,
  0x81, 0xFF, 0xF8, 0x7E, 0x3F, 0x03, 0xFF, 0xF8, 0x7E, 0x3F, 0x07, 0xFF,
  0xF8, 0x7E, 0x3E, 0x07, 0xF1, 0xF8, 0x7E, 0x7E, 0x0F, 0xE1, 0xF8, 0x3E,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x7E, 0x1F, 0xC1, 0xF8, 0x3F, 0x7E, 0x1F,
  0x81, 0xF8, 0x3F, 0x7C, 0x1F, 0x81, 0xF8, 0x3F, 0xFC, 0x1F, 0x81, 0xF8,
  0x3F, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0xFC,
  0x1F, 0x83, 0xF8, 0x3E, 0xFC, 0x1F, 0x83, 0xF8, 0x3E, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x7E, 0x1F, 0x87, 0xF8, 0x7C, 0x7E, 0x1F, 0xC7, 0xF8, 0xFC, 0x7E, 0x0F,
  0xFF, 0x7F, 0xF8, 0x7E, 0x0F, 0xFF, 0x7F, 0xF8, 0x7F, 0x07, 0xFE, 0x3F,
  0xF0, 0x3F, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x00,
  0x07, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F,
  0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F, 0xFC, 0xFF, 0x01, 0xFF,
  0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x00,
  0xFF, 0xBF, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF,
  0x01, 0xFF, 0x3F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0, 0x0F, 0xFB, 0xFC,
  0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFB, 0xFC, 0x03, 0xFE, 0xFF, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xF8, 0x3C, 0x3F, 0xF0, 0x06, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x23, 0xFF,
  0x80, 0x70, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0x9F, 0xE0, 0x3F,
  0xF3, 0xFC, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFD, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xF7,
  0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x1F, 0xFB, 0xFC, 0x03,
  0xFE, 0x7F, 0x81, 0xFF, 0xCF, 0xF0, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x7C, 0x1F,
  0xF8, 0x00, 0xC3, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F,
  0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3, 0xFE, 0x01,
  0xFF, 0x3F, 0xF0, 0x1F, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC,
  0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0xFF,
  0x00, 0x3F, 0xEF, 0xF0, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x0F,
  0xF8, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x03, 0xFE, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0xC0, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF1, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x0F, 0xF3, 0xFE, 0x00,
  0xFF, 0x7F, 0xE0, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x7F, 0xC0, 0x0F, 0xF7,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x00,
  0xFF, 0x0F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFC,
  0xFF, 0x00, 0x7F, 0xCF, 0xF0, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xBF, 0x00, 0xFE, 0xFF, 0xFF, 0x7F,
  0x01, 0xFD, 0xFF, 0xFE, 0xFE, 0x03, 0xF3, 0xFF, 0xFD, 0xFC, 0x07, 0xE7,
  0xFF, 0xF9, 0xF8, 0x1F, 0xCF, 0xFF, 0xF3, 0xF8, 0x3F, 0x9F, 0xFF, 0xE7,
  0xF0, 0x7E, 0x3F, 0xFF, 0xCF, 0xE0, 0xFC, 0x7F, 0xFF, 0x8F, 0xC3, 0xF8,
  0xFF, 0xFF, 0x1F, 0xC7, 0xF1, 0xFF, 0xFE, 0x3F, 0x8F, 0xC3, 0xFF, 0xFC,
  0x7F, 0x3F, 0x87, 0xFF, 0xF8, 0x7E, 0x7F, 0x0F, 0xFF, 0xF0, 0xFE, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFD, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xF8, 0x07,
  0xE0, 0x0F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xDF, 0xC0, 0xFF, 0xFF, 0x7F, 0x83, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0xF3,
  0xFC, 0x3F, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0xFC, 0x7F,
  0x87, 0xFF, 0xF0, 0xFE, 0x1F, 0xFF, 0xC3, 0xFC, 0x7F, 0xFF, 0x0F, 0xF1,
  0xFF, 0xFC, 0x1F, 0xE7, 0xFF, 0xF0, 0x7F, 0x9F, 0xFF, 0xC0, 0xFF, 0x7F,
  0xFF, 0x03, 0xFD, 0xFF, 0xFC, 0x0F, 0xF7, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0,
  0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF,
  0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF1,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFE, 0xFF, 0x07, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xFB,
  0xFC, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F,
  0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF,
  0x00, 0xFF, 0x83, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC,
  0x07, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0,
  0x3F, 0xE3, 0xFC, 0x0F, 0xFC, 0x7F, 0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x0F,
  0xF1, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8, 0x3F,
  0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x7F,
  0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x3F,
  0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x9F, 0xE0, 0x0F, 0xFB, 0xFC,
  0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xC0, 0xF3, 0xFE, 0x00, 0x4F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFE, 0xFC, 0x0F, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xE7,
  0xFC, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x00, 0x0F,
  0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF7, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xCF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x1F, 0xE0, 0x0F, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFC, 0x7F, 0x80, 0x7F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xC1, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0x83, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x7E, 0x07, 0xF8, 0x1F, 0xE0, 0x7E, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0xFD, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFB, 0xF8, 0x3F,
  0xC0, 0x7F, 0x87, 0xF3, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xE7, 0xE1, 0xFE,
  0x01, 0xFE, 0x1F, 0xCF, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0x1F, 0xC7, 0xF8,
  0x03, 0xF8, 0x7E, 0x3F, 0x8F, 0xF0, 0x07, 0xF9, 0xFC, 0x7F, 0x1F, 0xE0,
  0x0F, 0xF3, 0xF8, 0x7E, 0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0xFC, 0xFF, 0x00,
  0x1F, 0xCF, 0xC1, 0xFD, 0xFE, 0x00, 0x3F, 0x9F, 0x83, 0xFB, 0xFC, 0x00,
  0x7F, 0x3F, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x01,
  0xFF, 0xFC, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF3, 0xFC, 0x00,
  0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x7F, 0xBF, 0xC0,
  0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0xFF,
  0x9F, 0xE0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xDF, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x03, 0xFC, 0x7F, 0x80, 0x1F,
  0xE3, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x83, 0xF3, 0xFF, 0x07, 0x01, 0xFF, 0x08, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xBF, 0x9F, 0xFE, 0x7F, 0x3F, 0xF8, 0x7E, 0x3F, 0xE0, 0xFC, 0x06,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7C, 0x07, 0xF8, 0xFF, 0x83, 0xFC, 0xFF,
  0xE1, 0xFE, 0xFF, 0xF8, 0xFF, 0x7F, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFC, 0x3F, 0xEF, 0xFC, 0x0F, 0xF7, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07,
  0xFB, 0xFF, 0x03, 0xFD, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xEF, 0xFF, 0x8F, 0xE3, 0xFF, 0x87, 0xF0,
  0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x81, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7,
  0xFC, 0x0C, 0x3F, 0xC0, 0x23, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x5F, 0xF8, 0x0C, 0x7F, 0xE1, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x1F, 0x87, 0xF8, 0x3F, 0xE3, 0xFC, 0x3F, 0xF9, 0xFE,
  0x3F, 0xFE, 0xFF, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xEF, 0xFC, 0x3F, 0xF7, 0xFC, 0x0F, 0xFB, 0xFC, 0x07, 0xFD, 0xFE, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x0F, 0xFB, 0xFC, 0x07, 0xFD,
  0xFF, 0x07, 0xFE, 0x7F, 0xC7, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xEF, 0xE1, 0xFF, 0xE7, 0xF0, 0x7F, 0xE3, 0xF8, 0x1F, 0xE0,
  0xFC, 0x01, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xF7,
  0xFC, 0x3F, 0xC1, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00,
  0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x04, 0x3F, 0xE0, 0x1C, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xCE, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC1, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xC3,
  0xFF, 0xCF, 0xE1, 0xFF, 0xE7, 0xF1, 0xFF, 0xFB, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0, 0x7F,
  0xDF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF,
  0xC0, 0x7F, 0xDF, 0xF0, 0x7F, 0xE7, 0xFC, 0x7F, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F, 0xFE, 0xFF, 0x07, 0xFE, 0x7F,
  0x81, 0xFE, 0x3F, 0xC0, 0x18, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x80, 0x01, 0xFE, 0x30, 0x01,
  0xFF, 0x1F, 0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00,
  0xF4, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x07, 0xC0, 0xFF, 0x1F, 0xF0, 0xFF, 0x3F, 0xF8,
  0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x3F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x18, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE,
  0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xEF, 0xF7,
  0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x3F, 0x80, 0xFE, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFA, 0x3F, 0xEF,
  0xFF, 0xBF, 0xFC, 0xFF, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xE0, 0x1C, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xEF, 0xF0, 0x0F,
  0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF3, 0xFE, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xE0,
  0x0F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0xE0, 0x3F,
  0xE7, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF,
  0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE3, 0xF8, 0xFF, 0xF1, 0xFF, 0xE7, 0xF3, 0xFF, 0xE7, 0xFF, 0xCF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFC, 0x07,
  0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x07,
  0xFF, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xFC,
  0x03, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xF0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF0, 0xFE, 0x3F, 0xF8, 0xFE,
  0x7F, 0xFC, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFC, 0x7F, 0xC0,
  0xFF, 0x1F, 0xE0, 0x3F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0xFF,
  0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0,
  0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x0F, 0xF8, 0x3F, 0x8F, 0xFE, 0x1F,
  0xEF, 0xFF, 0x8F, 0xF7, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD,
  0xFF, 0xC3, 0xFE, 0xFF, 0xC0, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xBF,
  0xF0, 0x7F, 0xDF, 0xFE, 0x7F, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFD, 0xFF, 0xF1, 0xFE, 0xFF, 0xF8, 0xFF, 0x3F, 0xF8, 0x7F, 0x87, 0xF8,
  0x3F, 0xC0, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0x1F, 0xC3, 0xFF, 0xCF, 0xE1, 0xFF, 0xE7,
  0xF1, 0xFF, 0xFB, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xC3,
  0xFF, 0x7F, 0xC0, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xE0, 0x3F, 0xEF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFE,
  0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF, 0xF0, 0x7F,
  0xE7, 0xFC, 0x7F, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x1F, 0xFE, 0xFF, 0x07, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x18,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xFE, 0xFE, 0x7F, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xF8, 0x1C, 0xFF, 0x00,
  0x9F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0x80,
  0x07, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x31, 0xFF, 0xFC, 0x3F, 0xFF,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFE, 0x00, 0x30, 0x00,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0x7F, 0x83, 0xFF, 0x7F, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0x1F, 0xFE, 0x7F, 0x1F, 0xFE, 0x3F,
  0x07, 0xF8, 0x3F, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07,
  0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFC, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x01, 0xFD,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFE, 0xFE, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x7F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xCF, 0xF0, 0x1F, 0xF8, 0x0F, 0xE7, 0xF8, 0x1F, 0xFC, 0x0F, 0xF1,
  0xFC, 0x0F, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xFF, 0x03, 0xFC, 0x7F, 0x83,
  0xEF, 0xC1, 0xFC, 0x3F, 0xC1, 0xF7, 0xE0, 0xFE, 0x1F, 0xE1, 0xFB, 0xF0,
  0xFF, 0x07, 0xF0, 0xFC, 0xF8, 0x7F, 0x83, 0xFC, 0x7E, 0x7C, 0x3F, 0x81,
  0xFE, 0x3E, 0x3E, 0x1F, 0xC0, 0xFF, 0x1F, 0x1F, 0x9F, 0xE0, 0x3F, 0x8F,
  0x8F, 0xCF, 0xF0, 0x1F, 0xCF, 0xC3, 0xE7, 0xF8, 0x0F, 0xE7, 0xE1, 0xF3,
  0xF8, 0x07, 0xFB, 0xF0, 0xF9, 0xFC, 0x03, 0xFD, 0xF0, 0x7C, 0xFE, 0x00,
  0xFE, 0xF8, 0x3E, 0xFF, 0x00, 0x7F, 0x7C, 0x1F, 0x7F, 0x00, 0x3F, 0xBE,
  0x07, 0xFF, 0x80, 0x1F, 0xDF, 0x03, 0xFF, 0xC0, 0x07, 0xEF, 0x81, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0x9F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07,
  0xFC, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF0, 0x07, 0xF7, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xDF, 0xE0, 0x0F, 0xF3, 0xFC, 0x03, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC1, 0xFF, 0x0F, 0xF0,
  0x3F, 0xC7, 0xFC, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F, 0xC0,
  0xFF, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF9, 0xFC, 0x00, 0xFF, 0x3F,
  0x80, 0x0F, 0xEF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x03,
  0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x37, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x47, 0xFC, 0x00, 0x13, 0xFF, 0xC0, 0x0D, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xB0, 0x00, 0xFF, 0x88, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 10, 45, 16, 3, -44 },
  { 58, 21, 16, 27, 3, -44 },
  { 100, 29, 44, 31, 1, -44 },
  { 260, 24, 50, 28, 2, -46 },
  { 410, 43, 44, 47, 2, -44 },
  { 647, 33, 45, 34, 1, -44 },
  { 833, 9, 16, 14, 3, -44 },
  { 851, 15, 54, 19, 3, -44 },
  { 953, 15, 54, 19, 1, -44 },
  { 1055, 25, 24, 27, 1, -46 },
  { 1130, 25, 29, 28, 2, -36 },
  { 1221, 11, 15, 15, 2, -7 },
  { 1242, 15, 7, 19, 2, -20 },
  { 1256, 9, 10, 16, 3, -9 },
  { 1268, 23, 44, 25, 1, -44 },
  { 1395, 24, 45, 28, 2, -44 },
  { 1530, 19, 44, 28, 3, -44 },
  { 1635, 24, 44, 28, 2, -44 },
  { 1767, 24, 45, 28, 2, -44 },
  { 1902, 26, 44, 28, 1, -44 },
  { 2045, 23, 45, 28, 3, -44 },
  { 2175, 24, 45, 28, 2, -44 },
  { 2310, 25, 44, 28, 1, -44 },
  { 2448, 24, 45, 28, 2, -44 },
  { 2583, 24, 45, 28, 2, -44 },
  { 2718, 10, 35, 16, 3, -34 },
  { 2762, 11, 42, 16, 2, -34 },
  { 2820, 25, 29, 28, 2, -36 },
  { 2911, 25, 19, 28, 2, -31 },
  { 2971, 25, 29, 28, 2, -36 },
  { 3062, 22, 45, 23, 0, -44 },
  { 3186, 40, 49, 44, 2, -44 },
  { 3431, 32, 44, 32, 0, -44 },
  { 3607, 26, 44, 32, 4, -44 },
  { 3750, 25, 45, 29, 3, -44 },
  { 3891, 27, 44, 34, 4, -44 },
  { 4040, 20, 44, 27, 4, -44 },
  { 4150, 19, 44, 26, 4, -44 },
  { 4255, 28, 45, 34, 3, -44 },
  { 4413, 28, 44, 36, 4, -44 },
  { 4567, 17, 44, 19, 1, -44 },
  { 4661, 15, 57, 17, -3, -44 },
  { 4768, 28, 44, 31, 4, -44 },
  { 4922, 20, 44, 25, 4, -44 },
  { 5032, 39, 44, 47, 4, -44 },
  { 5247, 30, 44, 38, 4, -44 },
  { 5412, 31, 45, 36, 3, -44 },
  { 5587, 24, 44, 30, 4, -44 },
  { 5719, 31, 54, 36, 3, -44 },
  { 5929, 27, 44, 31, 4, -44 },
  { 6078, 22, 45, 26, 2, -44 },
  { 6202, 24, 44, 26, 1, -44 },
  { 6334, 27, 45, 35, 4, -44 },
  { 6486, 31, 44, 31, 0, -44 },
  { 6657, 47, 44, 45, -1, -44 },
  { 6916, 29, 44, 29, 0, -44 },
  { 7076, 29, 44, 29, 0, -44 },
  { 7236, 23, 44, 25, 1, -44 },
  { 7363, 15, 54, 19, 3, -44 },
  { 7465, 24, 44, 25, 0, -44 },
  { 7597, 15, 54, 19, 1, -44 },
  { 7699, 30, 27, 32, 1, -44 },
  { 7801, 25, 4, 25, 0, 5 },
  { 7814, 15, 10, 19, 2, -47 },
  { 7833, 23, 35, 28, 2, -34 },
  { 7934, 25, 47, 31, 3, -46 },
  { 8081, 21, 35, 24, 2, -34 },
  { 8173, 25, 47, 31, 2, -46 },
  { 8320, 24, 35, 28, 2, -34 },
  { 8425, 19, 47, 18, 1, -47 },
  { 8537, 25, 49, 31, 2, -34 },
  { 8691, 24, 46, 31, 3, -46 },
  { 8829, 9, 46, 15, 3, -46 },
  { 8881, 14, 61, 15, -2, -46 },
  { 8988, 26, 46, 29, 4, -46 },
  { 9138, 8, 46, 15, 3, -46 },
  { 9184, 39, 34, 46, 3, -34 },
  { 9350, 24, 34, 31, 3, -34 },
  { 9452, 26, 35, 30, 2, -34 },
  { 9566, 25, 49, 31, 3, -34 },
  { 9720, 25, 49, 31, 2, -34 },
  { 9874, 18, 34, 21, 3, -34 },
  { 9951, 19, 35, 23, 2, -34 },
  { 10035, 18, 41, 20, 1, -40 },
  { 10128, 24, 34, 31, 3, -33 },
  { 10230, 27, 33, 27, 0, -33 },
  { 10342, 41, 33, 41, 0, -33 },
  { 10512, 26, 33, 26, 0, -33 },
  { 10620, 27, 48, 27, 0, -33 },
  { 10782, 20, 33, 22, 1, -33 },
  { 10865, 18, 54, 21, 1, -44 },
  { 10987, 7, 61, 27, 10, -47 },
  { 11041, 19, 54, 21, 2, -44 },
  { 11170, 26, 11, 28, 1, -27 },
};

const GFXfont NotoSans_ExtraCondensed_Bold61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD61PT7B_H_
