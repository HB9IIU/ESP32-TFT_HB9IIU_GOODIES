#ifndef _NOTOSANS_EXTRACONDENSED_BOLD21PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xEC, 0x0F, 0xF8, 0xEF, 0xDF, 0x9F, 0x3E, 0x60,
  0x0D, 0x86, 0x61, 0x98, 0x66, 0x7F, 0xDF, 0xF1, 0xB0, 0x6C, 0x33, 0x3F,
  0xFF, 0xFC, 0xD8, 0x36, 0x0D, 0x83, 0x60, 0x18, 0x18, 0x7F, 0xFE, 0xFA,
  0xF8, 0xF8, 0x78, 0x3C, 0x1E, 0x1F, 0x1F, 0xDF, 0xFE, 0x7C, 0x18, 0x18,
  0x70, 0x61, 0xF1, 0x83, 0x63, 0x06, 0xE6, 0x0D, 0xD8, 0x1B, 0xB0, 0x36,
  0xEE, 0x7D, 0xBE, 0x73, 0x6C, 0x0C, 0xDC, 0x19, 0xB8, 0x73, 0x70, 0xC6,
  0xC1, 0x8F, 0x86, 0x0E, 0x00, 0x1E, 0x03, 0xF0, 0x33, 0x03, 0x30, 0x33,
  0x03, 0xF0, 0x1E, 0x03, 0xCE, 0x7E, 0xE7, 0x7E, 0xE7, 0xC6, 0x3C, 0x73,
  0xC7, 0xFE, 0x3E, 0xF0, 0xFF, 0xFE, 0x19, 0x9C, 0xE6, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x31, 0x8E, 0x31, 0xC0, 0xE1, 0xC3, 0x0E, 0x38, 0x61, 0x87,
  0x1C, 0x71, 0xC6, 0x18, 0x63, 0x8C, 0x73, 0x80, 0x1C, 0x06, 0x13, 0x4F,
  0xFF, 0xF1, 0xF1, 0xDC, 0x66, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xEC, 0xFF, 0xFE, 0xFF, 0x80, 0x03, 0x07, 0x06,
  0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0xE0,
  0x3C, 0x7E, 0xEE, 0xE7, 0xE7, 0xE7, 0xC7, 0xC7, 0xC7, 0xE7, 0xE7, 0xE7,
  0xEE, 0x7E, 0x3C, 0x0C, 0x73, 0xDF, 0xED, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC0, 0x7C, 0xFE, 0xCE, 0x87, 0x07, 0x06, 0x0E, 0x0E, 0x1C,
  0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0x7C, 0xFE, 0xCE, 0x07, 0x07, 0x0E,
  0x7C, 0x7C, 0x1E, 0x07, 0x07, 0x07, 0x8F, 0xFE, 0xFC, 0x07, 0x03, 0x83,
  0xC1, 0xE1, 0xF0, 0xB8, 0xDC, 0x6E, 0x67, 0x33, 0xBF, 0xFF, 0xF0, 0x70,
  0x38, 0x1C, 0x7E, 0xFE, 0xE0, 0xE0, 0xE0, 0xF8, 0xFE, 0xFE, 0x07, 0x07,
  0x07, 0x07, 0x8E, 0xFE, 0xFC, 0x1E, 0x7E, 0x70, 0xE0, 0xE0, 0xCC, 0xDE,
  0xFF, 0xE7, 0xC7, 0xC7, 0xE7, 0xE7, 0x7E, 0x3C, 0xFF, 0xFF, 0xC0, 0xE0,
  0x70, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x03, 0x81, 0xC1, 0xC0,
  0xE0, 0x7C, 0xFE, 0xE7, 0xE7, 0xE7, 0xFE, 0x7C, 0x7C, 0xFE, 0xE7, 0xC7,
  0xC7, 0xE7, 0xFE, 0x7C, 0x7C, 0xFE, 0xEE, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF,
  0xFF, 0x77, 0x07, 0x06, 0x0E, 0xFC, 0xF8, 0x5F, 0xB0, 0x00, 0x1F, 0xF0,
  0x5F, 0xB0, 0x00, 0x03, 0xFF, 0xB0, 0x01, 0x03, 0x0F, 0x3E, 0xF8, 0xE0,
  0xF8, 0x3E, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x1F, 0x7C, 0xF0, 0xC0, 0x7D, 0xFD, 0x38,
  0x30, 0x61, 0xC7, 0x0C, 0x38, 0x60, 0x00, 0x03, 0x87, 0x0E, 0x00, 0x0F,
  0xC1, 0xFF, 0x0C, 0x0C, 0xC0, 0x76, 0x7D, 0xE7, 0x6F, 0x33, 0x7B, 0xBB,
  0xD9, 0xDE, 0xCC, 0xF3, 0x77, 0x9F, 0xEE, 0x62, 0x30, 0x00, 0xE1, 0x03,
  0xF8, 0x07, 0x00, 0x0E, 0x03, 0xE0, 0x6C, 0x0D, 0x81, 0xB0, 0x77, 0x0E,
  0xE1, 0xDC, 0x31, 0x8F, 0xF9, 0xFF, 0x38, 0xE7, 0x1D, 0xC1, 0xF8, 0x38,
  0xFE, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0x1F, 0xFD, 0xFE, 0xE7, 0xF1, 0xF8,
  0xFC, 0x7E, 0x7F, 0xFB, 0xF8, 0x1F, 0x9F, 0x9E, 0x4E, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x91, 0xF8, 0x7C, 0xFE, 0x3F,
  0xCF, 0xFB, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B,
  0x8E, 0xFF, 0xBF, 0xCF, 0xC0, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0xFF,
  0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x87, 0x0E, 0x1C,
  0x38, 0x7F, 0xFF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00, 0x1F, 0xCF, 0xE7,
  0x89, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x9F, 0xE7, 0xF8, 0x7E, 0x1D, 0xC7,
  0x71, 0xCF, 0xF1, 0xF8, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFF,
  0xF3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3B, 0xFF, 0xC0, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFC, 0xE1,
  0xF8, 0xEE, 0x7B, 0x9C, 0xEE, 0x3B, 0x8F, 0xC3, 0xF8, 0xFE, 0x3F, 0x8E,
  0x73, 0x9C, 0xE3, 0xB8, 0xEE, 0x1C, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0F, 0xFF, 0xFF, 0x80, 0xF0, 0x3F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xF3, 0xFE, 0xCD, 0xFB, 0x37, 0xEC, 0xDF,
  0xBF, 0x7E, 0x79, 0xF9, 0xE7, 0xE7, 0x9F, 0x9C, 0x7E, 0x31, 0xC0, 0xF0,
  0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0xCF, 0xF9, 0xFB, 0xBF, 0x77, 0xE6, 0xFC,
  0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x78, 0x1F, 0x0F, 0xF1, 0xCF,
  0x78, 0xEE, 0x1D, 0xC3, 0xB8, 0x3F, 0x07, 0xE0, 0xFC, 0x3B, 0x87, 0x78,
  0xE7, 0x3C, 0xFF, 0x07, 0xC0, 0xFE, 0x7F, 0xBB, 0xDC, 0x7E, 0x3F, 0x1F,
  0x9D, 0xFE, 0xFE, 0x7E, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x1F, 0x0F,
  0xF1, 0xCF, 0x78, 0xEE, 0x1D, 0xC3, 0xB8, 0x3F, 0x07, 0xE0, 0xFC, 0x3B,
  0x87, 0x78, 0xE7, 0x3C, 0xFF, 0x07, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0xFE, 0x3F, 0xCE, 0xF3, 0x8E, 0xE3, 0xB8, 0xEE, 0x73, 0xFC, 0xFE,
  0x3B, 0x8E, 0x73, 0x9C, 0xE3, 0xB8, 0xEE, 0x3C, 0x7F, 0xFF, 0xDF, 0x0E,
  0x1C, 0x3E, 0x3E, 0x1E, 0x1C, 0x3C, 0x7C, 0xFF, 0xBE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0x73, 0x9F, 0xE3, 0xF0, 0xE0, 0xFC,
  0x19, 0x87, 0x30, 0xE7, 0x18, 0xE3, 0x0C, 0xE1, 0x9C, 0x3B, 0x07, 0x60,
  0x6C, 0x0F, 0x81, 0xE0, 0x3C, 0x03, 0x80, 0xE1, 0x87, 0xE3, 0x87, 0xE3,
  0xC6, 0xE3, 0xCE, 0x63, 0xCE, 0x73, 0xCE, 0x77, 0xCE, 0x76, 0xEC, 0x76,
  0xEC, 0x36, 0x7C, 0x36, 0x7C, 0x3E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x1C,
  0x38, 0xE3, 0xDC, 0xE7, 0x38, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0xC3, 0xF0, 0xCC, 0x73, 0x9C, 0xEE, 0x1C, 0xE1, 0xD8, 0x67, 0x39,
  0xCE, 0x33, 0x0F, 0xC3, 0xE0, 0x78, 0x1E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xFF, 0xFF, 0x07, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0x60, 0xFF, 0xFF, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x38,
  0x18, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x03, 0xFF, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0, 0x06, 0x01, 0xC0,
  0x38, 0x0F, 0x81, 0xB0, 0x77, 0x0C, 0x63, 0x8E, 0xE0, 0xE0, 0xFF, 0x80,
  0xE3, 0x8E, 0x38, 0xFE, 0x7E, 0x07, 0x07, 0x7F, 0xFF, 0xE7, 0xC7, 0xEF,
  0xFF, 0x77, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xC7, 0xFB, 0xFD, 0xC6, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0xBB, 0xFD, 0xDC, 0x1C, 0xFD, 0xF7, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC5, 0xF9, 0xE0, 0x03, 0x03, 0x03, 0x03, 0x33,
  0x7B, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xE7, 0x7F, 0x7B, 0x18,
  0x7E, 0xFE, 0xE7, 0xC7, 0xFF, 0xFF, 0xC0, 0xE0, 0xE1, 0x7E, 0x3E, 0x1E,
  0x7C, 0xEB, 0x87, 0x1F, 0xBF, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x7B, 0xFF, 0xE7, 0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0xE7, 0x7F,
  0x7B, 0x03, 0x07, 0xCF, 0xFE, 0x7C, 0xE0, 0xE0, 0xE0, 0xE0, 0xEC, 0xFF,
  0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0x39, 0xCE, 0x00, 0x1C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xEF, 0xFF, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F,
  0x1B, 0x9D, 0xDC, 0xEC, 0x7E, 0x3F, 0x1F, 0xCE, 0x67, 0x3B, 0x8D, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x73, 0xFF, 0xEF, 0xFF, 0xB9,
  0xE7, 0xE7, 0x1F, 0x9C, 0x7E, 0x71, 0xF9, 0xC7, 0xE7, 0x1F, 0x9C, 0x7E,
  0x71, 0xF9, 0xC7, 0x0C, 0xFF, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0x18, 0x7E, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0xE7, 0x7E, 0x3E, 0x0C, 0x7F, 0xBF, 0xDC, 0x6E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xFB, 0xBF, 0xDD, 0xCE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x30,
  0x7B, 0xFF, 0xE7, 0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0xE7, 0x7F, 0x7B, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x0F, 0x7F, 0xFC, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0x3B, 0xFF, 0xF0, 0xE3, 0xE7, 0xC7, 0x0E, 0x7F, 0xFE, 0x30, 0xC3,
  0x3F, 0xFD, 0xC7, 0x1C, 0x71, 0xC7, 0x1D, 0x3C, 0xF0, 0xE3, 0xE3, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xE7, 0x7F, 0x7B, 0xE3, 0xB1, 0xDC, 0xCE,
  0x67, 0x71, 0xB8, 0xD8, 0x7C, 0x3E, 0x0F, 0x07, 0x00, 0xE7, 0x9D, 0x9E,
  0x76, 0x79, 0x9D, 0xE6, 0x76, 0xF9, 0xD3, 0xE3, 0xCF, 0x8F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC1, 0xCF, 0x00, 0xE7, 0xBB, 0x8D, 0x87, 0xC3, 0xC0, 0xE0,
  0xF8, 0x7C, 0x77, 0x3B, 0xB8, 0xE0, 0xE3, 0xB1, 0xDC, 0xCE, 0x63, 0x71,
  0xB8, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC5, 0xC1, 0xE0, 0xE0,
  0x7E, 0xFC, 0x30, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xFF, 0xF8, 0x1E, 0x3C,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0xF1, 0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x1E, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE3, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x3C, 0xF7, 0x9C, 0x71, 0xC7, 0x1C, 0xF3, 0x80,
  0x78, 0xFF, 0xE3, 0xE0,
};

const GFXglyph NotoSans_ExtraCondensed_Bold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 7, 5, 9, 1, -15 },
  { 12, 10, 15, 11, 0, -15 },
  { 31, 8, 17, 10, 1, -16 },
  { 48, 15, 15, 16, 1, -15 },
  { 77, 12, 15, 12, 0, -15 },
  { 100, 3, 5, 5, 1, -15 },
  { 102, 5, 18, 7, 1, -15 },
  { 114, 6, 18, 7, 0, -15 },
  { 128, 9, 8, 9, 0, -16 },
  { 137, 8, 10, 10, 1, -12 },
  { 147, 3, 5, 5, 1, -2 },
  { 149, 5, 3, 6, 1, -7 },
  { 151, 3, 3, 5, 1, -3 },
  { 153, 8, 15, 8, 0, -15 },
  { 168, 8, 15, 10, 1, -15 },
  { 183, 6, 15, 10, 1, -15 },
  { 195, 8, 15, 10, 1, -15 },
  { 210, 8, 15, 10, 1, -15 },
  { 225, 9, 15, 10, 0, -15 },
  { 242, 8, 15, 10, 1, -15 },
  { 257, 8, 15, 10, 1, -15 },
  { 272, 9, 15, 10, 0, -15 },
  { 289, 8, 15, 10, 1, -15 },
  { 304, 8, 15, 10, 1, -15 },
  { 319, 3, 12, 5, 1, -12 },
  { 324, 3, 15, 5, 1, -12 },
  { 330, 8, 10, 10, 1, -13 },
  { 340, 8, 7, 10, 1, -11 },
  { 347, 8, 10, 10, 1, -13 },
  { 357, 7, 15, 8, 0, -15 },
  { 371, 13, 17, 15, 1, -15 },
  { 399, 11, 15, 11, 0, -15 },
  { 420, 9, 15, 11, 1, -15 },
  { 437, 9, 15, 10, 1, -15 },
  { 454, 10, 15, 12, 1, -15 },
  { 473, 7, 15, 9, 1, -15 },
  { 487, 7, 15, 9, 1, -15 },
  { 501, 10, 15, 12, 1, -15 },
  { 520, 10, 15, 12, 1, -15 },
  { 539, 6, 15, 7, 0, -15 },
  { 551, 5, 19, 6, -1, -15 },
  { 563, 10, 15, 11, 1, -15 },
  { 582, 7, 15, 9, 1, -15 },
  { 596, 14, 15, 16, 1, -15 },
  { 623, 11, 15, 13, 1, -15 },
  { 644, 11, 15, 12, 1, -15 },
  { 665, 9, 15, 10, 1, -15 },
  { 682, 11, 19, 12, 1, -15 },
  { 709, 10, 15, 11, 1, -15 },
  { 728, 7, 15, 9, 1, -15 },
  { 742, 9, 15, 9, 0, -15 },
  { 759, 10, 15, 12, 1, -15 },
  { 778, 11, 15, 11, 0, -15 },
  { 799, 16, 15, 16, 0, -15 },
  { 829, 10, 15, 10, 0, -15 },
  { 848, 10, 15, 10, 0, -15 },
  { 867, 8, 15, 9, 0, -15 },
  { 882, 5, 18, 7, 1, -15 },
  { 894, 8, 15, 8, 0, -15 },
  { 909, 5, 18, 7, 0, -15 },
  { 921, 11, 9, 11, 0, -15 },
  { 934, 9, 1, 9, 0, 2 },
  { 936, 5, 3, 7, 1, -16 },
  { 938, 8, 12, 10, 1, -12 },
  { 950, 9, 16, 11, 1, -16 },
  { 968, 7, 12, 8, 1, -12 },
  { 979, 8, 16, 11, 1, -16 },
  { 995, 8, 12, 10, 1, -12 },
  { 1007, 7, 16, 6, 0, -16 },
  { 1021, 8, 17, 11, 1, -12 },
  { 1038, 8, 16, 11, 1, -16 },
  { 1054, 3, 16, 5, 1, -16 },
  { 1060, 5, 21, 5, -1, -16 },
  { 1074, 9, 16, 10, 1, -16 },
  { 1092, 3, 16, 5, 1, -16 },
  { 1098, 14, 12, 16, 1, -12 },
  { 1119, 8, 12, 11, 1, -12 },
  { 1131, 8, 12, 10, 1, -12 },
  { 1143, 9, 17, 11, 1, -12 },
  { 1163, 8, 17, 11, 1, -12 },
  { 1180, 6, 12, 7, 1, -12 },
  { 1189, 6, 12, 8, 1, -12 },
  { 1198, 6, 14, 7, 0, -14 },
  { 1209, 8, 11, 11, 1, -11 },
  { 1220, 9, 11, 9, 0, -11 },
  { 1233, 14, 11, 14, 0, -11 },
  { 1253, 9, 11, 9, 0, -11 },
  { 1266, 9, 16, 9, 0, -11 },
  { 1284, 7, 11, 8, 0, -11 },
  { 1294, 7, 18, 7, 0, -15 },
  { 1310, 3, 21, 9, 3, -16 },
  { 1318, 6, 18, 7, 1, -15 },
  { 1332, 9, 3, 10, 0, -9 },
};

const GFXfont NotoSans_ExtraCondensed_Bold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD21PT7B_H_
