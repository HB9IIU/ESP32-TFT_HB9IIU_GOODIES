#ifndef _NOTOSANS_EXTRACONDENSED_BOLD24PT7B_H_
#define _NOTOSANS_EXTRACONDENSED_BOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_ExtraCondensed-Bold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraCondensed_Bold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x77, 0x76, 0x60, 0x06, 0xFF, 0x70, 0xF7, 0xF3,
  0xB9, 0xDC, 0xEE, 0x73, 0x38, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0D,
  0xC7, 0xFF, 0x7F, 0xF1, 0x98, 0x19, 0x81, 0x98, 0xFF, 0xEF, 0xFE, 0x3B,
  0x83, 0xB0, 0x33, 0x03, 0x30, 0x33, 0x00, 0x08, 0x06, 0x0F, 0xEF, 0xFF,
  0x97, 0x43, 0xA0, 0xF0, 0x7C, 0x0F, 0x83, 0xE1, 0x70, 0xBC, 0x5F, 0xFF,
  0xFE, 0x3C, 0x04, 0x02, 0x00, 0x78, 0x38, 0x7E, 0x18, 0x33, 0x1C, 0x19,
  0x8C, 0x0C, 0xE6, 0x06, 0x77, 0x03, 0x33, 0x11, 0x9B, 0xBE, 0xFD, 0xBF,
  0x3C, 0xDD, 0xC0, 0xEC, 0xE0, 0x66, 0x70, 0x73, 0x38, 0x31, 0x9C, 0x18,
  0xEC, 0x1C, 0x3E, 0x0C, 0x1E, 0x00, 0x3E, 0x07, 0xF0, 0x77, 0x07, 0x38,
  0x73, 0x07, 0x70, 0x7E, 0x03, 0xE0, 0x7C, 0x7F, 0xEF, 0xEF, 0xEE, 0x7E,
  0xE3, 0xEE, 0x3C, 0xFF, 0xEF, 0xFE, 0x7E, 0xF0, 0xFE, 0xEE, 0xE6, 0x1C,
  0xE3, 0x9C, 0x71, 0xC6, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x86, 0x1C, 0x70,
  0xE3, 0x86, 0x1C, 0xE1, 0xC3, 0x8E, 0x18, 0x71, 0xC7, 0x1C, 0x30, 0xC7,
  0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x1C, 0xE0, 0x0E, 0x03, 0x86, 0xCD, 0xFF,
  0xFF, 0xC7, 0x83, 0xF1, 0xEE, 0x33, 0x00, 0x1C, 0x0E, 0x07, 0x03, 0x8F,
  0xFF, 0xFF, 0xFE, 0x38, 0x1C, 0x0E, 0x07, 0x00, 0x77, 0xFE, 0xEE, 0xFF,
  0xFF, 0xC0, 0x6F, 0xFF, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0,
  0xE0, 0x00, 0x3E, 0x3F, 0x9D, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1D, 0xFC, 0xFE, 0x3E, 0x00, 0x0E, 0x3C,
  0xFB, 0xFF, 0xED, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x7E, 0x7F, 0xBD, 0xE8, 0xF0, 0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x0F,
  0x07, 0x07, 0x07, 0x83, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x7F, 0x9B,
  0xE8, 0x70, 0x38, 0x3C, 0x1C, 0x7C, 0x3E, 0x1F, 0x81, 0xE0, 0x70, 0x3C,
  0x3F, 0xFF, 0xFE, 0xFE, 0x00, 0x03, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8,
  0x37, 0x06, 0xE1, 0xDC, 0x33, 0x8E, 0x71, 0x8E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0x3F, 0x9F, 0xCE, 0x06, 0x07, 0x03,
  0xF9, 0xFE, 0xFF, 0x83, 0xC0, 0xE0, 0x70, 0x3C, 0x3F, 0xFD, 0xFE, 0xFE,
  0x00, 0x1F, 0x1F, 0x9F, 0x2E, 0x0E, 0x07, 0x03, 0xBD, 0xFE, 0xFF, 0xF1,
  0xF8, 0xFC, 0x7E, 0x3F, 0x1D, 0xFE, 0xFE, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38,
  0x0E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x00, 0x3E, 0x3F, 0xBD, 0xFC, 0x7E,
  0x3F, 0xBD, 0xFC, 0x7C, 0x3E, 0x3F, 0xB9, 0xFC, 0x7E, 0x3F, 0x1F, 0xDF,
  0xFE, 0x3E, 0x00, 0x3E, 0x3F, 0xBF, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7,
  0xFF, 0xBF, 0xDE, 0xE0, 0x70, 0x38, 0x3B, 0xFD, 0xFC, 0xFC, 0x00, 0x7F,
  0xF6, 0x00, 0x00, 0x06, 0xFF, 0x70, 0x7F, 0xF6, 0x00, 0x00, 0x00, 0x77,
  0xFE, 0xEE, 0x00, 0x81, 0xC3, 0xE7, 0xCF, 0x87, 0x03, 0xF0, 0x7E, 0x0F,
  0x81, 0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80,
  0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0xF9, 0xF8, 0xF8, 0x38, 0x08,
  0x00, 0x7E, 0xFF, 0x7F, 0x47, 0x07, 0x07, 0x0F, 0x1E, 0x1C, 0x18, 0x38,
  0x00, 0x00, 0x18, 0x3C, 0x3C, 0x38, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0x73,
  0x80, 0x66, 0x3C, 0xEC, 0xFC, 0xF9, 0x99, 0xE7, 0x33, 0xCC, 0x67, 0x98,
  0xCF, 0x33, 0x9E, 0x77, 0x3E, 0xFB, 0xDC, 0xF7, 0x98, 0x00, 0x38, 0x00,
  0x3C, 0x30, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xDC, 0x0E, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xE1, 0xC7, 0x0F, 0xF8,
  0xFF, 0xC7, 0xFF, 0x38, 0x79, 0xC1, 0xDE, 0x0E, 0xF0, 0x78, 0xFE, 0x3F,
  0xEF, 0xFB, 0x8E, 0xE3, 0xB8, 0xEE, 0x7B, 0xFC, 0xFF, 0x39, 0xEE, 0x3B,
  0x8F, 0xE3, 0xF8, 0xEF, 0xFB, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xF7, 0xD9,
  0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0,
  0x1E, 0x17, 0xFC, 0xFF, 0x1F, 0x80, 0xFE, 0x3F, 0xCF, 0xFB, 0x8F, 0xE3,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF9, 0xEF,
  0xFB, 0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x7F, 0xFF,
  0xFF, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C,
  0x38, 0x7F, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x0F, 0xE7,
  0xFC, 0xFB, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x9F, 0xE3, 0xFE, 0x7F,
  0xC3, 0xF8, 0x77, 0x0E, 0xF1, 0xDF, 0xF9, 0xFF, 0x1F, 0xC0, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0xFF, 0xF7, 0x9C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xBF, 0xFC, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xFE,
  0xFB, 0xC0, 0xE1, 0xDC, 0x7B, 0x9E, 0x73, 0x8E, 0xF1, 0xDC, 0x3F, 0x87,
  0xE0, 0xFE, 0x1F, 0xC3, 0xBC, 0x73, 0x8E, 0x79, 0xCF, 0x38, 0xE7, 0x1E,
  0xE1, 0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x3F, 0xFF, 0xFE, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3,
  0xFF, 0x87, 0xFF, 0x8D, 0xFF, 0x1B, 0xFE, 0x77, 0xEC, 0xEF, 0xDD, 0x9F,
  0xBB, 0x3F, 0x7E, 0x7E, 0x7C, 0xFC, 0xF1, 0xF9, 0xE3, 0xF3, 0xC7, 0xE3,
  0x0E, 0xF0, 0xFE, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF9, 0xFF, 0x3F, 0x77,
  0xEE, 0xFD, 0xFF, 0x9D, 0xF3, 0xBE, 0x3F, 0xC7, 0xF8, 0x7F, 0x0F, 0xE1,
  0xE0, 0x1F, 0x83, 0xFC, 0x7F, 0xE7, 0x0E, 0xF0, 0xFF, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7, 0x8E, 0x7F, 0xE3,
  0xFC, 0x1F, 0x80, 0xFE, 0x7F, 0xBF, 0xFC, 0xFE, 0x3F, 0x1F, 0x8F, 0xCF,
  0xFF, 0x7F, 0xBF, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x1F,
  0x83, 0xFC, 0x7F, 0xE7, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x7F, 0x07, 0x70, 0xF7, 0x8E, 0x7F, 0xE3, 0xFC, 0x1F,
  0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0xFE, 0x3F, 0xCF, 0xFB, 0x9E,
  0xE3, 0xB8, 0xEE, 0x7B, 0x9E, 0xFF, 0x3F, 0x8E, 0xE3, 0xBC, 0xE7, 0x39,
  0xEE, 0x3B, 0x8F, 0xE3, 0xC0, 0x3F, 0x7F, 0xFF, 0xE1, 0xE0, 0xE0, 0xF0,
  0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x07, 0x87, 0xFF, 0xFE, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7F, 0xFD, 0xFE, 0x3F, 0x00, 0xE0, 0x7E, 0x07, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x38, 0xC3, 0x9C, 0x39, 0xC3, 0x9C, 0x19, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE1, 0xC1, 0xF8, 0x78,
  0x7E, 0x1E, 0x3F, 0xC7, 0x8E, 0x71, 0xE3, 0x9C, 0xF8, 0xE7, 0x3F, 0x39,
  0xCF, 0xCE, 0x73, 0x77, 0x8E, 0xCD, 0xC3, 0xF3, 0x70, 0xFC, 0xFC, 0x3F,
  0x3F, 0x0F, 0xCF, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x00, 0xF1,
  0xEE, 0x39, 0xE7, 0x1D, 0xC3, 0xB8, 0x3F, 0x07, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0x7E, 0x1F, 0xC3, 0xB8, 0x73, 0x9C, 0x73, 0x8F, 0xF0, 0xE0, 0xF0,
  0xEE, 0x3D, 0xC7, 0x3C, 0xE3, 0xBC, 0x77, 0x07, 0xE0, 0xF8, 0x1F, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xFF,
  0xBF, 0xEF, 0xF8, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0xFF,
  0xFC, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0xFF,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFF,
  0x80, 0x0C, 0x01, 0xC0, 0x78, 0x0F, 0x83, 0xB0, 0x77, 0x1C, 0x63, 0x8E,
  0xE1, 0xDC, 0x1C, 0xFF, 0xFF, 0xF0, 0xF1, 0xE3, 0xC0, 0x7F, 0x3F, 0x99,
  0xE0, 0x70, 0x39, 0xFF, 0xFF, 0xC7, 0xE3, 0xF3, 0xFD, 0xFF, 0xF7, 0xB8,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3B, 0xCE, 0xFB, 0xEF, 0xF1, 0xFC,
  0x7E, 0x1F, 0x87, 0xE1, 0xFC, 0x7F, 0x1F, 0xEF, 0xFF, 0xBB, 0xC0, 0x3F,
  0x7F, 0x7A, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xFF, 0x7F, 0x3E,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xCF, 0x77, 0xFF, 0xDF, 0xE3, 0xF8,
  0xFE, 0x1F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0xDF, 0x7F, 0xCF, 0x70, 0x3E,
  0x3F, 0xBC, 0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x1C, 0x6F,
  0xF3, 0xF0, 0x1F, 0x3F, 0x3E, 0x38, 0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3D, 0xDF, 0xFF, 0x7F,
  0x8F, 0xE3, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xF8, 0xFF, 0xFD, 0xF7, 0x3D,
  0xC0, 0x70, 0x3A, 0x0E, 0xFF, 0xBF, 0xC3, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3B, 0xCF, 0xFB, 0xEF, 0xF3, 0xFC, 0x7F, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0xEF, 0xE0, 0x0E, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0x38, 0xF3, 0x80, 0x00, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3B, 0xEF, 0xB8, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE3, 0xBC, 0xE7, 0x9C, 0xF7, 0x1F, 0xC3,
  0xB8, 0x7F, 0x0F, 0xF1, 0xEE, 0x3C, 0xE7, 0x9C, 0xF1, 0xDE, 0x3C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xEF, 0xBE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF3, 0xCF, 0xF3, 0xCF, 0xF3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF,
  0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF, 0xEF, 0xBF, 0xEF, 0xBF,
  0xCF, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xC0, 0x3F, 0x1F, 0xEF, 0x7B, 0x8E, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0xE7, 0xF9, 0xFC, 0x3E, 0x00, 0xEF, 0x3B, 0xEF, 0xBF, 0xC7, 0xF1,
  0xF8, 0x7E, 0x1F, 0x87, 0xF1, 0xFC, 0x7F, 0xFF, 0xBE, 0xEF, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x3D, 0xDF, 0xFF, 0x7F, 0x8F, 0xE3,
  0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8, 0xFF, 0xFD, 0xF7, 0x3D, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0xEF, 0xDF, 0xFF, 0x8F, 0x1E, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x7F, 0xFF, 0x9F, 0x0F, 0x1F, 0x1F,
  0x1F, 0x0F, 0x1F, 0xFF, 0xFF, 0xC0, 0x38, 0x70, 0xE3, 0xFF, 0xE7, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0xCF, 0x8F, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8F, 0xE3, 0xFC, 0xF7, 0xFD, 0xFF, 0x3D,
  0xC0, 0xE1, 0xEE, 0x39, 0xC7, 0x38, 0xE7, 0x38, 0x77, 0x0E, 0xE1, 0xDC,
  0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0xE3, 0xC7, 0xF3, 0xC7, 0x73,
  0xC7, 0x73, 0xEE, 0x73, 0x6E, 0x77, 0x6E, 0x3E, 0x6E, 0x3E, 0x6C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x1E, 0x3C, 0x1E, 0x38, 0xF3, 0xDC, 0xE7,
  0xB8, 0xFC, 0x3F, 0x07, 0x81, 0xE0, 0x7C, 0x3F, 0x0F, 0xC7, 0x39, 0xCE,
  0xF1, 0xC0, 0xF1, 0xEE, 0x39, 0xC7, 0x38, 0xE7, 0x38, 0x77, 0x0E, 0xE1,
  0xDC, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x7C, 0x0F, 0x01, 0x80, 0x00, 0x7F, 0x7F, 0x7F, 0x0E, 0x0E, 0x1C, 0x1C,
  0x38, 0x38, 0x78, 0x7F, 0xFF, 0xFF, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x3D, 0xF3, 0xC7, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x78, 0xF0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE1,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7C, 0x79, 0xF3, 0x87, 0x0E, 0x1C,
  0x38, 0xF3, 0xC7, 0x8E, 0x00, 0xF8, 0xFF, 0xF8, 0xFA, 0x00,
};

const GFXglyph NotoSans_ExtraCondensed_Bold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 17, 6, 1, -17 },
  { 10, 9, 6, 11, 1, -17 },
  { 17, 12, 17, 12, 0, -17 },
  { 43, 9, 19, 11, 1, -18 },
  { 65, 17, 17, 19, 1, -17 },
  { 102, 12, 17, 13, 1, -17 },
  { 128, 4, 6, 6, 1, -17 },
  { 131, 6, 21, 8, 1, -17 },
  { 147, 6, 21, 8, 0, -17 },
  { 163, 10, 9, 11, 0, -18 },
  { 175, 9, 11, 11, 1, -14 },
  { 188, 4, 6, 6, 1, -3 },
  { 191, 6, 3, 7, 1, -8 },
  { 194, 4, 4, 6, 1, -4 },
  { 196, 10, 17, 10, 0, -17 },
  { 218, 9, 17, 11, 1, -17 },
  { 238, 7, 17, 11, 1, -17 },
  { 253, 9, 17, 11, 1, -17 },
  { 273, 9, 17, 11, 1, -17 },
  { 293, 11, 17, 11, 0, -17 },
  { 317, 9, 17, 11, 1, -17 },
  { 337, 9, 17, 11, 1, -17 },
  { 357, 10, 17, 11, 0, -17 },
  { 379, 9, 17, 11, 1, -17 },
  { 399, 9, 17, 11, 1, -17 },
  { 419, 4, 13, 6, 1, -13 },
  { 426, 4, 16, 6, 1, -13 },
  { 434, 9, 11, 11, 1, -14 },
  { 447, 9, 7, 11, 1, -12 },
  { 455, 10, 11, 11, 1, -14 },
  { 469, 8, 17, 9, 0, -17 },
  { 486, 15, 19, 17, 1, -17 },
  { 522, 13, 17, 13, 0, -17 },
  { 550, 10, 17, 13, 2, -17 },
  { 572, 10, 17, 12, 1, -17 },
  { 594, 10, 17, 13, 2, -17 },
  { 616, 7, 17, 10, 2, -17 },
  { 631, 7, 17, 10, 2, -17 },
  { 646, 11, 17, 14, 1, -17 },
  { 670, 10, 17, 14, 2, -17 },
  { 692, 6, 17, 8, 1, -17 },
  { 705, 6, 22, 7, -1, -17 },
  { 722, 11, 17, 12, 2, -17 },
  { 746, 7, 17, 10, 2, -17 },
  { 761, 15, 17, 19, 2, -17 },
  { 793, 11, 17, 15, 2, -17 },
  { 817, 12, 17, 14, 1, -17 },
  { 843, 9, 17, 12, 2, -17 },
  { 863, 12, 21, 14, 1, -17 },
  { 895, 10, 17, 12, 2, -17 },
  { 917, 8, 17, 10, 1, -17 },
  { 934, 10, 17, 10, 0, -17 },
  { 956, 10, 17, 14, 2, -17 },
  { 978, 12, 17, 12, 0, -17 },
  { 1004, 18, 17, 18, 0, -17 },
  { 1043, 11, 17, 11, 0, -17 },
  { 1067, 11, 17, 11, 0, -17 },
  { 1091, 10, 17, 10, 0, -17 },
  { 1113, 6, 21, 7, 1, -17 },
  { 1129, 10, 17, 10, 0, -17 },
  { 1151, 5, 21, 7, 1, -17 },
  { 1165, 11, 10, 13, 1, -17 },
  { 1179, 10, 2, 10, 0, 2 },
  { 1182, 6, 3, 7, 1, -18 },
  { 1185, 9, 13, 11, 1, -13 },
  { 1200, 10, 18, 12, 1, -18 },
  { 1223, 8, 13, 10, 1, -13 },
  { 1236, 10, 18, 12, 1, -18 },
  { 1259, 9, 13, 11, 1, -13 },
  { 1274, 8, 18, 7, 0, -18 },
  { 1292, 10, 19, 12, 1, -13 },
  { 1316, 10, 18, 12, 1, -18 },
  { 1339, 4, 18, 6, 1, -18 },
  { 1348, 6, 24, 6, -1, -18 },
  { 1366, 11, 18, 12, 1, -18 },
  { 1391, 3, 18, 6, 1, -18 },
  { 1398, 16, 13, 18, 1, -13 },
  { 1424, 10, 13, 12, 1, -13 },
  { 1441, 10, 13, 12, 1, -13 },
  { 1458, 10, 19, 12, 1, -13 },
  { 1482, 10, 19, 12, 1, -13 },
  { 1506, 7, 13, 8, 1, -13 },
  { 1518, 7, 13, 9, 1, -13 },
  { 1530, 7, 16, 8, 0, -16 },
  { 1544, 10, 13, 12, 1, -13 },
  { 1561, 11, 13, 11, 0, -13 },
  { 1579, 16, 13, 16, 0, -13 },
  { 1605, 10, 13, 10, 0, -13 },
  { 1622, 11, 19, 11, 0, -13 },
  { 1649, 8, 13, 9, 0, -13 },
  { 1662, 7, 21, 8, 0, -17 },
  { 1681, 3, 24, 11, 4, -18 },
  { 1690, 7, 21, 8, 1, -17 },
  { 1709, 10, 4, 11, 1, -10 },
};

const GFXfont NotoSans_ExtraCondensed_Bold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraCondensed_Bold24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraCondensed_Bold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRACONDENSED_BOLD24PT7B_H_
