#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC65PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0x08, 0x00, 0x00, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0E,
  0x3C, 0x0E, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x30,
  0xE0, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x7E, 0x73, 0xF0, 0x07, 0x83, 0x03,
  0x80, 0x78, 0x18, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x03,
  0xC0, 0x60, 0x00, 0x1E, 0x03, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x60, 0x00, 0x07, 0x83, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0xEE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x67, 0xC0, 0x00, 0x07, 0x1F,
  0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0C, 0x0F, 0x00,
  0x00, 0x60, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0C, 0x07, 0x80, 0x00, 0x60, 0x38, 0x00, 0x07, 0x03,
  0xC0, 0x80, 0x38, 0x3C, 0x06, 0x01, 0xC3, 0xE0, 0x3F, 0x0D, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0x80, 0x7F,
  0xF0, 0x00, 0x1C, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x0E, 0x07, 0x80, 0x03,
  0x80, 0x78, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0xF0, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x1C, 0x00,
  0x38, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x03, 0x80, 0x1C,
  0x1C, 0x00, 0x0E, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x03, 0x83, 0x83, 0xF8,
  0xE0, 0x0E, 0x1C, 0x3F, 0xF3, 0x80, 0x70, 0xF1, 0xFF, 0xEE, 0x01, 0xC3,
  0x87, 0x03, 0xB8, 0x0E, 0x1C, 0x38, 0x0E, 0xE0, 0x78, 0x71, 0xE0, 0x3F,
  0xC3, 0xC3, 0x87, 0x00, 0x77, 0xFE, 0x1E, 0x3C, 0x01, 0xCF, 0xF0, 0x70,
  0xE0, 0x07, 0x1F, 0x03, 0x83, 0x80, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0xF0,
  0x00, 0x70, 0x70, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x38, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0xF0, 0x03, 0x80,
  0x1E, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x3C, 0x03, 0x80, 0x01, 0xC1, 0xE0, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x70,
  0x00, 0x0F, 0xF8, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F,
  0x80, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x00,
  0xFC, 0x78, 0x00, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x3E, 0x03, 0xC0, 0x0E,
  0x0F, 0x00, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x01, 0xC3, 0xC0, 0x03, 0xC0,
  0xF0, 0xE0, 0x00, 0xF0, 0x38, 0x78, 0x00, 0x1E, 0x1E, 0x1E, 0x00, 0x07,
  0x8F, 0x07, 0x00, 0x00, 0xF3, 0xC1, 0xC0, 0x00, 0x3D, 0xE0, 0xF0, 0x00,
  0x07, 0xF0, 0x3C, 0x00, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x3E, 0x01, 0xC0,
  0x00, 0x1F, 0x80, 0x78, 0x00, 0x0F, 0xE0, 0x1E, 0x00, 0x07, 0xFC, 0x07,
  0xC0, 0x03, 0xEF, 0x00, 0xF8, 0x03, 0xE1, 0xE0, 0x1F, 0xFF, 0xF0, 0x78,
  0x03, 0xFF, 0xF8, 0x0F, 0x00, 0x7F, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x86,
  0x1C, 0x38, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x02, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x18,
  0x00, 0xFE, 0x0C, 0x00, 0x0F, 0xC6, 0x00, 0x01, 0xFF, 0x07, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xDC, 0x00, 0x03, 0xC6, 0x00, 0x03, 0xC3, 0x80, 0x03, 0xC1, 0xC0, 0x03,
  0xC0, 0x70, 0x03, 0xC0, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x20, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70,
  0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x39, 0xF7, 0xFF, 0xF9, 0xE2, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0x00,
  0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xEE, 0x0F, 0xDE, 0x1F, 0x1E, 0x3E,
  0x1C, 0xFC, 0x1C, 0x70, 0x3C, 0x60, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x03, 0x00, 0x07, 0x80, 0x04, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x02, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xC0, 0x01, 0xF0, 0x04, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x0C, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03,
  0xC7, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x83,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x38, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x78, 0x01, 0xC0, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x00, 0x78, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3B, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x03, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xE0, 0x20, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x38,
  0x7F, 0xF0, 0x03, 0xC7, 0xFF, 0xC0, 0x1E, 0xFC, 0x3F, 0x00, 0xEF, 0x00,
  0x7C, 0x07, 0x70, 0x01, 0xE0, 0x7E, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x3C,
  0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x38, 0x3C,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x0E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x03,
  0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1C, 0x01,
  0xE0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x01,
  0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xF0, 0x1E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x7C, 0x01, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3E,
  0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0xE0, 0x7C,
  0x03, 0xDC, 0x03, 0xFF, 0xF9, 0xC0, 0x1F, 0xFE, 0x3C, 0x00, 0xFF, 0xC3,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x08, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0xF0,
  0x3E, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x78, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x02,
  0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xE1,
  0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0xFC, 0x01, 0xC3, 0xC0,
  0x07, 0xFF, 0xC0, 0x38, 0x70, 0x01, 0xF0, 0xF8, 0x07, 0x1E, 0x00, 0xF8,
  0x07, 0x00, 0xE3, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0x9C, 0x01, 0xE0, 0x07, 0x00, 0x73, 0x80, 0x38, 0x01, 0xE0, 0x0E,
  0xF0, 0x0E, 0x00, 0x38, 0x01, 0xDC, 0x01, 0xC0, 0x07, 0x00, 0x3B, 0x80,
  0x70, 0x00, 0xE0, 0x0F, 0x70, 0x0E, 0x00, 0x3C, 0x01, 0xDE, 0x03, 0xC0,
  0x07, 0x00, 0x3B, 0x80, 0x70, 0x00, 0xE0, 0x07, 0x70, 0x0E, 0x00, 0x1C,
  0x01, 0xEE, 0x01, 0xC0, 0x07, 0x80, 0x39, 0xC0, 0x38, 0x00, 0xE0, 0x07,
  0x38, 0x07, 0x00, 0x3C, 0x01, 0xC7, 0x00, 0xE0, 0x07, 0x80, 0x38, 0xE0,
  0x1C, 0x01, 0xF0, 0x0E, 0x1C, 0x03, 0x80, 0x3E, 0x03, 0xC3, 0x80, 0x78,
  0x0C, 0xC0, 0xF0, 0x70, 0x07, 0x87, 0x9C, 0x3C, 0x0E, 0x00, 0xFF, 0xE3,
  0xFF, 0x01, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3C, 0x00, 0x7C, 0x01, 0xE0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0xFC, 0x00,
  0x70, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xF0, 0x03,
  0x80, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x38,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x3F, 0x00, 0x70, 0x01, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x06, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x06, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xE0, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x1C,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF0,
  0x0E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x7E, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x78, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x3F, 0x80, 0x07, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x00, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8, 0x70, 0x00,
  0x1F, 0xFF, 0x1E, 0x00, 0x03, 0xFF, 0xE3, 0xC0, 0x00, 0xFF, 0xF8, 0x78,
  0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x03, 0xDF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x00, 0x1C,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x0E, 0x1F, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0x9E, 0x00, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x01, 0xF8, 0x78, 0x00,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x1D, 0xC0,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0xEF, 0x00,
  0x77, 0x80, 0x00, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x38, 0x01,
  0xCE, 0x00, 0x00, 0x1E, 0xF0, 0x07, 0x9C, 0x00, 0x00, 0x39, 0xE0, 0x0F,
  0x38, 0x00, 0x00, 0xF3, 0xC0, 0x1C, 0x70, 0x00, 0x03, 0xC7, 0x00, 0x38,
  0xE0, 0x00, 0x07, 0x9E, 0x00, 0x71, 0xC0, 0x00, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x00, 0x38, 0x78, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xE0, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x3C, 0x1C,
  0x00, 0x0E, 0x0F, 0x00, 0x78, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x70,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x03, 0x81, 0xC0,
  0x03, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80,
  0x1C, 0x07, 0x80, 0x3C, 0x07, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x0E, 0x01,
  0xE0, 0x3C, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x38, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0x70, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x78,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0xC3, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x39, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x77, 0x80, 0x0F,
  0x00, 0x78, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x38,
  0x01, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x01,
  0xF8, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x00,
  0x03, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00,
  0x73, 0x80, 0x00, 0x3C, 0x00, 0xE7, 0x00, 0x00, 0x78, 0x01, 0xCF, 0x00,
  0x00, 0xE0, 0x07, 0x9E, 0x00, 0x01, 0xC0, 0x0F, 0x1C, 0x00, 0x07, 0x80,
  0x1C, 0x3C, 0x00, 0x0F, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x00, 0x70, 0x70,
  0x00, 0x38, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0x07, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x07,
  0x80, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x1E,
  0x00, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x70, 0x03, 0xC0,
  0x01, 0xC0, 0xE0, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x0E, 0x00, 0x07, 0x87,
  0x80, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0xF0,
  0x00, 0x1E, 0x38, 0x01, 0xE0, 0x00, 0x3C, 0xF0, 0x03, 0x80, 0x00, 0x39,
  0xE0, 0x07, 0x00, 0x00, 0x7B, 0x80, 0x1E, 0x00, 0x00, 0xF7, 0x00, 0x3C,
  0x00, 0x00, 0xEE, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x03,
  0xF8, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x1F, 0x80, 0x07, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0x80, 0x7F,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x80,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00,
  0x0F, 0x3E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0xF8, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x1F, 0xC0, 0x07, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x01, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x7E, 0x00, 0x38, 0x03,
  0xE0, 0x00, 0x20, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x0C, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x7F,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x78, 0x07,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x38, 0x03, 0xC0,
  0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x38, 0x00,
  0x07, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xC7, 0x00, 0x07, 0x87, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x0F, 0x00, 0x0F,
  0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x3C, 0x00, 0x78,
  0x70, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC1,
  0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x07,
  0x00, 0x38, 0x07, 0x80, 0x38, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x1C,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x80, 0x3C, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0x78, 0x0F, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x01, 0xC0,
  0x78, 0x01, 0xE0, 0x78, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0xE0, 0x07, 0x03,
  0xC0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x1C, 0x1E,
  0x00, 0x1E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0xF0,
  0x00, 0x78, 0x70, 0x00, 0xE1, 0xE0, 0x00, 0x71, 0xE0, 0x01, 0xC3, 0x80,
  0x00, 0xE3, 0x80, 0x03, 0x8F, 0x00, 0x01, 0xCF, 0x00, 0x07, 0x1C, 0x00,
  0x03, 0x9C, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0xEE, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x00, 0x3C, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x7C, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x01,
  0xE0, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x01,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C,
  0x0F, 0x01, 0xC0, 0x70, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0x38,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x3C,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0xE0, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x1E, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x01, 0xC0, 0x60, 0x00, 0x0F, 0xE0, 0x70, 0x03, 0xFF, 0x87, 0x00,
  0xFF, 0xFC, 0x70, 0x1F, 0x81, 0xCF, 0x03, 0xE0, 0x0E, 0xE0, 0x7C, 0x00,
  0x6E, 0x07, 0x80, 0x07, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78,
  0x70, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x70, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xE0, 0xE0,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x1D,
  0xC0, 0x78, 0x03, 0x9C, 0x07, 0xC0, 0x71, 0xC0, 0x3F, 0xFE, 0x38, 0x01,
  0xFF, 0xC3, 0x80, 0x0F, 0xF8, 0x38, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x81, 0xFC, 0x00, 0x3C, 0x3F, 0xF8, 0x01, 0xE3, 0xFF, 0xE0,
  0x0E, 0x3C, 0x1F, 0x80, 0x73, 0x80, 0x3C, 0x03, 0xB8, 0x01, 0xE0, 0x3F,
  0x80, 0x07, 0x81, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x7C, 0x00,
  0x07, 0x07, 0xC0, 0x00, 0x38, 0x3E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0xFE, 0x00,
  0x3E, 0x07, 0x30, 0x03, 0xE0, 0x39, 0xC0, 0x3E, 0x01, 0xC7, 0xFF, 0xE0,
  0x0E, 0x3F, 0xFE, 0x00, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x0E,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xC0,
  0x1F, 0xEF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x78,
  0x00, 0x3F, 0xF8, 0x70, 0x00, 0xFF, 0xFC, 0x70, 0x01, 0xF8, 0x1E, 0x70,
  0x03, 0xE0, 0x0E, 0xF0, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0x80, 0x03, 0xE0,
  0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x1F, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0xF0, 0x01, 0xDC, 0x00, 0x78, 0x03, 0xDC, 0x00,
  0x7C, 0x07, 0x9C, 0x00, 0x3F, 0xFF, 0x1C, 0x00, 0x1F, 0xFC, 0x1C, 0x00,
  0x0F, 0xF8, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x01, 0xF8, 0x1E, 0x03, 0xE0, 0x0F, 0x03,
  0xC0, 0x0F, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x3E, 0x78,
  0x00, 0x7C, 0x78, 0x01, 0xF8, 0x70, 0x0F, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x10, 0x3E, 0x00, 0x60, 0x1F, 0xEF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFE,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x04,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x0E, 0x00, 0x1F, 0xFC,
  0x38, 0x00, 0xFF, 0xFC, 0x70, 0x03, 0xF0, 0x3C, 0xE0, 0x0F, 0x80, 0x39,
  0xC0, 0x3E, 0x00, 0x3F, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7C,
  0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x1C, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x03, 0xE0, 0x38, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x1F, 0x00, 0xE0, 0x00,
  0x7E, 0x01, 0xE0, 0x00, 0xFC, 0x03, 0xC0, 0x03, 0xF8, 0x07, 0x80, 0x0E,
  0xF0, 0x07, 0x80, 0x3D, 0xC0, 0x0F, 0x80, 0xF3, 0x80, 0x0F, 0xFF, 0xCF,
  0x00, 0x0F, 0xFE, 0x1E, 0x00, 0x0F, 0xF8, 0x38, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x10,
  0x00, 0x3E, 0x00, 0x38, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x7F, 0x00, 0x1E, 0x1F, 0xFC, 0x01, 0xE3, 0xFF, 0xE0, 0x1C,
  0xF8, 0x3F, 0x01, 0xCE, 0x00, 0xF0, 0x1D, 0xC0, 0x0F, 0x03, 0xF8, 0x00,
  0x70, 0x3F, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x70, 0x3E, 0x00, 0x07, 0x07,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x1E, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x78, 0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x1E,
  0x00, 0x7C, 0x01, 0xC0, 0x0F, 0x80, 0x1C, 0x01, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0xF0,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x00,
  0xEF, 0xF0, 0x00, 0x0F, 0xEF, 0x00, 0x00, 0xFC, 0x78, 0x00, 0x1F, 0x87,
  0x80, 0x01, 0xF0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00,
  0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x38, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78,
  0x07, 0x80, 0x07, 0x80, 0x70, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0xFF, 0x00, 0x3F, 0x80, 0x0E,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x71, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0x9E,
  0x0F, 0x87, 0x83, 0xE0, 0x1D, 0xE0, 0x1E, 0x70, 0x0F, 0x80, 0xEC, 0x00,
  0xF7, 0x00, 0x3C, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x7F, 0x80, 0x1C, 0x1F, 0xFC, 0x01, 0xC7, 0xFF, 0xE0, 0x1C, 0xF8, 0x3F,
  0x01, 0xDE, 0x00, 0xF0, 0x3D, 0xC0, 0x0F, 0x03, 0xF8, 0x00, 0x70, 0x3F,
  0x00, 0x07, 0x03, 0xE0, 0x00, 0x70, 0x3E, 0x00, 0x07, 0x07, 0xC0, 0x00,
  0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38, 0x3C, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0x38, 0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0xFC, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x0F, 0x1C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x1C, 0x0F, 0xE0, 0x00, 0x38, 0x3F, 0xF8, 0x00,
  0x38, 0x7F, 0xFC, 0x00, 0x38, 0xF0, 0x7E, 0x00, 0x39, 0xC0, 0x1E, 0x00,
  0x3B, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x7E, 0x00, 0x0F, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x07, 0x00,
  0xF8, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0xE0, 0x03, 0xE0, 0x0F, 0x60, 0x07, 0xC0, 0x0F, 0x70, 0x0F, 0x80, 0x0E,
  0x3F, 0xFF, 0x00, 0x0E, 0x1F, 0xFE, 0x00, 0x1E, 0x0F, 0xF8, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x38, 0x01, 0xFF, 0xC3, 0x80, 0x3F, 0xFF, 0x1C, 0x03, 0xF0,
  0x3C, 0xE0, 0x3E, 0x00, 0xE7, 0x03, 0xE0, 0x03, 0xF8, 0x1E, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x07,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0xE0, 0xE0, 0x00, 0x1F, 0x07, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0xEF, 0x01,
  0xE0, 0x0F, 0x70, 0x0F, 0x80, 0xF3, 0x80, 0x3F, 0xFF, 0x3C, 0x00, 0xFF,
  0xE1, 0xE0, 0x03, 0xFE, 0x0E, 0x00, 0x03, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0xFE, 0x03, 0x83, 0xFC, 0x07, 0x1F, 0xF8, 0x0E, 0x7E,
  0x20, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x03, 0xF0, 0x1E, 0x07, 0xC0, 0x02, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x80, 0x01, 0xE0, 0xE0, 0x07, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xD0, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xFD, 0xE0, 0x3F, 0xF0, 0x0F,
  0xF8, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF0,
  0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xDC, 0x0F, 0x00, 0x1D,
  0xC0, 0xF0, 0x03, 0xBC, 0x0F, 0x80, 0xF3, 0x80, 0x7F, 0x7E, 0x38, 0x03,
  0xFF, 0xC3, 0x80, 0x1F, 0xF0, 0x38, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x0E, 0x03, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x1C, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x03, 0x9E,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x3B, 0x80, 0x03,
  0xE0, 0x00, 0xF7, 0x00, 0x07, 0xC0, 0x01, 0xCE, 0x00, 0x1F, 0x80, 0x07,
  0x9C, 0x00, 0x3F, 0x00, 0x0F, 0x38, 0x00, 0x7E, 0x00, 0x3C, 0x70, 0x01,
  0xDC, 0x00, 0x78, 0xE0, 0x03, 0xB8, 0x00, 0xE1, 0xC0, 0x0E, 0x70, 0x03,
  0xC3, 0x80, 0x1C, 0xF0, 0x07, 0x07, 0x80, 0x79, 0xE0, 0x1E, 0x0F, 0x00,
  0xE3, 0xC0, 0x38, 0x1E, 0x03, 0xC3, 0x80, 0xF0, 0x3C, 0x07, 0x07, 0x01,
  0xE0, 0x78, 0x1E, 0x0E, 0x07, 0x80, 0xF0, 0x38, 0x1C, 0x0F, 0x01, 0xE0,
  0x70, 0x38, 0x1C, 0x03, 0xC1, 0xC0, 0x70, 0x78, 0x07, 0x83, 0x80, 0xE0,
  0xE0, 0x0F, 0x0E, 0x01, 0xC3, 0xC0, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0x3C,
  0x78, 0x07, 0x1E, 0x00, 0x78, 0xE0, 0x0E, 0x3C, 0x00, 0xF3, 0xC0, 0x1C,
  0x70, 0x01, 0xE7, 0x00, 0x39, 0xE0, 0x01, 0xDE, 0x00, 0x73, 0x80, 0x03,
  0xB8, 0x00, 0xEF, 0x00, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x0F, 0xC0, 0x03,
  0xB8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x07, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0x03, 0xB8,
  0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xBF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x2F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFD, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 47, 15, 1, -46 },
  { 90, 16, 16, 22, 7, -46 },
  { 122, 35, 46, 35, 1, -46 },
  { 324, 29, 53, 31, 2, -49 },
  { 517, 38, 48, 46, 5, -47 },
  { 745, 34, 48, 37, 1, -47 },
  { 949, 7, 16, 12, 7, -46 },
  { 963, 19, 56, 17, 2, -46 },
  { 1096, 20, 56, 17, -5, -46 },
  { 1236, 25, 25, 30, 7, -49 },
  { 1315, 27, 30, 33, 4, -38 },
  { 1417, 11, 15, 13, -3, -7 },
  { 1438, 15, 3, 19, 2, -19 },
  { 1444, 6, 7, 14, 1, -6 },
  { 1450, 29, 46, 21, -3, -46 },
  { 1617, 28, 48, 31, 3, -47 },
  { 1785, 16, 46, 31, 9, -46 },
  { 1877, 31, 47, 31, -1, -47 },
  { 2060, 30, 48, 31, 0, -47 },
  { 2240, 30, 47, 31, 0, -47 },
  { 2417, 30, 47, 31, 1, -46 },
  { 2594, 29, 48, 31, 3, -47 },
  { 2768, 28, 46, 31, 5, -46 },
  { 2929, 29, 48, 31, 2, -47 },
  { 3103, 28, 48, 31, 2, -47 },
  { 3271, 12, 36, 14, 1, -35 },
  { 3325, 16, 43, 14, -3, -35 },
  { 3411, 27, 29, 33, 4, -38 },
  { 3509, 27, 16, 33, 4, -31 },
  { 3563, 27, 29, 33, 4, -38 },
  { 3661, 21, 48, 23, 4, -47 },
  { 3787, 43, 52, 48, 3, -46 },
  { 4067, 32, 47, 32, -4, -47 },
  { 4255, 32, 46, 34, 2, -46 },
  { 4439, 32, 48, 33, 4, -47 },
  { 4631, 34, 46, 38, 2, -46 },
  { 4827, 30, 46, 30, 2, -46 },
  { 5000, 30, 46, 28, 2, -46 },
  { 5173, 35, 48, 39, 4, -47 },
  { 5383, 37, 46, 39, 2, -46 },
  { 5596, 23, 46, 17, -2, -46 },
  { 5729, 25, 58, 15, -10, -46 },
  { 5911, 35, 46, 32, 2, -46 },
  { 6113, 21, 46, 28, 2, -46 },
  { 6234, 47, 46, 49, 2, -46 },
  { 6505, 39, 46, 40, 2, -46 },
  { 6730, 35, 48, 41, 4, -47 },
  { 6940, 31, 46, 32, 2, -46 },
  { 7119, 35, 58, 41, 4, -47 },
  { 7373, 31, 46, 33, 2, -46 },
  { 7552, 30, 48, 29, 0, -47 },
  { 7732, 27, 46, 28, 6, -46 },
  { 7888, 36, 47, 39, 4, -46 },
  { 8100, 31, 46, 31, 6, -46 },
  { 8279, 47, 46, 50, 7, -46 },
  { 8550, 38, 46, 29, -4, -46 },
  { 8769, 28, 46, 28, 6, -46 },
  { 8930, 34, 46, 30, -1, -46 },
  { 9126, 24, 56, 19, -1, -46 },
  { 9294, 10, 46, 21, 7, -46 },
  { 9352, 24, 56, 19, -4, -46 },
  { 9520, 29, 27, 33, 2, -47 },
  { 9618, 23, 3, 22, -6, 6 },
  { 9627, 9, 11, 16, 9, -50 },
  { 9640, 28, 36, 33, 3, -35 },
  { 9766, 29, 50, 33, 1, -49 },
  { 9948, 24, 36, 26, 3, -35 },
  { 10056, 32, 50, 33, 3, -49 },
  { 10256, 24, 36, 29, 3, -35 },
  { 10364, 33, 66, 17, -8, -50 },
  { 10637, 31, 51, 33, 1, -35 },
  { 10835, 28, 49, 32, 1, -49 },
  { 11007, 14, 47, 14, 1, -47 },
  { 11090, 24, 63, 14, -9, -47 },
  { 11279, 28, 49, 27, 1, -49 },
  { 11451, 14, 49, 14, 1, -49 },
  { 11537, 45, 35, 49, 1, -35 },
  { 11734, 28, 35, 32, 1, -35 },
  { 11857, 27, 36, 32, 3, -35 },
  { 11979, 32, 50, 33, -2, -35 },
  { 12179, 29, 50, 33, 3, -35 },
  { 12361, 23, 35, 22, 1, -35 },
  { 12462, 24, 36, 25, 0, -35 },
  { 12570, 17, 44, 18, 3, -43 },
  { 12664, 28, 36, 33, 3, -35 },
  { 12790, 25, 35, 25, 3, -35 },
  { 12900, 39, 35, 40, 4, -35 },
  { 13071, 30, 35, 27, -2, -35 },
  { 13203, 36, 51, 26, -7, -35 },
  { 13433, 26, 35, 24, -1, -35 },
  { 13547, 24, 56, 22, 1, -46 },
  { 13715, 3, 65, 31, 15, -49 },
  { 13740, 23, 56, 22, -3, -46 },
  { 13901, 27, 7, 33, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic65pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC65PT7B_H_
