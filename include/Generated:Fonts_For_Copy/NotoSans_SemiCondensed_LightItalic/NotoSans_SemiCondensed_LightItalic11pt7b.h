#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x29, 0x24, 0x84, 0xB6, 0x80, 0x14, 0xA7, 0xCA, 0x2B, 0xE5, 0x14,
  0x1B, 0x94, 0x43, 0x16, 0xCC, 0x40, 0x66, 0xAA, 0xAF, 0xF4, 0xD5, 0x67,
  0x38, 0xA2, 0x8C, 0x56, 0x58, 0x9E, 0xE0, 0x32, 0x44, 0x88, 0x88, 0x84,
  0x24, 0x92, 0x49, 0x50, 0xA5, 0x6A, 0x44, 0xF4, 0x40, 0xC0, 0xE0, 0x80,
  0x08, 0x44, 0x22, 0x11, 0x18, 0x3A, 0x52, 0x98, 0xC6, 0x4E, 0x75, 0x6A,
  0x78, 0x42, 0x11, 0x11, 0x1E, 0x78, 0x42, 0x61, 0x04, 0x3E, 0x08, 0xCA,
  0x55, 0x7C, 0x42, 0x3A, 0x10, 0xE0, 0x84, 0x3E, 0x34, 0x8E, 0x99, 0x9E,
  0xF8, 0x84, 0x42, 0x22, 0x10, 0x3A, 0x52, 0x65, 0x46, 0x2E, 0x3A, 0x52,
  0x97, 0x84, 0x5C, 0x40, 0x20, 0x20, 0x00, 0xB0, 0x3C, 0xC2, 0x10, 0xF0,
  0xF0, 0xC3, 0x34, 0x80, 0xE4, 0xA9, 0x04, 0x1E, 0x21, 0x4D, 0x55, 0xA5,
  0xA9, 0x96, 0x40, 0x38, 0x08, 0x61, 0x89, 0x3D, 0x14, 0x61, 0x38, 0x94,
  0x5E, 0x49, 0x28, 0xBC, 0x3A, 0x21, 0x08, 0x42, 0x1E, 0x39, 0x14, 0x51,
  0x45, 0x18, 0xBC, 0x3A, 0x10, 0xF4, 0x22, 0x1E, 0x3A, 0x10, 0x97, 0x22,
  0x10, 0x3D, 0x08, 0x20, 0x9A, 0x28, 0xBC, 0x22, 0x45, 0x13, 0xE4, 0x48,
  0xA1, 0x44, 0x72, 0x44, 0x44, 0x4C, 0x08, 0x44, 0x21, 0x08, 0x84, 0x26,
  0x00, 0x25, 0x25, 0x18, 0x51, 0x49, 0x22, 0x22, 0x44, 0x44, 0x8F, 0x21,
  0x21, 0x63, 0x65, 0x55, 0x5A, 0x9A, 0x92, 0x22, 0x45, 0x4A, 0xA5, 0x49,
  0xA3, 0x44, 0x39, 0x18, 0x61, 0x86, 0x28, 0xBC, 0x39, 0x14, 0x52, 0x71,
  0x08, 0x20, 0x39, 0x18, 0x61, 0x86, 0x28, 0xBC, 0x20, 0x40, 0x39, 0x14,
  0x52, 0x71, 0x49, 0x22, 0x3A, 0x10, 0x41, 0x08, 0x5E, 0xF9, 0x10, 0x84,
  0x21, 0x10, 0x46, 0x18, 0xA2, 0x8A, 0x29, 0x3C, 0x8C, 0x65, 0x2A, 0x53,
  0x08, 0x89, 0x99, 0x9A, 0xAA, 0xAA, 0xCC, 0xC8, 0x88, 0x22, 0x48, 0x60,
  0x81, 0x05, 0x12, 0x64, 0x8C, 0xA9, 0x44, 0x21, 0x10, 0x7C, 0x21, 0x04,
  0x21, 0x08, 0x3C, 0x34, 0x44, 0x44, 0x88, 0x8C, 0xAA, 0x55, 0x31, 0x11,
  0x12, 0x22, 0x2C, 0x11, 0x92, 0x98, 0x80, 0xF0, 0x80, 0x3A, 0x53, 0x19,
  0x38, 0x22, 0x1E, 0x94, 0xA6, 0x3E, 0x3A, 0x21, 0x08, 0x38, 0x04, 0x13,
  0x92, 0x4A, 0x29, 0x1C, 0x32, 0x5D, 0x08, 0x38, 0x18, 0x8C, 0x42, 0x11,
  0x08, 0x42, 0x20, 0x3A, 0x53, 0x19, 0x38, 0x42, 0xE0, 0x22, 0x1E, 0x94,
  0xA6, 0x32, 0x21, 0x24, 0xA4, 0x10, 0x22, 0x22, 0x44, 0x44, 0x80, 0x22,
  0x12, 0xA6, 0x32, 0x52, 0x29, 0x24, 0xA4, 0x7F, 0x49, 0x49, 0x49, 0x92,
  0x92, 0x7A, 0x52, 0x98, 0xC8, 0x32, 0x63, 0x18, 0xB8, 0x7A, 0x52, 0x98,
  0xFA, 0x10, 0x80, 0x3A, 0x53, 0x19, 0x38, 0x42, 0x10, 0x74, 0x44, 0x88,
  0x74, 0x42, 0x1E, 0x4D, 0x25, 0x38, 0x4A, 0x53, 0x19, 0x38, 0x9A, 0xAC,
  0xC8, 0xA6, 0x9D, 0xB6, 0x92, 0x40, 0x4A, 0x88, 0xC6, 0x48, 0x44, 0xA2,
  0x8C, 0x30, 0x82, 0x10, 0x80, 0x71, 0x24, 0x8E, 0x12, 0x22, 0xC4, 0x44,
  0x44, 0xFF, 0xE0, 0x31, 0x11, 0x12, 0x22, 0x2C, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 3, 3, 4, 1, -8 },
  { 6, 6, 8, 6, 0, -8 },
  { 12, 5, 9, 5, 0, -8 },
  { 18, 6, 8, 8, 1, -8 },
  { 24, 6, 8, 6, 0, -8 },
  { 30, 1, 3, 2, 1, -8 },
  { 31, 4, 10, 3, 0, -8 },
  { 36, 3, 10, 3, -1, -8 },
  { 40, 4, 4, 5, 1, -8 },
  { 42, 4, 5, 6, 1, -6 },
  { 45, 1, 2, 2, 0, -1 },
  { 46, 3, 1, 3, 0, -3 },
  { 47, 1, 1, 2, 0, -1 },
  { 48, 5, 8, 4, -1, -8 },
  { 53, 5, 8, 5, 0, -8 },
  { 58, 2, 8, 5, 2, -8 },
  { 60, 5, 8, 5, 0, -8 },
  { 65, 5, 8, 5, 0, -8 },
  { 70, 5, 8, 5, 0, -8 },
  { 75, 5, 8, 5, 0, -8 },
  { 80, 4, 8, 5, 1, -8 },
  { 84, 5, 8, 5, 1, -8 },
  { 89, 5, 8, 5, 0, -8 },
  { 94, 5, 8, 5, 0, -8 },
  { 99, 2, 6, 2, 0, -6 },
  { 101, 3, 7, 2, -1, -6 },
  { 104, 4, 5, 6, 1, -6 },
  { 107, 4, 3, 6, 1, -5 },
  { 109, 4, 5, 6, 1, -6 },
  { 112, 3, 8, 4, 1, -8 },
  { 115, 8, 9, 8, 0, -8 },
  { 124, 6, 8, 5, -1, -8 },
  { 130, 6, 8, 6, 0, -8 },
  { 136, 5, 8, 6, 1, -8 },
  { 141, 6, 8, 6, 0, -8 },
  { 147, 5, 8, 5, 0, -8 },
  { 152, 5, 8, 5, 0, -8 },
  { 157, 6, 8, 7, 1, -8 },
  { 163, 7, 8, 7, 0, -8 },
  { 170, 4, 8, 3, 0, -8 },
  { 174, 5, 10, 2, -2, -8 },
  { 181, 6, 8, 5, 0, -8 },
  { 187, 4, 8, 5, 0, -8 },
  { 191, 8, 8, 8, 0, -8 },
  { 199, 7, 8, 7, 0, -8 },
  { 206, 6, 8, 7, 1, -8 },
  { 212, 6, 8, 5, 0, -8 },
  { 218, 6, 10, 7, 1, -8 },
  { 226, 6, 8, 6, 0, -8 },
  { 232, 5, 8, 5, 0, -8 },
  { 237, 5, 8, 5, 1, -8 },
  { 242, 6, 8, 7, 1, -8 },
  { 248, 5, 8, 5, 1, -8 },
  { 253, 8, 8, 8, 1, -8 },
  { 261, 7, 8, 5, -1, -8 },
  { 268, 5, 8, 5, 1, -8 },
  { 273, 6, 8, 5, 0, -8 },
  { 279, 4, 10, 3, 0, -8 },
  { 284, 2, 8, 4, 1, -8 },
  { 286, 4, 10, 3, -1, -8 },
  { 291, 5, 5, 6, 0, -8 },
  { 295, 4, 1, 4, -1, 1 },
  { 296, 1, 1, 3, 2, -8 },
  { 297, 5, 6, 6, 0, -6 },
  { 301, 5, 8, 6, 0, -8 },
  { 306, 5, 6, 4, 0, -6 },
  { 310, 6, 8, 6, 0, -8 },
  { 316, 5, 6, 5, 0, -6 },
  { 320, 5, 11, 3, -1, -8 },
  { 327, 5, 9, 6, 0, -6 },
  { 333, 5, 8, 5, 0, -8 },
  { 338, 3, 8, 2, 0, -8 },
  { 341, 4, 11, 2, -1, -8 },
  { 347, 5, 8, 5, 0, -8 },
  { 352, 3, 8, 2, 0, -8 },
  { 355, 8, 6, 8, 0, -6 },
  { 361, 5, 6, 5, 0, -6 },
  { 365, 5, 6, 5, 0, -6 },
  { 369, 5, 9, 6, 0, -6 },
  { 375, 5, 9, 6, 0, -6 },
  { 381, 4, 6, 4, 0, -6 },
  { 384, 4, 6, 4, 0, -6 },
  { 387, 3, 7, 3, 0, -7 },
  { 390, 5, 6, 6, 0, -6 },
  { 394, 4, 6, 4, 1, -6 },
  { 397, 6, 6, 7, 1, -6 },
  { 402, 5, 6, 5, 0, -6 },
  { 406, 6, 9, 4, -1, -6 },
  { 413, 4, 6, 4, 0, -6 },
  { 416, 4, 10, 4, 0, -8 },
  { 421, 1, 11, 5, 2, -8 },
  { 423, 4, 10, 4, -1, -8 },
  { 428, 4, 1, 6, 1, -4 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC11PT7B_H_
