#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC12PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x80, 0x76, 0xD0, 0x14, 0x28, 0x93, 0xF2, 0x85,
  0x37, 0x28, 0x50, 0x10, 0xF5, 0x14, 0x30, 0xA2, 0xAE, 0x60, 0x80, 0x63,
  0x4A, 0xA5, 0x4B, 0xFD, 0x4A, 0xA9, 0x8C, 0x18, 0x92, 0x8A, 0x31, 0x58,
  0xE2, 0x74, 0x6A, 0x12, 0x24, 0x48, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11,
  0x12, 0x24, 0x80, 0x27, 0x0E, 0xA1, 0x00, 0x21, 0x3E, 0x42, 0x10, 0x58,
  0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0xC0, 0x32, 0x63, 0x18,
  0xCA, 0x52, 0xE0, 0x2B, 0x24, 0xA4, 0x80, 0x39, 0x10, 0x42, 0x08, 0x42,
  0x10, 0xF8, 0x39, 0x10, 0x42, 0x30, 0x20, 0x82, 0xF0, 0x04, 0x21, 0x8A,
  0x49, 0x2F, 0xC4, 0x10, 0x3C, 0x84, 0x10, 0x78, 0x20, 0x82, 0xF0, 0x3A,
  0x21, 0x4D, 0x4A, 0x52, 0xE0, 0xF8, 0x44, 0x22, 0x11, 0x08, 0x80, 0x18,
  0x94, 0x4A, 0x31, 0x28, 0xA2, 0x70, 0x19, 0x94, 0x51, 0x48, 0xE0, 0x84,
  0xE0, 0x40, 0x20, 0x20, 0x00, 0x94, 0x1B, 0x20, 0xC1, 0x80, 0xF8, 0x3E,
  0x83, 0x06, 0x6C, 0x00, 0xE1, 0x12, 0x48, 0x80, 0x80, 0x1C, 0x22, 0x41,
  0x9D, 0xA9, 0xCA, 0xCA, 0xB4, 0x80, 0x78, 0x04, 0x31, 0x45, 0x24, 0xF4,
  0x51, 0x84, 0x38, 0x92, 0x51, 0x79, 0x14, 0x52, 0xF0, 0x1D, 0x84, 0x20,
  0x82, 0x08, 0x20, 0x70, 0x38, 0x48, 0x8A, 0x14, 0x28, 0x51, 0x44, 0xF0,
  0x3C, 0x82, 0x10, 0x79, 0x04, 0x20, 0xF0, 0x3C, 0x82, 0x10, 0x79, 0x04,
  0x20, 0x80, 0x1D, 0x84, 0x20, 0x9A, 0x18, 0xA2, 0x78, 0x22, 0x44, 0x8A,
  0x17, 0xC8, 0x91, 0x22, 0x84, 0x72, 0x22, 0x44, 0x44, 0xC0, 0x08, 0x42,
  0x21, 0x08, 0x42, 0x21, 0x30, 0x22, 0x48, 0xA2, 0x86, 0x0A, 0x14, 0x44,
  0x88, 0x22, 0x24, 0x44, 0x48, 0xF0, 0x20, 0x90, 0xC8, 0x6A, 0x55, 0x32,
  0xA9, 0x55, 0x32, 0x92, 0x00, 0x22, 0x44, 0xCA, 0x95, 0x29, 0x53, 0x46,
  0x84, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x38, 0x92, 0x51, 0x49,
  0xC4, 0x20, 0x80, 0x39, 0x18, 0x61, 0x86, 0x18, 0x62, 0x70, 0x41, 0x00,
  0x38, 0x92, 0x51, 0x49, 0xC5, 0x22, 0x88, 0x3D, 0x04, 0x10, 0x20, 0x40,
  0x82, 0xF0, 0xF9, 0x08, 0x44, 0x21, 0x08, 0x80, 0x45, 0x18, 0x61, 0x86,
  0x28, 0xA2, 0xF0, 0x86, 0x28, 0xA4, 0x92, 0x8A, 0x30, 0x40, 0x88, 0xC4,
  0x66, 0x53, 0x2A, 0xA5, 0x53, 0x29, 0x88, 0x84, 0x00, 0x22, 0x24, 0x50,
  0xC1, 0x03, 0x0A, 0x24, 0xC4, 0x8C, 0x64, 0xC6, 0x21, 0x08, 0x80, 0x3C,
  0x10, 0x84, 0x10, 0x84, 0x20, 0xF0, 0x32, 0x44, 0x44, 0x48, 0x88, 0xC0,
  0xA9, 0x55, 0x40, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38, 0x10, 0xC2,
  0x92, 0xC4, 0xF0, 0xC0, 0x10, 0xB4, 0x92, 0x8A, 0x27, 0x80, 0x20, 0x85,
  0x99, 0x45, 0x14, 0xA2, 0xF0, 0x34, 0x88, 0x88, 0xE0, 0x04, 0x11, 0x4B,
  0x45, 0x28, 0xA2, 0x78, 0x25, 0x9E, 0x88, 0xE0, 0x1C, 0x41, 0x88, 0x20,
  0x82, 0x08, 0x41, 0x04, 0x20, 0x10, 0xB4, 0x52, 0x8A, 0x27, 0x82, 0x13,
  0x80, 0x21, 0x14, 0xD4, 0xA5, 0x31, 0x88, 0x20, 0x24, 0x94, 0x80, 0x08,
  0x00, 0x21, 0x08, 0x44, 0x21, 0x09, 0x80, 0x21, 0x10, 0x95, 0x31, 0x52,
  0x90, 0x25, 0x24, 0x94, 0x80, 0x13, 0x36, 0x52, 0x29, 0x24, 0x94, 0x4A,
  0x44, 0x1B, 0x52, 0x94, 0xC6, 0x20, 0x3A, 0x63, 0x18, 0xB8, 0x7D, 0x14,
  0x52, 0x8B, 0xC8, 0x20, 0x80, 0x10, 0xB4, 0x52, 0x8A, 0x27, 0x82, 0x10,
  0x40, 0x74, 0x44, 0x88, 0x34, 0x46, 0x11, 0xE0, 0x27, 0x44, 0x44, 0x86,
  0x8C, 0xA5, 0x29, 0x78, 0x9A, 0xAC, 0xC8, 0x93, 0x6B, 0x56, 0xC9, 0x92,
  0x00, 0x4A, 0x88, 0xC5, 0x48, 0x24, 0xA2, 0x8C, 0x30, 0x82, 0x10, 0xC0,
  0x78, 0x88, 0x88, 0x70, 0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF,
  0xF0, 0x20, 0x84, 0x21, 0x0C, 0x84, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 4, 4, 1, -9 },
  { 7, 7, 9, 7, 0, -9 },
  { 15, 6, 10, 6, 0, -9 },
  { 23, 7, 9, 8, 1, -9 },
  { 31, 6, 9, 7, 0, -9 },
  { 38, 2, 4, 2, 1, -9 },
  { 39, 4, 11, 3, 0, -9 },
  { 45, 4, 11, 3, -1, -9 },
  { 51, 5, 5, 6, 1, -9 },
  { 55, 5, 6, 6, 1, -7 },
  { 59, 2, 3, 2, -1, -1 },
  { 60, 3, 1, 4, 0, -4 },
  { 61, 1, 1, 3, 0, -1 },
  { 62, 6, 9, 4, -1, -9 },
  { 69, 5, 9, 6, 1, -9 },
  { 75, 3, 9, 6, 2, -9 },
  { 79, 6, 9, 6, 0, -9 },
  { 86, 6, 9, 6, 0, -9 },
  { 93, 6, 9, 6, 0, -9 },
  { 100, 6, 9, 6, 0, -9 },
  { 107, 5, 9, 6, 1, -9 },
  { 113, 5, 9, 6, 1, -9 },
  { 119, 6, 9, 6, 0, -9 },
  { 126, 6, 9, 6, 0, -9 },
  { 133, 2, 6, 3, 0, -6 },
  { 135, 3, 8, 3, -1, -6 },
  { 138, 5, 5, 6, 1, -7 },
  { 142, 5, 3, 6, 1, -6 },
  { 144, 5, 5, 6, 1, -7 },
  { 148, 4, 9, 4, 1, -9 },
  { 153, 8, 10, 9, 1, -9 },
  { 163, 6, 9, 6, -1, -9 },
  { 170, 6, 9, 6, 0, -9 },
  { 177, 6, 9, 6, 1, -9 },
  { 184, 7, 9, 7, 0, -9 },
  { 192, 6, 9, 6, 0, -9 },
  { 199, 6, 9, 5, 0, -9 },
  { 206, 6, 9, 7, 1, -9 },
  { 213, 7, 9, 7, 0, -9 },
  { 221, 4, 9, 3, 0, -9 },
  { 226, 5, 11, 3, -2, -9 },
  { 233, 7, 9, 6, 0, -9 },
  { 241, 4, 9, 5, 0, -9 },
  { 246, 9, 9, 9, 0, -9 },
  { 257, 7, 9, 7, 0, -9 },
  { 265, 6, 9, 8, 1, -9 },
  { 272, 6, 9, 6, 0, -9 },
  { 279, 6, 11, 8, 1, -9 },
  { 288, 6, 9, 6, 0, -9 },
  { 295, 6, 9, 5, 0, -9 },
  { 302, 5, 9, 5, 1, -9 },
  { 308, 6, 9, 7, 1, -9 },
  { 315, 6, 9, 6, 1, -9 },
  { 322, 9, 9, 9, 1, -9 },
  { 333, 7, 9, 5, -1, -9 },
  { 341, 5, 9, 5, 1, -9 },
  { 347, 6, 9, 5, 0, -9 },
  { 354, 4, 11, 3, 0, -9 },
  { 360, 2, 9, 4, 1, -9 },
  { 363, 5, 11, 3, -1, -9 },
  { 370, 6, 5, 6, 0, -9 },
  { 374, 4, 1, 4, -1, 1 },
  { 375, 1, 2, 3, 2, -9 },
  { 376, 6, 7, 6, 0, -7 },
  { 382, 6, 9, 6, 0, -9 },
  { 389, 4, 7, 5, 1, -7 },
  { 393, 6, 9, 6, 0, -9 },
  { 400, 4, 7, 5, 1, -7 },
  { 404, 6, 12, 3, -1, -9 },
  { 413, 6, 10, 6, 0, -7 },
  { 421, 5, 9, 6, 0, -9 },
  { 427, 3, 9, 3, 0, -9 },
  { 431, 5, 12, 3, -2, -9 },
  { 439, 5, 9, 5, 0, -9 },
  { 445, 3, 9, 3, 0, -9 },
  { 449, 9, 7, 9, 0, -7 },
  { 457, 5, 7, 6, 0, -7 },
  { 462, 5, 6, 6, 0, -6 },
  { 466, 6, 9, 6, 0, -6 },
  { 473, 6, 10, 6, 0, -7 },
  { 481, 4, 6, 4, 0, -6 },
  { 484, 4, 7, 5, 0, -7 },
  { 488, 4, 8, 3, 0, -8 },
  { 492, 5, 6, 6, 1, -6 },
  { 496, 4, 6, 5, 1, -6 },
  { 499, 7, 6, 7, 1, -6 },
  { 505, 5, 6, 5, 0, -6 },
  { 509, 6, 9, 5, -1, -6 },
  { 516, 5, 6, 4, 0, -6 },
  { 520, 5, 11, 4, 0, -9 },
  { 527, 1, 12, 6, 3, -9 },
  { 529, 5, 11, 4, -1, -9 },
  { 536, 5, 1, 6, 1, -5 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC12PT7B_H_
