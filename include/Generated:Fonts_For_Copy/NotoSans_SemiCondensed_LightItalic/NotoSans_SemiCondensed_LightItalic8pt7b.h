#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xF0, 0x33, 0x56, 0xFA, 0x36, 0x42, 0x6C, 0xDE, 0xEF,
  0x7B, 0x25, 0x67, 0x9F, 0xC0, 0x2A, 0x49, 0x20, 0x24, 0x92, 0xB0, 0x5F,
  0x00, 0x22, 0xF2, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x25, 0x99, 0x9E,
  0x75, 0xA0, 0x61, 0x12, 0x4E, 0x61, 0x16, 0x1E, 0x12, 0x5A, 0xF2, 0x74,
  0x61, 0x1E, 0x34, 0xE9, 0x9E, 0xE5, 0x29, 0x00, 0x25, 0x56, 0x9E, 0x25,
  0x96, 0x2E, 0x42, 0x42, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0x64, 0xA9,
  0x00, 0x39, 0x1B, 0xF5, 0xFA, 0x07, 0x00, 0x25, 0xBB, 0x40, 0x75, 0x5B,
  0x9E, 0x34, 0x88, 0x87, 0x75, 0x59, 0x9E, 0x74, 0x4A, 0x8E, 0x74, 0x4A,
  0x88, 0x3A, 0x21, 0x29, 0x38, 0x4A, 0x53, 0x69, 0x48, 0x69, 0x29, 0x00,
  0x24, 0xA4, 0xB0, 0x4A, 0x98, 0xCA, 0x50, 0x49, 0x49, 0xC0, 0x45, 0x14,
  0xED, 0xBA, 0xA0, 0x4A, 0x5B, 0x59, 0x48, 0x32, 0x63, 0x18, 0xB8, 0x65,
  0x56, 0x88, 0x32, 0x63, 0x18, 0xA8, 0xC0, 0x65, 0x56, 0xAA, 0x74, 0x42,
  0x2E, 0xEA, 0x49, 0x00, 0x99, 0x9A, 0xAE, 0x9A, 0xAC, 0x88, 0xA6, 0xAE,
  0xBA, 0x92, 0x40, 0x55, 0x24, 0xAA, 0xB7, 0x49, 0x00, 0x71, 0x24, 0x8E,
  0x69, 0x49, 0x20, 0xFC, 0x24, 0x92, 0x70, 0x26, 0x59, 0xE0, 0x80, 0x79,
  0x9E, 0x46, 0x59, 0x9E, 0x72, 0x70, 0x13, 0x59, 0x9E, 0x7E, 0x70, 0x36,
  0x24, 0x44, 0x48, 0x79, 0x9E, 0x2C, 0x46, 0x59, 0x9A, 0x46, 0xA0, 0x20,
  0xA4, 0x94, 0x45, 0x64, 0xAA, 0x56, 0xA0, 0x7E, 0x5A, 0x6A, 0x79, 0x9A,
  0x79, 0x9E, 0x79, 0x9E, 0x88, 0x79, 0x9E, 0x22, 0x72, 0x40, 0xE8, 0xF0,
  0xDA, 0xC0, 0x59, 0xAE, 0xBA, 0xC4, 0xAD, 0x55, 0x20, 0x74, 0x4A, 0x5A,
  0x98, 0x44, 0x60, 0x6A, 0x60, 0x29, 0x65, 0x30, 0xFF, 0x55, 0x68, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 6, 4, 0, -6 },
  { 10, 4, 6, 6, 1, -6 },
  { 13, 4, 6, 5, 0, -6 },
  { 16, 1, 2, 1, 1, -6 },
  { 17, 3, 7, 2, 0, -6 },
  { 20, 3, 7, 2, -1, -6 },
  { 23, 3, 3, 4, 1, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 3, 6, 4, 1, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 4, 4, 4, 0, -5 },
  { 67, 4, 2, 4, 0, -4 },
  { 68, 4, 4, 4, 0, -5 },
  { 70, 3, 6, 3, 0, -6 },
  { 73, 6, 7, 6, 0, -6 },
  { 79, 3, 6, 4, 0, -6 },
  { 82, 4, 6, 4, 0, -6 },
  { 85, 4, 6, 4, 0, -6 },
  { 88, 4, 6, 5, 0, -6 },
  { 91, 4, 6, 4, 0, -6 },
  { 94, 4, 6, 3, 0, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 3, 6, 2, 0, -6 },
  { 108, 3, 7, 2, -1, -6 },
  { 111, 5, 6, 4, 0, -6 },
  { 115, 3, 6, 3, 0, -6 },
  { 118, 6, 6, 6, 0, -6 },
  { 123, 5, 6, 5, 0, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 4, 6, 4, 0, -6 },
  { 134, 5, 7, 5, 0, -6 },
  { 139, 4, 6, 4, 0, -6 },
  { 142, 4, 6, 4, 0, -6 },
  { 145, 3, 6, 3, 1, -6 },
  { 148, 4, 6, 5, 1, -6 },
  { 151, 4, 6, 4, 1, -6 },
  { 154, 6, 6, 6, 1, -6 },
  { 159, 4, 6, 4, 0, -6 },
  { 162, 3, 6, 3, 1, -6 },
  { 165, 4, 6, 4, 0, -6 },
  { 168, 3, 7, 2, 0, -6 },
  { 171, 1, 6, 3, 1, -6 },
  { 172, 3, 7, 2, -1, -6 },
  { 175, 4, 4, 4, 0, -6 },
  { 177, 3, 1, 3, -1, 0 },
  { 178, 1, 1, 2, 1, -6 },
  { 179, 4, 4, 4, 0, -4 },
  { 181, 4, 6, 4, 0, -6 },
  { 184, 3, 4, 3, 0, -4 },
  { 186, 4, 6, 4, 0, -6 },
  { 189, 3, 4, 4, 0, -4 },
  { 191, 4, 8, 2, -1, -6 },
  { 195, 4, 6, 4, 0, -4 },
  { 198, 4, 6, 4, 0, -6 },
  { 201, 2, 6, 2, 0, -6 },
  { 203, 3, 8, 2, -1, -6 },
  { 206, 4, 6, 3, 0, -6 },
  { 209, 2, 6, 2, 0, -6 },
  { 211, 6, 4, 6, 0, -4 },
  { 214, 4, 4, 4, 0, -4 },
  { 216, 4, 4, 4, 0, -4 },
  { 218, 4, 6, 4, 0, -4 },
  { 221, 4, 6, 4, 0, -4 },
  { 224, 3, 4, 3, 0, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 2, 5, 2, 0, -5 },
  { 230, 4, 4, 4, 0, -4 },
  { 232, 4, 4, 3, 0, -4 },
  { 234, 5, 4, 5, 0, -4 },
  { 237, 4, 4, 3, 0, -4 },
  { 239, 5, 6, 3, -1, -4 },
  { 243, 3, 4, 3, 0, -4 },
  { 245, 3, 7, 3, 0, -6 },
  { 248, 1, 8, 4, 2, -6 },
  { 249, 2, 7, 3, 0, -6 },
  { 251, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC8PT7B_H_
