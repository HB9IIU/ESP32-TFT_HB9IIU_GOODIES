#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x1E, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x20, 0x00, 0x3C, 0x1E, 0x78, 0x3C,
  0xE0, 0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x07, 0x9C, 0x0E, 0x38, 0x1C, 0x70,
  0x38, 0xC0, 0x73, 0x80, 0xC7, 0x03, 0x8E, 0x07, 0x18, 0x0E, 0x30, 0x18,
  0x60, 0x30, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x06,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x38, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x18, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x30,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x0C, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x00, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0xFC, 0xE7, 0xE0, 0x3E, 0x18, 0x18, 0x0F, 0x03, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xC0, 0x60, 0x00,
  0x38, 0x0C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x0C,
  0x00, 0x01, 0xC1, 0x80, 0x00, 0x3E, 0x70, 0x00, 0x03, 0xEE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x06, 0x7C, 0x00, 0x00, 0xC7, 0xC0, 0x00,
  0x18, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x18, 0x0E,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x60, 0x78, 0x00, 0x0C, 0x0F, 0x04, 0x03, 0x87, 0xC0,
  0xF0, 0x73, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x20, 0x0F, 0xF0, 0x00, 0x0E, 0x00,
  0xFF, 0xC0, 0x00, 0xE0, 0x0F, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x38, 0x00,
  0x70, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x0E,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x07, 0x07, 0x00, 0x07, 0x00, 0x38, 0x78,
  0x00, 0x38, 0x03, 0x83, 0x83, 0xF1, 0xC0, 0x1C, 0x38, 0x7F, 0xCE, 0x00,
  0xE3, 0xC7, 0xFF, 0x70, 0x0E, 0x1C, 0x78, 0x39, 0xC0, 0xF1, 0xC3, 0x81,
  0xCE, 0x07, 0x0E, 0x38, 0x07, 0x78, 0x70, 0xE1, 0xC0, 0x39, 0xFF, 0x8E,
  0x1C, 0x01, 0xCF, 0xF0, 0x70, 0xE0, 0x0E, 0x1F, 0x07, 0x0F, 0x00, 0x70,
  0x00, 0x70, 0x70, 0x03, 0x80, 0x03, 0x83, 0x80, 0x38, 0x00, 0x38, 0x1C,
  0x01, 0xC0, 0x03, 0x81, 0xE0, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x78, 0x07, 0x80, 0x0E, 0x03, 0x80,
  0x38, 0x00, 0x78, 0x38, 0x03, 0x80, 0x01, 0xC3, 0xC0, 0x3C, 0x00, 0x0F,
  0xFC, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x70, 0x01, 0xC0, 0x00,
  0x70, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x07, 0xC1, 0xC0, 0x07, 0x0F, 0x01, 0xE0, 0x0F, 0x1E,
  0x00, 0xF0, 0x0E, 0x3C, 0x00, 0xF0, 0x1E, 0x3C, 0x00, 0x78, 0x1C, 0x78,
  0x00, 0x78, 0x3C, 0x78, 0x00, 0x3C, 0x38, 0x70, 0x00, 0x1C, 0x78, 0x70,
  0x00, 0x1E, 0xF0, 0xF0, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x0F, 0xE0, 0xF0,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0xC0, 0x78,
  0x00, 0x1F, 0xC0, 0x78, 0x00, 0x7D, 0xE0, 0x3C, 0x01, 0xF0, 0xE0, 0x3F,
  0x8F, 0xE0, 0xF0, 0x1F, 0xFF, 0xC0, 0x78, 0x07, 0xFF, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0xF3, 0x8E, 0x79, 0xE7, 0x1C, 0x71, 0xCE, 0x38,
  0xE3, 0x8C, 0x30, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x08, 0x03, 0x80,
  0x18, 0x07, 0x00, 0x7C, 0x0C, 0x00, 0xFE, 0x18, 0x00, 0x3F, 0x30, 0x00,
  0x1F, 0x63, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x77, 0x00, 0x01, 0xC6, 0x00, 0x07, 0x8E, 0x00, 0x1E, 0x1C, 0x00, 0x78,
  0x1C, 0x03, 0xE0, 0x38, 0x03, 0x80, 0x78, 0x02, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x11, 0xE7, 0xFF, 0xF9, 0xE2, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x03, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x1E, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x0F, 0x01, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x7D, 0xC1,
  0xF7, 0x8F, 0x8F, 0x3E, 0x1C, 0xF8, 0x39, 0xC0, 0xF1, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x30, 0x00, 0x78,
  0x01, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0, 0x3F, 0xE7,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x1C,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x03,
  0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3C, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x10, 0x00, 0x1F, 0x00, 0xE0, 0x01,
  0xF0, 0x07, 0xF9, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3D, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xF0, 0x30, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x60, 0x00, 0xF0, 0xFF, 0xC0, 0x1E, 0x7F, 0xFC,
  0x03, 0x9F, 0xDF, 0xC0, 0x77, 0x80, 0x7C, 0x1F, 0xC0, 0x07, 0x83, 0xF0,
  0x00, 0x70, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x78, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x07,
  0xC0, 0x7C, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x1F,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x8F, 0xF0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x83,
  0xC0, 0x03, 0xF0, 0x78, 0x01, 0xDC, 0x07, 0xC0, 0x7B, 0x80, 0xFF, 0xFE,
  0x70, 0x0F, 0xFF, 0x1E, 0x00, 0x7F, 0x83, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x10, 0x03, 0xE0, 0x03, 0xE7, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0x0F, 0xE0, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x70, 0x00,
  0x7F, 0x00, 0x38, 0x70, 0x00, 0xFF, 0xF0, 0x1C, 0x38, 0x01, 0xFF, 0xF0,
  0x0E, 0x38, 0x01, 0xE0, 0x38, 0x07, 0x1C, 0x01, 0xE0, 0x1C, 0x03, 0x9C,
  0x01, 0xE0, 0x0E, 0x01, 0xCE, 0x01, 0xE0, 0x0E, 0x00, 0xEF, 0x00, 0xE0,
  0x07, 0x00, 0x77, 0x00, 0xE0, 0x03, 0x80, 0x3B, 0x80, 0x70, 0x01, 0xC0,
  0x1D, 0xC0, 0x70, 0x01, 0xC0, 0x0F, 0xC0, 0x38, 0x00, 0xE0, 0x0E, 0xE0,
  0x1C, 0x00, 0x70, 0x07, 0x70, 0x0E, 0x00, 0x38, 0x03, 0xB8, 0x0E, 0x00,
  0x38, 0x03, 0x9C, 0x07, 0x00, 0x1C, 0x01, 0xCE, 0x03, 0x80, 0x1E, 0x00,
  0xE7, 0x01, 0xC0, 0x0F, 0x00, 0xE3, 0x80, 0xE0, 0x0F, 0x80, 0x71, 0xC0,
  0x70, 0x07, 0xC0, 0x70, 0xE0, 0x3C, 0x06, 0xE0, 0x78, 0x70, 0x0E, 0x07,
  0x70, 0x78, 0x38, 0x07, 0xCF, 0x1E, 0xF8, 0x1C, 0x01, 0xFF, 0x0F, 0xF8,
  0x0E, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x78, 0x03,
  0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xF0, 0x0F, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x0E, 0x00,
  0x07, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x80, 0x70, 0x01,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0x87, 0xE0, 0x03, 0xF0, 0x00, 0xC0, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1E, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x03,
  0xE0, 0x03, 0x80, 0x00, 0xF8, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0E, 0x00, 0x00, 0x78,
  0x07, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xFC,
  0x01, 0xC0, 0x00, 0xFC, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x07, 0xF8,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03,
  0xFE, 0x0F, 0xF0, 0x03, 0xF0, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x08, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF1, 0xE0, 0x00, 0x7F,
  0xF8, 0xF0, 0x00, 0x3F, 0xFC, 0x78, 0x00, 0x3F, 0xFE, 0x3C, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x10, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x0F, 0x80, 0x1C,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x80, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x70, 0x07, 0x80, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x03, 0x87, 0xC0, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x00, 0x73, 0xF0, 0x00, 0x00, 0x3B, 0xF8, 0x00, 0x00, 0x3F, 0x9E, 0x00,
  0x00, 0x1F, 0x8F, 0x00, 0x00, 0x0F, 0x83, 0x80, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x77,
  0x00, 0x00, 0x07, 0xF8, 0x03, 0xB8, 0x00, 0x00, 0x3B, 0x80, 0x1D, 0xC0,
  0x00, 0x03, 0xDC, 0x01, 0xEE, 0x00, 0x00, 0x1D, 0xE0, 0x0E, 0x70, 0x00,
  0x01, 0xEF, 0x00, 0x73, 0x80, 0x00, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0x00,
  0xF3, 0x80, 0x3C, 0xE0, 0x00, 0x07, 0x1C, 0x01, 0xE7, 0x80, 0x00, 0x71,
  0xE0, 0x0E, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x3C, 0x38, 0x00, 0x1C, 0x1C, 0x01,
  0xE1, 0xC0, 0x01, 0xE1, 0xE0, 0x0E, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x70,
  0x70, 0x00, 0xF0, 0x70, 0x03, 0x83, 0x80, 0x07, 0x03, 0x80, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xE0, 0x0E, 0x03, 0x80,
  0x3C, 0x0F, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xE0, 0x0E, 0x01, 0xC0, 0xF0, 0x0E, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC3, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x9E, 0x00, 0x70, 0x07, 0x80, 0x1C, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xEF, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x3F,
  0x80, 0x0E, 0x00, 0x70, 0x00, 0xF8, 0x00, 0x70, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x1F, 0x00, 0x00, 0x1C, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x0F, 0xC0, 0x00,
  0x0F, 0x00, 0x7F, 0x00, 0x00, 0x70, 0x03, 0xB8, 0x00, 0x03, 0x80, 0x1D,
  0xC0, 0x00, 0x1C, 0x01, 0xEF, 0x00, 0x01, 0xE0, 0x0E, 0x38, 0x00, 0x0F,
  0x00, 0x71, 0xC0, 0x00, 0x70, 0x03, 0x8F, 0x00, 0x03, 0x80, 0x3C, 0x78,
  0x00, 0x3C, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0x0E, 0x0F, 0x00, 0x0F, 0x00,
  0x70, 0x78, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x03, 0x80, 0x3C, 0x0F, 0x00,
  0x3C, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x3C,
  0x01, 0xC0, 0x0E, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x70, 0x07, 0x80, 0x0E, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x3C, 0x01,
  0xC0, 0x01, 0xC1, 0xE0, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x00, 0x78,
  0x70, 0x07, 0x80, 0x01, 0xC3, 0x80, 0x3C, 0x00, 0x0E, 0x3C, 0x01, 0xC0,
  0x00, 0x79, 0xC0, 0x0E, 0x00, 0x01, 0xCE, 0x00, 0x70, 0x00, 0x0E, 0x70,
  0x07, 0x80, 0x00, 0x7B, 0x80, 0x3C, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x00,
  0x0F, 0xC0, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x78, 0x03, 0x80,
  0x01, 0xE0, 0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07,
  0xC0, 0x70, 0x00, 0x7C, 0x03, 0x80, 0x0F, 0xC0, 0x3C, 0x03, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xCF,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xE0, 0x0F, 0xC0, 0x0F, 0x00,
  0x1F, 0x00, 0x70, 0x00, 0x78, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80, 0x70, 0x00, 0xF8, 0x03,
  0x80, 0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0E, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x7C, 0x00, 0x08, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x80, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x78, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xE0,
  0x0F, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x38,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xC0, 0x00, 0x3D,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xCE, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x70,
  0x00, 0x1F, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0x1C, 0x00,
  0x0E, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x87, 0x00, 0x07,
  0x38, 0x00, 0x3C, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0xCE,
  0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xE3, 0x80,
  0x0F, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0x80, 0xE0, 0x07, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC0,
  0x38, 0x03, 0x81, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x70, 0x0F, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x03, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x38,
  0x07, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x38, 0x1C, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x3C,
  0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x03, 0x9E, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x01,
  0xCE, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0x70, 0x00,
  0x0E, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x78,
  0x00, 0x78, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0xF0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x07, 0x80, 0x07, 0x00, 0xE0, 0x00, 0xE0,
  0x38, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x78, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xF0, 0x78, 0x78,
  0x38, 0x3C, 0x1C, 0x0E, 0x06, 0x07, 0x00, 0x03, 0x00, 0x00, 0x07, 0xFC,
  0x1C, 0x03, 0xFF, 0xC3, 0x80, 0xFF, 0xFC, 0xE0, 0x3E, 0x03, 0x9C, 0x0F,
  0x80, 0x3B, 0x81, 0xE0, 0x03, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38, 0x70, 0x00,
  0x0F, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0x83, 0x80, 0x03,
  0xE0, 0x70, 0x00, 0xFC, 0x0F, 0x00, 0x1B, 0x81, 0xE0, 0x06, 0x70, 0x1E,
  0x03, 0xCE, 0x03, 0xF3, 0xF3, 0x80, 0x3F, 0xF8, 0x70, 0x03, 0xFE, 0x0E,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x01, 0xE1, 0xFF, 0x00, 0x1C, 0x3F,
  0xF8, 0x01, 0xCF, 0xDF, 0xC0, 0x3D, 0xE0, 0x3E, 0x03, 0xDC, 0x01, 0xE0,
  0x3B, 0x80, 0x0E, 0x03, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x07, 0xC0,
  0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xF0, 0x3E, 0x00, 0x0F, 0x07, 0xE0, 0x01, 0xE0, 0x77, 0x00, 0x3C, 0x07,
  0x38, 0x0F, 0x80, 0x73, 0xF7, 0xF0, 0x06, 0x1F, 0xFE, 0x00, 0xE0, 0xFF,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x7F, 0xBF, 0x03, 0xE0, 0x04, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x08, 0x0F, 0xE7, 0xE0, 0x1F, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x08, 0x03, 0x80, 0x03,
  0xFE, 0x0E, 0x00, 0x3F, 0xFC, 0x38, 0x01, 0xFF, 0xF9, 0xE0, 0x0F, 0x80,
  0x77, 0x00, 0x7C, 0x00, 0xDC, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1C,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x78, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x3C,
  0x03, 0x80, 0x01, 0xF0, 0x0E, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x3F, 0x00,
  0xE0, 0x01, 0xFC, 0x03, 0xC0, 0x07, 0xE0, 0x0F, 0x00, 0x3B, 0x80, 0x1E,
  0x03, 0xCE, 0x00, 0x7E, 0x3E, 0x38, 0x00, 0xFF, 0xF0, 0xE0, 0x01, 0xFF,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xE0, 0x0F, 0xE7, 0xE0, 0x3E, 0x03, 0xC0, 0xF8, 0x03, 0xC1,
  0xE0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0xF0,
  0x00, 0x71, 0xC0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x1C, 0x00,
  0xFC, 0x38, 0x0F, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x30, 0x1F,
  0xC3, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x7F, 0xC1, 0xC0, 0x0F, 0xFF, 0x0E, 0x00, 0xFF, 0x7C, 0x70, 0x0F, 0x80,
  0x77, 0x00, 0xF8, 0x01, 0xB8, 0x07, 0x80, 0x0F, 0xC0, 0x78, 0x00, 0x3E,
  0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x1C,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3E, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00,
  0x1F, 0x01, 0xC0, 0x00, 0xF8, 0x0E, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0xFE,
  0x03, 0xC0, 0x07, 0xE0, 0x1E, 0x00, 0xF7, 0x00, 0x78, 0x0F, 0x38, 0x03,
  0xF1, 0xF3, 0xC0, 0x0F, 0xFF, 0x1E, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x18,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x08, 0x00,
  0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x20, 0x00, 0x78, 0x7F, 0xC0, 0x0E, 0x1F, 0xFC, 0x01,
  0xCF, 0xDF, 0xC0, 0x7B, 0xC0, 0x7C, 0x0F, 0xE0, 0x07, 0x81, 0xD8, 0x00,
  0xF0, 0x3E, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xC1, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x07,
  0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x83, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0,
  0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0F,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x87, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x0E, 0x00,
  0x1E, 0x01, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x1C,
  0x78, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0xFC, 0x00,
  0x03, 0xBB, 0x80, 0x00, 0x7E, 0x70, 0x00, 0x1F, 0x8F, 0x00, 0x03, 0xE0,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00,
  0x78, 0x07, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x07,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x38, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0x1F, 0xFC, 0x0F,
  0xFE, 0x00, 0xE7, 0xFF, 0xC3, 0xEF, 0xE0, 0x39, 0xC0, 0x78, 0xE0, 0x3C,
  0x07, 0x70, 0x07, 0x38, 0x03, 0xC0, 0xEC, 0x00, 0xFE, 0x00, 0x78, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x83, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC1, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x38, 0x3F, 0xE0, 0x07, 0x1F, 0xFE, 0x00, 0xE7,
  0xFF, 0xE0, 0x3D, 0xE0, 0x3E, 0x07, 0x78, 0x03, 0xC0, 0xEC, 0x00, 0x78,
  0x1F, 0x80, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x38,
  0x00, 0x0F, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x07, 0x80,
  0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x83, 0x80, 0x00, 0xE0,
  0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x3E, 0x01, 0xE0, 0x3E,
  0x00, 0x78, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8E,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3B,
  0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x3C, 0xE0, 0x00,
  0x1E, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x7F, 0x3F, 0x80, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x70, 0x7F, 0xC0, 0x00, 0xE1, 0xFF, 0xC0, 0x01, 0xC7, 0xCF,
  0xC0, 0x07, 0x1C, 0x07, 0xC0, 0x0E, 0x70, 0x07, 0x80, 0x1D, 0xC0, 0x07,
  0x00, 0x3F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x01, 0xF8, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0xFC, 0x00,
  0x3C, 0x01, 0xDC, 0x00, 0xF0, 0x03, 0x9C, 0x07, 0xC0, 0x07, 0x3F, 0x7F,
  0x00, 0x0E, 0x3F, 0xFC, 0x00, 0x3C, 0x3F, 0xF0, 0x00, 0x78, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07,
  0xFC, 0x1C, 0x03, 0xFF, 0xC3, 0x80, 0xFF, 0xFC, 0x70, 0x3E, 0x01, 0xDC,
  0x0F, 0x80, 0x1B, 0x81, 0xE0, 0x03, 0xF0, 0x78, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x38, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x0F,
  0x87, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0x83, 0x80,
  0x03, 0xF0, 0x70, 0x00, 0xFE, 0x0F, 0x00, 0x1F, 0x81, 0xE0, 0x07, 0x70,
  0x1E, 0x03, 0xCE, 0x03, 0xF1, 0xF3, 0xC0, 0x3F, 0xFC, 0x78, 0x03, 0xFE,
  0x0E, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x30, 0x07, 0x07, 0xF0, 0x1C,
  0x7F, 0xC0, 0x73, 0xFE, 0x03, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x1F, 0xC7, 0xE0, 0x7C, 0x00, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x10, 0x00, 0x78, 0x38, 0x01, 0xF0, 0x7E, 0x1F, 0xC0, 0xFF,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00,
  0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1E,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03,
  0x83, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x1F, 0x03,
  0x80, 0x07, 0xE0, 0x70, 0x01, 0xDC, 0x0F, 0x00, 0x77, 0x01, 0xE0, 0x1C,
  0xE0, 0x1F, 0x9F, 0x1C, 0x03, 0xFF, 0xC3, 0x80, 0x1F, 0xF0, 0x70, 0x00,
  0x60, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x01, 0xC0, 0x78, 0x03, 0xC0, 0x78, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x38, 0x07, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xE0, 0x00,
  0x1D, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0x80, 0x03, 0xB8, 0x00, 0x7C, 0x00, 0x3D, 0xC0, 0x03, 0xE0, 0x01,
  0xCE, 0x00, 0x3F, 0x00, 0x1E, 0x70, 0x01, 0xF8, 0x00, 0xE3, 0x80, 0x1D,
  0xC0, 0x0F, 0x1C, 0x00, 0xEE, 0x00, 0x70, 0xE0, 0x0F, 0x70, 0x03, 0x87,
  0x00, 0x73, 0x80, 0x3C, 0x38, 0x03, 0x9C, 0x01, 0xC1, 0xC0, 0x38, 0xE0,
  0x1E, 0x0E, 0x01, 0xC7, 0x00, 0xE0, 0x70, 0x1C, 0x1C, 0x0F, 0x03, 0x80,
  0xE0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x38,
  0x07, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x0E, 0x1E, 0x01, 0xC3, 0xC0,
  0x70, 0xE0, 0x0E, 0x1C, 0x03, 0x8F, 0x00, 0x71, 0xE0, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0xE7, 0x80, 0x1C, 0x70, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x0E, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x38, 0x03,
  0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x03,
  0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x03, 0xC0,
  0x0E, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x00, 0x38,
  0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x08, 0x7C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x5F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xA0, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 45, 14, 1, -44 },
  { 80, 15, 16, 21, 7, -44 },
  { 110, 34, 44, 34, 1, -44 },
  { 297, 27, 51, 30, 2, -47 },
  { 470, 37, 46, 43, 4, -45 },
  { 683, 32, 46, 35, 1, -45 },
  { 867, 6, 16, 11, 7, -44 },
  { 879, 18, 54, 16, 2, -44 },
  { 1001, 18, 54, 16, -4, -44 },
  { 1123, 23, 24, 29, 7, -47 },
  { 1192, 26, 29, 32, 4, -36 },
  { 1287, 10, 15, 13, -3, -7 },
  { 1306, 14, 3, 18, 2, -18 },
  { 1312, 6, 7, 13, 1, -6 },
  { 1318, 28, 44, 20, -3, -44 },
  { 1472, 26, 46, 30, 3, -45 },
  { 1622, 15, 44, 30, 9, -44 },
  { 1705, 30, 45, 30, -1, -45 },
  { 1874, 29, 46, 30, 0, -45 },
  { 2041, 29, 45, 30, 0, -45 },
  { 2205, 29, 45, 30, 1, -44 },
  { 2369, 27, 46, 30, 3, -45 },
  { 2525, 26, 44, 30, 5, -44 },
  { 2668, 28, 46, 30, 2, -45 },
  { 2829, 27, 46, 30, 2, -45 },
  { 2985, 11, 34, 13, 1, -33 },
  { 3032, 15, 41, 13, -3, -33 },
  { 3109, 26, 28, 32, 4, -36 },
  { 3200, 26, 16, 32, 4, -30 },
  { 3252, 26, 28, 32, 4, -36 },
  { 3343, 21, 46, 22, 3, -45 },
  { 3464, 41, 50, 45, 3, -44 },
  { 3721, 31, 44, 30, -4, -44 },
  { 3892, 30, 44, 33, 2, -44 },
  { 4057, 31, 46, 31, 4, -45 },
  { 4236, 33, 44, 36, 2, -44 },
  { 4418, 29, 44, 29, 2, -44 },
  { 4578, 29, 44, 26, 2, -44 },
  { 4738, 33, 46, 38, 4, -45 },
  { 4928, 36, 44, 37, 2, -44 },
  { 5126, 21, 44, 17, -1, -44 },
  { 5242, 25, 55, 14, -10, -44 },
  { 5414, 33, 44, 30, 2, -44 },
  { 5596, 20, 44, 26, 2, -44 },
  { 5706, 45, 44, 46, 2, -44 },
  { 5954, 37, 44, 38, 2, -44 },
  { 6158, 33, 46, 39, 4, -45 },
  { 6348, 29, 44, 31, 2, -44 },
  { 6508, 33, 56, 39, 4, -45 },
  { 6739, 29, 44, 31, 2, -44 },
  { 6899, 29, 46, 28, 0, -45 },
  { 7066, 27, 44, 27, 5, -44 },
  { 7215, 34, 45, 37, 4, -44 },
  { 7407, 29, 44, 30, 6, -44 },
  { 7567, 45, 44, 47, 7, -44 },
  { 7815, 36, 44, 28, -4, -44 },
  { 8013, 26, 44, 27, 6, -44 },
  { 8156, 32, 44, 28, -1, -44 },
  { 8332, 23, 54, 18, -1, -44 },
  { 8488, 10, 44, 20, 6, -44 },
  { 8543, 23, 54, 18, -4, -44 },
  { 8699, 27, 25, 31, 2, -44 },
  { 8784, 22, 3, 21, -5, 6 },
  { 8793, 8, 9, 15, 9, -47 },
  { 8802, 27, 35, 31, 3, -34 },
  { 8921, 28, 48, 32, 1, -47 },
  { 9089, 22, 35, 24, 3, -34 },
  { 9186, 30, 48, 32, 3, -47 },
  { 9366, 23, 35, 27, 3, -34 },
  { 9467, 32, 62, 16, -8, -47 },
  { 9715, 29, 49, 32, 1, -34 },
  { 9893, 27, 47, 31, 1, -47 },
  { 10052, 13, 45, 13, 1, -45 },
  { 10126, 22, 60, 13, -8, -45 },
  { 10291, 27, 47, 26, 1, -47 },
  { 10450, 14, 47, 13, 1, -47 },
  { 10533, 43, 34, 47, 1, -34 },
  { 10716, 27, 34, 31, 1, -34 },
  { 10831, 25, 35, 31, 3, -34 },
  { 10941, 31, 49, 32, -2, -34 },
  { 11131, 27, 49, 32, 3, -34 },
  { 11297, 22, 34, 21, 1, -34 },
  { 11391, 23, 35, 24, 0, -34 },
  { 11492, 16, 42, 17, 3, -41 },
  { 11576, 27, 34, 31, 3, -33 },
  { 11691, 24, 33, 24, 3, -33 },
  { 11790, 37, 33, 38, 4, -33 },
  { 11943, 29, 33, 26, -2, -33 },
  { 12063, 33, 48, 24, -6, -33 },
  { 12261, 25, 33, 23, -1, -33 },
  { 12365, 23, 54, 21, 1, -44 },
  { 12521, 3, 62, 29, 14, -47 },
  { 12545, 22, 54, 21, -3, -44 },
  { 12694, 26, 6, 32, 4, -25 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC62PT7B_H_
