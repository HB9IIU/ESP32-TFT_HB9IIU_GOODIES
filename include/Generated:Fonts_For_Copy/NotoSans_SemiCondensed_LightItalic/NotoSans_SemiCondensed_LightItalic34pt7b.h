#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x83,
  0x06, 0x0C, 0x10, 0x20, 0xC0, 0x00, 0x00, 0x18, 0x38, 0x60, 0x63, 0x63,
  0x42, 0xC6, 0xC6, 0xC6, 0x84, 0x84, 0x84, 0x00, 0xC1, 0x00, 0x20, 0xC0,
  0x08, 0x30, 0x06, 0x08, 0x01, 0x86, 0x00, 0x41, 0x80, 0x30, 0x40, 0xFF,
  0xFF, 0x3F, 0xFF, 0xC0, 0x82, 0x00, 0x60, 0x80, 0x18, 0x60, 0x04, 0x18,
  0x03, 0x04, 0x00, 0xC3, 0x03, 0xFF, 0xFC, 0x18, 0x20, 0x06, 0x08, 0x01,
  0x06, 0x00, 0x41, 0x00, 0x30, 0x40, 0x0C, 0x30, 0x02, 0x0C, 0x01, 0x82,
  0x00, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x0F, 0xC0, 0x7F, 0xE1, 0x88,
  0x86, 0x10, 0x0C, 0x60, 0x18, 0x80, 0x31, 0x00, 0x62, 0x00, 0xEC, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x78, 0x00, 0xB8, 0x03, 0x30, 0x06, 0x30, 0x08,
  0x60, 0x10, 0xC0, 0x23, 0x00, 0xC6, 0x39, 0xB8, 0x7F, 0xC0, 0x04, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x06, 0x18,
  0x80, 0xC3, 0x0C, 0x08, 0x20, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0x82, 0x04,
  0x08, 0x60, 0x41, 0x8C, 0x0C, 0x18, 0x80, 0xC1, 0x99, 0xEC, 0x13, 0x3F,
  0xC3, 0x26, 0x36, 0x66, 0x41, 0x7C, 0xCC, 0x11, 0x08, 0xC1, 0x01, 0x88,
  0x10, 0x31, 0x83, 0x03, 0x18, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x20, 0xC1,
  0x86, 0x18, 0x18, 0x43, 0x01, 0x8C, 0x30, 0x0F, 0x80, 0x00, 0x60, 0x00,
  0xFC, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x20, 0x60, 0x10, 0x30,
  0x08, 0x38, 0x06, 0x18, 0x03, 0x38, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x78,
  0x00, 0xEC, 0x00, 0xE3, 0x06, 0xC1, 0x83, 0x60, 0x63, 0x60, 0x31, 0xB0,
  0x0D, 0x98, 0x07, 0x8C, 0x01, 0xC6, 0x01, 0xE3, 0x01, 0xB0, 0xE7, 0x8C,
  0x3F, 0x87, 0x00, 0x6D, 0x6D, 0xA4, 0x80, 0x00, 0xC0, 0x60, 0x30, 0x18,
  0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x40, 0x10, 0x06, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0x40, 0x18,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x03, 0x00, 0x18,
  0x00, 0xC1, 0x04, 0x0E, 0x20, 0x3D, 0x04, 0x3F, 0xE1, 0xC0, 0x1A, 0x01,
  0x98, 0x18, 0x40, 0xC3, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x19,
  0xCC, 0x66, 0x33, 0x18, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x0F, 0xC0,
  0xE3, 0x83, 0x06, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x60, 0x0D,
  0x80, 0x36, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x06,
  0xC0, 0x1A, 0x00, 0xC8, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x0C, 0x1C,
  0x1C, 0xE0, 0x3F, 0x00, 0x07, 0x0F, 0x3B, 0x76, 0xC6, 0x86, 0x06, 0x04,
  0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x20, 0x60, 0x60, 0x00, 0x60, 0x03, 0xFC, 0x07, 0x0E, 0x04, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x70, 0x03, 0xFC, 0x0F, 0x0E,
  0x04, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x80, 0x30, 0xF1, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x16, 0x00, 0x36, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x8C,
  0x01, 0x8C, 0x03, 0x0C, 0x06, 0x08, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x30, 0x18, 0x60, 0x10, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x07, 0xFE, 0x0C, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x2F, 0x00, 0xFF, 0x80, 0x83, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x10,
  0x0C, 0x38, 0xF0, 0x7F, 0xC0, 0x00, 0x1E, 0x03, 0xF8, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x9F, 0x03, 0x7F, 0x8D, 0x03, 0x1C, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0,
  0x19, 0x80, 0x33, 0x00, 0x46, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x38, 0x38,
  0x3C, 0xE0, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x07, 0xF8, 0x1C, 0x30, 0x60, 0x30, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x8C,
  0x03, 0x0C, 0x0C, 0x18, 0x38, 0x18, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xDC,
  0x0E, 0x1C, 0x30, 0x1C, 0x60, 0x19, 0x80, 0x33, 0x00, 0x66, 0x00, 0xCC,
  0x01, 0x98, 0x03, 0x18, 0x0C, 0x3C, 0x70, 0x3F, 0xC0, 0x00, 0x60, 0x07,
  0xF0, 0x18, 0x70, 0x60, 0x61, 0x80, 0x43, 0x00, 0xCC, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x0C, 0xC0, 0x39, 0x80, 0x63, 0x01, 0xC7, 0x07, 0x87,
  0xFB, 0x03, 0x84, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x63, 0xC0, 0xFE, 0x00, 0x1C, 0x71, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0xC3, 0x00, 0x03, 0x81,
  0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x00, 0x00,
  0x04, 0x00, 0x30, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0x20, 0x00, 0x02, 0x0F, 0xF8,
  0xC3, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x20, 0x04, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x07, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x01,
  0xE0, 0xE0, 0x06, 0x00, 0x60, 0x18, 0x00, 0x60, 0x60, 0x00, 0x41, 0x80,
  0x00, 0xC6, 0x01, 0x01, 0x8C, 0x1F, 0xE3, 0x30, 0x70, 0x82, 0x61, 0x83,
  0x05, 0x83, 0x06, 0x1B, 0x0C, 0x08, 0x36, 0x18, 0x30, 0x68, 0x20, 0x60,
  0xD0, 0xC0, 0xC1, 0x61, 0x83, 0x06, 0xC3, 0x06, 0x09, 0x86, 0x1C, 0x31,
  0x06, 0x6C, 0xC2, 0x0F, 0x8F, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x06, 0xC0, 0x03,
  0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC1, 0x00,
  0x60, 0x80, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x1F, 0xFC, 0x1F, 0xFE,
  0x0C, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x33, 0x00,
  0x19, 0x80, 0x05, 0x80, 0x03, 0x07, 0xFC, 0x03, 0x0F, 0x81, 0x00, 0xC1,
  0x80, 0x70, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x06, 0x18, 0x07,
  0x0C, 0x07, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0,
  0x18, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x86,
  0x01, 0xC2, 0x01, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x7F,
  0xC0, 0xF0, 0x60, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x7C, 0xE0, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x01, 0x8F, 0x80, 0x40, 0x70, 0x30, 0x06, 0x0C,
  0x01, 0x83, 0x00, 0x30, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x0C, 0x60, 0x03, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x06, 0x30, 0x03, 0x18, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x30, 0x60,
  0x1C, 0x10, 0x1C, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0x06, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3F, 0xF8, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xF0, 0x3C, 0x1C, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x0F, 0xEC, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x03, 0x30, 0x00,
  0xCC, 0x00, 0x33, 0x00, 0x18, 0x60, 0x06, 0x18, 0x01, 0x83, 0x00, 0x60,
  0x79, 0xF8, 0x0F, 0xF8, 0x00, 0x06, 0x00, 0x30, 0x60, 0x06, 0x04, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0x80,
  0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x30,
  0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x03, 0x00, 0x30, 0x30, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x20, 0x60, 0x06, 0x04, 0x00, 0x60,
  0xC0, 0x06, 0x0C, 0x00, 0x60, 0x07, 0xF0, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x0F, 0xC0, 0x7C, 0x00, 0x06, 0x01, 0xC1, 0x80, 0xE0, 0x40,
  0x70, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x61, 0x80,
  0x18, 0xC0, 0x06, 0x60, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x3D, 0x80, 0x0E,
  0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0x60, 0x18, 0x18, 0x06, 0x07,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x70,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0x07, 0x00, 0x07,
  0x83, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xD0, 0x01,
  0xB0, 0x68, 0x00, 0xD0, 0x36, 0x00, 0xD8, 0x33, 0x00, 0x4C, 0x19, 0x80,
  0x66, 0x0C, 0xC0, 0x63, 0x06, 0x60, 0x33, 0x02, 0x30, 0x31, 0x83, 0x08,
  0x18, 0xC1, 0x84, 0x18, 0x60, 0xC2, 0x0C, 0x30, 0x61, 0x8C, 0x30, 0x20,
  0xC6, 0x18, 0x30, 0x66, 0x0C, 0x18, 0x33, 0x06, 0x0C, 0x1B, 0x02, 0x06,
  0x0D, 0x03, 0x02, 0x03, 0x81, 0x83, 0x01, 0x80, 0xC1, 0x80, 0xC0, 0x60,
  0x06, 0x00, 0x30, 0x70, 0x03, 0x07, 0x00, 0x30, 0xF0, 0x06, 0x0D, 0x80,
  0x60, 0xD8, 0x06, 0x0D, 0x80, 0x61, 0x8C, 0x06, 0x18, 0xC0, 0xC1, 0x8C,
  0x0C, 0x18, 0x60, 0xC1, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x03, 0x18, 0x30,
  0x31, 0x83, 0x03, 0x18, 0x20, 0x19, 0x86, 0x01, 0x90, 0x60, 0x1B, 0x06,
  0x00, 0xB0, 0x60, 0x0F, 0x04, 0x00, 0xF0, 0xC0, 0x06, 0x0C, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x7F, 0x80, 0x38, 0x70, 0x18, 0x06, 0x0C, 0x01, 0xC6,
  0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x36, 0x00,
  0x0D, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x06, 0x18,
  0x03, 0x87, 0x01, 0xC0, 0xF9, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x06,
  0x3E, 0x04, 0x06, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x1C, 0x3F, 0xF8, 0x3F,
  0xE0, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x7F, 0x80, 0x38, 0x70, 0x18, 0x06, 0x0C, 0x01, 0xC6, 0x00, 0x33, 0x80,
  0x0C, 0xC0, 0x03, 0x30, 0x00, 0xD8, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x06, 0xC0, 0x01, 0xB0,
  0x00, 0x6C, 0x00, 0x33, 0x00, 0x0C, 0x60, 0x06, 0x18, 0x03, 0x83, 0x01,
  0xC0, 0xF9, 0xE0, 0x0F, 0xE0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x07, 0xF8, 0x06, 0x3E, 0x04,
  0x06, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18,
  0x07, 0x18, 0x06, 0x18, 0x0C, 0x18, 0x3C, 0x3F, 0xF0, 0x3F, 0xC0, 0x30,
  0x40, 0x30, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x30, 0x60, 0x30, 0x60,
  0x30, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0x00, 0x30, 0x03, 0xFF, 0x07,
  0x87, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x80, 0x70, 0xFB, 0xE0, 0x7F, 0xC0, 0xFF, 0xFC, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x61, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0x61, 0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x61, 0x80, 0x0C, 0x30, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x04, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x06,
  0x18, 0x00, 0xC2, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x18,
  0x60, 0x06, 0x0E, 0x01, 0xC0, 0xC0, 0x70, 0x0F, 0x3C, 0x00, 0xFE, 0x00,
  0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x40, 0x0C, 0x40, 0x18,
  0x60, 0x18, 0x60, 0x30, 0x60, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0xC0,
  0x60, 0xC0, 0x61, 0x80, 0x61, 0x80, 0x63, 0x00, 0x63, 0x00, 0x26, 0x00,
  0x26, 0x00, 0x2C, 0x00, 0x2C, 0x00, 0x28, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x06, 0x80, 0x78, 0x06,
  0x80, 0x78, 0x0C, 0xC0, 0x58, 0x0C, 0xC0, 0xD8, 0x0C, 0xC0, 0x98, 0x18,
  0xC1, 0x88, 0x18, 0xC1, 0x88, 0x30, 0xC3, 0x08, 0x30, 0xC3, 0x08, 0x60,
  0xC6, 0x08, 0x60, 0xC6, 0x08, 0x60, 0xC4, 0x08, 0xC0, 0xCC, 0x08, 0xC0,
  0xC8, 0x09, 0x80, 0xD8, 0x09, 0x80, 0xD8, 0x0B, 0x00, 0xF0, 0x0B, 0x00,
  0xF0, 0x0A, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0x03, 0x00, 0x70, 0x30, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x01, 0x83,
  0x00, 0x08, 0x30, 0x00, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xD8, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xB0, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x0C, 0x18, 0x01,
  0x80, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x06, 0x0E, 0x00, 0x60,
  0xC0, 0x0F, 0x80, 0x19, 0x80, 0x63, 0x01, 0x86, 0x03, 0x0C, 0x0C, 0x08,
  0x30, 0x18, 0x60, 0x31, 0x80, 0x63, 0x00, 0xCC, 0x00, 0xB0, 0x01, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x03, 0xFF, 0xC1,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x07, 0xFF,
  0xC3, 0xFF, 0xE0, 0x03, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFC, 0x00, 0xC1,
  0x06, 0x18, 0x61, 0x82, 0x08, 0x30, 0xC3, 0x0C, 0x30, 0x41, 0x06, 0x18,
  0x61, 0x82, 0x08, 0x30, 0xC3, 0x03, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0xFC,
  0x00, 0x00, 0xC0, 0x03, 0x80, 0x05, 0x80, 0x1B, 0x00, 0x22, 0x00, 0xC6,
  0x03, 0x04, 0x06, 0x0C, 0x18, 0x18, 0x20, 0x10, 0xC0, 0x33, 0x00, 0x66,
  0x00, 0x78, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC6, 0x63, 0x10, 0x03, 0xE2,
  0x1C, 0x6C, 0x70, 0x78, 0xC0, 0x73, 0x00, 0xC6, 0x01, 0x98, 0x03, 0x30,
  0x06, 0x60, 0x0C, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x98, 0x06,
  0x18, 0x14, 0x30, 0x78, 0x73, 0xB0, 0x7E, 0x60, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x19,
  0xF8, 0x37, 0x38, 0x78, 0x30, 0xA0, 0x31, 0x80, 0x67, 0x00, 0xCC, 0x01,
  0x98, 0x03, 0x30, 0x06, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0x8C,
  0x03, 0x38, 0x0C, 0x78, 0x38, 0xD8, 0xE1, 0x1F, 0x80, 0x03, 0xF8, 0x78,
  0x87, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x38,
  0xC0, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x03, 0xF2, 0x07, 0x1B,
  0x07, 0x03, 0x83, 0x01, 0xC3, 0x00, 0xE1, 0x80, 0x61, 0x80, 0x30, 0xC0,
  0x18, 0x60, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x86,
  0x01, 0xC1, 0x81, 0xC0, 0xC1, 0xA0, 0x73, 0xB0, 0x1F, 0x98, 0x00, 0x03,
  0xF0, 0x71, 0xC7, 0x06, 0x30, 0x33, 0x01, 0x98, 0x0D, 0x80, 0xCC, 0x1C,
  0x7F, 0xC3, 0xC0, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x38, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x03, 0xFC,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x00, 0xB8, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF9, 0x83, 0x8C, 0x83, 0x81,
  0xC1, 0x80, 0xE1, 0x80, 0x70, 0xC0, 0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30,
  0x06, 0x18, 0x03, 0x1C, 0x03, 0x0C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xE0,
  0xC0, 0xE0, 0x60, 0xF0, 0x39, 0xD8, 0x0F, 0xCC, 0x00, 0x06, 0x00, 0x02,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x81, 0x01, 0xC0, 0xFF, 0xC0, 0x3F,
  0x80, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x00, 0x19, 0xF8, 0x6C, 0x71, 0xE0, 0xC7, 0x03, 0x18,
  0x0C, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x66, 0x01, 0x98,
  0x06, 0x60, 0x19, 0x80, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC0,
  0x04, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06,
  0x0C, 0x18, 0x60, 0xC1, 0x83, 0x06, 0x18, 0x30, 0x60, 0xC0, 0x00, 0x10,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x1F, 0x80, 0xF8, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x0C, 0x60, 0x61, 0x83, 0x06,
  0x18, 0x10, 0xC0, 0xC6, 0x03, 0x30, 0x0D, 0x80, 0x2F, 0x01, 0xEC, 0x07,
  0x30, 0x18, 0x60, 0x61, 0x81, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x63,
  0x01, 0x80, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60,
  0xC1, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1,
  0x80, 0x19, 0xF8, 0xFC, 0x36, 0x33, 0x1C, 0x78, 0x3C, 0x18, 0xE0, 0x70,
  0x31, 0x80, 0xC0, 0x67, 0x01, 0x80, 0xCC, 0x06, 0x01, 0x98, 0x0C, 0x03,
  0x30, 0x18, 0x0C, 0xC0, 0x30, 0x19, 0x80, 0x60, 0x33, 0x01, 0x80, 0x66,
  0x03, 0x00, 0x8C, 0x06, 0x03, 0x30, 0x0C, 0x06, 0x60, 0x10, 0x0C, 0xC0,
  0x60, 0x19, 0x80, 0xC0, 0x60, 0x19, 0xF8, 0x6E, 0x71, 0xE0, 0xC7, 0x03,
  0x38, 0x0C, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x66, 0x01,
  0x98, 0x06, 0x60, 0x19, 0x80, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0xC0, 0x03, 0xF0, 0x1E, 0x70, 0x70, 0x30, 0xC0, 0x63, 0x00, 0xC6, 0x00,
  0xD8, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xC0, 0x1B, 0x00, 0x36, 0x00, 0x6C,
  0x01, 0x88, 0x03, 0x18, 0x0C, 0x30, 0x38, 0x39, 0xE0, 0x3F, 0x00, 0x06,
  0x7E, 0x03, 0x73, 0x81, 0xE0, 0xC0, 0xA0, 0x30, 0x60, 0x18, 0x70, 0x0C,
  0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x60, 0xC0, 0x30, 0xE0, 0x30, 0x78, 0x38, 0x36, 0x38, 0x19,
  0xF8, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF3, 0x0F, 0x32, 0x1C,
  0x0E, 0x18, 0x0E, 0x30, 0x0E, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0x60,
  0x70, 0x60, 0xF0, 0x73, 0xB0, 0x3F, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x19,
  0xF1, 0xBA, 0x1E, 0x01, 0x40, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x0F, 0xF8, 0xE1, 0x86, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x03, 0x10, 0x18, 0xE3, 0x87, 0xF8, 0x00, 0x04, 0x06, 0x03, 0x01,
  0x07, 0xF8, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x06, 0x43, 0xE0, 0x18, 0x06, 0x30,
  0x0C, 0x60, 0x18, 0x80, 0x23, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06,
  0x20, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x03, 0x88, 0x06, 0x30,
  0x1C, 0x30, 0x78, 0x73, 0xB0, 0x7C, 0x40, 0xC0, 0x1E, 0x01, 0xB0, 0x0D,
  0x80, 0xCC, 0x06, 0x60, 0x63, 0x03, 0x18, 0x30, 0x43, 0x02, 0x18, 0x19,
  0x80, 0xCC, 0x06, 0xC0, 0x36, 0x01, 0xA0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x00, 0xC0, 0x60, 0x3C, 0x0E, 0x03, 0xC0, 0xE0, 0x6C, 0x0A, 0x06, 0xC1,
  0xA0, 0xCC, 0x12, 0x0C, 0xC3, 0x20, 0x8C, 0x22, 0x18, 0xC6, 0x31, 0x8C,
  0x43, 0x30, 0xCC, 0x33, 0x0C, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0x40,
  0xD0, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x0C, 0x07,
  0x0C, 0x06, 0x06, 0x0C, 0x06, 0x18, 0x06, 0x30, 0x03, 0x70, 0x03, 0x60,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0x40,
  0x18, 0x60, 0x30, 0x60, 0x30, 0x20, 0x60, 0x30, 0xC0, 0x30, 0x03, 0x00,
  0x60, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x02, 0x06,
  0x00, 0x40, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31, 0x80, 0x06, 0x30,
  0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x2C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x5C, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0xF0, 0x1C, 0x03,
  0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x0F,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x00, 0x0C, 0x00, 0x70, 0x00, 0xE0, 0x1E, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xFC,
  0x18, 0x3F, 0xE0, 0x1C,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 7, 24, 8, 1, -24 },
  { 22, 8, 9, 11, 4, -24 },
  { 31, 18, 24, 19, 1, -24 },
  { 85, 15, 28, 16, 1, -26 },
  { 138, 20, 25, 24, 2, -25 },
  { 201, 17, 25, 19, 1, -25 },
  { 255, 3, 9, 6, 4, -24 },
  { 259, 10, 29, 9, 1, -24 },
  { 296, 10, 29, 9, -2, -24 },
  { 333, 13, 13, 16, 4, -26 },
  { 355, 14, 16, 17, 2, -20 },
  { 383, 5, 8, 7, -1, -4 },
  { 388, 8, 2, 10, 1, -10 },
  { 390, 3, 3, 7, 1, -3 },
  { 392, 16, 24, 11, -2, -24 },
  { 440, 14, 25, 16, 2, -25 },
  { 484, 8, 24, 16, 5, -24 },
  { 508, 16, 25, 16, 0, -25 },
  { 558, 16, 25, 16, 0, -25 },
  { 608, 16, 24, 16, 0, -24 },
  { 656, 15, 24, 16, 1, -24 },
  { 701, 15, 25, 16, 2, -25 },
  { 748, 14, 24, 16, 3, -24 },
  { 790, 15, 25, 16, 1, -25 },
  { 837, 15, 25, 16, 1, -25 },
  { 884, 6, 18, 7, 1, -18 },
  { 898, 9, 22, 7, -2, -18 },
  { 923, 14, 16, 17, 2, -20 },
  { 951, 14, 8, 17, 2, -16 },
  { 965, 14, 16, 17, 2, -20 },
  { 993, 11, 25, 12, 2, -25 },
  { 1028, 23, 27, 25, 1, -24 },
  { 1106, 17, 24, 16, -2, -24 },
  { 1157, 17, 24, 18, 1, -24 },
  { 1208, 17, 25, 17, 2, -25 },
  { 1262, 18, 24, 20, 1, -24 },
  { 1316, 16, 24, 16, 1, -24 },
  { 1364, 16, 24, 14, 1, -24 },
  { 1412, 18, 25, 21, 2, -25 },
  { 1469, 20, 24, 20, 1, -24 },
  { 1529, 12, 24, 9, -1, -24 },
  { 1565, 13, 30, 8, -5, -24 },
  { 1614, 18, 24, 17, 1, -24 },
  { 1668, 11, 24, 14, 1, -24 },
  { 1701, 25, 24, 25, 1, -24 },
  { 1776, 20, 24, 21, 1, -24 },
  { 1836, 18, 25, 21, 2, -25 },
  { 1893, 16, 24, 17, 1, -24 },
  { 1941, 18, 31, 21, 2, -25 },
  { 2011, 16, 24, 17, 1, -24 },
  { 2059, 16, 25, 15, 0, -25 },
  { 2109, 14, 24, 15, 3, -24 },
  { 2151, 19, 24, 20, 2, -24 },
  { 2208, 16, 24, 16, 3, -24 },
  { 2256, 24, 24, 26, 4, -24 },
  { 2328, 20, 24, 15, -2, -24 },
  { 2388, 15, 24, 15, 3, -24 },
  { 2433, 18, 24, 16, -1, -24 },
  { 2487, 12, 29, 10, 0, -24 },
  { 2531, 6, 24, 11, 3, -24 },
  { 2549, 12, 29, 10, -2, -24 },
  { 2593, 15, 14, 17, 1, -24 },
  { 2620, 12, 2, 12, -3, 3 },
  { 2623, 4, 5, 8, 5, -26 },
  { 2626, 15, 18, 17, 1, -18 },
  { 2660, 15, 26, 17, 1, -26 },
  { 2709, 13, 18, 13, 1, -18 },
  { 2739, 17, 26, 17, 1, -26 },
  { 2795, 13, 18, 15, 1, -18 },
  { 2825, 17, 34, 9, -4, -26 },
  { 2898, 17, 26, 17, 0, -18 },
  { 2954, 14, 26, 17, 1, -26 },
  { 3000, 7, 25, 7, 1, -25 },
  { 3022, 13, 33, 7, -5, -25 },
  { 3076, 14, 26, 14, 1, -26 },
  { 3122, 7, 26, 7, 1, -26 },
  { 3145, 23, 18, 26, 1, -18 },
  { 3197, 14, 18, 17, 1, -18 },
  { 3229, 15, 18, 17, 1, -18 },
  { 3263, 17, 26, 17, -1, -18 },
  { 3319, 16, 26, 17, 1, -18 },
  { 3371, 12, 18, 11, 1, -18 },
  { 3398, 13, 18, 13, 0, -18 },
  { 3428, 9, 22, 10, 1, -22 },
  { 3453, 15, 18, 17, 1, -18 },
  { 3487, 13, 18, 13, 2, -18 },
  { 3517, 20, 18, 21, 2, -18 },
  { 3562, 16, 18, 14, -1, -18 },
  { 3598, 19, 26, 13, -4, -18 },
  { 3660, 14, 18, 13, -1, -18 },
  { 3692, 12, 29, 11, 1, -24 },
  { 3736, 1, 34, 16, 8, -26 },
  { 3741, 13, 29, 11, -2, -24 },
  { 3789, 14, 4, 17, 2, -14 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC34PT7B_H_
