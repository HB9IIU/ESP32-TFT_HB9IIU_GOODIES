#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC2, 0x08, 0x61, 0x84,
  0x00, 0x00, 0x0C, 0x30, 0x66, 0x8D, 0x12, 0x2C, 0x51, 0xA2, 0x00, 0x01,
  0x08, 0x06, 0x10, 0x08, 0x60, 0x10, 0x80, 0x61, 0x00, 0x86, 0x1F, 0xFF,
  0x82, 0x10, 0x0C, 0x60, 0x10, 0x80, 0x21, 0x00, 0xC2, 0x01, 0x0C, 0x1F,
  0xFF, 0x0C, 0x20, 0x10, 0xC0, 0x21, 0x00, 0x42, 0x01, 0x8C, 0x02, 0x18,
  0x00, 0x00, 0x80, 0x08, 0x07, 0xE0, 0xF7, 0x19, 0x03, 0x10, 0x31, 0x03,
  0x20, 0x32, 0x01, 0xA0, 0x0E, 0x00, 0x78, 0x05, 0xC0, 0x4C, 0x04, 0x40,
  0x44, 0x0C, 0xC8, 0x98, 0xFF, 0x03, 0xC0, 0x08, 0x01, 0x00, 0x10, 0x00,
  0x1E, 0x02, 0x32, 0x04, 0x63, 0x0C, 0x43, 0x08, 0x42, 0x18, 0xC2, 0x30,
  0x82, 0x20, 0x82, 0x60, 0x86, 0xCF, 0x84, 0x91, 0xCD, 0xB1, 0x7B, 0x21,
  0x02, 0x61, 0x06, 0x61, 0x0C, 0x41, 0x08, 0x43, 0x18, 0x42, 0x10, 0x42,
  0x20, 0x64, 0x60, 0x3C, 0x03, 0xC0, 0x11, 0x80, 0xC3, 0x02, 0x0C, 0x08,
  0x20, 0x21, 0x80, 0x84, 0x03, 0x60, 0x07, 0x00, 0x38, 0x01, 0xA0, 0x18,
  0xC3, 0x41, 0x8B, 0x06, 0x68, 0x0D, 0x20, 0x3C, 0x80, 0x63, 0x03, 0x8E,
  0x3B, 0x1F, 0x86, 0x6D, 0x2D, 0x20, 0x03, 0x06, 0x04, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x06, 0x02, 0x03, 0x03, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x06, 0x06, 0x04,
  0x0C, 0x08, 0x18, 0x30, 0x20, 0xC0, 0x06, 0x00, 0xC2, 0x10, 0x72, 0x03,
  0xDE, 0x1F, 0xC7, 0x01, 0x90, 0x62, 0x08, 0x60, 0x08, 0x00, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x0F, 0xFF, 0xFF, 0xF0, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x33, 0x26, 0x4C, 0x80, 0xFC, 0xF0,
  0x00, 0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x07, 0xE0, 0xC6, 0x18, 0x31, 0x83,
  0x30, 0x13, 0x01, 0x20, 0x16, 0x03, 0x60, 0x34, 0x03, 0x40, 0x3C, 0x02,
  0xC0, 0x2C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xC4, 0x18, 0x63, 0x03, 0xE0,
  0x06, 0x3C, 0xD7, 0x28, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06,
  0x0C, 0x18, 0x20, 0x41, 0x83, 0x00, 0x07, 0xE0, 0x61, 0x82, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x09, 0xFF, 0x80, 0x07, 0xF0, 0xE1, 0x82, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x7C, 0x00, 0x70, 0x00, 0xC0, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60, 0x06, 0x30, 0x70, 0xFE, 0x00,
  0x00, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xA0, 0x09, 0x00, 0x98, 0x0C, 0xC0,
  0xC4, 0x0C, 0x20, 0x43, 0x04, 0x18, 0x60, 0xC6, 0x04, 0x20, 0x23, 0xFF,
  0xE0, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x03, 0x00, 0x07, 0xF8, 0x20,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x1F, 0x80,
  0x87, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x30, 0x70, 0xFE, 0x00, 0x01, 0xF8, 0x38, 0x03, 0x00, 0x10,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x6F, 0xC3, 0xC3, 0x18, 0x18,
  0xC0, 0x44, 0x02, 0x60, 0x13, 0x01, 0x98, 0x0C, 0x40, 0x43, 0x06, 0x18,
  0x60, 0x7E, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x07, 0xE0, 0xC3,
  0x18, 0x11, 0x01, 0x10, 0x11, 0x01, 0x18, 0x31, 0x86, 0x0D, 0xC0, 0x70,
  0x19, 0x83, 0x0C, 0x40, 0x4C, 0x06, 0x80, 0x68, 0x06, 0x80, 0x4C, 0x0C,
  0x61, 0x83, 0xF0, 0x07, 0xC1, 0xC6, 0x18, 0x33, 0x03, 0x20, 0x36, 0x03,
  0x60, 0x36, 0x03, 0x60, 0x36, 0x07, 0x30, 0xA1, 0xF2, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x86, 0x0F, 0xC0, 0x18, 0xC2, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0x80, 0x0C, 0x30, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0xC6, 0x18, 0x43, 0x08, 0x00, 0x00, 0x30,
  0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x08, 0x00, 0x3E, 0x31, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x04, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x38, 0x70,
  0x18, 0x02, 0x06, 0x00, 0x21, 0x80, 0x04, 0x20, 0x00, 0xCC, 0x3F, 0x09,
  0x0C, 0x21, 0x63, 0x0C, 0x28, 0x41, 0x0D, 0x18, 0x21, 0xE3, 0x0C, 0x2C,
  0x41, 0x85, 0x88, 0x21, 0xB1, 0x0C, 0x26, 0x32, 0xD8, 0xC3, 0x8E, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x80, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x80, 0x16, 0x00, 0xD8, 0x02, 0x60, 0x19,
  0x80, 0x46, 0x03, 0x08, 0x08, 0x20, 0x60, 0x81, 0x02, 0x0F, 0xF8, 0x20,
  0x21, 0x80, 0xC4, 0x03, 0x30, 0x0C, 0x80, 0x36, 0x00, 0xF0, 0x03, 0x0F,
  0xE0, 0x21, 0xE0, 0x81, 0x86, 0x03, 0x18, 0x0C, 0x40, 0x21, 0x01, 0x8C,
  0x06, 0x30, 0x70, 0xFE, 0x02, 0x0E, 0x08, 0x0C, 0x60, 0x31, 0x80, 0xC6,
  0x03, 0x10, 0x0C, 0x40, 0x23, 0x01, 0x8C, 0x3C, 0x3F, 0xC0, 0x03, 0xFC,
  0x1C, 0x20, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x04, 0x07, 0xF0, 0x0F, 0xE0, 0x11,
  0xE0, 0x20, 0x60, 0xC0, 0x61, 0x80, 0x42, 0x00, 0x84, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x08, 0x80, 0x11, 0x00, 0x66, 0x00, 0xCC, 0x01, 0x18,
  0x06, 0x20, 0x18, 0x40, 0x71, 0x81, 0xC3, 0x1E, 0x07, 0xF0, 0x00, 0x0F,
  0xF8, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0xFF, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0xF0, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x00, 0x03, 0xFC, 0x0E, 0x1C, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x0B,
  0x03, 0xE4, 0x00, 0x48, 0x01, 0x90, 0x03, 0x20, 0x06, 0x60, 0x08, 0xC0,
  0x30, 0xC0, 0x60, 0xC1, 0xC0, 0xFF, 0x00, 0x0C, 0x03, 0x08, 0x03, 0x08,
  0x02, 0x18, 0x02, 0x18, 0x06, 0x10, 0x06, 0x10, 0x06, 0x30, 0x04, 0x30,
  0x04, 0x3F, 0xFC, 0x20, 0x0C, 0x20, 0x0C, 0x60, 0x08, 0x60, 0x08, 0x60,
  0x18, 0x40, 0x18, 0x40, 0x10, 0xC0, 0x10, 0xC0, 0x30, 0xC0, 0x30, 0x0F,
  0xC0, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00,
  0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x03, 0xF0,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x05, 0xC0, 0xF0, 0x00, 0x0C,
  0x06, 0x10, 0x18, 0x20, 0x60, 0xC1, 0x81, 0x86, 0x02, 0x18, 0x04, 0x60,
  0x19, 0x80, 0x36, 0x00, 0x7C, 0x00, 0xE8, 0x01, 0x98, 0x06, 0x10, 0x0C,
  0x30, 0x18, 0x60, 0x20, 0x40, 0x40, 0xC1, 0x81, 0x83, 0x01, 0x04, 0x03,
  0x00, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x18,
  0x08, 0x04, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x60, 0x30, 0x1F, 0xF0,
  0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00, 0xF1, 0xE0, 0x0A, 0x1E, 0x01,
  0xA1, 0x60, 0x16, 0x12, 0x03, 0x63, 0x20, 0x26, 0x32, 0x06, 0x43, 0x20,
  0x44, 0x22, 0x0C, 0xC2, 0x30, 0x8C, 0x63, 0x18, 0x86, 0x33, 0x08, 0x63,
  0x21, 0x84, 0x16, 0x18, 0x41, 0x41, 0x8C, 0x1C, 0x10, 0xC1, 0x81, 0x08,
  0x18, 0x30, 0x0C, 0x01, 0x0C, 0x01, 0x0E, 0x03, 0x1E, 0x03, 0x1A, 0x02,
  0x12, 0x02, 0x13, 0x02, 0x31, 0x06, 0x31, 0x06, 0x31, 0x84, 0x21, 0x84,
  0x20, 0x8C, 0x60, 0xCC, 0x60, 0xCC, 0x60, 0x48, 0x40, 0x68, 0x40, 0x78,
  0xC0, 0x38, 0xC0, 0x38, 0x80, 0x30, 0x03, 0xF0, 0x1C, 0x30, 0x60, 0x31,
  0x80, 0x23, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xA0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x14, 0x00, 0x68, 0x00, 0xD0, 0x01, 0xA0, 0x06, 0x60, 0x0C,
  0xC0, 0x30, 0xC0, 0xC1, 0xC3, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x47, 0x82,
  0x06, 0x30, 0x31, 0x81, 0x88, 0x0C, 0x40, 0x66, 0x03, 0x30, 0x31, 0x83,
  0x0F, 0xF0, 0x7E, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x00, 0x03, 0xF0, 0x1C, 0x30, 0x60, 0x31, 0x80,
  0x23, 0x00, 0x6C, 0x00, 0xD8, 0x01, 0xA0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x14, 0x00, 0x68, 0x00, 0xD0, 0x01, 0xA0, 0x06, 0x60, 0x0C, 0xC0,
  0x30, 0xC0, 0xC1, 0xC3, 0x01, 0xFC, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xC0, 0x0F, 0xE0, 0x47, 0x82, 0x06, 0x30, 0x31, 0x81,
  0x88, 0x0C, 0x40, 0x66, 0x03, 0x30, 0x31, 0x83, 0x0F, 0xF0, 0x42, 0x06,
  0x18, 0x30, 0xC1, 0x82, 0x08, 0x10, 0x40, 0xC6, 0x06, 0x30, 0x11, 0x80,
  0xC0, 0x07, 0xF8, 0x70, 0xC6, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x30, 0xE1, 0xFE, 0x00, 0x7F, 0xF8,
  0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x06, 0x20, 0x0C, 0xC0, 0x19, 0x80, 0x22,
  0x00, 0x44, 0x01, 0x98, 0x03, 0x30, 0x04, 0x60, 0x08, 0x80, 0x31, 0x00,
  0x66, 0x00, 0xCC, 0x01, 0x18, 0x02, 0x20, 0x0C, 0x40, 0x18, 0xC0, 0x61,
  0x80, 0xC1, 0x87, 0x01, 0xF8, 0x00, 0x80, 0x1C, 0x01, 0xA0, 0x0D, 0x00,
  0xC8, 0x06, 0x60, 0x63, 0x03, 0x18, 0x30, 0xC1, 0x86, 0x18, 0x30, 0xC1,
  0x8C, 0x04, 0x60, 0x26, 0x01, 0x30, 0x0B, 0x00, 0x58, 0x02, 0x80, 0x1C,
  0x00, 0xC0, 0x00, 0x80, 0x60, 0x18, 0x06, 0x03, 0xC0, 0xE0, 0x2C, 0x0A,
  0x06, 0xC1, 0xA0, 0x6C, 0x12, 0x0C, 0xC1, 0x20, 0xCC, 0x32, 0x08, 0xC2,
  0x21, 0x8C, 0x62, 0x10, 0xC4, 0x23, 0x0C, 0xC2, 0x20, 0xC8, 0x26, 0x0D,
  0x82, 0x60, 0xD8, 0x24, 0x0D, 0x02, 0xC0, 0xF0, 0x28, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x81, 0x01, 0x80, 0x81, 0x80,
  0x61, 0x80, 0x30, 0x80, 0x08, 0xC0, 0x06, 0xC0, 0x03, 0x40, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x68, 0x00, 0x26, 0x00, 0x33, 0x00, 0x30,
  0x80, 0x10, 0x40, 0x18, 0x30, 0x18, 0x18, 0x18, 0x04, 0x1C, 0x03, 0x00,
  0x80, 0x38, 0x06, 0xC0, 0xCC, 0x08, 0xC1, 0x84, 0x30, 0x43, 0x06, 0x60,
  0x64, 0x02, 0xC0, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0x07, 0xFE, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xC1, 0x00, 0xC0,
  0x30, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30,
  0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0xE0, 0x8C, 0xCC, 0x44, 0x44, 0x66, 0x22, 0x22, 0x33, 0x31, 0x11,
  0x07, 0xE0, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x07, 0xE0, 0x03, 0x00, 0x30,
  0x07, 0x80, 0x48, 0x0C, 0xC1, 0x8C, 0x10, 0x43, 0x06, 0x20, 0x26, 0x02,
  0x40, 0x3C, 0x01, 0xFF, 0xC0, 0xC6, 0x23, 0x07, 0x91, 0xCD, 0x30, 0x53,
  0x03, 0x60, 0x36, 0x02, 0x40, 0x2C, 0x06, 0xC0, 0x6C, 0x04, 0xC0, 0xCC,
  0x0C, 0xC1, 0xC6, 0x2C, 0x3C, 0x80, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x13, 0xC3, 0x66, 0x38, 0x33, 0x03, 0x30, 0x32, 0x03,
  0x60, 0x36, 0x03, 0x40, 0x34, 0x02, 0x40, 0x6C, 0x04, 0xE0, 0xCA, 0x18,
  0x9F, 0x00, 0x07, 0xC7, 0x13, 0x00, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x43, 0xF0, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x79, 0x87, 0x34, 0x30,
  0x30, 0xC0, 0xC6, 0x03, 0x18, 0x08, 0x40, 0x23, 0x01, 0x8C, 0x06, 0x30,
  0x18, 0xC0, 0xC3, 0x03, 0x0C, 0x14, 0x18, 0xB0, 0x3C, 0xC0, 0x07, 0xC3,
  0x98, 0xC1, 0x98, 0x36, 0x04, 0xC1, 0x91, 0xE7, 0xF0, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x04, 0x00, 0xC3, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x7E, 0x02, 0x40, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x0F, 0x00, 0x30, 0x00, 0x03, 0xCC, 0x39, 0xA1,
  0x81, 0x86, 0x06, 0x30, 0x18, 0xC0, 0x62, 0x01, 0x18, 0x0C, 0x60, 0x31,
  0x80, 0xC6, 0x06, 0x18, 0x18, 0x60, 0xA0, 0xC5, 0x81, 0xE6, 0x00, 0x10,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x20, 0x60, 0xFF, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x13, 0xE3, 0x66, 0x38,
  0x33, 0x03, 0x30, 0x32, 0x02, 0x60, 0x26, 0x06, 0x60, 0x64, 0x06, 0x40,
  0x4C, 0x04, 0xC0, 0xC8, 0x0C, 0x80, 0x80, 0x18, 0xC0, 0x00, 0x08, 0xC6,
  0x31, 0x08, 0xC6, 0x21, 0x08, 0xC6, 0x21, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x1E, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x10, 0x73, 0x04, 0x30, 0x83,
  0x18, 0x23, 0x02, 0x60, 0x6C, 0x07, 0xC0, 0x76, 0x04, 0x60, 0x42, 0x0C,
  0x30, 0xC3, 0x08, 0x10, 0x81, 0x80, 0x0C, 0x21, 0x86, 0x18, 0x41, 0x0C,
  0x30, 0xC2, 0x08, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x80, 0x13, 0xC7,
  0xC6, 0xCD, 0x9C, 0xE1, 0xE1, 0x98, 0x18, 0x33, 0x06, 0x06, 0x40, 0xC0,
  0xD8, 0x18, 0x13, 0x02, 0x02, 0x60, 0x40, 0xC8, 0x18, 0x19, 0x03, 0x02,
  0x60, 0x60, 0x4C, 0x08, 0x19, 0x01, 0x03, 0x20, 0x60, 0x60, 0x13, 0xE3,
  0x66, 0x38, 0x33, 0x03, 0x30, 0x32, 0x02, 0x60, 0x26, 0x06, 0x60, 0x64,
  0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0xC8, 0x0C, 0x80, 0x80, 0x07, 0xC1, 0xCE,
  0x30, 0x23, 0x03, 0x60, 0x36, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x2C, 0x06,
  0xC0, 0x6C, 0x04, 0x40, 0xC6, 0x38, 0x3F, 0x00, 0x04, 0xF0, 0x36, 0x60,
  0xE0, 0xC3, 0x03, 0x0C, 0x0C, 0x20, 0x31, 0x80, 0xC6, 0x03, 0x10, 0x0C,
  0x40, 0x21, 0x01, 0x8C, 0x04, 0x38, 0x30, 0xA1, 0x82, 0x7C, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07,
  0x98, 0xE6, 0x8C, 0x1C, 0x60, 0x66, 0x03, 0x30, 0x19, 0x00, 0x98, 0x0C,
  0xC0, 0x66, 0x03, 0x30, 0x31, 0x81, 0x8C, 0x14, 0x31, 0x60, 0xF3, 0x00,
  0x10, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00, 0x80, 0x13,
  0x9B, 0x4E, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18,
  0x0C, 0x04, 0x02, 0x00, 0x0F, 0xC6, 0x33, 0x00, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x38, 0x07, 0x00, 0x40, 0x18, 0x06, 0x01, 0x20, 0xCF, 0xE0, 0x08,
  0x18, 0x10, 0x7F, 0xB0, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0x78, 0x30, 0x13, 0x03, 0x30, 0x32, 0x03, 0x20,
  0x26, 0x02, 0x60, 0x66, 0x06, 0x40, 0x64, 0x04, 0xC0, 0xCC, 0x0C, 0xC1,
  0xCE, 0x28, 0x7C, 0x80, 0xC0, 0x68, 0x0D, 0x03, 0x20, 0x64, 0x18, 0x83,
  0x18, 0xC3, 0x10, 0x66, 0x0C, 0x81, 0xB0, 0x34, 0x03, 0x80, 0x60, 0x0C,
  0x00, 0x81, 0x81, 0x81, 0x83, 0x82, 0x82, 0x82, 0x86, 0x86, 0x84, 0x84,
  0x8C, 0x8C, 0x8C, 0x88, 0x88, 0x98, 0x98, 0x90, 0x90, 0xB0, 0xB0, 0xA0,
  0xA0, 0xA0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x18, 0x41, 0x83, 0x08,
  0x18, 0xC0, 0x4C, 0x03, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x68, 0x06,
  0x60, 0x21, 0x03, 0x08, 0x30, 0x63, 0x01, 0x00, 0x04, 0x02, 0x08, 0x0C,
  0x10, 0x10, 0x20, 0x60, 0x60, 0x80, 0xC3, 0x01, 0x84, 0x03, 0x18, 0x02,
  0x20, 0x04, 0xC0, 0x09, 0x00, 0x16, 0x00, 0x28, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40, 0x0F, 0x80, 0x1C,
  0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xFF,
  0x80, 0x01, 0xC0, 0xC0, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08,
  0x06, 0x01, 0x03, 0xC0, 0xE0, 0x08, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x06, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x01, 0xC0, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x0C,
  0x02, 0x00, 0x80, 0x20, 0x0E, 0x01, 0xC1, 0x80, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x20, 0x18, 0x06, 0x03, 0x03, 0x80, 0xFC, 0x18, 0x7E, 0x80,
  0xC0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 20, 6, 1, -20 },
  { 16, 7, 7, 9, 3, -20 },
  { 23, 15, 20, 15, 1, -20 },
  { 61, 12, 23, 14, 1, -21 },
  { 96, 16, 20, 20, 2, -20 },
  { 136, 14, 20, 16, 1, -20 },
  { 171, 3, 7, 5, 3, -20 },
  { 174, 8, 24, 7, 1, -20 },
  { 198, 8, 24, 7, -2, -20 },
  { 222, 11, 11, 13, 3, -21 },
  { 238, 12, 13, 14, 2, -16 },
  { 258, 4, 7, 6, -1, -3 },
  { 262, 6, 1, 8, 1, -8 },
  { 263, 2, 2, 6, 1, -2 },
  { 264, 12, 20, 9, -1, -20 },
  { 294, 12, 20, 14, 1, -20 },
  { 324, 7, 20, 14, 4, -20 },
  { 342, 13, 20, 14, 0, -20 },
  { 375, 13, 20, 14, 0, -20 },
  { 408, 13, 20, 14, 0, -20 },
  { 441, 13, 20, 14, 0, -20 },
  { 474, 13, 20, 14, 1, -20 },
  { 507, 12, 20, 14, 2, -20 },
  { 537, 12, 20, 14, 1, -20 },
  { 567, 12, 20, 14, 1, -20 },
  { 597, 5, 15, 6, 0, -15 },
  { 607, 6, 19, 6, -1, -15 },
  { 622, 12, 12, 14, 2, -16 },
  { 640, 11, 7, 14, 2, -13 },
  { 650, 12, 12, 14, 2, -16 },
  { 668, 9, 20, 10, 2, -20 },
  { 691, 19, 22, 21, 1, -20 },
  { 744, 14, 20, 14, -2, -20 },
  { 779, 14, 20, 15, 1, -20 },
  { 814, 14, 20, 14, 2, -20 },
  { 849, 15, 20, 16, 1, -20 },
  { 887, 13, 20, 13, 1, -20 },
  { 920, 13, 20, 12, 1, -20 },
  { 953, 15, 20, 17, 2, -20 },
  { 991, 16, 20, 17, 1, -20 },
  { 1031, 10, 20, 8, -1, -20 },
  { 1056, 11, 25, 6, -4, -20 },
  { 1091, 15, 20, 14, 1, -20 },
  { 1129, 9, 20, 12, 1, -20 },
  { 1152, 20, 20, 21, 1, -20 },
  { 1202, 16, 20, 17, 1, -20 },
  { 1242, 15, 20, 18, 2, -20 },
  { 1280, 13, 20, 14, 1, -20 },
  { 1313, 15, 25, 18, 2, -20 },
  { 1360, 13, 20, 14, 1, -20 },
  { 1393, 13, 20, 13, 0, -20 },
  { 1426, 12, 20, 12, 2, -20 },
  { 1456, 15, 20, 17, 2, -20 },
  { 1494, 13, 20, 13, 3, -20 },
  { 1527, 20, 20, 21, 3, -20 },
  { 1577, 17, 20, 12, -2, -20 },
  { 1620, 12, 20, 12, 3, -20 },
  { 1650, 15, 20, 13, -1, -20 },
  { 1688, 10, 24, 8, 0, -20 },
  { 1718, 4, 20, 9, 3, -20 },
  { 1728, 11, 24, 8, -2, -20 },
  { 1761, 12, 12, 14, 1, -20 },
  { 1779, 10, 1, 10, -2, 3 },
  { 1781, 4, 4, 7, 4, -21 },
  { 1783, 12, 15, 14, 1, -15 },
  { 1806, 12, 21, 14, 1, -21 },
  { 1838, 10, 15, 11, 1, -15 },
  { 1857, 14, 21, 14, 1, -21 },
  { 1894, 11, 15, 12, 1, -15 },
  { 1915, 14, 28, 7, -3, -21 },
  { 1964, 14, 22, 14, 0, -15 },
  { 2003, 12, 21, 14, 1, -21 },
  { 2035, 5, 20, 6, 1, -20 },
  { 2048, 11, 27, 6, -4, -20 },
  { 2086, 12, 21, 12, 1, -21 },
  { 2118, 6, 21, 6, 1, -21 },
  { 2134, 19, 15, 21, 1, -15 },
  { 2170, 12, 15, 14, 1, -15 },
  { 2193, 12, 15, 14, 1, -15 },
  { 2216, 14, 22, 14, -1, -15 },
  { 2255, 13, 22, 14, 1, -15 },
  { 2291, 9, 15, 9, 1, -15 },
  { 2308, 10, 15, 11, 0, -15 },
  { 2327, 8, 18, 8, 1, -18 },
  { 2345, 12, 15, 14, 1, -15 },
  { 2368, 11, 15, 11, 1, -15 },
  { 2389, 16, 15, 17, 2, -15 },
  { 2419, 13, 15, 12, -1, -15 },
  { 2444, 15, 22, 11, -3, -15 },
  { 2486, 12, 15, 10, -1, -15 },
  { 2509, 10, 24, 9, 1, -20 },
  { 2539, 2, 28, 13, 6, -21 },
  { 2546, 10, 24, 9, -1, -20 },
  { 2576, 12, 3, 14, 2, -11 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC28PT7B_H_
