#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC58PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x01, 0x00, 0x00, 0x3C, 0x1E,
  0x78, 0x38, 0xE0, 0x71, 0xC1, 0xE3, 0x83, 0x87, 0x07, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x30, 0xE0, 0xE1, 0x81, 0xC3, 0x03, 0x8E, 0x06, 0x1C, 0x0C,
  0x30, 0x18, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x30, 0x0E, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x06, 0x00, 0x00, 0x60,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x80, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x0C,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xC0,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0C, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xE0, 0x18, 0x00, 0x01, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x01, 0x80, 0x30, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xF0, 0xC1, 0xC0,
  0x78, 0x30, 0x20, 0x3C, 0x1C, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x81, 0x80,
  0x01, 0xE0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83,
  0x00, 0x00, 0xE0, 0xC0, 0x00, 0x3C, 0x30, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0x7C, 0x00, 0x00, 0xC7, 0x80, 0x00, 0x30,
  0xF0, 0x00, 0x0C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0x81, 0xC0, 0x00,
  0x60, 0x70, 0x00, 0x18, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xC0, 0xE0, 0x80, 0x30, 0x78, 0x18, 0x0C, 0x7C, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xC0,
  0x7F, 0xE0, 0x00, 0xE0, 0x3C, 0x38, 0x00, 0x70, 0x1E, 0x07, 0x00, 0x1C,
  0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0x60, 0x0E, 0x07, 0x00, 0x38, 0x03,
  0x81, 0xC0, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x38, 0x70, 0x00, 0xE0,
  0x1C, 0x1C, 0x00, 0x38, 0x07, 0x0E, 0x1F, 0xCE, 0x01, 0xC7, 0x0F, 0xFB,
  0x80, 0xE1, 0xC7, 0x8E, 0xE0, 0x38, 0xE3, 0x81, 0xF8, 0x1C, 0x70, 0xE0,
  0x77, 0x0F, 0x1C, 0x70, 0x1D, 0xFF, 0x8E, 0x1C, 0x07, 0x3F, 0xC7, 0x0E,
  0x01, 0xC7, 0xC1, 0xC3, 0x80, 0x70, 0x00, 0xE0, 0xC0, 0x1C, 0x00, 0x30,
  0x70, 0x07, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x60, 0x03,
  0x81, 0xC0, 0x38, 0x01, 0xC0, 0x60, 0x0E, 0x00, 0xE0, 0x38, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0xE0, 0x01, 0xC1,
  0xC0, 0x38, 0x00, 0x70, 0xF0, 0x1C, 0x00, 0x0F, 0xF8, 0x0E, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x70, 0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x07,
  0x0F, 0x03, 0xC0, 0x3C, 0x78, 0x07, 0x00, 0xE3, 0xC0, 0x1E, 0x03, 0x8E,
  0x00, 0x38, 0x1C, 0x78, 0x00, 0xF0, 0xF1, 0xC0, 0x01, 0xC3, 0x87, 0x00,
  0x07, 0x9E, 0x3C, 0x00, 0x0E, 0xF0, 0xF0, 0x00, 0x3F, 0x83, 0x80, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x3F,
  0x01, 0xE0, 0x03, 0xFE, 0x07, 0xC0, 0x1E, 0x38, 0x0F, 0xC3, 0xF0, 0xF0,
  0x1F, 0xFF, 0x81, 0xE0, 0x3F, 0xF8, 0x03, 0x80, 0x0C, 0x00, 0x00, 0x00,
  0x1C, 0xF3, 0x8E, 0x38, 0xE3, 0x1C, 0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x00,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x20,
  0x1C, 0x03, 0x80, 0xC0, 0x1F, 0x06, 0x00, 0x7E, 0x30, 0x00, 0xFF, 0x03,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xD8, 0x00, 0x1C,
  0xE0, 0x01, 0xC3, 0x00, 0x1E, 0x1C, 0x01, 0xE0, 0xE0, 0x1E, 0x03, 0x80,
  0x60, 0x1C, 0x02, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xE0,
  0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7B, 0xFF, 0xFF, 0x10, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xF8,
  0x3E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0F, 0x07, 0x80,
  0x07, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x38, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x78, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01,
  0xC0, 0xF0, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x0F, 0xB8, 0x7C, 0xE3, 0xE3, 0xBE, 0x1E,
  0x70, 0x79, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7E, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x80, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xE0, 0x0E, 0x00,
  0x3C, 0x01, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC1, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x1E, 0x00, 0xE0, 0x03, 0x80, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x01, 0xC0,
  0x07, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x08, 0x00, 0x0F,
  0x01, 0x80, 0x07, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xE0, 0x10, 0x07, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x1C,
  0x3F, 0xF0, 0x0E, 0x7F, 0xFC, 0x0F, 0x78, 0x1F, 0x07, 0x70, 0x07, 0x83,
  0xF0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x1C,
  0x78, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x07, 0x00,
  0x0E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xC0, 0x03, 0x80, 0x78, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x1C, 0x03, 0x80, 0x07, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x78,
  0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x78, 0x00,
  0x3E, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00,
  0x70, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x07, 0xC0, 0x1E, 0x00, 0xE0,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07,
  0x87, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00,
  0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x1C, 0x00,
  0x07, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x03, 0xC3, 0x80, 0x03, 0xE1, 0xE0,
  0x01, 0xF0, 0xF0, 0x01, 0xB8, 0x3C, 0x03, 0xB8, 0x0F, 0xDF, 0xDC, 0x03,
  0xFF, 0x8E, 0x00, 0xFF, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xC1, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0xF8, 0x3E,
  0x0F, 0x00, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0xC1, 0xE0, 0x3C, 0x08, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x7F, 0x00, 0x70, 0x70, 0x03, 0xFF, 0xC0, 0xE1, 0xC0, 0x0F, 0xFF,
  0x01, 0xC3, 0x80, 0x38, 0x0E, 0x03, 0x8E, 0x00, 0xE0, 0x1C, 0x07, 0x1C,
  0x03, 0x80, 0x38, 0x0E, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0xE0, 0x1C, 0x01,
  0xC0, 0x39, 0xC0, 0x70, 0x03, 0x80, 0x73, 0x00, 0xE0, 0x06, 0x00, 0xEE,
  0x03, 0x80, 0x1C, 0x01, 0xDC, 0x07, 0x00, 0x38, 0x03, 0x38, 0x0E, 0x00,
  0x70, 0x0E, 0x70, 0x38, 0x01, 0xC0, 0x1C, 0xE0, 0x70, 0x03, 0x80, 0x31,
  0x80, 0xE0, 0x07, 0x00, 0xE3, 0x01, 0xC0, 0x1E, 0x01, 0xCE, 0x03, 0x80,
  0x3C, 0x07, 0x1C, 0x07, 0x00, 0xF8, 0x1E, 0x18, 0x07, 0x03, 0xF0, 0x38,
  0x30, 0x0E, 0x0E, 0x71, 0xE0, 0x70, 0x1F, 0xF8, 0xFF, 0x80, 0xE0, 0x1F,
  0xE0, 0xFE, 0x01, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03, 0x00, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x38, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x1C,
  0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x0E, 0x1E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xE0, 0x7F, 0xC0, 0x0E, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xE0, 0x1C,
  0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x70, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00,
  0x3C, 0x07, 0x00, 0x0F, 0x80, 0x70, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xE0, 0x03, 0xE0, 0x0E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x38, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0x01, 0xE0, 0x07, 0xC0, 0x02, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x40, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0E, 0x0F, 0xFC, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xE0, 0x01, 0xF0,
  0x07, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C,
  0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x78, 0x70, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x07, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x1F, 0x00, 0x70, 0x01, 0xF8, 0x03,
  0xC0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFE, 0x38, 0x00, 0x3F, 0xFC, 0x70, 0x00,
  0x7F, 0xF8, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xC0,
  0x07, 0xF8, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E,
  0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0xE7, 0xE0, 0x01, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x01,
  0xC0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xE0, 0x00, 0xE0,
  0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x00, 0x7B, 0xF0, 0x00,
  0x00, 0xEE, 0xE0, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x03, 0xE1, 0xC0, 0x00,
  0x0F, 0x83, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x77, 0x00,
  0x00, 0x0F, 0xE0, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x07, 0x70, 0x00, 0x03,
  0xDC, 0x01, 0xDC, 0x00, 0x00, 0xE7, 0x00, 0xE7, 0x00, 0x00, 0x7B, 0xC0,
  0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x0E, 0x70, 0x00, 0x0F, 0x38, 0x03, 0x8C,
  0x00, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x00,
  0x71, 0xE0, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x01, 0xC3, 0x80, 0x07, 0x07, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x38,
  0x38, 0x00, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x03, 0x81, 0x80,
  0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x78, 0x1C, 0x03, 0x81,
  0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x01,
  0xC0, 0x70, 0x3C, 0x07, 0x00, 0x70, 0x1C, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x03, 0x80, 0x30, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x38, 0x03, 0x80, 0x78, 0x03, 0x9C, 0x00, 0xE0,
  0x1C, 0x00, 0xE7, 0x00, 0x78, 0x07, 0x00, 0x3B, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0xFC,
  0x00, 0xF0, 0x0E, 0x00, 0x3E, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0x0E,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x3E, 0x00, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0E,
  0x01, 0xF8, 0x00, 0x03, 0x80, 0x77, 0x00, 0x00, 0xE0, 0x1D, 0xC0, 0x00,
  0x78, 0x07, 0x70, 0x00, 0x1C, 0x01, 0xCE, 0x00, 0x07, 0x00, 0xE3, 0x80,
  0x01, 0xC0, 0x38, 0xE0, 0x00, 0x70, 0x0E, 0x3C, 0x00, 0x3C, 0x03, 0x87,
  0x00, 0x0E, 0x01, 0xE1, 0xC0, 0x03, 0x80, 0x70, 0x78, 0x00, 0xE0, 0x1C,
  0x0E, 0x00, 0x38, 0x07, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0xF0, 0x07, 0x00,
  0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x78, 0x03, 0xC0,
  0xE0, 0x1C, 0x00, 0x70, 0x38, 0x07, 0x00, 0x1C, 0x1E, 0x01, 0xC0, 0x07,
  0x87, 0x00, 0x70, 0x00, 0xE1, 0xC0, 0x38, 0x00, 0x38, 0x70, 0x0E, 0x00,
  0x0E, 0x1C, 0x03, 0x80, 0x01, 0xCF, 0x00, 0xE0, 0x00, 0x73, 0x80, 0x78,
  0x00, 0x1C, 0xE0, 0x1C, 0x00, 0x03, 0xB8, 0x07, 0x00, 0x00, 0xEE, 0x01,
  0xC0, 0x00, 0x3B, 0x80, 0x70, 0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x01, 0xF0,
  0x0E, 0x00, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07,
  0x9C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1E, 0x38, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0xF0, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0x83, 0xFE, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x78, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x80, 0xE0, 0x0F, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x38,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x0F, 0x70, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0x83, 0xFE, 0x00, 0x70, 0x03, 0xE0, 0x1E, 0x00, 0x3C, 0x03,
  0x80, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x07, 0x80,
  0x3F, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0xF0, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x70, 0x0F, 0x00, 0x0E,
  0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x70, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x04, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x81, 0x00, 0x01, 0xF0, 0x38, 0x00, 0xFC,
  0x07, 0xF0, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x07, 0x07, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0,
  0x70, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF7, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x38, 0x07, 0x80, 0x07, 0x80, 0x38, 0x00, 0x70, 0x03,
  0x80, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x80, 0x3C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xF8, 0x00, 0x0E, 0x70,
  0x00, 0x1F, 0x00, 0x03, 0xCE, 0x00, 0x03, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xFC, 0x00, 0x0E, 0x38, 0x00, 0x1F, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x70,
  0x00, 0x70, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0x1C, 0x00, 0x39, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x1C, 0x00, 0xF0, 0x38, 0x01,
  0xC3, 0x80, 0x1C, 0x07, 0x80, 0x38, 0x70, 0x07, 0x80, 0xF0, 0x0E, 0x06,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0xC0, 0x1C, 0x03, 0xC0, 0x70, 0x18, 0x07,
  0x00, 0x38, 0x0E, 0x03, 0x00, 0xE0, 0x07, 0x03, 0xC0, 0x60, 0x3C, 0x00,
  0xE0, 0x70, 0x0C, 0x07, 0x00, 0x1C, 0x0E, 0x01, 0xC1, 0xE0, 0x03, 0x83,
  0x80, 0x38, 0x38, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00,
  0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x03, 0x8E,
  0x00, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x0E,
  0x78, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x38,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE0, 0xE0, 0x01, 0xE0,
  0x70, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x78, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x3C,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC3, 0x80,
  0x00, 0x71, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x78, 0x38,
  0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x00, 0x3F, 0xC1, 0xC0, 0x1F, 0xFC,
  0x70, 0x1F, 0xDF, 0x18, 0x0F, 0x80, 0xEE, 0x03, 0xC0, 0x1B, 0x81, 0xE0,
  0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E,
  0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x78, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0,
  0x70, 0x00, 0xF8, 0x1C, 0x00, 0x6E, 0x07, 0x80, 0x33, 0x01, 0xE0, 0x1D,
  0xC0, 0x3E, 0x3E, 0x70, 0x07, 0xFF, 0x1C, 0x00, 0xFF, 0x06, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0xFF, 0x00,
  0x3C, 0x7F, 0xE0, 0x0E, 0x3E, 0xFC, 0x03, 0x9C, 0x07, 0x80, 0xEE, 0x00,
  0xE0, 0x3F, 0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x07, 0xC0, 0x01, 0xC1, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x1E, 0x1C, 0x00,
  0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x07, 0xC0, 0x03, 0xC1, 0xD8, 0x01, 0xE0,
  0x77, 0x00, 0xF0, 0x18, 0xF0, 0xF8, 0x0E, 0x3F, 0xFC, 0x03, 0x83, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x0F,
  0xEF, 0x80, 0x78, 0x02, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x20, 0x1F, 0x07,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0xE0,
  0x01, 0xFF, 0xC7, 0x00, 0x3F, 0xBF, 0x38, 0x03, 0xE0, 0x3B, 0xC0, 0x1E,
  0x00, 0xFC, 0x01, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0x38,
  0x00, 0x7C, 0x01, 0xC0, 0x06, 0xE0, 0x0F, 0x00, 0x77, 0x00, 0x78, 0x07,
  0x30, 0x01, 0xF0, 0xF3, 0x80, 0x07, 0xFF, 0x1C, 0x00, 0x1F, 0xE0, 0xE0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x7E,
  0x7C, 0x07, 0x80, 0xF0, 0x78, 0x03, 0x87, 0x80, 0x1C, 0x78, 0x00, 0xE3,
  0x80, 0x07, 0x3C, 0x00, 0x39, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xE0, 0x03,
  0xC7, 0x00, 0x3E, 0x78, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF,
  0x80, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x01, 0x03, 0xF0, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x60, 0x07,
  0xFF, 0x1C, 0x03, 0xF9, 0xF3, 0x80, 0xF8, 0x0E, 0x70, 0x1E, 0x00, 0xFC,
  0x07, 0x80, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x38, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F,
  0x83, 0xC0, 0x03, 0xE0, 0x38, 0x00, 0x7C, 0x07, 0x00, 0x1B, 0x80, 0xF0,
  0x07, 0x70, 0x1E, 0x01, 0xDC, 0x01, 0xF0, 0xF3, 0x80, 0x1F, 0xFC, 0x70,
  0x01, 0xFE, 0x0E, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x07,
  0x80, 0x1C, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x1F, 0xE0, 0x0F,
  0x1F, 0xFC, 0x07, 0x3F, 0x7E, 0x03, 0xBC, 0x07, 0x81, 0xD8, 0x03, 0xC0,
  0xF8, 0x00, 0xE0, 0xF8, 0x00, 0x70, 0x7C, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x03,
  0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00,
  0x0F, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x0F,
  0x00, 0x3C, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x3C, 0x00,
  0xE0, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x1E, 0x00,
  0x03, 0x9E, 0x00, 0x01, 0xDF, 0x80, 0x01, 0xDF, 0xC0, 0x00, 0xFC, 0xE0,
  0x00, 0x7C, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38,
  0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x00, 0x01, 0x83, 0xF8,
  0x03, 0xF8, 0x03, 0x8F, 0xFC, 0x0F, 0xFE, 0x03, 0x9F, 0x7E, 0x1F, 0x7E,
  0x03, 0xB8, 0x0F, 0x38, 0x0F, 0x03, 0xB0, 0x0F, 0x70, 0x0F, 0x03, 0x60,
  0x07, 0xE0, 0x07, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x07, 0x80, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x00, 0x70, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0xC1, 0xFE, 0x00, 0xE1, 0xFF, 0xC0, 0x73, 0xF7, 0xE0, 0x3B, 0xC0, 0x78,
  0x1D, 0x80, 0x3C, 0x1F, 0x80, 0x0E, 0x0F, 0xC0, 0x07, 0x07, 0xC0, 0x03,
  0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00,
  0x0F, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFC, 0xFC, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x0E, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x38, 0x00, 0x07,
  0x38, 0x00, 0x07, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x3C, 0x03, 0xE0,
  0x1F, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x3F, 0x80, 0x03, 0x87, 0xFE, 0x00, 0x1C, 0x79, 0xF8, 0x00,
  0xE7, 0x01, 0xE0, 0x07, 0x70, 0x07, 0x00, 0x37, 0x00, 0x3C, 0x03, 0xF0,
  0x01, 0xE0, 0x1F, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x38, 0x07, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0x7C, 0x00, 0x3C, 0x03, 0xB0,
  0x03, 0xC0, 0x1D, 0xC0, 0x3C, 0x00, 0xE7, 0x87, 0xC0, 0x0F, 0x3F, 0xFC,
  0x00, 0x70, 0x7F, 0x80, 0x03, 0x80, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xC0,
  0x1F, 0xFC, 0x70, 0x1F, 0xDF, 0x9C, 0x0F, 0x80, 0xE7, 0x03, 0xC0, 0x1F,
  0x81, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x38, 0x00, 0x1E, 0x1E, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0,
  0x03, 0xE0, 0x70, 0x00, 0xF8, 0x1C, 0x00, 0x6E, 0x07, 0x80, 0x3B, 0x81,
  0xE0, 0x1D, 0xC0, 0x3E, 0x1E, 0x70, 0x07, 0xFF, 0x1C, 0x00, 0xFF, 0x07,
  0x00, 0x06, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x83, 0xF8, 0x1C, 0x7F, 0x80, 0xE7, 0xFC, 0x07, 0x78, 0x00, 0x3B, 0x80,
  0x01, 0xB0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0xC0, 0xFC, 0x7E, 0x0F, 0x00, 0x30, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE1, 0x80, 0x0F, 0x0F, 0x83,
  0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x1F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x40, 0x7F, 0xC0, 0x3F,
  0xC0, 0x06, 0x00, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0x80, 0x01,
  0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C,
  0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x83,
  0x80, 0x03, 0xC1, 0xC0, 0x03, 0xE0, 0xE0, 0x03, 0xE0, 0x70, 0x01, 0xF0,
  0x38, 0x01, 0xB8, 0x1E, 0x03, 0x9C, 0x0F, 0x87, 0xCE, 0x03, 0xFF, 0x86,
  0x00, 0xFF, 0x87, 0x00, 0x04, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xF0, 0x00, 0x73, 0xC0, 0x03, 0xC7,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x0F, 0x07, 0x00,
  0x38, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0x78, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xFE, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x07, 0x78, 0x00,
  0xF8, 0x01, 0xEF, 0x00, 0x3F, 0x00, 0x38, 0xE0, 0x06, 0xE0, 0x07, 0x1C,
  0x01, 0xDC, 0x01, 0xC3, 0x80, 0x3B, 0x80, 0x38, 0x70, 0x0E, 0x70, 0x0E,
  0x0E, 0x01, 0xCE, 0x01, 0xC1, 0xC0, 0x71, 0xC0, 0x78, 0x38, 0x0E, 0x38,
  0x0E, 0x07, 0x03, 0x87, 0x03, 0xC0, 0xE0, 0x70, 0xE0, 0x70, 0x1C, 0x1C,
  0x1C, 0x0E, 0x03, 0x83, 0x83, 0x83, 0x80, 0x70, 0x60, 0x70, 0x70, 0x0E,
  0x1C, 0x0E, 0x1C, 0x01, 0xC3, 0x81, 0xC3, 0x80, 0x38, 0xE0, 0x38, 0xF0,
  0x07, 0x1C, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x1C, 0xE0, 0x0C,
  0xE0, 0x03, 0xB8, 0x01, 0x9C, 0x00, 0x77, 0x00, 0x37, 0x00, 0x0E, 0xC0,
  0x06, 0xE0, 0x01, 0xF8, 0x00, 0xD8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x03, 0x80, 0x0F, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x3C, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x00,
  0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x03,
  0x80, 0x07, 0x80, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x1C,
  0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0x7F,
  0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0xF4, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 42, 13, 1, -41 },
  { 70, 15, 15, 19, 6, -41 },
  { 99, 31, 41, 32, 1, -41 },
  { 258, 26, 47, 28, 1, -44 },
  { 411, 34, 43, 41, 4, -42 },
  { 594, 30, 43, 33, 1, -42 },
  { 756, 6, 15, 11, 6, -41 },
  { 768, 17, 50, 15, 2, -41 },
  { 875, 17, 50, 15, -4, -41 },
  { 982, 21, 22, 27, 7, -44 },
  { 1040, 25, 27, 30, 3, -34 },
  { 1125, 10, 13, 12, -3, -6 },
  { 1142, 13, 3, 17, 2, -17 },
  { 1147, 5, 6, 12, 1, -5 },
  { 1151, 26, 41, 19, -3, -41 },
  { 1285, 24, 43, 28, 3, -42 },
  { 1414, 14, 41, 28, 8, -41 },
  { 1486, 27, 42, 28, 0, -42 },
  { 1628, 27, 43, 28, 0, -42 },
  { 1774, 27, 42, 28, 0, -42 },
  { 1916, 27, 42, 28, 1, -41 },
  { 2058, 25, 43, 28, 3, -42 },
  { 2193, 25, 41, 28, 4, -41 },
  { 2322, 27, 43, 28, 1, -42 },
  { 2468, 25, 43, 28, 2, -42 },
  { 2603, 10, 32, 12, 1, -31 },
  { 2643, 14, 38, 12, -3, -31 },
  { 2710, 25, 26, 30, 3, -34 },
  { 2792, 25, 15, 30, 3, -28 },
  { 2839, 25, 26, 30, 3, -34 },
  { 2921, 20, 43, 21, 3, -42 },
  { 3029, 39, 46, 43, 2, -41 },
  { 3254, 28, 42, 28, -3, -42 },
  { 3401, 28, 41, 31, 2, -41 },
  { 3545, 29, 43, 29, 4, -42 },
  { 3701, 30, 41, 34, 2, -41 },
  { 3855, 27, 41, 27, 2, -41 },
  { 3994, 27, 41, 25, 2, -41 },
  { 4133, 31, 43, 35, 4, -42 },
  { 4300, 33, 41, 35, 2, -41 },
  { 4470, 20, 41, 16, -1, -41 },
  { 4573, 23, 52, 13, -9, -41 },
  { 4723, 31, 41, 28, 2, -41 },
  { 4882, 18, 41, 25, 2, -41 },
  { 4975, 42, 41, 43, 2, -41 },
  { 5191, 34, 41, 36, 2, -41 },
  { 5366, 31, 43, 36, 4, -42 },
  { 5533, 27, 41, 29, 2, -41 },
  { 5672, 31, 52, 36, 4, -42 },
  { 5874, 27, 41, 29, 2, -41 },
  { 6013, 27, 43, 26, 0, -42 },
  { 6159, 25, 41, 25, 5, -41 },
  { 6288, 31, 42, 35, 4, -41 },
  { 6451, 28, 41, 28, 5, -41 },
  { 6595, 43, 41, 44, 6, -41 },
  { 6816, 33, 41, 26, -3, -41 },
  { 6986, 25, 41, 25, 5, -41 },
  { 7115, 30, 41, 26, -1, -41 },
  { 7269, 22, 50, 17, -1, -41 },
  { 7407, 9, 41, 19, 6, -41 },
  { 7454, 22, 50, 17, -4, -41 },
  { 7592, 25, 25, 29, 2, -42 },
  { 7671, 21, 2, 20, -5, 6 },
  { 7677, 8, 9, 14, 8, -44 },
  { 7686, 26, 32, 29, 2, -31 },
  { 7790, 26, 45, 29, 1, -44 },
  { 7937, 22, 32, 23, 2, -31 },
  { 8025, 29, 45, 30, 2, -44 },
  { 8189, 21, 32, 26, 3, -31 },
  { 8273, 30, 58, 15, -7, -44 },
  { 8491, 27, 45, 30, 1, -31 },
  { 8643, 25, 44, 29, 1, -44 },
  { 8781, 12, 42, 12, 1, -42 },
  { 8844, 21, 56, 12, -8, -42 },
  { 8991, 25, 44, 24, 1, -44 },
  { 9129, 13, 44, 12, 1, -44 },
  { 9201, 40, 31, 44, 1, -31 },
  { 9356, 25, 32, 29, 1, -32 },
  { 9456, 24, 32, 29, 2, -31 },
  { 9552, 29, 45, 29, -2, -31 },
  { 9716, 26, 45, 30, 2, -31 },
  { 9863, 21, 31, 20, 1, -31 },
  { 9945, 21, 32, 22, 0, -31 },
  { 10029, 16, 39, 16, 2, -38 },
  { 10107, 25, 32, 29, 3, -31 },
  { 10207, 22, 31, 23, 3, -31 },
  { 10293, 35, 31, 36, 3, -31 },
  { 10429, 27, 31, 24, -2, -31 },
  { 10534, 32, 45, 23, -6, -31 },
  { 10714, 23, 31, 22, -1, -31 },
  { 10804, 21, 50, 19, 1, -41 },
  { 10936, 3, 58, 27, 13, -44 },
  { 10958, 21, 50, 19, -3, -41 },
  { 11090, 25, 7, 30, 3, -24 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC58PT7B_H_
