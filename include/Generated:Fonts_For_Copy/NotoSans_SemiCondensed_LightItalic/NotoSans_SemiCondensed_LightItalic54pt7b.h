#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x00,
  0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCC,
  0x0C, 0x60, 0x67, 0x07, 0x38, 0x39, 0x81, 0x8C, 0x0C, 0x60, 0x60, 0x00,
  0x03, 0x00, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x01, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0x80, 0x60, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE0, 0x06, 0x01, 0xC0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x18, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0xF9, 0x9F, 0x01, 0xE3, 0x82,
  0x03, 0x83, 0x00, 0x03, 0x83, 0x00, 0x07, 0x03, 0x00, 0x07, 0x03, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x86, 0x00,
  0x03, 0x86, 0x00, 0x03, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1B, 0xE0, 0x00, 0x19, 0xE0,
  0x00, 0x18, 0xF0, 0x00, 0x18, 0x70, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38,
  0x00, 0x30, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x60, 0xF0, 0xC0, 0x61, 0xE0, 0xF8, 0x6F, 0xC0, 0xFF, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x1C, 0x0F, 0xF0, 0x00, 0x70, 0x3C, 0xF0, 0x00, 0xC0, 0xE0, 0xE0, 0x03,
  0x81, 0xC0, 0xC0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x0E, 0x03, 0x00, 0x70,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x01,
  0x80, 0x30, 0x38, 0x07, 0x00, 0xE0, 0x60, 0x0E, 0x01, 0xC1, 0xC0, 0x1C,
  0x03, 0x87, 0x00, 0x30, 0x06, 0x0C, 0x00, 0x60, 0x1C, 0x38, 0x10, 0xC0,
  0x38, 0xE1, 0xFD, 0x80, 0x61, 0x87, 0xFB, 0x01, 0xC7, 0x1C, 0x3F, 0x03,
  0x1C, 0x70, 0x3E, 0x0E, 0x30, 0xC0, 0x6E, 0x78, 0xE3, 0x80, 0xDF, 0xE3,
  0x86, 0x01, 0x9F, 0x07, 0x1C, 0x03, 0x00, 0x1C, 0x38, 0x06, 0x00, 0x70,
  0x60, 0x0C, 0x00, 0xE1, 0xC0, 0x38, 0x03, 0x83, 0x80, 0x70, 0x0E, 0x07,
  0x00, 0xE0, 0x1C, 0x0E, 0x01, 0x80, 0x70, 0x18, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0x60, 0x18, 0x0E, 0x00, 0xC0, 0x70, 0x18, 0x01, 0x80,
  0xE0, 0x70, 0x03, 0x83, 0x81, 0xC0, 0x07, 0x0E, 0x03, 0x00, 0x07, 0xFC,
  0x0E, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x70,
  0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x78, 0xF0,
  0x07, 0x0F, 0x07, 0x00, 0x71, 0xC0, 0x78, 0x0E, 0x38, 0x03, 0x80, 0xE3,
  0x80, 0x1C, 0x1C, 0x70, 0x01, 0xC1, 0xC7, 0x00, 0x0E, 0x38, 0xE0, 0x00,
  0xF7, 0x0E, 0x00, 0x07, 0x70, 0xE0, 0x00, 0x7E, 0x0E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0x70, 0x00, 0xEE, 0x07, 0x80,
  0x3C, 0xF0, 0x3E, 0x0F, 0x87, 0x01, 0xFF, 0xF0, 0x78, 0x0F, 0xFC, 0x03,
  0xC0, 0x08, 0x00, 0x00, 0x39, 0xCE, 0x77, 0x39, 0xCE, 0x63, 0x39, 0xCC,
  0x60, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x06, 0x03, 0x00, 0xF0, 0x30, 0x0F, 0xC3, 0x00, 0x1F, 0x60, 0x10,
  0x7E, 0xFF, 0x00, 0xFF, 0xF0, 0x0E, 0x00, 0x03, 0xB0, 0x00, 0x73, 0x00,
  0x0E, 0x18, 0x01, 0xE1, 0x80, 0x3C, 0x1C, 0x07, 0x80, 0xC0, 0x10, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x07, 0x0F, 0x0E,
  0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x60, 0xE0, 0xC0, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFE, 0x33, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0xE0, 0x07, 0x81, 0xE0, 0x1E, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0xE0, 0x03,
  0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80,
  0x00, 0xF7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x01, 0xC0, 0xE0, 0x07, 0x81, 0xE0, 0x1E, 0x01, 0xC0, 0x78, 0x03,
  0xE1, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xF8, 0x3C, 0xE1, 0xE3, 0x9F,
  0x1C, 0xF0, 0x71, 0x81, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x3E, 0x01, 0xE0, 0x0C, 0x00, 0x70,
  0x04, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x01, 0xE0, 0x1C,
  0x00, 0x78, 0x04, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x18,
  0x00, 0x3C, 0x0F, 0x80, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x01,
  0xDC, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x38, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xE1, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x18, 0x00, 0xF8, 0x0F, 0x01, 0xF8,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x1F, 0x80, 0x39, 0xFF, 0x80, 0xE7,
  0xFF, 0xC1, 0xDC, 0x07, 0x83, 0xF0, 0x07, 0x87, 0x80, 0x07, 0x1F, 0x00,
  0x0E, 0x3C, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x79, 0xC0, 0x00,
  0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x81,
  0xC0, 0x0E, 0x03, 0xC0, 0x3C, 0x03, 0xC1, 0xF0, 0x03, 0xFF, 0xC0, 0x03,
  0xFE, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0x70, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x70, 0x01, 0xC0, 0xF0,
  0x00, 0x71, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x00,
  0xE0, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x8F, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x7C, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x0F, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x87,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0,
  0x00, 0x73, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x0F, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x03,
  0xE1, 0xE0, 0x1D, 0xC1, 0xF0, 0xF3, 0x81, 0xFF, 0xCE, 0x01, 0xFF, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x0C, 0x0F,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0x70, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x60,
  0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x00, 0x70, 0x70, 0x01, 0xF8,
  0x03, 0x0E, 0x00, 0x7F, 0xE0, 0x30, 0xC0, 0x1F, 0xBE, 0x03, 0x1C, 0x03,
  0xC0, 0xE0, 0x31, 0x80, 0x70, 0x0E, 0x03, 0x38, 0x06, 0x00, 0xC0, 0x33,
  0x80, 0xE0, 0x1C, 0x03, 0x30, 0x1C, 0x01, 0xC0, 0x37, 0x01, 0xC0, 0x1C,
  0x07, 0x70, 0x38, 0x01, 0x80, 0x77, 0x03, 0x80, 0x38, 0x07, 0x60, 0x38,
  0x03, 0x80, 0x66, 0x03, 0x00, 0x38, 0x0E, 0xE0, 0x70, 0x07, 0x00, 0xEE,
  0x07, 0x00, 0x70, 0x0C, 0xE0, 0x70, 0x07, 0x01, 0xCE, 0x07, 0x00, 0xF0,
  0x18, 0xE0, 0x30, 0x1B, 0x03, 0x8E, 0x03, 0x83, 0xB0, 0x70, 0xE0, 0x3C,
  0x73, 0x8E, 0x06, 0x01, 0xFE, 0x1F, 0xC0, 0x60, 0x0F, 0xC0, 0xF8, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x76, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x0E, 0x60,
  0x00, 0x03, 0x98, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x03, 0x80, 0x30, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x38, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x07,
  0x80, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x3C,
  0x0E, 0x00, 0x3E, 0x03, 0x81, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1E, 0x00, 0xF8, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x78, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x0F, 0x83, 0x80, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0x00, 0x60, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x08, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xA0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1C, 0x03, 0xF0, 0x01, 0xC0, 0x0F, 0x80,
  0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x07, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x83,
  0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x3C, 0x07, 0x00, 0x0F, 0x80, 0x70, 0x01, 0xF0, 0x0E, 0x00, 0x7E, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x10, 0x07, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x70, 0x00, 0xFF, 0xE1, 0xC0, 0x03,
  0xFF, 0x07, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x70, 0x07, 0xC0, 0x03, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C,
  0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x41, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x78, 0x03, 0x80,
  0x07, 0x80, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0x70, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x03, 0x83,
  0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x03, 0xBF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xF9, 0xC0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x37, 0x00, 0x00,
  0x3B, 0x80, 0xEE, 0x00, 0x00, 0x7E, 0x01, 0xDC, 0x00, 0x01, 0xDC, 0x03,
  0xB8, 0x00, 0x03, 0xB8, 0x07, 0x70, 0x00, 0x0E, 0x70, 0x0E, 0xE0, 0x00,
  0x1C, 0xE0, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x71, 0x80, 0x00, 0xE7, 0x00,
  0xE3, 0x00, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x0F, 0x1C, 0x03, 0x0E, 0x00,
  0x1C, 0x38, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x00, 0xE1, 0xC0,
  0x38, 0x70, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x07, 0x07, 0x01, 0xC1, 0xC0,
  0x1C, 0x1C, 0x03, 0x81, 0x80, 0x38, 0x38, 0x07, 0x03, 0x00, 0xE0, 0x70,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0E, 0x07, 0x00, 0xE0, 0x38, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x70, 0x1C,
  0x03, 0x80, 0xE1, 0xC0, 0x38, 0x07, 0x00, 0xC7, 0x00, 0x70, 0x1C, 0x01,
  0x8E, 0x01, 0xC0, 0x38, 0x03, 0x38, 0x03, 0x80, 0x70, 0x07, 0x70, 0x07,
  0x00, 0xE0, 0x0F, 0xC0, 0x0E, 0x01, 0x80, 0x1F, 0x80, 0x3C, 0x07, 0x00,
  0x3E, 0x00, 0x70, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x01,
  0xC0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x0E, 0x01,
  0xF0, 0x00, 0x0E, 0x01, 0xB8, 0x00, 0x0E, 0x03, 0xB8, 0x00, 0x1C, 0x03,
  0xB8, 0x00, 0x1C, 0x03, 0x9C, 0x00, 0x1C, 0x03, 0x9C, 0x00, 0x1C, 0x03,
  0x1C, 0x00, 0x1C, 0x07, 0x1C, 0x00, 0x38, 0x07, 0x0E, 0x00, 0x38, 0x07,
  0x0E, 0x00, 0x38, 0x07, 0x0E, 0x00, 0x38, 0x06, 0x07, 0x00, 0x70, 0x0E,
  0x07, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x01, 0xC0, 0xE0, 0x1C,
  0x01, 0xC0, 0xE0, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x00, 0xE0, 0xE0, 0x38,
  0x00, 0xE1, 0xC0, 0x38, 0x00, 0xE1, 0xC0, 0x38, 0x00, 0x71, 0xC0, 0x38,
  0x00, 0x71, 0xC0, 0x38, 0x00, 0x71, 0x80, 0x70, 0x00, 0x3B, 0x80, 0x70,
  0x00, 0x3B, 0x80, 0x70, 0x00, 0x3B, 0x80, 0x70, 0x00, 0x3F, 0x80, 0x60,
  0x00, 0x1F, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1C, 0xE0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x0F, 0x80, 0x3C, 0x00, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x38, 0x0F, 0xC0, 0x1C, 0x00, 0xF0,
  0x0E, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0F, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x1F, 0x01, 0xE1,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x38, 0x78, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x9E, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x38, 0x0F, 0xC0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x0F,
  0x00, 0x1E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x3C,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F,
  0x03, 0x80, 0x1F, 0x01, 0xC0, 0x7F, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x1E, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x03, 0x83, 0x80, 0x01, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0x10, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x18, 0x00, 0x7C, 0x0F, 0xC1,
  0xFC, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x05, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0xF0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x07, 0x07, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71,
  0x80, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8E, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x39, 0x80, 0x00,
  0x0D, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x77, 0x00, 0x03,
  0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x80, 0x03, 0x9C, 0x00, 0x1B, 0x00, 0x07,
  0x38, 0x00, 0x76, 0x00, 0x1E, 0x70, 0x00, 0xEC, 0x00, 0x38, 0xE0, 0x03,
  0x98, 0x00, 0x71, 0xC0, 0x07, 0x30, 0x01, 0xC3, 0x80, 0x0C, 0x60, 0x03,
  0x87, 0x00, 0x38, 0xC0, 0x0E, 0x0E, 0x00, 0x61, 0x80, 0x1C, 0x1C, 0x01,
  0xC3, 0x00, 0x78, 0x38, 0x03, 0x86, 0x00, 0xE0, 0x70, 0x0E, 0x0C, 0x01,
  0xC0, 0xE0, 0x1C, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x30, 0x0E, 0x03, 0x80,
  0xE0, 0x60, 0x38, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x0E, 0x07, 0x01, 0x81,
  0xE0, 0x1C, 0x0E, 0x03, 0x03, 0x80, 0x38, 0x38, 0x06, 0x07, 0x00, 0x70,
  0x70, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x38,
  0xE0, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x0E,
  0x30, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1D, 0x80, 0x01,
  0xD8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x1C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0x3C, 0x60, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x01, 0xE0, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x73, 0x80,
  0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0xF0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00,
  0x1C, 0x38, 0x00, 0x18, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x30, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18, 0x18, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xB0, 0x00, 0x07, 0x70, 0x00, 0x1C, 0x60, 0x00,
  0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x03, 0x80, 0x1C,
  0x07, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0C, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x30, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xE7, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0x80, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x83,
  0x07, 0x00, 0x3F, 0x83, 0x00, 0xFF, 0xC7, 0x01, 0xFB, 0xE7, 0x03, 0xC0,
  0x66, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x0E, 0x00, 0x3E, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x38, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x03,
  0xE0, 0x70, 0x06, 0xE0, 0x78, 0x0E, 0xE0, 0x3C, 0x3C, 0xC0, 0x3F, 0xF8,
  0xC0, 0x0F, 0xE0, 0xC0, 0x01, 0x01, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x83, 0xF0, 0x03, 0x8F,
  0xFC, 0x03, 0x9E, 0x7C, 0x07, 0x38, 0x1E, 0x07, 0x60, 0x0E, 0x07, 0xC0,
  0x07, 0x07, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x78, 0x00, 0x38, 0x7C, 0x00, 0x70, 0x7C, 0x00, 0xF0, 0x66, 0x01,
  0xE0, 0x67, 0x07, 0xC0, 0xE3, 0xFF, 0x80, 0xE1, 0xFE, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xF9, 0xF0, 0x3C, 0x01, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x10, 0x3E, 0x07, 0x01, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x70,
  0x01, 0xFF, 0x8E, 0x00, 0x7E, 0xF9, 0xC0, 0x1E, 0x03, 0xB8, 0x07, 0x80,
  0x36, 0x01, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x01,
  0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x3E, 0x03, 0x80,
  0x07, 0xC0, 0x38, 0x01, 0xB0, 0x07, 0x00, 0x7E, 0x00, 0xF0, 0x1D, 0xC0,
  0x0F, 0x0F, 0x38, 0x01, 0xFF, 0xC7, 0x00, 0x0F, 0xE0, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7E, 0x7C, 0x07, 0x80,
  0xE0, 0x78, 0x07, 0x07, 0x80, 0x1C, 0x38, 0x00, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x70, 0x07, 0x87, 0x00, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x0F, 0x81,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3E, 0x20, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x0F, 0xFC,
  0x30, 0x07, 0xE7, 0x9C, 0x03, 0xC0, 0x77, 0x01, 0xE0, 0x0D, 0x80, 0xF0,
  0x01, 0xE0, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x83,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x38,
  0x00, 0x3C, 0x0E, 0x00, 0x1F, 0x03, 0x80, 0x07, 0xC0, 0x70, 0x03, 0x60,
  0x1C, 0x01, 0xF8, 0x07, 0x80, 0xEE, 0x00, 0xF0, 0xF3, 0x80, 0x3F, 0xF8,
  0xE0, 0x07, 0xF8, 0x70, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x20, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x3F,
  0x00, 0x71, 0xFF, 0x80, 0xE7, 0x9F, 0x83, 0x9C, 0x0F, 0x07, 0x60, 0x0E,
  0x0F, 0x80, 0x1C, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0xF0, 0x00, 0xE1,
  0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00,
  0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1C,
  0x07, 0x80, 0x70, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0,
  0xF0, 0x01, 0xC3, 0xC0, 0x03, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0C, 0x70,
  0x00, 0x39, 0xF0, 0x00, 0x77, 0xE0, 0x00, 0xFD, 0xC0, 0x01, 0xF1, 0xC0,
  0x03, 0xC3, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x78, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x00, 0x03, 0x87, 0xF0, 0x0F, 0xC0, 0x18, 0xFF, 0xC1, 0xFF, 0x80, 0xCF,
  0xBE, 0x1E, 0x7C, 0x0E, 0xE0, 0x79, 0xC0, 0xF0, 0x76, 0x01, 0xDC, 0x03,
  0x83, 0xE0, 0x0F, 0xC0, 0x1C, 0x1E, 0x00, 0x7C, 0x00, 0xE0, 0xF0, 0x03,
  0xC0, 0x07, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x78, 0x00, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0x80,
  0x07, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x00, 0x0E, 0x1C, 0x00, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x00,
  0x0E, 0x1C, 0x00, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x03, 0x87, 0xF8, 0x06, 0x1F, 0xF8, 0x0C, 0xFD,
  0xF8, 0x3B, 0xC0, 0xF0, 0x76, 0x00, 0xE0, 0xF8, 0x01, 0xC1, 0xE0, 0x03,
  0x83, 0xC0, 0x07, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x07,
  0x0E, 0x00, 0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xE7,
  0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0xF7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0x9C, 0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00,
  0x70, 0x78, 0x01, 0xC0, 0x70, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x0C, 0x3F, 0xF0, 0x01,
  0x8F, 0x3E, 0x00, 0x73, 0x81, 0xE0, 0x0E, 0xE0, 0x1E, 0x01, 0xF8, 0x01,
  0xC0, 0x3E, 0x00, 0x38, 0x07, 0x80, 0x07, 0x01, 0xF0, 0x00, 0xE0, 0x3C,
  0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xC0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00,
  0x70, 0x0F, 0x80, 0x1E, 0x01, 0xD8, 0x07, 0x80, 0x3B, 0x83, 0xE0, 0x0E,
  0x3F, 0xF8, 0x01, 0xC3, 0xFC, 0x00, 0x38, 0x08, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x83, 0x00, 0xFF, 0xC3, 0x01, 0xFB, 0xE7, 0x03,
  0xC0, 0x77, 0x07, 0x80, 0x36, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xF0, 0xE0, 0x01, 0xF0, 0xF0,
  0x03, 0x60, 0x70, 0x07, 0xE0, 0x78, 0x0E, 0xE0, 0x3C, 0x3C, 0xE0, 0x3F,
  0xF8, 0xE0, 0x1F, 0xE1, 0xC0, 0x01, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x03, 0x87, 0xE0, 0x61,
  0xFC, 0x0C, 0xFF, 0x03, 0x9C, 0x00, 0x76, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xE3,
  0xE0, 0x70, 0x02, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x08, 0x00, 0xF0, 0xF0, 0x3E,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x0F, 0xFF, 0x7F,
  0xFC, 0xFF, 0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x81,
  0xFE, 0x01, 0xFC, 0x00, 0x40, 0x00, 0x07, 0x00, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xE0, 0xF0, 0x06, 0xE0, 0x70, 0x0C, 0xC0,
  0x78, 0x3C, 0xC0, 0x3F, 0xF1, 0xC0, 0x1F, 0xE1, 0xC0, 0x02, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xCE, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x60, 0x07, 0x03,
  0x80, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x1C,
  0x38, 0x00, 0x61, 0xC0, 0x03, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0x70, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xE0,
  0x03, 0xB8, 0x00, 0xF0, 0x03, 0xDC, 0x00, 0xF8, 0x01, 0xCE, 0x00, 0x6C,
  0x00, 0xE7, 0x00, 0x76, 0x00, 0xE3, 0x80, 0x3B, 0x00, 0x71, 0xC0, 0x39,
  0x80, 0x70, 0xE0, 0x1C, 0xC0, 0x38, 0x70, 0x1C, 0x60, 0x38, 0x38, 0x0E,
  0x30, 0x1C, 0x1C, 0x06, 0x18, 0x0E, 0x0E, 0x07, 0x0C, 0x0E, 0x07, 0x03,
  0x06, 0x07, 0x01, 0x83, 0x83, 0x07, 0x00, 0xC1, 0x81, 0xC3, 0x80, 0x61,
  0xC0, 0xE3, 0x80, 0x30, 0xE0, 0x71, 0xC0, 0x18, 0xE0, 0x38, 0xC0, 0x0C,
  0x70, 0x1C, 0xE0, 0x06, 0x70, 0x0E, 0x70, 0x03, 0x38, 0x07, 0x70, 0x01,
  0x98, 0x03, 0xB8, 0x00, 0xDC, 0x01, 0xD8, 0x00, 0x6C, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x01, 0xE0,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x0F,
  0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x1E,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0xC0,
  0xF0, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x60, 0x38, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x00, 0xCE, 0x00, 0x00, 0x03, 0x70, 0x00, 0x00, 0x0D,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x08, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x20, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x0A, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x1F,
  0x80, 0x02, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xD0, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 39, 12, 1, -39 },
  { 60, 13, 14, 18, 6, -39 },
  { 83, 29, 39, 29, 1, -39 },
  { 225, 24, 44, 26, 1, -41 },
  { 357, 31, 40, 38, 4, -39 },
  { 512, 28, 40, 31, 1, -39 },
  { 652, 5, 14, 10, 6, -39 },
  { 661, 16, 48, 14, 2, -39 },
  { 757, 16, 48, 14, -4, -39 },
  { 853, 20, 21, 25, 6, -41 },
  { 906, 23, 26, 28, 3, -32 },
  { 981, 8, 13, 11, -2, -6 },
  { 994, 13, 3, 16, 1, -16 },
  { 999, 5, 5, 12, 1, -5 },
  { 1003, 24, 39, 18, -2, -39 },
  { 1120, 23, 40, 26, 2, -39 },
  { 1235, 14, 39, 26, 7, -39 },
  { 1304, 25, 39, 26, 0, -39 },
  { 1426, 25, 40, 26, 0, -39 },
  { 1551, 25, 39, 26, 0, -39 },
  { 1673, 25, 40, 26, 1, -39 },
  { 1798, 23, 40, 26, 3, -39 },
  { 1913, 23, 39, 26, 4, -39 },
  { 2026, 25, 40, 26, 1, -39 },
  { 2151, 23, 40, 26, 2, -39 },
  { 2266, 9, 29, 12, 1, -29 },
  { 2299, 14, 36, 12, -3, -29 },
  { 2362, 23, 25, 28, 3, -32 },
  { 2434, 23, 14, 28, 3, -26 },
  { 2475, 23, 25, 28, 3, -32 },
  { 2547, 18, 39, 20, 3, -39 },
  { 2635, 36, 44, 40, 2, -39 },
  { 2833, 26, 39, 26, -3, -39 },
  { 2960, 26, 39, 28, 2, -39 },
  { 3087, 27, 40, 27, 3, -39 },
  { 3222, 28, 39, 32, 2, -39 },
  { 3359, 25, 39, 25, 2, -39 },
  { 3481, 25, 39, 23, 2, -39 },
  { 3603, 30, 40, 33, 3, -39 },
  { 3753, 31, 39, 32, 2, -39 },
  { 3905, 19, 39, 15, -1, -39 },
  { 3998, 21, 49, 12, -8, -39 },
  { 4127, 29, 39, 26, 2, -39 },
  { 4269, 17, 39, 23, 2, -39 },
  { 4352, 39, 39, 40, 2, -39 },
  { 4543, 32, 39, 33, 2, -39 },
  { 4699, 29, 40, 34, 3, -39 },
  { 4844, 25, 39, 27, 2, -39 },
  { 4966, 29, 48, 34, 3, -39 },
  { 5140, 25, 39, 27, 2, -39 },
  { 5262, 25, 40, 24, 0, -39 },
  { 5387, 23, 39, 23, 5, -39 },
  { 5500, 29, 40, 32, 4, -39 },
  { 5645, 25, 39, 26, 5, -39 },
  { 5767, 39, 39, 41, 6, -39 },
  { 5958, 31, 39, 24, -3, -39 },
  { 6110, 23, 39, 23, 5, -39 },
  { 6223, 28, 39, 25, -1, -39 },
  { 6360, 20, 48, 16, -1, -39 },
  { 6480, 8, 39, 18, 6, -39 },
  { 6519, 20, 48, 16, -4, -39 },
  { 6639, 23, 23, 27, 2, -39 },
  { 6706, 20, 3, 19, -5, 5 },
  { 6714, 7, 8, 13, 8, -41 },
  { 6721, 24, 30, 27, 2, -29 },
  { 6811, 24, 42, 27, 1, -41 },
  { 6937, 20, 30, 21, 2, -29 },
  { 7012, 27, 42, 28, 2, -41 },
  { 7154, 21, 30, 24, 2, -29 },
  { 7233, 28, 54, 14, -7, -41 },
  { 7422, 26, 42, 28, 0, -29 },
  { 7559, 23, 41, 27, 1, -41 },
  { 7677, 11, 39, 11, 1, -39 },
  { 7731, 20, 52, 11, -7, -39 },
  { 7861, 23, 41, 22, 1, -41 },
  { 7979, 12, 41, 11, 1, -41 },
  { 8041, 37, 29, 41, 1, -29 },
  { 8176, 23, 29, 27, 1, -29 },
  { 8260, 23, 29, 27, 2, -29 },
  { 8344, 27, 42, 27, -2, -29 },
  { 8486, 24, 42, 28, 2, -29 },
  { 8612, 19, 29, 18, 1, -29 },
  { 8681, 20, 30, 20, 0, -29 },
  { 8756, 15, 37, 15, 2, -36 },
  { 8826, 24, 30, 27, 2, -29 },
  { 8916, 21, 29, 21, 3, -29 },
  { 8993, 33, 29, 33, 3, -29 },
  { 9113, 26, 29, 22, -2, -29 },
  { 9208, 30, 42, 21, -6, -29 },
  { 9366, 22, 29, 20, -1, -29 },
  { 9446, 20, 48, 18, 1, -39 },
  { 9566, 3, 54, 26, 12, -41 },
  { 9587, 20, 48, 18, -3, -39 },
  { 9707, 23, 6, 28, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC54PT7B_H_
