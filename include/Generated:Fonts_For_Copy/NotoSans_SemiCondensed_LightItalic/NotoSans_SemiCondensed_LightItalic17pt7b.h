#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x24, 0x40, 0x4C, 0xD9, 0xAA, 0x08, 0x84, 0x82,
  0x4F, 0xF1, 0x20, 0x90, 0x49, 0xFE, 0x24, 0x12, 0x11, 0x09, 0x00, 0x04,
  0x04, 0x1F, 0x24, 0x28, 0x28, 0x18, 0x0C, 0x12, 0x12, 0x12, 0xFC, 0x10,
  0x20, 0x38, 0xD2, 0x28, 0x92, 0x28, 0x92, 0xA5, 0x5E, 0xA4, 0x29, 0x12,
  0x49, 0x12, 0x49, 0x0E, 0x0E, 0x08, 0x84, 0x42, 0x41, 0x40, 0xC0, 0xA2,
  0x89, 0x85, 0x41, 0x31, 0x8F, 0x20, 0xEA, 0x19, 0x08, 0x84, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x00, 0x10, 0x82, 0x10, 0x84, 0x21, 0x10, 0x84,
  0x44, 0x22, 0x00, 0x10, 0x4D, 0x0F, 0x52, 0x40, 0x80, 0x10, 0x20, 0x40,
  0x8F, 0xE2, 0x04, 0x08, 0x29, 0x40, 0xF0, 0x70, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x3C, 0x45, 0x0A, 0x18,
  0x30, 0x60, 0xC2, 0x85, 0x0A, 0x23, 0x80, 0x1B, 0xA4, 0x21, 0x10, 0x84,
  0x21, 0x10, 0x80, 0x3E, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0xFC, 0x1E, 0x21, 0x01, 0x01, 0x02, 0x1C, 0x04, 0x02, 0x02,
  0x02, 0x04, 0xF8, 0x03, 0x05, 0x06, 0x0A, 0x12, 0x22, 0x22, 0x44, 0xFF,
  0x04, 0x04, 0x08, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x3C, 0x02, 0x02, 0x02,
  0x02, 0x04, 0xF8, 0x1E, 0x41, 0x02, 0x05, 0x9C, 0xA1, 0x42, 0x85, 0x0A,
  0x23, 0xC0, 0x7F, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20,
  0x40, 0xC0, 0x1F, 0x21, 0x21, 0x21, 0x12, 0x0C, 0x34, 0x42, 0x82, 0x82,
  0x42, 0x7C, 0x1E, 0x21, 0x21, 0x41, 0x41, 0x43, 0x3E, 0x02, 0x02, 0x04,
  0x08, 0xF0, 0x24, 0x00, 0x02, 0xC0, 0x11, 0x00, 0x00, 0x02, 0x44, 0x80,
  0x02, 0x18, 0xC6, 0x04, 0x07, 0x01, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x80,
  0xC0, 0x60, 0x30, 0x63, 0x18, 0x40, 0x78, 0x10, 0x42, 0x08, 0x42, 0x10,
  0x40, 0x08, 0x20, 0x0F, 0x82, 0x08, 0x80, 0xA3, 0x98, 0x93, 0x22, 0x64,
  0x4C, 0x91, 0x92, 0x53, 0xB2, 0x00, 0x40, 0x06, 0x20, 0x38, 0x00, 0x02,
  0x06, 0x05, 0x09, 0x09, 0x11, 0x11, 0x3F, 0x21, 0x41, 0x41, 0x81, 0x3E,
  0x21, 0x41, 0x41, 0x42, 0x7C, 0x44, 0x82, 0x82, 0x82, 0x84, 0xF8, 0x1F,
  0x98, 0x08, 0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x10, 0x07,
  0x80, 0x1F, 0x08, 0x48, 0x24, 0x12, 0x09, 0x04, 0x82, 0x81, 0x41, 0xA0,
  0x91, 0x9F, 0x00, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x3E, 0x20, 0x40, 0x40,
  0x40, 0x40, 0xFC, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x20, 0x3E, 0x40, 0x40,
  0x40, 0x40, 0xC0, 0x1F, 0x98, 0x18, 0x08, 0x04, 0x04, 0x02, 0x1D, 0x02,
  0x81, 0x40, 0x90, 0x87, 0xC0, 0x20, 0x90, 0x50, 0x28, 0x14, 0x13, 0xF9,
  0x05, 0x02, 0x82, 0x41, 0x20, 0x90, 0x40, 0x3C, 0x41, 0x04, 0x20, 0x82,
  0x08, 0x21, 0x04, 0x38, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x04, 0x08,
  0x10, 0x20, 0x41, 0x02, 0x38, 0x00, 0x10, 0xC4, 0x42, 0x20, 0x90, 0x28,
  0x0E, 0x02, 0x81, 0x10, 0x44, 0x11, 0x04, 0x23, 0x08, 0x10, 0x42, 0x08,
  0x20, 0x82, 0x10, 0x41, 0x04, 0x3F, 0x10, 0x18, 0xC1, 0x4A, 0x0C, 0x50,
  0xA2, 0x85, 0x14, 0x48, 0xA2, 0x89, 0x24, 0x49, 0x22, 0x31, 0x11, 0x89,
  0x88, 0x80, 0x10, 0x63, 0x08, 0xA1, 0x14, 0x22, 0x44, 0x49, 0x09, 0x22,
  0x14, 0x42, 0x88, 0x51, 0x04, 0x60, 0x80, 0x1F, 0x10, 0x50, 0x28, 0x14,
  0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0x90, 0x8F, 0x80, 0x1F, 0x08, 0x88,
  0x24, 0x22, 0x11, 0x18, 0xF0, 0x80, 0x40, 0x20, 0x10, 0x18, 0x00, 0x1F,
  0x10, 0x50, 0x28, 0x14, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x40, 0x90, 0x8F,
  0x80, 0x80, 0x20, 0x18, 0x1F, 0x08, 0x88, 0x24, 0x22, 0x11, 0x18, 0xF0,
  0x88, 0x44, 0x22, 0x10, 0x98, 0x40, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x10,
  0x0C, 0x04, 0x02, 0x02, 0x04, 0xF8, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x20, 0x20, 0x20, 0x20, 0x40, 0x40, 0x20, 0x90, 0x50, 0x28, 0x14, 0x12,
  0x09, 0x05, 0x02, 0x81, 0x41, 0x21, 0x8F, 0x80, 0x83, 0x82, 0x84, 0x84,
  0x88, 0x88, 0x90, 0x90, 0xA0, 0xA0, 0xC0, 0xC0, 0x86, 0x18, 0x61, 0x8A,
  0x28, 0xA2, 0x92, 0x49, 0x24, 0x92, 0x8A, 0x28, 0xA2, 0x8C, 0x30, 0xC3,
  0x08, 0x20, 0x10, 0xC4, 0x20, 0x90, 0x28, 0x0A, 0x01, 0x00, 0xC0, 0x50,
  0x12, 0x08, 0x84, 0x22, 0x08, 0x87, 0x0A, 0x24, 0x49, 0x0C, 0x18, 0x20,
  0x40, 0x82, 0x04, 0x00, 0x3F, 0x80, 0x80, 0x80, 0x80, 0x40, 0x40, 0x40,
  0x60, 0x20, 0x20, 0x20, 0x1F, 0x80, 0x1C, 0x42, 0x08, 0x20, 0x84, 0x10,
  0x41, 0x04, 0x20, 0x82, 0x0E, 0x00, 0xAA, 0x95, 0x55, 0x1C, 0x10, 0x42,
  0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x8E, 0x00, 0x18, 0x30, 0xA2,
  0x24, 0x50, 0x60, 0x80, 0xFC, 0xC8, 0x80, 0x3A, 0x8F, 0x0C, 0x28, 0x50,
  0xA1, 0x46, 0xF8, 0x10, 0x10, 0x10, 0x20, 0x2E, 0x31, 0x21, 0x21, 0x41,
  0x42, 0x42, 0x46, 0xBC, 0x3D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x78, 0x01,
  0x01, 0x01, 0x02, 0x3E, 0x46, 0xC2, 0x82, 0x84, 0x84, 0x84, 0x8C, 0xF4,
  0x3D, 0x18, 0x62, 0xF2, 0x08, 0x20, 0x78, 0x03, 0x82, 0x01, 0x01, 0x01,
  0xE0, 0x40, 0x20, 0x10, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80,
  0x40, 0xC0, 0x00, 0x1F, 0x23, 0x61, 0x41, 0x42, 0x42, 0x42, 0x46, 0x7A,
  0x04, 0x04, 0x0C, 0xF8, 0x10, 0x10, 0x10, 0x20, 0x2E, 0x31, 0x21, 0x42,
  0x42, 0x42, 0x42, 0x42, 0x84, 0x10, 0x02, 0x22, 0x44, 0x44, 0x48, 0x04,
  0x00, 0x02, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x30, 0x10,
  0x10, 0x10, 0x20, 0x23, 0x24, 0x28, 0x50, 0x70, 0x48, 0x48, 0x44, 0x84,
  0x11, 0x12, 0x22, 0x24, 0x44, 0x44, 0x80, 0x2E, 0xF3, 0x31, 0x23, 0x14,
  0x21, 0x42, 0x14, 0x22, 0x42, 0x24, 0x42, 0x84, 0x20, 0x2E, 0x31, 0x21,
  0x62, 0x42, 0x42, 0x42, 0x42, 0x84, 0x3C, 0x8E, 0x0C, 0x18, 0x30, 0xA1,
  0x44, 0x70, 0x17, 0x0C, 0x44, 0x22, 0x12, 0x09, 0x04, 0x84, 0x46, 0x5E,
  0x20, 0x10, 0x08, 0x0C, 0x00, 0x3E, 0x8F, 0x0C, 0x18, 0x50, 0xA1, 0x46,
  0xF4, 0x10, 0x20, 0x40, 0x80, 0x2C, 0xC2, 0x08, 0x41, 0x04, 0x10, 0x80,
  0x3D, 0x04, 0x08, 0x10, 0x20, 0x82, 0xF0, 0x24, 0xF4, 0x48, 0x88, 0x88,
  0xE0, 0x42, 0x85, 0x0C, 0x28, 0x50, 0xA3, 0x44, 0xF8, 0x86, 0x18, 0xA2,
  0x92, 0x4A, 0x28, 0x40, 0x8C, 0x63, 0x19, 0x4A, 0x52, 0xA5, 0x29, 0x4A,
  0x63, 0x18, 0xC4, 0x00, 0x31, 0x12, 0x14, 0x0C, 0x08, 0x18, 0x24, 0x24,
  0xC2, 0x10, 0xC4, 0x21, 0x10, 0x44, 0x12, 0x02, 0x80, 0xC0, 0x30, 0x08,
  0x02, 0x01, 0x00, 0x40, 0xE0, 0x00, 0x3E, 0x08, 0x20, 0x81, 0x04, 0x10,
  0x40, 0xF8, 0x0E, 0x10, 0x40, 0x81, 0x02, 0x08, 0x60, 0x20, 0x40, 0x82,
  0x04, 0x08, 0x0C, 0x00, 0xFF, 0xFF, 0x80, 0x18, 0x10, 0x82, 0x08, 0x20,
  0x83, 0x10, 0x41, 0x04, 0x20, 0x8C, 0x00, 0x73, 0x1C,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 4, 4, 6, 2, -12 },
  { 9, 9, 12, 9, 0, -12 },
  { 23, 8, 14, 8, 0, -13 },
  { 37, 10, 12, 12, 1, -12 },
  { 52, 9, 12, 10, 0, -12 },
  { 66, 2, 4, 3, 2, -12 },
  { 67, 5, 15, 4, 1, -12 },
  { 77, 5, 15, 4, -1, -12 },
  { 87, 6, 7, 8, 2, -13 },
  { 93, 7, 8, 9, 1, -10 },
  { 100, 3, 4, 3, -1, -2 },
  { 102, 4, 1, 5, 0, -5 },
  { 103, 2, 2, 4, 0, -2 },
  { 104, 8, 12, 6, -1, -12 },
  { 116, 7, 12, 8, 1, -12 },
  { 127, 5, 12, 8, 2, -12 },
  { 135, 8, 12, 8, 0, -12 },
  { 147, 8, 12, 8, 0, -12 },
  { 159, 8, 12, 8, 0, -12 },
  { 171, 8, 12, 8, 0, -12 },
  { 183, 7, 12, 8, 1, -12 },
  { 194, 8, 12, 8, 1, -12 },
  { 206, 8, 12, 8, 0, -12 },
  { 218, 8, 12, 8, 0, -12 },
  { 230, 3, 9, 4, 0, -9 },
  { 234, 4, 11, 4, -1, -9 },
  { 240, 7, 8, 9, 1, -10 },
  { 247, 7, 4, 9, 1, -8 },
  { 251, 7, 8, 9, 1, -10 },
  { 258, 6, 12, 6, 1, -12 },
  { 267, 11, 14, 12, 1, -12 },
  { 287, 8, 12, 8, -1, -12 },
  { 299, 8, 12, 9, 1, -12 },
  { 311, 9, 12, 9, 1, -12 },
  { 325, 9, 12, 10, 0, -12 },
  { 339, 8, 12, 8, 0, -12 },
  { 351, 8, 12, 7, 0, -12 },
  { 363, 9, 12, 10, 1, -12 },
  { 377, 9, 12, 10, 1, -12 },
  { 391, 6, 12, 5, 0, -12 },
  { 400, 7, 15, 4, -3, -12 },
  { 414, 10, 12, 8, 0, -12 },
  { 429, 6, 12, 7, 0, -12 },
  { 438, 13, 12, 13, 0, -12 },
  { 458, 11, 12, 10, 0, -12 },
  { 475, 9, 12, 11, 1, -12 },
  { 489, 9, 12, 8, 0, -12 },
  { 503, 9, 15, 11, 1, -12 },
  { 520, 9, 12, 9, 0, -12 },
  { 534, 8, 12, 8, 0, -12 },
  { 546, 8, 12, 7, 1, -12 },
  { 558, 9, 12, 10, 1, -12 },
  { 572, 8, 12, 8, 2, -12 },
  { 584, 12, 12, 13, 2, -12 },
  { 602, 10, 12, 8, -1, -12 },
  { 617, 7, 12, 7, 2, -12 },
  { 628, 9, 12, 8, 0, -12 },
  { 642, 6, 15, 5, 0, -12 },
  { 654, 2, 12, 6, 2, -12 },
  { 657, 6, 15, 5, -1, -12 },
  { 669, 7, 7, 9, 1, -12 },
  { 676, 6, 1, 6, -1, 1 },
  { 677, 3, 3, 4, 2, -13 },
  { 679, 7, 9, 9, 1, -9 },
  { 687, 8, 13, 9, 0, -13 },
  { 700, 6, 9, 7, 1, -9 },
  { 707, 8, 13, 9, 1, -13 },
  { 720, 6, 9, 8, 1, -9 },
  { 727, 9, 17, 4, -2, -13 },
  { 747, 8, 13, 9, 0, -9 },
  { 760, 8, 13, 8, 0, -13 },
  { 773, 4, 12, 4, 0, -12 },
  { 779, 6, 16, 4, -2, -12 },
  { 791, 8, 13, 7, 0, -13 },
  { 804, 4, 13, 4, 0, -13 },
  { 811, 12, 9, 13, 0, -9 },
  { 825, 8, 9, 8, 0, -9 },
  { 834, 7, 9, 8, 1, -9 },
  { 842, 9, 13, 9, -1, -9 },
  { 857, 7, 13, 9, 1, -9 },
  { 869, 6, 9, 6, 0, -9 },
  { 876, 6, 9, 6, 0, -9 },
  { 883, 4, 11, 5, 1, -11 },
  { 889, 7, 9, 9, 1, -9 },
  { 897, 6, 9, 7, 1, -9 },
  { 904, 10, 9, 11, 1, -9 },
  { 916, 8, 9, 7, -1, -9 },
  { 925, 10, 13, 7, -2, -9 },
  { 942, 7, 9, 6, 0, -9 },
  { 950, 7, 15, 6, 0, -12 },
  { 964, 1, 17, 8, 4, -13 },
  { 967, 6, 15, 6, -1, -12 },
  { 979, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC17PT7B_H_
