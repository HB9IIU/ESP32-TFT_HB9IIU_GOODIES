#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC63PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x78,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0x78, 0x00, 0x80, 0x00, 0x3C, 0x0E,
  0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xF3, 0x81, 0xCF, 0x03, 0x9E, 0x07, 0x38,
  0x1E, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xE7, 0x01, 0x8E, 0x07, 0x1C, 0x0E,
  0x30, 0x1C, 0x60, 0x30, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x18, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x60, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x30, 0x07, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x20, 0x3C, 0x0C, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00,
  0x07, 0x01, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00, 0x78,
  0x38, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x1E, 0x30, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0E, 0x7C, 0x00, 0x00, 0xC3,
  0xC0, 0x00, 0x0C, 0x1E, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x1C, 0x0E, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x03, 0xC0,
  0xC0, 0x30, 0x78, 0x0F, 0x87, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x0F, 0x8F, 0x00, 0x07,
  0x80, 0x70, 0x38, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x78, 0x0E,
  0x00, 0x3C, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x1C, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x70, 0x01, 0xC0,
  0x0E, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x70, 0x07, 0x03, 0x80,
  0x03, 0x80, 0x38, 0x38, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x41, 0xC0, 0x1E,
  0x1C, 0x1F, 0xCE, 0x00, 0xE1, 0xC3, 0xFF, 0x70, 0x07, 0x0E, 0x3E, 0x7D,
  0xC0, 0x70, 0xE1, 0xC0, 0xEE, 0x07, 0x8F, 0x1C, 0x07, 0x70, 0x38, 0x71,
  0xE0, 0x3B, 0xC7, 0x87, 0x0E, 0x01, 0xCF, 0xF8, 0x78, 0xF0, 0x0E, 0x3F,
  0x83, 0x87, 0x00, 0x70, 0x20, 0x38, 0x38, 0x03, 0x80, 0x03, 0xC1, 0xC0,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x1E,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x1C,
  0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x3C, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x3C, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x01, 0xC0,
  0xE0, 0x1C, 0x00, 0x0F, 0x1E, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x0E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x03,
  0x80, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00, 0x07,
  0x1F, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x03, 0xC1, 0xE0, 0x78, 0x01, 0xE1,
  0xE0, 0x1C, 0x00, 0xE1, 0xE0, 0x0F, 0x00, 0xF1, 0xE0, 0x03, 0xC0, 0x70,
  0xF0, 0x01, 0xE0, 0x78, 0xF0, 0x00, 0x78, 0x38, 0x78, 0x00, 0x3C, 0x38,
  0x38, 0x00, 0x0F, 0x3C, 0x1C, 0x00, 0x07, 0xBC, 0x1E, 0x00, 0x01, 0xFE,
  0x0F, 0x00, 0x00, 0x7E, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x1F, 0xE0, 0x3E, 0x00, 0x3E,
  0xF0, 0x0F, 0x80, 0x3E, 0x3C, 0x07, 0xF9, 0xFE, 0x0E, 0x01, 0xFF, 0xFC,
  0x07, 0x80, 0x3F, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x3C, 0xF3,
  0xCE, 0x39, 0xE7, 0x9C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x30, 0x00, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x1C, 0x00, 0x78, 0x1C,
  0x00, 0xFC, 0x1C, 0x00, 0x3F, 0x18, 0x00, 0x0F, 0xD8, 0x0F, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xCC,
  0x00, 0x03, 0x8E, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x3E, 0x07,
  0x00, 0x7C, 0x03, 0x80, 0x18, 0x03, 0x80, 0x10, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF7, 0xFF, 0xE0, 0x11, 0xE7, 0xFF,
  0xF9, 0xE2, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0xF8, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0,
  0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0x1C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1C,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x1E, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1E,
  0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0E, 0x3C, 0x00,
  0x03, 0xC7, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3,
  0x80, 0x00, 0x78, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x00, 0xF0, 0x1F, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xC1, 0xFB, 0x87, 0xCF, 0x1F, 0x1E, 0xF8,
  0x3D, 0xE0, 0x71, 0x80, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xC0, 0x03,
  0xE0, 0x04, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x03,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0x3F, 0xF7, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x39,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0x80, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x80, 0x00, 0x7C, 0x07,
  0x00, 0x0F, 0xC0, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x9E, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x0F, 0xE0,
  0x03, 0xC3, 0xFF, 0x80, 0x3C, 0xFF, 0xFC, 0x03, 0x9E, 0x07, 0xE0, 0x3B,
  0x80, 0x1E, 0x07, 0xF0, 0x00, 0xF0, 0x7E, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0F,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x07, 0x80,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x01, 0xE0,
  0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0,
  0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E,
  0x03, 0xC0, 0x01, 0xE0, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x03,
  0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0,
  0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0x7E, 0x00, 0xF8, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x80,
  0x78, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0xF0,
  0x00, 0x07, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x87, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x6E, 0x0F, 0x80, 0x3F, 0xC0, 0xF8, 0x1F, 0x70,
  0x0F, 0xFF, 0xCE, 0x00, 0xFF, 0xE1, 0xC0, 0x07, 0xF0, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x02, 0x00, 0x7C, 0x00, 0x7E, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x00, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0E, 0x00, 0xF0, 0x20,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x83, 0xC0, 0x03, 0xFF, 0x00, 0x70, 0xE0, 0x03, 0xFF,
  0xE0, 0x1C, 0x78, 0x01, 0xF0, 0xF8, 0x07, 0x1C, 0x00, 0xF0, 0x0E, 0x01,
  0xC7, 0x00, 0x78, 0x07, 0x00, 0x73, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0xE0,
  0x1E, 0x00, 0x70, 0x07, 0x78, 0x07, 0x00, 0x1C, 0x01, 0xDC, 0x03, 0xC0,
  0x0E, 0x00, 0xE7, 0x00, 0xE0, 0x03, 0x80, 0x39, 0xC0, 0x38, 0x00, 0xE0,
  0x0E, 0xF0, 0x1C, 0x00, 0x78, 0x03, 0xB8, 0x07, 0x00, 0x1C, 0x00, 0xEE,
  0x01, 0xC0, 0x07, 0x00, 0x73, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0xE0, 0x38,
  0x00, 0xF0, 0x07, 0x38, 0x0E, 0x00, 0x38, 0x03, 0x8E, 0x03, 0x80, 0x1E,
  0x00, 0xE3, 0x80, 0xE0, 0x07, 0x80, 0x70, 0xE0, 0x3C, 0x03, 0x60, 0x3C,
  0x38, 0x07, 0x01, 0xD8, 0x0E, 0x0E, 0x01, 0xE0, 0xE7, 0x07, 0x03, 0x80,
  0x7F, 0xF1, 0xFF, 0x80, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x38, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x07,
  0x07, 0x00, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xE0, 0x07,
  0x00, 0x03, 0x80, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x1F, 0xC0, 0x0F, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x78,
  0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x3F, 0x00, 0xE0, 0x03, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xC0, 0x00,
  0x80, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x38, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0E, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x07, 0x80, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0xF8, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F, 0x03, 0x80,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x83, 0x80, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x7C,
  0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x3E,
  0x03, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0x70, 0x00, 0xFE, 0x00, 0x38, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x00, 0x60, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xF8, 0xF0, 0x00, 0x3F, 0xFE,
  0x3C, 0x00, 0x0F, 0xFF, 0x0F, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x3E, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x07, 0x00, 0x01, 0xF0, 0x01, 0xC0, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x07, 0x80, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x03, 0x83, 0xE0, 0x00, 0x00, 0xE1, 0xF0, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0xBF, 0x00,
  0x00, 0x01, 0xCF, 0xC0, 0x00, 0x00, 0x77, 0x78, 0x00, 0x00, 0x3F, 0x9E,
  0x00, 0x00, 0x0F, 0xC3, 0x80, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xB8, 0x00, 0x00, 0x1F, 0xC0,
  0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0xEE, 0x00, 0x00, 0x1E, 0xF0, 0x07, 0xB8, 0x00, 0x00, 0x73, 0xC0, 0x1E,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x73, 0xC0, 0x00, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x00, 0x79, 0xE0, 0x0F, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x3C, 0x70,
  0x00, 0x0F, 0x1C, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00,
  0x01, 0xE3, 0xC0, 0x0E, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x3C, 0x01, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x80, 0x07,
  0x83, 0x80, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x70, 0x38, 0x00, 0xF0,
  0x78, 0x03, 0xC0, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0x80, 0x1C, 0x07,
  0x00, 0x38, 0x0E, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xF0,
  0x03, 0x80, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x78, 0x0F, 0x03, 0xC0, 0x38, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xC1, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x71, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC7, 0x00, 0x3C, 0x01, 0xE0, 0x07,
  0x38, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x3F,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x78, 0x01, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0x00, 0x7F, 0x00, 0x00, 0x38,
  0x03, 0xB8, 0x00, 0x03, 0xC0, 0x1D, 0xE0, 0x00, 0x1E, 0x00, 0xEF, 0x00,
  0x00, 0xE0, 0x0F, 0x38, 0x00, 0x07, 0x00, 0x71, 0xC0, 0x00, 0x38, 0x03,
  0x8F, 0x00, 0x03, 0xC0, 0x1C, 0x38, 0x00, 0x1E, 0x01, 0xE1, 0xC0, 0x00,
  0xE0, 0x0F, 0x0F, 0x00, 0x07, 0x00, 0x70, 0x38, 0x00, 0x78, 0x03, 0x81,
  0xC0, 0x03, 0xC0, 0x1C, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x38, 0x00, 0xE0,
  0x0F, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x78, 0x03, 0x80, 0x0F, 0x03,
  0xC0, 0x1C, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x0F, 0x00,
  0x0F, 0x07, 0x00, 0x70, 0x00, 0x78, 0x78, 0x03, 0x80, 0x01, 0xC3, 0xC0,
  0x3C, 0x00, 0x0E, 0x1C, 0x01, 0xE0, 0x00, 0x78, 0xE0, 0x0E, 0x00, 0x01,
  0xC7, 0x00, 0x70, 0x00, 0x0E, 0x78, 0x03, 0x80, 0x00, 0x7B, 0x80, 0x3C,
  0x00, 0x01, 0xDC, 0x01, 0xE0, 0x00, 0x0E, 0xE0, 0x0E, 0x00, 0x00, 0x7F,
  0x00, 0x70, 0x00, 0x01, 0xF8, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x00, 0x7C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1C, 0x03, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78,
  0x07, 0x80, 0x03, 0xE0, 0x1C, 0x00, 0x1F, 0x00, 0x70, 0x01, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x00, 0xF3, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1C, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0,
  0x0F, 0x00, 0x07, 0x80, 0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x38, 0x07,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x1C, 0x00, 0x7E, 0x00,
  0x70, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x07,
  0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x01, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0x08,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x7E, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01,
  0xE0, 0x07, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0x80,
  0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1E,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x3C, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF3, 0x80, 0x00, 0x7E, 0x00, 0x03, 0x8E,
  0x00, 0x03, 0xB8, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0xE0,
  0x00, 0x73, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE0, 0xE0, 0x01,
  0xE3, 0x80, 0x07, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x80, 0xE0, 0x03, 0x83,
  0x80, 0x1E, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x38,
  0x03, 0xC0, 0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x03, 0x80,
  0x78, 0x03, 0x80, 0x78, 0x0E, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x0F,
  0x00, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0xE0,
  0x03, 0x80, 0xE0, 0x0E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x38, 0x1C, 0x00,
  0x3C, 0x1C, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0x80, 0x03,
  0xC3, 0x80, 0x0E, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x00, 0x3C,
  0x70, 0x00, 0xE1, 0xC0, 0x00, 0xF1, 0xC0, 0x03, 0x8F, 0x00, 0x03, 0xCE,
  0x00, 0x0E, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x39, 0xE0, 0x00, 0x3D, 0xE0,
  0x00, 0xE7, 0x00, 0x00, 0xF7, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x00, 0xE7, 0x80,
  0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xC7, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x00, 0xE0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x00, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x1E, 0x70, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x38,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x78, 0x78,
  0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x00, 0x1F, 0xC0, 0x60, 0x0F,
  0xFE, 0x1C, 0x03, 0xFF, 0xE3, 0x80, 0xFC, 0x1C, 0x70, 0x3E, 0x01, 0xDC,
  0x0F, 0x80, 0x1B, 0x83, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x38, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x07,
  0x87, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x83, 0x80,
  0x03, 0xF0, 0x78, 0x00, 0x7E, 0x0F, 0x00, 0x1B, 0x81, 0xF0, 0x07, 0x70,
  0x1E, 0x03, 0xCE, 0x01, 0xFB, 0xF1, 0xC0, 0x3F, 0xFC, 0x38, 0x01, 0xFE,
  0x0E, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x7E, 0x00, 0x1E,
  0x1F, 0xF8, 0x01, 0xC7, 0xFF, 0xC0, 0x1C, 0xF0, 0x3E, 0x01, 0xDE, 0x01,
  0xE0, 0x3F, 0x80, 0x0F, 0x03, 0xB0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x70, 0x7C, 0x00, 0x07, 0x07, 0xC0, 0x00, 0x70, 0x78, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x0E, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x1E,
  0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x78, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7E, 0x00, 0x1E,
  0x07, 0x70, 0x03, 0xE0, 0x73, 0x80, 0x7C, 0x07, 0x3E, 0x7F, 0x80, 0x61,
  0xFF, 0xE0, 0x0E, 0x0F, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xC0, 0x60, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x20, 0x1F, 0xE7, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xF0,
  0x3C, 0x00, 0x3F, 0xF8, 0x70, 0x00, 0xFF, 0xF8, 0xE0, 0x03, 0xF0, 0x79,
  0xC0, 0x0F, 0x80, 0x37, 0x80, 0x3E, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0, 0x3C,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0x70, 0x00,
  0x3E, 0x00, 0xE0, 0x00, 0xFC, 0x01, 0xE0, 0x01, 0xB8, 0x03, 0xC0, 0x07,
  0x70, 0x07, 0xC0, 0x1D, 0xE0, 0x07, 0x80, 0xF3, 0x80, 0x07, 0xE7, 0xC7,
  0x00, 0x0F, 0xFF, 0x0E, 0x00, 0x07, 0xF8, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0x81,
  0xF0, 0x3E, 0x01, 0xE0, 0xF8, 0x01, 0xC3, 0xE0, 0x03, 0x87, 0x80, 0x07,
  0x1E, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xC0, 0x01, 0xE7,
  0x80, 0x07, 0xCF, 0x00, 0x1F, 0x1C, 0x00, 0xFC, 0x38, 0x7F, 0xE0, 0xFF,
  0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x38, 0x1F, 0xE3, 0xF0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x20, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x10, 0x78, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x1C, 0x00, 0x7F, 0xF0, 0x60, 0x03, 0xFF,
  0xE3, 0x80, 0x1F, 0x83, 0xCE, 0x00, 0xF8, 0x03, 0x38, 0x07, 0xC0, 0x0F,
  0xE0, 0x3E, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xE0, 0x38, 0x00, 0x0F, 0x80,
  0xE0, 0x00, 0x7C, 0x03, 0x80, 0x03, 0xF0, 0x0F, 0x00, 0x0F, 0xC0, 0x3C,
  0x00, 0x7F, 0x00, 0xF8, 0x03, 0xBC, 0x01, 0xE0, 0x3C, 0xE0, 0x07, 0xF3,
  0xE3, 0x80, 0x0F, 0xFF, 0x1E, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x06, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x80,
  0x03, 0xE0, 0x03, 0xC0, 0x3F, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x1F, 0x80, 0x0F, 0x0F, 0xFC,
  0x01, 0xC7, 0xFF, 0xC0, 0x39, 0xE0, 0x7C, 0x07, 0x70, 0x07, 0x81, 0xFC,
  0x00, 0x70, 0x3B, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xC0, 0xF8, 0x00, 0x38,
  0x3E, 0x00, 0x07, 0x07, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0F,
  0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x01, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x01,
  0xC0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x3C, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C, 0xFC, 0x00, 0x03, 0x9F,
  0x80, 0x00, 0x77, 0x70, 0x00, 0x0F, 0xCF, 0x00, 0x03, 0xF0, 0xE0, 0x00,
  0x7C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x78, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0xFE, 0x00, 0x7F, 0x00, 0x1C, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xC7,
  0xFF, 0x83, 0xFF, 0xC0, 0x1C, 0xF0, 0x78, 0x78, 0x3E, 0x01, 0xDC, 0x03,
  0xCE, 0x01, 0xE0, 0x3B, 0x80, 0x3D, 0xC0, 0x0F, 0x03, 0xB0, 0x01, 0xF8,
  0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x70,
  0x00, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x01, 0xC0, 0xFF, 0x00, 0x1C, 0x3F,
  0xF8, 0x01, 0xC7, 0xFF, 0xC0, 0x1C, 0xF0, 0x3E, 0x03, 0xDE, 0x01, 0xE0,
  0x3B, 0x80, 0x0E, 0x03, 0xB0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0xE0, 0x7C, 0x00, 0x0E, 0x07, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x1C,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x1E, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0,
  0x70, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x00, 0xFF, 0x7F,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x38, 0x0F, 0xC0, 0x00, 0x70, 0x7F, 0xE0, 0x00, 0xE3, 0xFF, 0xE0, 0x01,
  0xCF, 0x03, 0xE0, 0x03, 0xBC, 0x03, 0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0x1D,
  0xC0, 0x07, 0x80, 0x3F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0E, 0x01, 0xF0,
  0x00, 0x1C, 0x03, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x70, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x0F, 0x00,
  0xFC, 0x00, 0x3C, 0x01, 0xFC, 0x00, 0xF8, 0x03, 0x9C, 0x03, 0xE0, 0x07,
  0x3F, 0x7F, 0x80, 0x0E, 0x3F, 0xFC, 0x00, 0x3C, 0x3F, 0xF0, 0x00, 0x78,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x70, 0x07, 0xFF, 0x06, 0x00, 0xFF, 0xF8, 0xE0, 0x1F, 0x03, 0xCE, 0x03,
  0xE0, 0x0C, 0xE0, 0x7C, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00,
  0x7C, 0x1E, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x38, 0x78, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x87, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70,
  0xF0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x3E,
  0x0E, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x0D, 0xC0, 0xF0,
  0x01, 0xFC, 0x0F, 0x00, 0x3B, 0xC0, 0x78, 0x0F, 0x38, 0x07, 0xF3, 0xE3,
  0x80, 0x3F, 0xFC, 0x78, 0x00, 0xFF, 0x07, 0x80, 0x01, 0x80, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0xFC, 0x07, 0x0F, 0xF0, 0x1C, 0x7F, 0xC0, 0x73, 0xE1,
  0x01, 0xDE, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0x00, 0xF0, 0x7C,
  0x00, 0x40, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x10, 0x00,
  0x7C, 0x38, 0x01, 0xF0, 0x7F, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFD, 0xC0, 0x7F, 0xC0,
  0x3F, 0xC0, 0x06, 0x00, 0x07, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x1C,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70,
  0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0x38, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xE0, 0x70,
  0x00, 0x7C, 0x0E, 0x00, 0x1B, 0x81, 0xE0, 0x07, 0x70, 0x3E, 0x03, 0xCE,
  0x03, 0xF3, 0xF3, 0x80, 0x7F, 0xF8, 0x70, 0x03, 0xFE, 0x0E, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xCE, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x01, 0xE1, 0xC0, 0x00,
  0xF0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x78, 0x1E, 0x00,
  0x38, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x07, 0x80, 0x0E,
  0x03, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x70, 0x00, 0x0E, 0x78, 0x00,
  0x07, 0x38, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xEE, 0x00, 0x1F, 0x00,
  0x0F, 0x70, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x07, 0x9C, 0x00,
  0xF7, 0x00, 0x38, 0xE0, 0x07, 0x38, 0x03, 0xC7, 0x00, 0x39, 0xC0, 0x1C,
  0x38, 0x03, 0x8E, 0x01, 0xE1, 0xC0, 0x1C, 0x70, 0x0F, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0x70, 0x0E, 0x1C, 0x07, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x1C,
  0x07, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC1,
  0xE0, 0x38, 0x3C, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x0E, 0x0E,
  0x03, 0x87, 0x80, 0x78, 0xE0, 0x1C, 0x38, 0x03, 0xC7, 0x00, 0xE3, 0xC0,
  0x1E, 0x70, 0x07, 0x1C, 0x00, 0xF3, 0x80, 0x39, 0xE0, 0x07, 0xB8, 0x01,
  0xCE, 0x00, 0x3D, 0xC0, 0x0E, 0x70, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0D, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x01, 0xC0, 0x01,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xC0, 0x1E,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x0E, 0x00, 0x07, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x38, 0x70, 0x00, 0x00, 0x07, 0x1E,
  0x00, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x17, 0xFF,
  0xC0, 0x0F, 0xF7, 0xFC, 0x07, 0xE0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE8,
  0x00, 0x0F, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 14, 46, 14, 1, -45 },
  { 82, 15, 16, 21, 7, -45 },
  { 112, 34, 45, 34, 1, -45 },
  { 304, 28, 52, 30, 2, -48 },
  { 486, 37, 47, 44, 4, -46 },
  { 704, 33, 47, 36, 1, -46 },
  { 898, 6, 16, 12, 7, -45 },
  { 910, 19, 55, 16, 2, -45 },
  { 1041, 18, 55, 16, -4, -45 },
  { 1165, 24, 25, 29, 7, -48 },
  { 1240, 26, 30, 32, 4, -37 },
  { 1338, 10, 15, 13, -3, -7 },
  { 1357, 15, 4, 18, 2, -19 },
  { 1365, 6, 7, 13, 1, -6 },
  { 1371, 28, 45, 20, -3, -45 },
  { 1529, 27, 47, 30, 3, -46 },
  { 1688, 15, 45, 30, 9, -45 },
  { 1773, 30, 46, 30, -1, -46 },
  { 1946, 30, 47, 30, 0, -46 },
  { 2123, 29, 45, 30, 0, -45 },
  { 2287, 29, 46, 30, 1, -45 },
  { 2454, 28, 47, 30, 3, -46 },
  { 2619, 27, 45, 30, 5, -45 },
  { 2771, 28, 47, 30, 2, -46 },
  { 2936, 27, 47, 30, 2, -46 },
  { 3095, 11, 35, 13, 1, -34 },
  { 3144, 15, 42, 13, -3, -34 },
  { 3223, 26, 29, 32, 4, -37 },
  { 3318, 26, 16, 32, 4, -30 },
  { 3370, 26, 29, 32, 4, -37 },
  { 3465, 22, 47, 23, 3, -46 },
  { 3595, 42, 51, 46, 3, -45 },
  { 3863, 31, 45, 31, -4, -45 },
  { 4038, 31, 45, 33, 2, -45 },
  { 4213, 31, 47, 32, 4, -46 },
  { 4396, 33, 45, 37, 2, -45 },
  { 4582, 29, 45, 29, 2, -45 },
  { 4746, 29, 45, 27, 2, -45 },
  { 4910, 34, 47, 38, 4, -46 },
  { 5110, 36, 45, 38, 2, -45 },
  { 5313, 22, 45, 17, -2, -45 },
  { 5437, 25, 56, 14, -10, -45 },
  { 5612, 34, 45, 31, 2, -45 },
  { 5804, 20, 45, 27, 2, -45 },
  { 5917, 46, 45, 47, 2, -45 },
  { 6176, 37, 45, 39, 2, -45 },
  { 6385, 34, 47, 40, 4, -46 },
  { 6585, 30, 45, 31, 2, -45 },
  { 6754, 34, 57, 40, 4, -46 },
  { 6997, 30, 45, 32, 2, -45 },
  { 7166, 29, 47, 28, 0, -46 },
  { 7337, 26, 45, 27, 6, -45 },
  { 7484, 34, 46, 38, 4, -45 },
  { 7680, 30, 45, 30, 6, -45 },
  { 7849, 46, 45, 48, 7, -45 },
  { 8108, 37, 45, 28, -4, -45 },
  { 8317, 27, 45, 27, 6, -45 },
  { 8469, 33, 45, 29, -1, -45 },
  { 8655, 24, 55, 18, -1, -45 },
  { 8820, 11, 45, 21, 6, -45 },
  { 8882, 23, 55, 18, -4, -45 },
  { 9041, 28, 26, 32, 2, -45 },
  { 9132, 22, 3, 22, -5, 6 },
  { 9141, 8, 10, 15, 9, -48 },
  { 9151, 27, 35, 32, 3, -34 },
  { 9270, 28, 49, 32, 1, -48 },
  { 9442, 23, 35, 25, 3, -34 },
  { 9543, 31, 49, 32, 3, -48 },
  { 9733, 23, 35, 28, 3, -34 },
  { 9834, 33, 63, 16, -8, -48 },
  { 10094, 30, 49, 32, 1, -34 },
  { 10278, 27, 48, 31, 1, -48 },
  { 10440, 14, 46, 13, 1, -46 },
  { 10521, 23, 61, 13, -8, -46 },
  { 10697, 27, 48, 26, 1, -48 },
  { 10859, 14, 48, 13, 1, -48 },
  { 10943, 44, 34, 48, 1, -34 },
  { 11130, 28, 34, 31, 1, -34 },
  { 11249, 26, 35, 31, 3, -34 },
  { 11363, 31, 49, 32, -2, -34 },
  { 11553, 28, 49, 32, 3, -34 },
  { 11725, 22, 34, 21, 1, -34 },
  { 11819, 23, 35, 24, 0, -34 },
  { 11920, 16, 42, 18, 3, -41 },
  { 12004, 27, 35, 32, 3, -34 },
  { 12123, 25, 34, 25, 3, -34 },
  { 12230, 37, 34, 39, 4, -34 },
  { 12388, 30, 34, 26, -2, -34 },
  { 12516, 35, 49, 25, -7, -34 },
  { 12731, 25, 34, 24, -1, -34 },
  { 12838, 23, 55, 21, 1, -45 },
  { 12997, 3, 63, 30, 14, -48 },
  { 13021, 23, 55, 21, -3, -45 },
  { 13180, 26, 7, 32, 4, -26 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC63PT7B_H_
