#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC66PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1E, 0x00, 0x18, 0x00, 0x1E, 0x0F, 0x8E, 0x07, 0x8F,
  0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x70, 0x3C,
  0x78, 0x1C, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x70, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x38,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xC3, 0x83, 0x80, 0x7C, 0x1C, 0x04, 0x03, 0xC0, 0xC0, 0x00,
  0x3C, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0,
  0x18, 0x00, 0x07, 0x80, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x18, 0x00, 0x01, 0xF0, 0xC0, 0x00,
  0x07, 0xCE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0x3F, 0x00, 0x00, 0x18, 0x78, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0x01, 0xE0, 0x00,
  0x18, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x38, 0x1E, 0x04, 0x01, 0xC1, 0xF0,
  0x38, 0x0E, 0x1F, 0x01, 0xFC, 0x6F, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0xF0, 0x00, 0x0E, 0x01, 0xE1,
  0xE0, 0x00, 0x70, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x38, 0x03,
  0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x0E,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x78, 0x00,
  0xE0, 0x07, 0x83, 0xC0, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x0E, 0x00, 0x70,
  0x78, 0x00, 0x38, 0x03, 0xC1, 0xC0, 0xF0, 0xE0, 0x0E, 0x0E, 0x0F, 0xF3,
  0x80, 0x38, 0x78, 0xFF, 0xEE, 0x01, 0xE1, 0xC3, 0xC7, 0xF8, 0x07, 0x0E,
  0x1E, 0x0F, 0xE0, 0x3C, 0x78, 0xF0, 0x1F, 0xC1, 0xE1, 0xC3, 0x80, 0x77,
  0x8F, 0x0E, 0x1E, 0x01, 0xDF, 0xF8, 0x78, 0x70, 0x07, 0x3F, 0xC1, 0xC3,
  0xC0, 0x1C, 0x3C, 0x0E, 0x0E, 0x00, 0x70, 0x00, 0x78, 0x38, 0x01, 0xC0,
  0x01, 0xC0, 0xE0, 0x07, 0x00, 0x0E, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x3C, 0x03, 0x80, 0x78, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x01, 0xC0,
  0x70, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0x1E, 0x01, 0xC0,
  0x00, 0x3F, 0xF0, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x70,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00,
  0x00, 0x0F, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0x3C, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83,
  0xE0, 0x78, 0x01, 0xE0, 0xF8, 0x0F, 0x00, 0x3C, 0x3E, 0x00, 0xF0, 0x07,
  0x07, 0x80, 0x1E, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0x38, 0x38, 0x00, 0x1E,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC1, 0xE0, 0x00, 0x3C, 0x78, 0x38, 0x00,
  0x07, 0x9E, 0x07, 0x00, 0x00, 0x7F, 0x81, 0xE0, 0x00, 0x0F, 0xF0, 0x3C,
  0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x0F, 0x00, 0x00, 0xFE, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0x1F,
  0x3C, 0x03, 0xE0, 0x0F, 0xC7, 0x80, 0x3F, 0xFF, 0xE0, 0x78, 0x03, 0xFF,
  0xF8, 0x0F, 0x80, 0x3F, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0C,
  0x38, 0x70, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x01, 0x80, 0x38, 0x00, 0xF0,
  0x1C, 0x00, 0xFE, 0x0E, 0x00, 0x1F, 0xC6, 0x00, 0x03, 0xF3, 0x00, 0x60,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x00,
  0x01, 0xDC, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0x80, 0x03, 0xE0, 0xE0,
  0x03, 0xE0, 0x70, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x60, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E,
  0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xF7, 0xFF, 0xFD, 0xE3, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x7C, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00,
  0x0E, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3, 0x80,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x7C, 0x07, 0x80, 0x07, 0x80,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x07,
  0xEE, 0x0F, 0x9E, 0x3F, 0x1E, 0x7C, 0x1E, 0xF8, 0x1C, 0x70, 0x1C, 0x40,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x3E, 0x00,
  0x18, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x80, 0x18,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x06, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x38, 0xF0,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00,
  0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x70, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x10,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x0C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3A, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xF8, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x1F, 0xE0,
  0x01, 0xC3, 0xFF, 0xC0, 0x1E, 0x7F, 0xFF, 0x00, 0xF7, 0xC0, 0xFC, 0x07,
  0x78, 0x01, 0xE0, 0x3B, 0x00, 0x07, 0x83, 0xF0, 0x00, 0x3C, 0x1F, 0x00,
  0x00, 0xE0, 0xF8, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3C,
  0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x0F, 0xC1, 0xE0,
  0x00, 0x7E, 0x0F, 0x00, 0x0E, 0xE0, 0x3C, 0x00, 0xFF, 0x01, 0xF8, 0x1F,
  0x78, 0x07, 0xFF, 0xF3, 0xC0, 0x1F, 0xFE, 0x1C, 0x00, 0x3F, 0xC1, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x08, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x40, 0x1E,
  0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0x20, 0x00, 0x00, 0x04, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1E, 0x01, 0xF8, 0x20, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x3F, 0xC0,
  0x0F, 0x07, 0x00, 0x0F, 0xFF, 0x80, 0x70, 0xE0, 0x01, 0xFF, 0xF8, 0x07,
  0x0E, 0x00, 0x7C, 0x07, 0x00, 0x71, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x73, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0x38, 0x03,
  0xC0, 0x0E, 0x00, 0x73, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x78, 0x07, 0x00,
  0x0E, 0x00, 0xF7, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x70, 0x0E, 0x00, 0x1C,
  0x00, 0xE7, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0xF0, 0x0E, 0x00, 0x1C, 0x00,
  0xEE, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0xE0, 0x1C, 0x00, 0x38, 0x01, 0xCE,
  0x01, 0xC0, 0x03, 0x80, 0x1C, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x8E, 0x01,
  0xC0, 0x07, 0x80, 0x38, 0xE0, 0x1C, 0x00, 0xF8, 0x07, 0x0E, 0x01, 0xC0,
  0x0F, 0x80, 0x70, 0xE0, 0x1E, 0x01, 0xB8, 0x0E, 0x0E, 0x01, 0xE0, 0x3B,
  0x81, 0xE0, 0xE0, 0x0F, 0x0F, 0x3C, 0x7C, 0x0E, 0x00, 0xFF, 0xE1, 0xFF,
  0x80, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x18,
  0x00, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E,
  0x07, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x78, 0x01, 0xFC,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF8,
  0x03, 0xC0, 0x01, 0xF0, 0x03, 0x80, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0F, 0xC0,
  0x0F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xF0, 0x38, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x1F, 0x80,
  0x70, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x70, 0x01, 0xF8, 0x00, 0x08, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x70, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0x40, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3C, 0x01, 0xFE, 0x00, 0x07, 0x80, 0x07,
  0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x07, 0x81, 0xC0, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01,
  0xF0, 0x0E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x0F, 0xC0, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xFC, 0x00, 0x38,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x20, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x00, 0x04, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x1F, 0xFF, 0x87, 0x00, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0x1F, 0xFF,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x78,
  0x01, 0xF8, 0x00, 0x07, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x03, 0x8F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x1F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00,
  0x1C, 0x0F, 0x80, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x03, 0x8F,
  0x80, 0x00, 0x00, 0x79, 0xF8, 0x00, 0x00, 0x07, 0xBF, 0x80, 0x00, 0x00,
  0x7F, 0xBC, 0x00, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x00, 0xFE, 0x3C, 0x00,
  0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xDC, 0x00, 0xF7,
  0x00, 0x00, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x00, 0x07, 0xBC, 0x00, 0xE7,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x3C, 0x01, 0xE7,
  0x00, 0x00, 0x0E, 0x38, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x78, 0x01, 0xE7,
  0x80, 0x00, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x01, 0xC7,
  0x80, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x70, 0x03, 0xC3,
  0x80, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xF0, 0x03, 0x83,
  0x80, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x07, 0x83,
  0x80, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x07, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x07, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x01,
  0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x0F, 0x01,
  0xC0, 0x1E, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x0E, 0x01,
  0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x1E, 0x01,
  0xE0, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x70, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xE1, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE3, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE3, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE7, 0x80, 0x0F, 0x00, 0x78, 0x00,
  0xF7, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xFE, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x00, 0x00,
  0x78, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x0F,
  0xE0, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x7B, 0x80, 0x00,
  0x1E, 0x00, 0xE7, 0x80, 0x00, 0x38, 0x01, 0xCF, 0x00, 0x00, 0xF0, 0x03,
  0x8E, 0x00, 0x01, 0xE0, 0x0F, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x3C, 0x00,
  0x07, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x00, 0x70, 0x78, 0x00, 0x3C, 0x00,
  0xE0, 0xF0, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x07, 0x81, 0xC0,
  0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0x07, 0x80, 0x0F, 0x00,
  0x38, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x00,
  0xF0, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x01, 0xC0, 0xF0,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x1E, 0x00,
  0x07, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x70, 0x00, 0x1E, 0x3C,
  0x01, 0xE0, 0x00, 0x1C, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0xE0, 0x07, 0x80,
  0x00, 0x79, 0xC0, 0x0E, 0x00, 0x00, 0xF7, 0x80, 0x3C, 0x00, 0x00, 0xEF,
  0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xC0,
  0x00, 0x03, 0xF0, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x0F,
  0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xC0, 0x3F, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x0F, 0x80, 0x3C,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0xF8, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x3E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x7C,
  0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x07, 0x80, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x3F,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C,
  0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x1C,
  0x00, 0x07, 0xC0, 0x38, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0,
  0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x07,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0x80,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x06, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E, 0x1C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0xF0, 0x70, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x78, 0xF0, 0x00,
  0x1D, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x39, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x79, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x71, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF1, 0xC0, 0x01, 0xC0, 0xF0, 0x00,
  0xE1, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC0, 0xF0, 0x01,
  0xC1, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC1, 0xC0, 0x07, 0x80, 0xF0, 0x03,
  0xC1, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0x81, 0xC0, 0x0F, 0x00, 0xF0, 0x07,
  0x81, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C,
  0x01, 0xE0, 0x78, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x01, 0xE0, 0xF0, 0x00, 0x70, 0x78, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x70,
  0x01, 0xE1, 0xE0, 0x00, 0x70, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0xE0,
  0x01, 0xE3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0,
  0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x80, 0x00, 0x73, 0xC0,
  0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0xEF, 0x00, 0x00, 0x77, 0x80,
  0x00, 0xEF, 0x00, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x1E,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x07, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1E, 0x1C, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x78, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x70, 0x0E,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00,
  0x03, 0x87, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1E, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0x81, 0xC0, 0x1F, 0xFF, 0x1C, 0x01, 0xFE,
  0xF8, 0xE0, 0x1F, 0x00, 0xE7, 0x01, 0xF0, 0x03, 0x78, 0x1F, 0x00, 0x1F,
  0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07,
  0x80, 0x00, 0xF8, 0x78, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x1F, 0x07, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x7F, 0x03,
  0xC0, 0x07, 0x70, 0x0F, 0x00, 0x7B, 0x80, 0x7C, 0x07, 0x9C, 0x01, 0xFF,
  0xF8, 0xE0, 0x07, 0xFF, 0x07, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38,
  0x3F, 0xE0, 0x01, 0xE1, 0xFF, 0xE0, 0x07, 0x9F, 0xFF, 0xC0, 0x1E, 0xF0,
  0x1F, 0x00, 0x73, 0x80, 0x3E, 0x01, 0xDC, 0x00, 0x78, 0x0F, 0xE0, 0x01,
  0xE0, 0x3F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C,
  0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x38, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0x7F,
  0x00, 0x0F, 0x01, 0xCC, 0x00, 0x78, 0x07, 0x3C, 0x07, 0xE0, 0x1C, 0x7F,
  0xFF, 0x00, 0x70, 0xFF, 0xF0, 0x03, 0x81, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xF8, 0x02, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1F, 0xF8, 0x78, 0x00, 0x7F, 0xFC,
  0x78, 0x00, 0xFF, 0x7E, 0x78, 0x01, 0xF0, 0x0E, 0x70, 0x03, 0xE0, 0x07,
  0x70, 0x07, 0xC0, 0x03, 0x70, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0xEE,
  0x00, 0xF0, 0x01, 0xEE, 0x00, 0x78, 0x03, 0xDE, 0x00, 0x7C, 0x07, 0x9C,
  0x00, 0x3F, 0xFF, 0x1C, 0x00, 0x1F, 0xFE, 0x1C, 0x00, 0x0F, 0xF8, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xEF, 0xC0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0x78,
  0x1F, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x03,
  0x87, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xC0, 0x01,
  0xF1, 0xE0, 0x01, 0xF0, 0xF0, 0x03, 0xF0, 0x78, 0x3F, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x20, 0x3E, 0x00, 0x70,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0C, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x1C, 0x00, 0x7F, 0xFC, 0x38, 0x01, 0xFE, 0xFC, 0xF0, 0x07, 0xC0,
  0x39, 0xC0, 0x1F, 0x00, 0x3B, 0x80, 0x7C, 0x00, 0x37, 0x00, 0xF0, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x1E,
  0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x0F, 0x80, 0xE0,
  0x00, 0x3F, 0x01, 0xE0, 0x00, 0x7E, 0x03, 0xC0, 0x01, 0xF8, 0x07, 0x80,
  0x07, 0x70, 0x0F, 0x00, 0x1F, 0xE0, 0x0F, 0x00, 0x7B, 0xC0, 0x1F, 0x01,
  0xE7, 0x00, 0x1F, 0xFF, 0x8E, 0x00, 0x1F, 0xFE, 0x3C, 0x00, 0x1F, 0xF0,
  0x78, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x20, 0x00, 0x7C, 0x00, 0x60, 0x01, 0xF0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1C,
  0x1F, 0xF8, 0x01, 0xE3, 0xFF, 0xE0, 0x0F, 0x3F, 0xFF, 0x80, 0x73, 0xC0,
  0x3C, 0x03, 0xBC, 0x01, 0xF0, 0x1D, 0xC0, 0x07, 0x81, 0xFC, 0x00, 0x3C,
  0x0F, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C,
  0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xC7, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x1F, 0x00, 0x1C, 0x01, 0xF0, 0x01, 0xE0,
  0x1F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xEF,
  0xE0, 0x00, 0x0E, 0xFF, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x03, 0xF1, 0xE0,
  0x00, 0x3F, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0,
  0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x83, 0xFE, 0x01, 0xFF, 0x80, 0x1C, 0x3F, 0xFC, 0x0F, 0xFF, 0x00,
  0x71, 0xFF, 0xF0, 0x7F, 0xFE, 0x01, 0xCF, 0x03, 0xE3, 0xC0, 0x78, 0x07,
  0x70, 0x07, 0x9C, 0x01, 0xF0, 0x1F, 0x80, 0x0E, 0xE0, 0x03, 0xC0, 0xFC,
  0x00, 0x3B, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0x07, 0xFE, 0x00, 0x78, 0xFF, 0xF8, 0x03, 0x8F, 0xFF, 0xE0,
  0x1C, 0xF0, 0x1F, 0x00, 0xEF, 0x00, 0x7C, 0x07, 0x70, 0x01, 0xE0, 0x7F,
  0x00, 0x0F, 0x03, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x78,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xF7, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x0F, 0xF8, 0x00, 0x0F, 0x0F,
  0xFF, 0x00, 0x07, 0x1F, 0x9F, 0xC0, 0x03, 0x9E, 0x03, 0xE0, 0x01, 0xCE,
  0x00, 0xF8, 0x00, 0xEE, 0x00, 0x3C, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x3F, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x07, 0x80, 0x1E, 0xC0, 0x07,
  0x80, 0x0F, 0x78, 0x0F, 0xC0, 0x07, 0x1F, 0xFF, 0xC0, 0x03, 0x87, 0xFF,
  0x80, 0x03, 0xC1, 0xFF, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xC1, 0xC0, 0x1F, 0xFF, 0x0E, 0x01, 0xFE, 0xFC, 0xF0, 0x1F,
  0x00, 0xE7, 0x01, 0xF0, 0x03, 0xB8, 0x1F, 0x00, 0x0D, 0xC0, 0xF0, 0x00,
  0x7E, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xE0,
  0x00, 0x1F, 0x07, 0x00, 0x00, 0xF8, 0x38, 0x00, 0x0F, 0xC1, 0xE0, 0x00,
  0x7E, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x77, 0x03, 0xC0, 0x07, 0xF8,
  0x0F, 0x00, 0x7B, 0xC0, 0x7C, 0x07, 0x9C, 0x01, 0xFF, 0xF8, 0xE0, 0x07,
  0xFF, 0x8F, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x01, 0xC1, 0xFC, 0x07,
  0x0F, 0xF8, 0x0E, 0x3F, 0xF0, 0x1C, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0x77,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFC,
  0x7F, 0x03, 0xE0, 0x06, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x80, 0x01,
  0xE0, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x1C, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x07, 0x80, 0x00, 0x70,
  0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x1D, 0xC0, 0xF0,
  0x03, 0x9C, 0x0F, 0x80, 0xF1, 0xC0, 0x7F, 0xFE, 0x3C, 0x03, 0xFF, 0xC3,
  0x80, 0x1F, 0xF8, 0x38, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xDC,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x38, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x03, 0xC0, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x38, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0x70,
  0xF0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x77, 0x00, 0x07, 0xE0, 0x01, 0xEE, 0x00, 0x0F,
  0xC0, 0x03, 0x9E, 0x00, 0x3B, 0x80, 0x0F, 0x3C, 0x00, 0x77, 0x00, 0x1E,
  0x78, 0x01, 0xCE, 0x00, 0x78, 0xF0, 0x03, 0x9C, 0x00, 0xF1, 0xE0, 0x0F,
  0x38, 0x03, 0xC3, 0xC0, 0x1C, 0x70, 0x07, 0x87, 0x80, 0x78, 0xE0, 0x0E,
  0x0F, 0x00, 0xE1, 0xC0, 0x3C, 0x1E, 0x03, 0xC3, 0x80, 0x70, 0x3C, 0x07,
  0x07, 0x01, 0xE0, 0x78, 0x0E, 0x0E, 0x03, 0xC0, 0xF0, 0x38, 0x1C, 0x0F,
  0x01, 0xE0, 0x70, 0x38, 0x1E, 0x03, 0xC1, 0xC0, 0x70, 0x38, 0x07, 0x83,
  0x80, 0xE0, 0xF0, 0x0F, 0x0F, 0x01, 0xC1, 0xC0, 0x1E, 0x1C, 0x03, 0x87,
  0x80, 0x3C, 0x78, 0x07, 0x0E, 0x00, 0x78, 0xE0, 0x0F, 0x3C, 0x00, 0x73,
  0xC0, 0x1E, 0x78, 0x00, 0xE7, 0x00, 0x3C, 0xE0, 0x01, 0xDE, 0x00, 0x7B,
  0xC0, 0x03, 0xB8, 0x00, 0xF7, 0x00, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x78, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0x03, 0xBC, 0x00, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0C, 0x7E, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x13, 0xFF, 0x80, 0x01, 0x7F, 0xFE, 0x00, 0x3F, 0xC7,
  0xFC, 0x0F, 0xE0, 0x0F, 0xFF, 0xE8, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0xFF,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 48, 15, 1, -47 },
  { 91, 17, 17, 22, 7, -47 },
  { 128, 36, 47, 36, 1, -47 },
  { 340, 29, 54, 32, 2, -50 },
  { 536, 38, 49, 46, 5, -48 },
  { 769, 35, 49, 37, 1, -48 },
  { 984, 7, 17, 12, 7, -47 },
  { 999, 20, 57, 17, 2, -47 },
  { 1142, 20, 57, 17, -5, -47 },
  { 1285, 25, 26, 31, 7, -50 },
  { 1367, 28, 31, 34, 4, -39 },
  { 1476, 11, 16, 14, -3, -7 },
  { 1498, 15, 4, 19, 2, -20 },
  { 1506, 6, 7, 14, 1, -6 },
  { 1512, 30, 47, 21, -3, -47 },
  { 1689, 28, 49, 32, 3, -48 },
  { 1861, 16, 47, 32, 9, -47 },
  { 1955, 32, 48, 32, -1, -48 },
  { 2147, 31, 49, 32, 0, -48 },
  { 2337, 31, 47, 32, 0, -47 },
  { 2520, 30, 48, 32, 1, -47 },
  { 2700, 29, 49, 32, 3, -48 },
  { 2878, 28, 47, 32, 5, -47 },
  { 3043, 30, 49, 32, 2, -48 },
  { 3227, 29, 49, 32, 2, -48 },
  { 3405, 12, 37, 14, 1, -36 },
  { 3461, 16, 45, 14, -3, -36 },
  { 3551, 28, 30, 34, 4, -39 },
  { 3656, 28, 17, 34, 4, -32 },
  { 3716, 28, 30, 34, 4, -39 },
  { 3821, 22, 49, 24, 4, -48 },
  { 3956, 44, 53, 48, 3, -47 },
  { 4248, 32, 47, 32, -4, -47 },
  { 4436, 32, 47, 35, 2, -47 },
  { 4624, 33, 49, 33, 4, -48 },
  { 4827, 35, 47, 39, 2, -47 },
  { 5033, 31, 47, 30, 2, -47 },
  { 5216, 31, 47, 28, 2, -47 },
  { 5399, 36, 49, 40, 4, -48 },
  { 5620, 38, 47, 40, 2, -47 },
  { 5844, 23, 47, 18, -2, -47 },
  { 5980, 26, 59, 15, -10, -47 },
  { 6172, 36, 47, 32, 2, -47 },
  { 6384, 21, 47, 28, 2, -47 },
  { 6508, 48, 47, 49, 2, -47 },
  { 6790, 39, 47, 41, 2, -47 },
  { 7020, 35, 49, 41, 4, -48 },
  { 7235, 31, 47, 33, 2, -47 },
  { 7418, 35, 59, 41, 4, -48 },
  { 7677, 31, 47, 33, 2, -47 },
  { 7860, 31, 49, 30, 0, -48 },
  { 8050, 28, 47, 28, 6, -47 },
  { 8215, 36, 48, 39, 4, -47 },
  { 8431, 31, 47, 32, 6, -47 },
  { 8614, 48, 47, 50, 7, -47 },
  { 8896, 38, 47, 29, -4, -47 },
  { 9120, 29, 47, 29, 6, -47 },
  { 9291, 34, 47, 30, -1, -47 },
  { 9491, 25, 58, 19, -1, -47 },
  { 9673, 10, 47, 22, 7, -47 },
  { 9732, 25, 58, 19, -5, -47 },
  { 9914, 29, 27, 33, 2, -47 },
  { 10012, 24, 3, 23, -6, 6 },
  { 10021, 8, 10, 16, 10, -50 },
  { 10031, 29, 37, 33, 3, -36 },
  { 10166, 30, 51, 34, 1, -50 },
  { 10358, 24, 37, 26, 3, -36 },
  { 10469, 32, 51, 34, 3, -50 },
  { 10673, 25, 37, 29, 3, -36 },
  { 10789, 34, 66, 17, -8, -50 },
  { 11070, 31, 52, 34, 1, -36 },
  { 11272, 29, 50, 33, 1, -50 },
  { 11454, 14, 48, 14, 1, -48 },
  { 11538, 24, 64, 14, -9, -48 },
  { 11730, 29, 50, 27, 1, -50 },
  { 11912, 15, 50, 14, 1, -50 },
  { 12006, 46, 36, 50, 1, -36 },
  { 12213, 29, 36, 33, 1, -36 },
  { 12344, 27, 37, 33, 3, -36 },
  { 12469, 33, 51, 34, -2, -36 },
  { 12680, 29, 52, 34, 3, -36 },
  { 12869, 23, 36, 22, 1, -36 },
  { 12973, 24, 37, 25, 0, -36 },
  { 13084, 17, 44, 18, 3, -43 },
  { 13178, 28, 36, 33, 3, -35 },
  { 13304, 26, 35, 26, 3, -35 },
  { 13418, 39, 35, 41, 4, -35 },
  { 13589, 32, 35, 27, -3, -35 },
  { 13729, 36, 51, 26, -7, -35 },
  { 13959, 26, 35, 25, -1, -35 },
  { 14073, 25, 57, 22, 1, -47 },
  { 14252, 3, 66, 31, 15, -50 },
  { 14277, 24, 57, 22, -3, -47 },
  { 14448, 28, 7, 34, 4, -27 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC66PT7B_H_
