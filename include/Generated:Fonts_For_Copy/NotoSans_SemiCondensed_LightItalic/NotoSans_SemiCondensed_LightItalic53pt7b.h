#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC53PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x70, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x38, 0x39,
  0xC3, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0x81, 0x8C, 0x1C, 0xE0,
  0xE7, 0x06, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x60, 0xC0, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00, 0x01,
  0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x06, 0x03,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8,
  0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x03,
  0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x03,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x30, 0x00, 0x06,
  0x01, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x18, 0x06,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF,
  0x01, 0xE3, 0x0E, 0x03, 0xC3, 0x02, 0x03, 0x83, 0x00, 0x07, 0x03, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x8E, 0x00, 0x03, 0xCC, 0x00, 0x01, 0xEC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x19, 0xE0, 0x00, 0x18, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x30, 0x70,
  0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x60, 0x70, 0x00, 0x60, 0xE0, 0xC0, 0x61, 0xE0, 0xF8, 0x67, 0xC0,
  0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x38, 0x0F, 0xF0, 0x00, 0xE0, 0x38, 0xF0, 0x01, 0x80,
  0xE0, 0xE0, 0x07, 0x03, 0x81, 0xC0, 0x1C, 0x07, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x00, 0xE0, 0x38, 0x06, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xC0,
  0x38, 0x1C, 0x03, 0x80, 0x70, 0x30, 0x07, 0x00, 0xE0, 0xE0, 0x0E, 0x01,
  0x83, 0x80, 0x18, 0x07, 0x06, 0x00, 0x30, 0x0E, 0x1C, 0x00, 0x60, 0x18,
  0x70, 0xF8, 0xC0, 0x30, 0xC3, 0xFD, 0x80, 0xE3, 0x8E, 0x3B, 0x01, 0x8E,
  0x38, 0x3F, 0x07, 0x18, 0xE0, 0x7E, 0x1C, 0x71, 0x80, 0xEF, 0xF1, 0xC7,
  0x01, 0xCF, 0xC3, 0x0E, 0x03, 0x80, 0x0E, 0x18, 0x07, 0x00, 0x38, 0x70,
  0x0E, 0x00, 0x60, 0xE0, 0x18, 0x01, 0xC1, 0xC0, 0x30, 0x07, 0x03, 0x00,
  0xE0, 0x0C, 0x06, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x06,
  0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x30, 0x1C, 0x01, 0xC0, 0xE0,
  0x38, 0x01, 0x81, 0x80, 0xE0, 0x03, 0x87, 0x03, 0x80, 0x07, 0xFC, 0x07,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x10, 0xF0, 0xF0,
  0x0E, 0x1E, 0x07, 0x00, 0xE3, 0xC0, 0x38, 0x1C, 0x38, 0x03, 0x81, 0xC7,
  0x00, 0x1C, 0x38, 0x70, 0x01, 0xC3, 0x8E, 0x00, 0x0E, 0x70, 0xE0, 0x00,
  0xFE, 0x0E, 0x00, 0x07, 0xE0, 0xE0, 0x00, 0x7C, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x7C, 0x07, 0x00, 0x1F, 0xC0, 0x78, 0x03, 0xCE, 0x03, 0xC0,
  0xF8, 0xF0, 0x3F, 0xFE, 0x07, 0x00, 0xFF, 0xC0, 0x78, 0x00, 0xC0, 0x00,
  0x00, 0x39, 0xCE, 0xE7, 0x39, 0xCC, 0x67, 0x31, 0x8C, 0x60, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x40, 0x30, 0x06, 0x07, 0x00,
  0xF8, 0x60, 0x07, 0xE6, 0x00, 0x0F, 0x60, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF0, 0x1E, 0x00, 0x03, 0xB0, 0x00, 0x73, 0x00, 0x1E, 0x38, 0x03, 0xC1,
  0x80, 0x78, 0x1C, 0x03, 0x00, 0xC0, 0x10, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x07,
  0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x60, 0xE0, 0xC0,
  0x7F, 0xFB, 0xFF, 0xFF, 0xFC, 0x33, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xE1, 0xE0, 0x0F, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x70, 0x03, 0x81, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xE3, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xF3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x03, 0x80, 0xF0, 0x0F,
  0x00, 0xE0, 0x3C, 0x01, 0xF0, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7B,
  0x8F, 0xB8, 0xF1, 0xDF, 0x0E, 0x60, 0x72, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0C, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x18, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x30, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x70, 0x00,
  0x03, 0xB0, 0x00, 0x03, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xC7, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0x60, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x04, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x80, 0x07, 0xC0, 0xF0, 0x1F, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x10,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x1C, 0x7F,
  0xC0, 0x73, 0xFF, 0xC0, 0xEF, 0x07, 0xC1, 0xF8, 0x07, 0x83, 0xE0, 0x07,
  0x8F, 0x80, 0x07, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x8E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0,
  0x03, 0xC0, 0xE0, 0x07, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0xF0, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0xE0, 0x0E, 0x01, 0xC0,
  0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0x7B,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xC3,
  0xC0, 0x0F, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0x70, 0x38, 0x00,
  0x78, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0x70, 0x00,
  0x70, 0x78, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x07, 0xC3, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xE0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE7, 0x00, 0x03, 0x8E,
  0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x70,
  0x01, 0xF0, 0xF0, 0x06, 0xC0, 0xF0, 0x3B, 0x81, 0xFF, 0xE7, 0x00, 0xFF,
  0x8E, 0x00, 0x78, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x04,
  0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x01, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x78, 0x3C, 0x1E, 0x0F, 0x00, 0x00, 0x20, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07,
  0xFC, 0x0F, 0xFF, 0x81, 0xF1, 0xF0, 0x60, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x00, 0x60, 0xE0, 0x07, 0xFC, 0x06, 0x0E, 0x00, 0xFF, 0xE0, 0x71,
  0xC0, 0x3C, 0x0C, 0x07, 0x1C, 0x07, 0x80, 0xC0, 0x73, 0x80, 0x70, 0x1C,
  0x07, 0x38, 0x0E, 0x01, 0xC0, 0x73, 0x01, 0xC0, 0x18, 0x07, 0x70, 0x18,
  0x01, 0x80, 0x67, 0x03, 0x80, 0x38, 0x06, 0x70, 0x38, 0x03, 0x80, 0xE6,
  0x03, 0x00, 0x30, 0x0E, 0x60, 0x70, 0x07, 0x00, 0xCE, 0x07, 0x00, 0x70,
  0x0C, 0xE0, 0x70, 0x07, 0x01, 0xCE, 0x07, 0x00, 0xE0, 0x18, 0xE0, 0x70,
  0x0E, 0x03, 0x8E, 0x07, 0x01, 0xE0, 0x30, 0xE0, 0x70, 0x37, 0x07, 0x0E,
  0x03, 0x87, 0x31, 0xE0, 0x60, 0x1F, 0xE3, 0xFC, 0x06, 0x00, 0xF8, 0x1F,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE1, 0x80,
  0x00, 0x38, 0x60, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C,
  0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x07,
  0x70, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03,
  0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x0E,
  0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x70, 0x1F, 0xC0,
  0x1C, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x78, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x18, 0x00, 0x3C, 0x0E, 0x00, 0x3E,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x1F, 0x00, 0x3E, 0x00,
  0x60, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x40, 0x07, 0xE0, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1C, 0x01,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x1E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x38,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0x38, 0x38, 0x00, 0x07, 0x83, 0x80, 0x00,
  0x70, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x07,
  0x00, 0x07, 0xC0, 0x70, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x00, 0xE0, 0x0F,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x10, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xF0, 0xFE, 0x00,
  0xF8, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xFF,
  0x87, 0x00, 0x1F, 0xFC, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x70, 0x07, 0xC0, 0x03, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00,
  0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xC0,
  0x7F, 0xF0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x08, 0x3C, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E,
  0x01, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70,
  0x00, 0x38, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xDD, 0xC0, 0x00, 0x1F, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0,
  0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xB0,
  0x00, 0x01, 0xF8, 0x0E, 0xC0, 0x00, 0x0E, 0xE0, 0x3B, 0x00, 0x00, 0x3B,
  0x80, 0xEE, 0x00, 0x01, 0xDC, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x0C, 0xE0,
  0x00, 0x39, 0xC0, 0x73, 0x80, 0x00, 0xE7, 0x01, 0xCE, 0x00, 0x07, 0x1C,
  0x07, 0x38, 0x00, 0x1C, 0xE0, 0x1C, 0x60, 0x00, 0xE3, 0x80, 0xE1, 0x80,
  0x03, 0x8E, 0x03, 0x86, 0x00, 0x1C, 0x38, 0x0E, 0x1C, 0x00, 0x70, 0xE0,
  0x38, 0x70, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x07, 0x07, 0x00,
  0x70, 0x70, 0x1C, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x0E, 0x0E, 0x01,
  0xC0, 0xC0, 0x70, 0x38, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x0C, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x38, 0x0E, 0x03, 0x80, 0xE1, 0xC0, 0x70, 0x0E,
  0x03, 0x87, 0x01, 0xC0, 0x30, 0x0E, 0x38, 0x07, 0x01, 0xC0, 0x38, 0xE0,
  0x1C, 0x07, 0x00, 0xE7, 0x00, 0x70, 0x1C, 0x01, 0x9C, 0x03, 0x80, 0x70,
  0x06, 0xE0, 0x0E, 0x03, 0x80, 0x1F, 0x00, 0x38, 0x0E, 0x00, 0x7C, 0x00,
  0xE0, 0x38, 0x01, 0xE0, 0x03, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0x38, 0x0F, 0x80, 0x00, 0xE0, 0x1F, 0x00, 0x01, 0xC0,
  0x7E, 0x00, 0x03, 0x80, 0xEE, 0x00, 0x07, 0x01, 0xDC, 0x00, 0x0C, 0x03,
  0xB8, 0x00, 0x38, 0x06, 0x38, 0x00, 0x70, 0x1C, 0x70, 0x00, 0xE0, 0x38,
  0xE0, 0x01, 0xC0, 0x70, 0xE0, 0x07, 0x00, 0xE1, 0xC0, 0x0E, 0x03, 0x83,
  0x80, 0x1C, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x07, 0x00, 0x70, 0x1C, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x03, 0x80, 0x38, 0x18, 0x07, 0x00, 0x70, 0x70, 0x0C, 0x00, 0xE0,
  0xE0, 0x38, 0x00, 0xE1, 0xC0, 0x70, 0x01, 0xC3, 0x80, 0xE0, 0x03, 0x86,
  0x01, 0xC0, 0x07, 0x1C, 0x03, 0x00, 0x07, 0x38, 0x0E, 0x00, 0x0E, 0x70,
  0x1C, 0x00, 0x1C, 0xE0, 0x38, 0x00, 0x1D, 0x80, 0x70, 0x00, 0x3F, 0x01,
  0xC0, 0x00, 0x7E, 0x03, 0x80, 0x00, 0x7C, 0x07, 0x00, 0x00, 0xF8, 0x0E,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1E,
  0x38, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C,
  0x0F, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x38, 0x07, 0xC0, 0x1C, 0x00, 0xF0, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x81, 0xC0,
  0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x1E, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x7E, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x70, 0x70, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x73, 0x80, 0x00, 0x03, 0x9C, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x38, 0x07, 0xC0, 0x1C, 0x00, 0xF0,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07,
  0x81, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x3E, 0x03, 0x80, 0x7E, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38,
  0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80,
  0x70, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1E,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x3F, 0x87, 0xC0, 0x3E, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x30, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0B, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0E,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8, 0x00,
  0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0x70, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x01, 0x80, 0xE0,
  0x00, 0xC0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x03, 0xB0, 0x00, 0x3E, 0x00, 0x0E, 0xC0, 0x00,
  0xF8, 0x00, 0x7B, 0x80, 0x07, 0xE0, 0x01, 0xCE, 0x00, 0x1B, 0x80, 0x07,
  0x38, 0x00, 0xEE, 0x00, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0xE3, 0x80, 0x1C,
  0xE0, 0x07, 0x0E, 0x00, 0x73, 0x80, 0x1C, 0x38, 0x01, 0x8E, 0x00, 0xE0,
  0xE0, 0x0E, 0x38, 0x03, 0x83, 0x80, 0x30, 0xE0, 0x0E, 0x0E, 0x01, 0xC3,
  0x80, 0x70, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0xE0, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x0E,
  0x07, 0x00, 0xE0, 0x60, 0x38, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x0E,
  0x0C, 0x03, 0x83, 0x80, 0x38, 0x70, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x38,
  0x70, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x39,
  0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x00, 0x19, 0xC0, 0x03, 0x98, 0x00, 0x67,
  0x00, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x3B, 0x00, 0x06, 0xE0, 0x00, 0xFC,
  0x00, 0x1B, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x00,
  0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00,
  0x70, 0xF0, 0x00, 0x00, 0x61, 0xC0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x70, 0x01, 0xC0, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0xE7, 0x00, 0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x83, 0x80,
  0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x18, 0xE0, 0x00,
  0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xE0, 0x30, 0x18, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x0E, 0x07, 0x01,
  0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x38,
  0x1C, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB0, 0x00, 0x0E,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x70, 0xC0, 0x00, 0xC1, 0xC0, 0x03, 0x81,
  0x80, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x03, 0x80, 0x1C, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x30,
  0xE0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xDC, 0x00, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC3, 0xC3, 0x83, 0x87, 0x07, 0x06,
  0x06, 0x00, 0x0E, 0x01, 0x00, 0x7F, 0x86, 0x01, 0xFF, 0xC6, 0x03, 0xE0,
  0xEE, 0x07, 0x80, 0x6E, 0x0F, 0x00, 0x3E, 0x0E, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xE0, 0xF0, 0x03,
  0xE0, 0x70, 0x06, 0xC0, 0x78, 0x0C, 0xC0, 0x3C, 0x38, 0xC0, 0x3F, 0xF1,
  0xC0, 0x1F, 0xE1, 0xC0, 0x01, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x81, 0xC0, 0x03, 0x8F, 0xF8, 0x03, 0x9F,
  0xFC, 0x07, 0x38, 0x3C, 0x07, 0x70, 0x1E, 0x07, 0xE0, 0x0E, 0x07, 0xC0,
  0x0E, 0x07, 0x80, 0x07, 0x0F, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00,
  0x78, 0x7C, 0x00, 0x70, 0x7C, 0x00, 0xE0, 0x6E, 0x01, 0xE0, 0x67, 0x07,
  0xC0, 0xE3, 0xFF, 0x00, 0xE1, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0x02, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x10, 0x3E, 0x06, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x7F, 0x87, 0x00, 0x7F, 0xF1, 0x80, 0x3E,
  0x0E, 0xE0, 0x1E, 0x01, 0xF8, 0x0F, 0x00, 0x3E, 0x03, 0x80, 0x0F, 0x81,
  0xE0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x01, 0xE0,
  0x38, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x01, 0xC0, 0x1B, 0x80, 0x78, 0x0E,
  0xE0, 0x0F, 0x0F, 0x30, 0x03, 0xFF, 0x8C, 0x00, 0x7F, 0x87, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3E,
  0x0F, 0x07, 0x80, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C,
  0x00, 0x73, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x0F, 0x87,
  0x3F, 0xF0, 0x7F, 0xFC, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x10, 0x3E, 0x07, 0x01, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0x82, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x70, 0x07, 0xFF,
  0x18, 0x03, 0xE0, 0xE6, 0x01, 0xE0, 0x1F, 0x80, 0xF0, 0x03, 0xE0, 0x38,
  0x00, 0xF8, 0x1E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E,
  0x00, 0x1E, 0x03, 0x80, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x1C, 0x01, 0xB8,
  0x07, 0x80, 0xEE, 0x00, 0xF0, 0xF3, 0x00, 0x3F, 0xF9, 0xC0, 0x07, 0xF8,
  0x70, 0x00, 0x10, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x20, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x38, 0xFF, 0x80, 0x73, 0xFF,
  0x81, 0xCE, 0x0F, 0x03, 0xB8, 0x0F, 0x07, 0xC0, 0x0E, 0x0F, 0x80, 0x1C,
  0x1E, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xC0, 0x01, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x70, 0x00, 0x40, 0x1C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07,
  0x01, 0xE0, 0x0E, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x00, 0xE1,
  0xE0, 0x01, 0xC3, 0x80, 0x03, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x1C, 0xF0,
  0x00, 0x3B, 0xF0, 0x00, 0x7E, 0xE0, 0x00, 0xF9, 0xC0, 0x03, 0xE1, 0xC0,
  0x07, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x38, 0x0C,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x18, 0x7F, 0x81, 0xFF, 0x00, 0xC7, 0xFE, 0x1F, 0xF8, 0x0E, 0x70,
  0x71, 0xC1, 0xE0, 0x76, 0x03, 0xDC, 0x07, 0x03, 0xE0, 0x0F, 0xC0, 0x3C,
  0x1E, 0x00, 0x7C, 0x00, 0xE0, 0xF0, 0x03, 0xC0, 0x07, 0x0F, 0x00, 0x1E,
  0x00, 0x70, 0x78, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x70, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x06, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x00, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x00, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x00,
  0xE1, 0xC0, 0x03, 0x80, 0x06, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xE0, 0x06, 0x1F, 0xF0, 0x0C, 0x7F, 0xF0, 0x39, 0xC1, 0xE0, 0x77,
  0x01, 0xE0, 0xFC, 0x01, 0xC1, 0xF0, 0x03, 0x83, 0xC0, 0x07, 0x0F, 0x00,
  0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE1, 0xE0, 0x01,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xE0,
  0x01, 0xC1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF8, 0x3C, 0x07, 0x80,
  0x78, 0x3C, 0x00, 0xE0, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0xDE, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCF,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0xE0,
  0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x00, 0x0C,
  0x3F, 0xE0, 0x01, 0x8F, 0xFE, 0x00, 0x73, 0x83, 0xC0, 0x0E, 0xE0, 0x3C,
  0x01, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0x70, 0x07, 0x80, 0x07, 0x01, 0xF0,
  0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x03,
  0xC0, 0x7C, 0x00, 0x70, 0x0F, 0x80, 0x1C, 0x01, 0xF8, 0x07, 0x80, 0x33,
  0x83, 0xE0, 0x0E, 0x3F, 0xF0, 0x01, 0xC3, 0xFC, 0x00, 0x38, 0x0C, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0x87, 0x01, 0xFF, 0xC6, 0x03,
  0xE0, 0xE6, 0x07, 0x80, 0x7E, 0x0F, 0x00, 0x3E, 0x0E, 0x00, 0x3E, 0x1E,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xE0, 0xF0,
  0x03, 0xE0, 0x70, 0x06, 0xE0, 0x78, 0x0E, 0xE0, 0x3C, 0x3C, 0xC0, 0x3F,
  0xF9, 0xC0, 0x1F, 0xE1, 0xC0, 0x01, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x61,
  0xF8, 0x0C, 0x7F, 0x03, 0x9E, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0xF0, 0x78, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x08, 0x00, 0xE0, 0xF0, 0x3E,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x20, 0x00, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x1F, 0xFF, 0x7F, 0xFC,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x81, 0xFE, 0x03, 0xF8, 0x01, 0x00, 0x07,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x60, 0xE0,
  0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x7C, 0x38, 0x00, 0xF0, 0x78, 0x03, 0x60, 0x70, 0x0D, 0xC0, 0xF0,
  0x73, 0x80, 0xFF, 0xC7, 0x00, 0xFF, 0x0C, 0x00, 0x30, 0x00, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0xE0,
  0x70, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x38,
  0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x1C,
  0x00, 0x31, 0xC0, 0x03, 0x38, 0x00, 0x33, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0xC0, 0x0E, 0xE0, 0x07, 0xC0,
  0x1C, 0xE0, 0x0F, 0xC0, 0x1C, 0xE0, 0x0D, 0xC0, 0x38, 0xE0, 0x1D, 0xC0,
  0x38, 0xE0, 0x1D, 0xC0, 0x70, 0xE0, 0x39, 0xC0, 0x70, 0xE0, 0x39, 0xC0,
  0x70, 0xE0, 0x31, 0xC0, 0xE0, 0xE0, 0x71, 0xC0, 0xE0, 0xE0, 0x61, 0xC1,
  0xC0, 0xE0, 0xE0, 0xC1, 0xC0, 0xE0, 0xC0, 0xC3, 0x80, 0x61, 0xC0, 0xC3,
  0x80, 0x61, 0x80, 0xC3, 0x00, 0x63, 0x80, 0xC7, 0x00, 0x63, 0x80, 0xC7,
  0x00, 0x67, 0x00, 0xCE, 0x00, 0x67, 0x00, 0xCE, 0x00, 0x6E, 0x00, 0xCC,
  0x00, 0x6E, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0xC1, 0xC0, 0x00,
  0xE1, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x77, 0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x3C, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01,
  0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x78, 0x00, 0x38,
  0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0C, 0x0E, 0x00, 0x00, 0x60, 0x70, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07,
  0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x60,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xC0, 0x05, 0xFF,
  0xE0, 0x1F, 0x03, 0xF9, 0xFC, 0x01, 0xFF, 0xD0, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 38, 12, 1, -38 },
  { 58, 13, 14, 18, 6, -38 },
  { 81, 29, 38, 29, 1, -38 },
  { 219, 24, 43, 26, 1, -40 },
  { 348, 31, 39, 37, 4, -38 },
  { 500, 28, 39, 30, 1, -38 },
  { 637, 5, 14, 10, 6, -38 },
  { 646, 15, 46, 14, 2, -38 },
  { 733, 16, 46, 14, -4, -38 },
  { 825, 20, 20, 25, 6, -40 },
  { 875, 23, 25, 27, 3, -31 },
  { 947, 8, 13, 11, -2, -6 },
  { 960, 13, 3, 16, 1, -16 },
  { 965, 5, 5, 11, 1, -5 },
  { 969, 23, 38, 17, -2, -38 },
  { 1079, 23, 39, 26, 2, -38 },
  { 1192, 13, 38, 26, 7, -38 },
  { 1254, 25, 38, 26, 0, -38 },
  { 1373, 25, 39, 26, 0, -38 },
  { 1495, 25, 38, 26, 0, -38 },
  { 1614, 24, 39, 26, 1, -38 },
  { 1731, 23, 39, 26, 3, -38 },
  { 1844, 23, 38, 26, 4, -38 },
  { 1954, 24, 39, 26, 1, -38 },
  { 2071, 23, 39, 26, 2, -38 },
  { 2184, 9, 29, 11, 1, -29 },
  { 2217, 12, 36, 11, -2, -29 },
  { 2271, 23, 24, 27, 3, -31 },
  { 2340, 23, 13, 27, 3, -25 },
  { 2378, 23, 24, 27, 3, -31 },
  { 2447, 18, 38, 19, 3, -38 },
  { 2533, 36, 43, 39, 2, -38 },
  { 2727, 26, 38, 26, -3, -38 },
  { 2851, 26, 38, 28, 2, -38 },
  { 2975, 27, 39, 27, 3, -38 },
  { 3107, 28, 38, 31, 2, -38 },
  { 3240, 24, 38, 24, 2, -38 },
  { 3354, 24, 38, 23, 2, -38 },
  { 3468, 29, 39, 32, 3, -38 },
  { 3610, 30, 38, 32, 2, -38 },
  { 3753, 18, 38, 14, -1, -38 },
  { 3839, 21, 48, 12, -8, -38 },
  { 3965, 28, 38, 26, 2, -38 },
  { 4098, 17, 38, 22, 2, -38 },
  { 4179, 38, 38, 40, 2, -38 },
  { 4360, 31, 38, 33, 2, -38 },
  { 4508, 29, 39, 33, 3, -38 },
  { 4650, 25, 38, 26, 2, -38 },
  { 4769, 29, 47, 33, 3, -38 },
  { 4940, 25, 38, 27, 2, -38 },
  { 5059, 25, 39, 24, 0, -38 },
  { 5181, 22, 38, 23, 5, -38 },
  { 5286, 29, 39, 32, 3, -38 },
  { 5428, 25, 38, 26, 5, -38 },
  { 5547, 38, 38, 40, 6, -38 },
  { 5728, 31, 38, 24, -3, -38 },
  { 5876, 23, 38, 23, 5, -38 },
  { 5986, 28, 38, 24, -1, -38 },
  { 6119, 20, 46, 15, -1, -38 },
  { 6234, 9, 38, 17, 5, -38 },
  { 6277, 20, 46, 15, -4, -38 },
  { 6392, 23, 22, 27, 2, -38 },
  { 6456, 19, 2, 18, -5, 5 },
  { 6461, 7, 9, 13, 8, -41 },
  { 6469, 24, 30, 27, 2, -29 },
  { 6559, 24, 41, 27, 1, -40 },
  { 6682, 20, 30, 21, 2, -29 },
  { 6757, 26, 41, 27, 2, -40 },
  { 6891, 20, 30, 23, 2, -29 },
  { 6966, 28, 54, 14, -7, -41 },
  { 7155, 26, 42, 27, 0, -29 },
  { 7292, 23, 40, 26, 1, -40 },
  { 7407, 11, 39, 11, 1, -39 },
  { 7461, 19, 52, 11, -7, -39 },
  { 7585, 23, 40, 22, 1, -40 },
  { 7700, 12, 40, 11, 1, -40 },
  { 7760, 37, 29, 40, 1, -29 },
  { 7895, 23, 29, 26, 1, -29 },
  { 7979, 22, 29, 26, 2, -29 },
  { 8059, 27, 41, 27, -2, -29 },
  { 8198, 24, 42, 27, 2, -29 },
  { 8324, 19, 29, 18, 1, -29 },
  { 8393, 20, 30, 20, 0, -29 },
  { 8468, 14, 36, 15, 2, -35 },
  { 8531, 23, 29, 27, 2, -28 },
  { 8615, 20, 28, 21, 3, -28 },
  { 8685, 32, 28, 33, 3, -28 },
  { 8797, 25, 28, 22, -2, -28 },
  { 8885, 29, 41, 21, -6, -28 },
  { 9034, 21, 28, 20, -1, -28 },
  { 9108, 20, 46, 18, 1, -38 },
  { 9223, 3, 53, 25, 12, -40 },
  { 9243, 19, 46, 18, -3, -38 },
  { 9353, 23, 6, 27, 3, -22 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC53PT7B_H_
