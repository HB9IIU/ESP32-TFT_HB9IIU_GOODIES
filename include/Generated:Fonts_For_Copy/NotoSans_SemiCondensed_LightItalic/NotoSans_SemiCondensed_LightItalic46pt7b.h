#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x66, 0x1D, 0xC3, 0xB8,
  0x77, 0x0C, 0xC1, 0x98, 0x33, 0x0E, 0xC1, 0x98, 0x33, 0x06, 0x60, 0x80,
  0x00, 0x0C, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03,
  0x00, 0x03, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0x60,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x30, 0x18, 0x07, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE0, 0x0C, 0x06, 0x00, 0x06, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03,
  0x01, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00,
  0x60, 0x30, 0x00, 0x30, 0x30, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0,
  0x0C, 0x0E, 0x00, 0x06, 0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x81, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60,
  0x00, 0x70, 0x30, 0x00, 0x30, 0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFC,
  0x0F, 0xB3, 0xC0, 0xF1, 0x82, 0x07, 0x0C, 0x00, 0x70, 0x60, 0x03, 0x82,
  0x00, 0x1C, 0x30, 0x00, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x18, 0x40, 0x00,
  0xE6, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x06, 0xF0, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x30, 0x00,
  0x41, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x87, 0x00, 0x0C, 0x38,
  0x60, 0xC3, 0x83, 0xF7, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x07, 0xE0, 0x01, 0xC1, 0xFE, 0x00, 0x70, 0x70, 0xC0, 0x0C, 0x0C, 0x1C,
  0x03, 0x03, 0x83, 0x80, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03,
  0x01, 0xC1, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x06, 0x0E, 0x01, 0x80, 0xC1,
  0x80, 0x70, 0x18, 0x60, 0x0C, 0x07, 0x1C, 0x01, 0x80, 0xC3, 0x1F, 0x30,
  0x18, 0xC7, 0xF6, 0x07, 0x39, 0xC7, 0xE0, 0xC6, 0x70, 0x6C, 0x31, 0x8C,
  0x0D, 0xFE, 0x73, 0x81, 0x9F, 0x0C, 0x60, 0x30, 0x03, 0x0C, 0x06, 0x00,
  0xE3, 0x80, 0xC0, 0x18, 0x70, 0x18, 0x06, 0x0C, 0x07, 0x01, 0xC1, 0x80,
  0xC0, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x80, 0xC0, 0xC0, 0x60,
  0x18, 0x18, 0x18, 0x03, 0x07, 0x07, 0x00, 0x71, 0xC0, 0xC0, 0x0F, 0xF0,
  0x30, 0x00, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0x60, 0x01, 0xC0, 0x70, 0x01, 0x80,
  0x70, 0x01, 0x80, 0x70, 0x03, 0x80, 0x60, 0x03, 0x80, 0xE0, 0x01, 0x80,
  0xE0, 0x01, 0x81, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC7, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x38,
  0x00, 0x1E, 0x18, 0x07, 0x1C, 0x1C, 0x06, 0x38, 0x0E, 0x0E, 0x70, 0x0E,
  0x0C, 0x60, 0x07, 0x1C, 0xE0, 0x07, 0x38, 0xE0, 0x03, 0xB0, 0xE0, 0x03,
  0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xE0, 0x70, 0x07,
  0x70, 0x78, 0x1E, 0x70, 0x3F, 0xFC, 0x38, 0x1F, 0xF0, 0x3C, 0x39, 0x9C,
  0xE7, 0x31, 0x8C, 0xE6, 0x31, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x04, 0x0C, 0x03, 0x86, 0x03, 0xE3, 0x00,
  0x3D, 0x83, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0xCC, 0x00, 0xC6,
  0x01, 0xE3, 0x81, 0xE0, 0xC0, 0x60, 0x70, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0xC7, 0x0E, 0x18,
  0x60, 0xC3, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xE1, 0xC0, 0x38, 0x0E, 0x07,
  0x00, 0xE0, 0x60, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x1C, 0x00, 0x71,
  0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x67, 0x00, 0x06,
  0x70, 0x00, 0x67, 0x00, 0x0E, 0x60, 0x00, 0xE6, 0x00, 0x0E, 0x60, 0x00,
  0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x60,
  0x0E, 0x07, 0x01, 0xC0, 0x38, 0x38, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x70, 0x1E, 0x03, 0xE0, 0x76, 0x1E, 0xE3, 0xCE, 0xF0, 0xC6, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x38, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0xF8, 0x3C, 0x03, 0x00,
  0x70, 0x10, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x3E,
  0x07, 0x00, 0xE0, 0x0E, 0x02, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x82, 0x00, 0x1E, 0x0E, 0x01, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1B, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0xC0, 0x01, 0xCE, 0x00, 0x0C, 0x70,
  0x00, 0xC3, 0x00, 0x0E, 0x18, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x60,
  0x60, 0x07, 0x03, 0x00, 0x70, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03,
  0x00, 0x60, 0x38, 0x03, 0x03, 0x80, 0x18, 0x18, 0x01, 0xC1, 0x80, 0x0E,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x40, 0x07, 0x83, 0x00, 0xF8,
  0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00,
  0x78, 0x10, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x9F, 0xE0, 0x33, 0xFF, 0x07, 0x70, 0x78, 0x7C, 0x03,
  0x87, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x18, 0xE0,
  0x03, 0x86, 0x00, 0x30, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x78, 0x3C,
  0x07, 0x00, 0xE0, 0x30, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0x81, 0xC0, 0x1C, 0x06, 0x01, 0xC0,
  0x38, 0x1C, 0x00, 0xE1, 0xC0, 0x03, 0xBC, 0x00, 0x0F, 0x80, 0x01, 0xFC,
  0x00, 0x3C, 0x70, 0x03, 0x81, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x18, 0x38,
  0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC7, 0x00, 0x06,
  0x38, 0x00, 0x71, 0xC0, 0x03, 0x86, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0,
  0x3C, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x01, 0xC1, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x30, 0xC0, 0x03, 0x1C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x31, 0x80,
  0x03, 0x18, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00, 0xF1, 0xC0, 0x0F, 0x1C,
  0x01, 0xE0, 0xE0, 0x76, 0x0F, 0xFE, 0xE0, 0x3F, 0xCE, 0x00, 0x40, 0xC0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x80, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x0F, 0x0F, 0x0E, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xE0, 0x00, 0x40, 0x3C, 0x07, 0x80,
  0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x1C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0xF0, 0xE0, 0xF1, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x03, 0x00, 0x38, 0x00, 0x03,
  0x00, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x06, 0x0E, 0x00, 0x00, 0x0C,
  0x18, 0x01, 0xE0, 0x18, 0x70, 0x0F, 0xF8, 0x38, 0xC0, 0x78, 0x70, 0x73,
  0x81, 0xC0, 0xC0, 0x66, 0x03, 0x01, 0x80, 0xDC, 0x0C, 0x03, 0x03, 0xB0,
  0x38, 0x0E, 0x07, 0x60, 0x60, 0x18, 0x0C, 0xC0, 0xC0, 0x30, 0x1B, 0x83,
  0x00, 0x60, 0x37, 0x06, 0x01, 0xC0, 0xEC, 0x0C, 0x03, 0x01, 0x98, 0x18,
  0x06, 0x03, 0x30, 0x30, 0x1C, 0x0E, 0x60, 0x60, 0x38, 0x18, 0xC0, 0xC0,
  0xF0, 0x61, 0x81, 0xC3, 0x71, 0xC3, 0x01, 0xFC, 0x7F, 0x07, 0x01, 0xE0,
  0x78, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3E, 0x01, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x9C,
  0x00, 0x06, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0xC0,
  0x01, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x38, 0x0C, 0x00,
  0x60, 0x18, 0x01, 0xC0, 0x30, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x06, 0x00,
  0x1C, 0x1C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xE0, 0x00, 0x61, 0x80, 0x00,
  0xC7, 0x00, 0x01, 0x8C, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x0E,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x06, 0x07, 0xE0, 0x0C, 0x01, 0xE0,
  0x38, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x07, 0x03,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x30, 0x30, 0x00, 0xE0, 0x60,
  0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x18, 0x03, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03,
  0x03, 0x00, 0x06, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30,
  0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0E,
  0x00, 0x78, 0x18, 0x07, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0x70, 0x0F, 0x00, 0x20, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x40, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x60, 0xFE, 0x00, 0x30, 0x07, 0x80, 0x38,
  0x01, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x0E, 0x03,
  0x00, 0x03, 0x03, 0x80, 0x01, 0x81, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x06,
  0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0xE0, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x70, 0x00,
  0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0C, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x3C, 0x01, 0x81, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x00, 0x20, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x07,
  0xFC, 0x70, 0x03, 0xFE, 0x38, 0x01, 0xFF, 0x1C, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0xC3, 0x80, 0x00, 0x61, 0xC0, 0x00, 0x70, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x07,
  0x80, 0x07, 0x01, 0xE0, 0x03, 0x80, 0x78, 0x03, 0x80, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x06,
  0x00, 0x03, 0x00, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0C, 0x03, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x00, 0x01, 0x80, 0x60, 0x00, 0x30,
  0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0C,
  0x03, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x78, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x60, 0x03, 0x80, 0x30, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x06, 0x03, 0x80,
  0x03, 0x03, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC3, 0xC0, 0x00, 0xC3, 0xC0,
  0x00, 0x63, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1D, 0xE0,
  0x00, 0x0D, 0xF8, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x86, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x0C, 0x01, 0x80, 0x07, 0x00,
  0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x06, 0xE0, 0x37,
  0x00, 0x03, 0xB0, 0x0D, 0xC0, 0x00, 0xCC, 0x03, 0x70, 0x00, 0x77, 0x01,
  0xCC, 0x00, 0x19, 0xC0, 0x73, 0x00, 0x0E, 0x70, 0x18, 0xC0, 0x03, 0x18,
  0x06, 0x30, 0x01, 0xCE, 0x03, 0x8C, 0x00, 0x63, 0x80, 0xE3, 0x80, 0x38,
  0xE0, 0x38, 0xE0, 0x1C, 0x30, 0x0C, 0x38, 0x07, 0x0C, 0x03, 0x06, 0x03,
  0x87, 0x01, 0xC1, 0x80, 0xC1, 0xC0, 0x70, 0x60, 0x70, 0x70, 0x18, 0x18,
  0x18, 0x18, 0x06, 0x06, 0x0E, 0x06, 0x01, 0x81, 0x83, 0x03, 0x80, 0xE0,
  0x71, 0xC0, 0xE0, 0x38, 0x1C, 0x60, 0x38, 0x0C, 0x07, 0x38, 0x0C, 0x03,
  0x00, 0xCC, 0x03, 0x01, 0xC0, 0x37, 0x01, 0xC0, 0x70, 0x0D, 0x80, 0x70,
  0x1C, 0x03, 0xE0, 0x18, 0x06, 0x00, 0xF0, 0x06, 0x01, 0x80, 0x38, 0x03,
  0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x06, 0x01, 0xE0, 0x00, 0x60, 0x1E, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0xE0,
  0x37, 0x00, 0x0E, 0x03, 0x70, 0x00, 0xC0, 0x33, 0x00, 0x0C, 0x03, 0x38,
  0x01, 0xC0, 0x73, 0x80, 0x1C, 0x07, 0x18, 0x01, 0x80, 0x61, 0xC0, 0x18,
  0x06, 0x1C, 0x03, 0x80, 0xE0, 0xC0, 0x38, 0x0E, 0x0E, 0x03, 0x80, 0xE0,
  0xE0, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x70, 0x1C, 0x07, 0x07,
  0x01, 0xC0, 0x30, 0x70, 0x18, 0x03, 0x86, 0x01, 0x80, 0x38, 0x60, 0x18,
  0x01, 0x8E, 0x03, 0x80, 0x18, 0xE0, 0x38, 0x01, 0xCC, 0x03, 0x00, 0x0C,
  0xC0, 0x30, 0x00, 0xCC, 0x07, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0x7C, 0x07,
  0x00, 0x07, 0x80, 0x60, 0x00, 0x78, 0x06, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00,
  0xE6, 0x00, 0x00, 0x77, 0x00, 0x00, 0x33, 0x80, 0x00, 0x19, 0x80, 0x00,
  0x0D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80,
  0x00, 0x31, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x0E, 0x00,
  0xF8, 0x1E, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x18, 0x7F, 0x00, 0x60, 0x1E, 0x03, 0x80, 0x38,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x18, 0x38, 0x00,
  0xE0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x0C, 0x03, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x7C, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x78, 0x00, 0xE0, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x1C, 0x00, 0x01,
  0x8E, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x77, 0x00, 0x00, 0x33, 0x80, 0x00,
  0x19, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00,
  0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xCE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x0E, 0x00, 0xF8, 0x1E, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x18, 0x7F, 0x00, 0x60,
  0x1E, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xC0, 0x07,
  0x03, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0x80, 0x07, 0x06,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x78, 0x0C, 0x0F,
  0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0E, 0x00,
  0x60, 0x38, 0x01, 0x80, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x06,
  0x06, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xE0, 0x01, 0xC0, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x02, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x82, 0x00, 0x1C, 0x0E, 0x01, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x03, 0x83, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0xE1, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x60, 0x00, 0x38, 0x30, 0x00,
  0x1C, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x0E, 0x00, 0x07, 0x06, 0x00,
  0x03, 0x83, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xE0,
  0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x1C,
  0x00, 0x06, 0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x87, 0x00, 0x01, 0x83,
  0x80, 0x00, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x30,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x1C,
  0x01, 0xF0, 0x3C, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xE6, 0x00, 0x03, 0x98, 0x00, 0x1C, 0x60, 0x00,
  0x71, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x30, 0x60, 0x01, 0xC1,
  0xC0, 0x06, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xC0, 0x70, 0x07, 0x01, 0xC0,
  0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x60,
  0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0x80, 0x03,
  0x0E, 0x00, 0x0E, 0x30, 0x00, 0x39, 0xC0, 0x00, 0xE6, 0x00, 0x03, 0xB8,
  0x00, 0x0E, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0xEC, 0x00, 0x3C, 0x00, 0x3B, 0x00, 0x0F, 0x00, 0x1C, 0xC0,
  0x03, 0xC0, 0x07, 0x30, 0x01, 0xB0, 0x01, 0x8C, 0x00, 0x6C, 0x00, 0xE3,
  0x00, 0x3B, 0x00, 0x30, 0xC0, 0x0C, 0xC0, 0x1C, 0x30, 0x07, 0x30, 0x06,
  0x0C, 0x01, 0x8C, 0x03, 0x83, 0x80, 0xE3, 0x00, 0xE0, 0xE0, 0x30, 0xC0,
  0x30, 0x38, 0x0C, 0x30, 0x1C, 0x0E, 0x06, 0x0C, 0x06, 0x03, 0x81, 0x83,
  0x03, 0x80, 0xE0, 0xE0, 0xC0, 0xC0, 0x38, 0x30, 0x30, 0x70, 0x0E, 0x1C,
  0x0C, 0x1C, 0x03, 0x86, 0x03, 0x06, 0x00, 0xE3, 0x80, 0xC3, 0x80, 0x38,
  0xC0, 0x30, 0xC0, 0x0E, 0x70, 0x0E, 0x70, 0x03, 0x9C, 0x03, 0x98, 0x00,
  0xE6, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x3B, 0x80, 0x0E, 0xC0, 0x0E, 0xC0,
  0x03, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x0C, 0x00, 0x38, 0x01, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x00, 0x60, 0x1C, 0x00,
  0x0E, 0x03, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x06,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x06, 0x70, 0x00, 0x00, 0xDC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07,
  0x38, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x00,
  0x70, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03,
  0x80, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x0E,
  0x60, 0x00, 0xE6, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x07,
  0x03, 0x00, 0x60, 0x30, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x18, 0x01, 0x83,
  0x80, 0x18, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x01, 0xCC, 0x00, 0x0D,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x07, 0xF8,
  0x03, 0xFE, 0x00, 0xC1, 0x83, 0x07, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0xC3, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x70, 0x60, 0xC1, 0x83, 0x07, 0x0E,
  0x1C, 0x18, 0x30, 0x60, 0xC1, 0xC3, 0x83, 0x06, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0,
  0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x07, 0x00, 0x70, 0x30, 0x06, 0x03,
  0x00, 0xC0, 0x38, 0x1C, 0x01, 0x81, 0x80, 0x1C, 0x38, 0x00, 0xC3, 0x00,
  0x0C, 0x70, 0x00, 0xE6, 0x00, 0x06, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0x87, 0x0C, 0x38, 0x60, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xE3,
  0x07, 0xCF, 0x30, 0xF0, 0x37, 0x0E, 0x01, 0xE1, 0xC0, 0x1E, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x30, 0x00, 0xC7, 0x00, 0x0C, 0x70, 0x01, 0xC6, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x1B, 0x0E,
  0x03, 0xF0, 0x70, 0x76, 0x03, 0xFE, 0x60, 0x1F, 0x86, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x0F, 0x80, 0x63, 0xFC, 0x06, 0x73, 0xE0, 0xEC, 0x0F, 0x0F, 0x80, 0x70,
  0xF0, 0x03, 0x0F, 0x00, 0x30, 0xE0, 0x03, 0x1E, 0x00, 0x31, 0xC0, 0x03,
  0x1C, 0x00, 0x31, 0x80, 0x03, 0x18, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00,
  0x73, 0x80, 0x06, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x78, 0x03, 0x87, 0x80, 0x70, 0xEC, 0x0F, 0x0C, 0x7F, 0xC0, 0xC3,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xC1, 0xF9, 0xC1, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x20, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x01, 0xF0, 0xC0, 0x0F, 0xF1, 0x80, 0x7C, 0xF3, 0x01, 0xE0, 0x3E,
  0x03, 0x80, 0x7C, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0C, 0x0C, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x38, 0x07,
  0xC0, 0x70, 0x0D, 0x80, 0x70, 0x73, 0x00, 0x7F, 0xCE, 0x00, 0x7E, 0x18,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0xF1, 0xE0, 0xE0, 0x70, 0xE0, 0x18,
  0xE0, 0x0C, 0xE0, 0x06, 0x70, 0x07, 0x30, 0x03, 0x38, 0x03, 0x98, 0x07,
  0x8C, 0x7F, 0x8F, 0xFF, 0x07, 0xF0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x30, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xC1, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x8E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x30, 0x1F, 0x3C, 0xC0, 0xF0, 0x1B,
  0x03, 0x80, 0x7C, 0x1C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0C,
  0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0x80, 0x06, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xE0, 0x07, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0xC0, 0xE0,
  0x3B, 0x01, 0xC1, 0xDC, 0x03, 0xFE, 0x70, 0x07, 0xF1, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x80, 0x1C, 0x03, 0xC1, 0xF0, 0x0F, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x0F, 0x80, 0x63, 0xFC, 0x06, 0x79,
  0xE0, 0xEC, 0x07, 0x0F, 0x80, 0x70, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x07, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x18,
  0x00, 0xE3, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0x87, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x38,
  0xE0, 0x03, 0x8E, 0x00, 0x30, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x38,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x80, 0x60, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03,
  0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x47, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x10, 0x60, 0x0E, 0x06, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x07, 0x00, 0xE0, 0xE0, 0x0C, 0x1C, 0x00, 0xC3, 0x80, 0x1C, 0x70, 0x01,
  0xCE, 0x00, 0x18, 0xC0, 0x01, 0x9C, 0x00, 0x1B, 0xE0, 0x03, 0xE6, 0x00,
  0x3C, 0x70, 0x03, 0x87, 0x00, 0x30, 0x30, 0x07, 0x03, 0x80, 0x70, 0x38,
  0x07, 0x01, 0x80, 0x60, 0x1C, 0x06, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00,
  0xE0, 0xE0, 0x06, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x06, 0x3F, 0xC3, 0xFC, 0x06, 0x73, 0xC7, 0x1E,
  0x0E, 0xC0, 0xEC, 0x0E, 0x0F, 0x80, 0xF8, 0x07, 0x0F, 0x00, 0xF0, 0x07,
  0x0E, 0x00, 0xF0, 0x07, 0x0E, 0x00, 0xE0, 0x06, 0x1C, 0x00, 0xE0, 0x06,
  0x1C, 0x00, 0xE0, 0x06, 0x1C, 0x00, 0xC0, 0x0E, 0x18, 0x01, 0xC0, 0x0E,
  0x18, 0x01, 0xC0, 0x0C, 0x38, 0x01, 0xC0, 0x0C, 0x38, 0x01, 0x80, 0x1C,
  0x30, 0x01, 0x80, 0x1C, 0x30, 0x03, 0x80, 0x1C, 0x30, 0x03, 0x80, 0x18,
  0x70, 0x03, 0x80, 0x18, 0x70, 0x03, 0x00, 0x38, 0x60, 0x03, 0x00, 0x38,
  0x60, 0x07, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x30, 0xE0, 0x06, 0x00, 0x30,
  0xE0, 0x06, 0x00, 0x70, 0x06, 0x0F, 0x80, 0x63, 0xFC, 0x06, 0x79, 0xE0,
  0xEC, 0x0F, 0x0F, 0x80, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07,
  0x1C, 0x00, 0x61, 0xC0, 0x06, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x18, 0x00,
  0xE3, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x80, 0x1C, 0x30, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x01, 0x87, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x38, 0xE0,
  0x03, 0x8E, 0x00, 0x30, 0xE0, 0x07, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xE0,
  0x1F, 0x1E, 0x07, 0x80, 0xE0, 0xE0, 0x1C, 0x38, 0x01, 0xCE, 0x00, 0x39,
  0xC0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0x80, 0x03, 0xB0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x33, 0x80, 0x0E, 0x70, 0x03, 0x8E, 0x00, 0x70, 0xE0, 0x1C, 0x1E,
  0x0F, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x06, 0x3F,
  0xC0, 0x19, 0xC7, 0x80, 0xEC, 0x07, 0x03, 0xE0, 0x1C, 0x0F, 0x00, 0x30,
  0x3C, 0x00, 0xC0, 0xE0, 0x03, 0x07, 0x80, 0x0C, 0x1C, 0x00, 0x30, 0x70,
  0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01,
  0xC3, 0x80, 0x06, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x1E, 0x00, 0xE0, 0x68, 0x07, 0x03, 0xB0, 0x3C, 0x0E, 0x7F,
  0xC0, 0x38, 0xFE, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x1F, 0xE3, 0x07, 0xCF, 0x30, 0xF0, 0x1B, 0x0E, 0x01, 0xF1, 0xC0,
  0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x30, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0xC6, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x8E,
  0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x8E, 0x00, 0xF0,
  0xE0, 0x1F, 0x0E, 0x01, 0xB0, 0x70, 0x77, 0x03, 0xFE, 0x70, 0x1F, 0x86,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x06, 0x3F, 0x06, 0x7F, 0x0E, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xC1, 0xE3,
  0xE1, 0xC0, 0x21, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x01, 0xC4, 0x00, 0xE3, 0x00, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x00,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x7F, 0xFF, 0xFF,
  0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0x07, 0xF0, 0x0C, 0x00, 0x71,
  0xC0, 0x06, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0xE1, 0x80, 0x0E,
  0x38, 0x00, 0xC3, 0x80, 0x0C, 0x38, 0x01, 0xC3, 0x00, 0x1C, 0x30, 0x01,
  0xC7, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x38, 0x60, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x01, 0xF0, 0xE0,
  0x36, 0x0F, 0x07, 0x60, 0x7F, 0xE6, 0x03, 0xF8, 0x60, 0xE0, 0x01, 0xD8,
  0x00, 0xE6, 0x00, 0x39, 0x80, 0x1C, 0x60, 0x07, 0x18, 0x03, 0x86, 0x00,
  0xE1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0,
  0x30, 0x60, 0x0C, 0x38, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C,
  0xE0, 0x03, 0x30, 0x00, 0xDC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0xC0, 0x0E, 0x00, 0xF8, 0x03, 0xC0, 0x1B, 0x00, 0x78,
  0x07, 0x60, 0x1B, 0x00, 0xEC, 0x03, 0x60, 0x39, 0x80, 0xEC, 0x07, 0x30,
  0x19, 0x80, 0xC6, 0x07, 0x30, 0x38, 0xC0, 0xC6, 0x06, 0x18, 0x18, 0xC1,
  0xC3, 0x06, 0x18, 0x30, 0x60, 0xC3, 0x0E, 0x0C, 0x30, 0x61, 0xC1, 0x86,
  0x0C, 0x30, 0x31, 0xC1, 0x8E, 0x06, 0x30, 0x31, 0x80, 0xCE, 0x06, 0x70,
  0x19, 0x80, 0xCC, 0x03, 0x70, 0x1F, 0x80, 0x6C, 0x03, 0xE0, 0x0D, 0x80,
  0x6C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x70, 0x38, 0x00,
  0xC1, 0xC0, 0x03, 0x07, 0x00, 0x0E, 0x38, 0x00, 0x19, 0xC0, 0x00, 0x6E,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x0D, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x8E, 0x00, 0x1C,
  0x38, 0x00, 0xE0, 0x60, 0x03, 0x81, 0xC0, 0x1C, 0x03, 0x00, 0xE0, 0x0C,
  0x07, 0x00, 0x38, 0x3C, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x60, 0x01,
  0x80, 0x30, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x60, 0x03, 0x80, 0x70, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x30,
  0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0E, 0x00, 0x03,
  0x86, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x19, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x8F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0x80,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x1F, 0x80, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0xF8, 0x01, 0x7C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xF8,
  0x07, 0xFF, 0xC1, 0xE0, 0x7F, 0xF8, 0x01, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 33, 11, 1, -33 },
  { 43, 11, 12, 15, 5, -33 },
  { 60, 25, 33, 25, 1, -33 },
  { 164, 21, 38, 22, 1, -35 },
  { 264, 27, 34, 32, 3, -33 },
  { 379, 24, 33, 26, 1, -33 },
  { 478, 5, 12, 9, 5, -33 },
  { 486, 14, 40, 12, 1, -33 },
  { 556, 13, 40, 12, -3, -33 },
  { 621, 17, 18, 21, 5, -35 },
  { 660, 19, 22, 24, 3, -27 },
  { 713, 7, 11, 9, -2, -5 },
  { 723, 11, 3, 13, 1, -14 },
  { 728, 4, 4, 10, 1, -4 },
  { 730, 21, 33, 15, -2, -33 },
  { 817, 20, 33, 22, 2, -33 },
  { 900, 12, 33, 22, 6, -33 },
  { 950, 21, 33, 22, 0, -33 },
  { 1037, 22, 33, 22, 0, -33 },
  { 1128, 21, 33, 22, 0, -33 },
  { 1215, 21, 33, 22, 1, -33 },
  { 1302, 20, 33, 22, 2, -33 },
  { 1385, 20, 33, 22, 3, -33 },
  { 1468, 21, 33, 22, 1, -33 },
  { 1555, 20, 33, 22, 1, -33 },
  { 1638, 8, 25, 10, 1, -25 },
  { 1663, 11, 31, 10, -2, -25 },
  { 1706, 19, 21, 24, 3, -27 },
  { 1756, 19, 12, 24, 3, -22 },
  { 1785, 19, 21, 24, 3, -27 },
  { 1835, 15, 33, 17, 3, -33 },
  { 1897, 31, 37, 34, 2, -33 },
  { 2041, 23, 33, 22, -3, -33 },
  { 2136, 23, 33, 24, 1, -33 },
  { 2231, 23, 33, 23, 3, -33 },
  { 2326, 25, 33, 27, 1, -33 },
  { 2430, 22, 33, 21, 1, -33 },
  { 2521, 22, 33, 20, 1, -33 },
  { 2612, 25, 33, 28, 3, -33 },
  { 2716, 27, 33, 28, 1, -33 },
  { 2828, 16, 33, 12, -1, -33 },
  { 2894, 18, 41, 10, -7, -33 },
  { 2987, 25, 33, 22, 1, -33 },
  { 3091, 15, 33, 20, 1, -33 },
  { 3153, 34, 33, 34, 1, -33 },
  { 3294, 28, 33, 28, 1, -33 },
  { 3410, 25, 33, 29, 3, -33 },
  { 3514, 22, 33, 23, 1, -33 },
  { 3605, 25, 41, 29, 3, -33 },
  { 3734, 22, 33, 23, 1, -33 },
  { 3825, 22, 33, 21, 0, -33 },
  { 3916, 20, 33, 20, 4, -33 },
  { 3999, 25, 33, 28, 3, -33 },
  { 4103, 22, 33, 22, 4, -33 },
  { 4194, 34, 33, 35, 5, -33 },
  { 4335, 27, 33, 20, -3, -33 },
  { 4447, 20, 33, 20, 4, -33 },
  { 4530, 24, 33, 21, -1, -33 },
  { 4629, 18, 40, 13, -1, -33 },
  { 4719, 7, 33, 15, 5, -33 },
  { 4748, 17, 40, 13, -3, -33 },
  { 4833, 20, 19, 23, 2, -33 },
  { 4881, 16, 2, 16, -4, 4 },
  { 4885, 6, 7, 11, 7, -35 },
  { 4891, 20, 25, 23, 2, -25 },
  { 4954, 20, 35, 23, 1, -35 },
  { 5042, 17, 25, 18, 2, -25 },
  { 5096, 23, 35, 23, 2, -35 },
  { 5197, 17, 25, 20, 2, -25 },
  { 5251, 24, 46, 12, -6, -35 },
  { 5389, 22, 36, 23, 0, -25 },
  { 5488, 20, 35, 23, 1, -35 },
  { 5576, 10, 33, 10, 1, -33 },
  { 5618, 17, 44, 10, -6, -33 },
  { 5712, 20, 35, 19, 1, -35 },
  { 5800, 10, 35, 10, 1, -35 },
  { 5844, 32, 25, 35, 1, -25 },
  { 5944, 20, 25, 23, 1, -25 },
  { 6007, 19, 25, 23, 2, -25 },
  { 6067, 22, 36, 23, -1, -25 },
  { 6166, 20, 36, 23, 2, -25 },
  { 6256, 16, 25, 16, 1, -25 },
  { 6306, 17, 25, 17, 0, -25 },
  { 6360, 12, 30, 13, 2, -30 },
  { 6405, 20, 24, 23, 2, -24 },
  { 6465, 18, 24, 18, 2, -24 },
  { 6519, 27, 24, 28, 3, -24 },
  { 6600, 22, 24, 19, -2, -24 },
  { 6666, 25, 35, 18, -5, -24 },
  { 6776, 19, 24, 17, -1, -24 },
  { 6833, 17, 40, 15, 1, -33 },
  { 6918, 3, 46, 22, 10, -35 },
  { 6936, 16, 40, 15, -2, -33 },
  { 7016, 19, 5, 24, 3, -19 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC46PT7B_H_
