#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x08, 0x21, 0x86,
  0x10, 0x00, 0x0C, 0x30, 0xC0, 0x62, 0xCD, 0x9A, 0x34, 0x58, 0xA1, 0x44,
  0x01, 0x0C, 0x02, 0x10, 0x0C, 0x20, 0x10, 0xC0, 0x21, 0x80, 0xC2, 0x0F,
  0xFF, 0xBF, 0xFF, 0x04, 0x20, 0x18, 0x40, 0x21, 0x80, 0x42, 0x01, 0x84,
  0x1F, 0xFF, 0x3F, 0xFE, 0x08, 0x40, 0x30, 0x80, 0x43, 0x00, 0x84, 0x03,
  0x08, 0x04, 0x30, 0x00, 0x00, 0x80, 0x04, 0x00, 0x60, 0x1F, 0xF1, 0x91,
  0x08, 0x80, 0xC4, 0x06, 0x20, 0x33, 0x00, 0xD0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x03, 0x60, 0x11, 0x80, 0x8C, 0x04, 0x60, 0x22, 0x23, 0x31, 0xFF,
  0x01, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x1E, 0x03, 0x19, 0x81, 0x08,
  0xC1, 0x8C, 0x21, 0x84, 0x30, 0x86, 0x18, 0xC3, 0x0C, 0x41, 0x84, 0x40,
  0x82, 0x66, 0x43, 0x27, 0xF1, 0x26, 0x79, 0xB6, 0x17, 0x92, 0x08, 0x11,
  0x04, 0x19, 0x86, 0x08, 0xC3, 0x08, 0x61, 0x0C, 0x30, 0x84, 0x18, 0xC6,
  0x0C, 0xC6, 0x03, 0xC0, 0x03, 0xC0, 0x0C, 0xC0, 0x30, 0xC0, 0x61, 0x80,
  0x83, 0x01, 0x06, 0x02, 0x18, 0x06, 0x60, 0x0D, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0x98, 0x36, 0x10, 0x58, 0x31, 0xB0, 0x32, 0x40, 0x6C, 0x80, 0x71,
  0x00, 0xC3, 0x03, 0xC7, 0x1C, 0x87, 0xE1, 0x80, 0x6D, 0xA5, 0xB4, 0x01,
  0x81, 0x01, 0x81, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x01,
  0x00, 0x80, 0x60, 0x10, 0x00, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x08,
  0x04, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C, 0x06, 0x02,
  0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x00, 0x02,
  0x00, 0x40, 0x08, 0x73, 0x03, 0x40, 0x1F, 0xC3, 0x80, 0x90, 0x33, 0x0C,
  0x20, 0x04, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x33, 0x26, 0x4C, 0x80, 0xFF, 0xF8, 0x7C, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x3B, 0x83, 0x0C, 0x30,
  0x21, 0x01, 0x98, 0x0C, 0xC0, 0x64, 0x03, 0x60, 0x13, 0x00, 0x90, 0x04,
  0x80, 0x6C, 0x03, 0x60, 0x1B, 0x01, 0x98, 0x0C, 0xC0, 0x42, 0x06, 0x18,
  0x60, 0xC6, 0x03, 0xE0, 0x00, 0x06, 0x1C, 0x7B, 0xBC, 0x51, 0x83, 0x06,
  0x08, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x18, 0x30, 0x60, 0x83, 0x06, 0x00,
  0x03, 0xE0, 0x7B, 0xC3, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0F, 0xFE, 0x00, 0x03,
  0xE0, 0x3D, 0xE0, 0x81, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x07, 0x80, 0xF8, 0x00, 0x38, 0x00, 0x20, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x30, 0x70, 0x7F, 0x80,
  0x00, 0x18, 0x00, 0xC0, 0x0A, 0x00, 0xF0, 0x0D, 0x80, 0xC8, 0x04, 0x40,
  0x46, 0x06, 0x30, 0x61, 0x82, 0x08, 0x20, 0xC3, 0x06, 0x30, 0x33, 0x01,
  0x1F, 0xFF, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x07,
  0xFC, 0x1F, 0xF0, 0x40, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x19, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x30, 0x70, 0x7F, 0x00,
  0x00, 0xF8, 0x1E, 0x41, 0x80, 0x18, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x27, 0x83, 0x7F, 0x1C, 0x18, 0xC0, 0x46, 0x03, 0x20, 0x1B, 0x00,
  0xD8, 0x04, 0xC0, 0x62, 0x03, 0x18, 0x30, 0xE3, 0x03, 0xF0, 0x00, 0x7F,
  0xFB, 0xFF, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0xE0,
  0x7B, 0x86, 0x06, 0x30, 0x31, 0x01, 0x88, 0x0C, 0x60, 0x43, 0x06, 0x0C,
  0x60, 0x3C, 0x03, 0xC0, 0x73, 0x06, 0x0C, 0x60, 0x33, 0x01, 0x90, 0x04,
  0x80, 0x66, 0x03, 0x30, 0x30, 0xC3, 0x83, 0xF0, 0x00, 0x03, 0xC0, 0xEE,
  0x18, 0x33, 0x01, 0x30, 0x12, 0x01, 0x60, 0x16, 0x01, 0x60, 0x36, 0x03,
  0x20, 0x73, 0x9B, 0x1F, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18,
  0x03, 0x08, 0x60, 0xFC, 0x00, 0x08, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x06, 0x38, 0x04, 0x1C, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x04, 0x00, 0x00,
  0x10, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0x80, 0x00, 0x3E, 0x3F, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x02, 0x03, 0x01, 0x00, 0x80, 0x00, 0x00, 0x20, 0x18,
  0x0C, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0x00, 0xC0, 0x60, 0x06,
  0x0C, 0x00, 0x61, 0x80, 0x02, 0x30, 0x3C, 0x32, 0x0C, 0x63, 0x61, 0x84,
  0x36, 0x30, 0x43, 0x42, 0x0C, 0x24, 0x20, 0xC2, 0xC6, 0x08, 0x2C, 0x61,
  0x86, 0xC6, 0x18, 0x4C, 0x62, 0x8C, 0xC3, 0x6F, 0x8C, 0x18, 0x60, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x80, 0x0F, 0xF8, 0x00,
  0x1C, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x48, 0x03,
  0x20, 0x08, 0x80, 0x62, 0x01, 0x08, 0x0C, 0x20, 0x20, 0xC1, 0x83, 0x07,
  0xFC, 0x3F, 0xF0, 0x80, 0xC6, 0x03, 0x10, 0x0C, 0xC0, 0x12, 0x00, 0x58,
  0x01, 0xC0, 0x04, 0x0F, 0xE0, 0x3F, 0xE0, 0x81, 0xC2, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x80, 0xC4, 0x02, 0x30, 0x18, 0xFF, 0x83, 0xFC, 0x0C, 0x1C,
  0x20, 0x31, 0x80, 0x66, 0x01, 0x98, 0x06, 0x40, 0x31, 0x00, 0xCC, 0x06,
  0x30, 0xF0, 0xFF, 0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xE0, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0E, 0x10, 0x1F, 0xC0, 0x0F, 0x80, 0x1F, 0xF0, 0x20, 0x70, 0x40,
  0x61, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x88, 0x03, 0x30, 0x06, 0x60, 0x0C,
  0xC0, 0x19, 0x80, 0x32, 0x00, 0x6C, 0x01, 0x98, 0x03, 0x30, 0x0C, 0x40,
  0x18, 0x80, 0x63, 0x03, 0x86, 0x3E, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x7F,
  0xC2, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0xFF, 0x0F, 0xF8, 0x40, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x7F, 0xC2,
  0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0F, 0xF8, 0x7F, 0xC2, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x38,
  0x08, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01,
  0x80, 0x03, 0x03, 0xF6, 0x07, 0xEC, 0x00, 0xD8, 0x01, 0x30, 0x02, 0x60,
  0x0C, 0xC0, 0x19, 0x80, 0x31, 0x80, 0x41, 0xC3, 0x81, 0xFE, 0x00, 0x0C,
  0x01, 0x86, 0x00, 0x82, 0x00, 0xC1, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x10,
  0x60, 0x08, 0x20, 0x0C, 0x10, 0x06, 0x1F, 0xFF, 0x0F, 0xFF, 0x04, 0x00,
  0x82, 0x00, 0xC3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x10, 0x40, 0x08, 0x20,
  0x0C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x00, 0x07, 0xC0, 0xE0, 0x30,
  0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x40, 0xFC, 0x00, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x8C,
  0x0F, 0x80, 0x0C, 0x07, 0x0C, 0x0C, 0x08, 0x1C, 0x08, 0x18, 0x18, 0x30,
  0x18, 0x60, 0x18, 0xC0, 0x11, 0x80, 0x33, 0x00, 0x36, 0x00, 0x3F, 0x00,
  0x3B, 0x00, 0x31, 0x00, 0x61, 0x80, 0x61, 0x80, 0x60, 0x80, 0x40, 0xC0,
  0x40, 0xC0, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0x60, 0x0C, 0x06, 0x02, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0F, 0xF8, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xA1, 0xE0, 0x0F, 0x0D, 0x00, 0x58,
  0x48, 0x06, 0xC2, 0x40, 0x64, 0x32, 0x03, 0x61, 0x98, 0x33, 0x0C, 0xC1,
  0x98, 0x46, 0x18, 0xC2, 0x30, 0x84, 0x30, 0x8C, 0x61, 0x84, 0x43, 0x0C,
  0x26, 0x18, 0x41, 0x20, 0x82, 0x0B, 0x04, 0x30, 0x70, 0x61, 0x83, 0x83,
  0x0C, 0x18, 0x18, 0x00, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x80, 0x61, 0xC0,
  0x21, 0xA0, 0x10, 0xD8, 0x18, 0x4C, 0x0C, 0x22, 0x06, 0x31, 0x82, 0x18,
  0xC3, 0x0C, 0x21, 0x84, 0x18, 0xC2, 0x0C, 0x43, 0x02, 0x21, 0x81, 0xB0,
  0xC0, 0xD8, 0x40, 0x2C, 0x20, 0x14, 0x30, 0x0E, 0x18, 0x07, 0x0C, 0x01,
  0x80, 0x01, 0xF0, 0x0F, 0xF0, 0x30, 0x30, 0xC0, 0x33, 0x00, 0x66, 0x00,
  0x58, 0x00, 0xB0, 0x01, 0x40, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x19, 0x80, 0x71, 0x80,
  0xC3, 0x87, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x81, 0x82, 0x06,
  0x18, 0x08, 0x60, 0x31, 0x80, 0x84, 0x02, 0x30, 0x18, 0xC0, 0xC3, 0x07,
  0x0F, 0xF0, 0x3E, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x30, 0x30,
  0xC0, 0x33, 0x00, 0x66, 0x00, 0x58, 0x00, 0xB0, 0x01, 0x40, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xB0, 0x03, 0x60, 0x06,
  0xC0, 0x19, 0x80, 0x31, 0x80, 0xC3, 0x87, 0x01, 0xF8, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x81,
  0x82, 0x02, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x84, 0x06, 0x30, 0x18, 0xC0,
  0xC3, 0x1E, 0x0F, 0xE0, 0x21, 0x81, 0x86, 0x06, 0x08, 0x18, 0x30, 0x40,
  0xC1, 0x03, 0x0C, 0x06, 0x30, 0x18, 0xC0, 0x60, 0x03, 0xF0, 0x1F, 0xF0,
  0xC0, 0x86, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x80, 0x0C, 0x30, 0x70, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x40, 0x00, 0x18, 0x03, 0x10, 0x02, 0x10, 0x02, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x04, 0x60, 0x04, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x0C, 0x40, 0x08, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x10, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0x71, 0xC0, 0x3F, 0x80, 0x80,
  0x1C, 0x00, 0xE0, 0x0D, 0x80, 0x6C, 0x06, 0x60, 0x33, 0x01, 0x18, 0x18,
  0xC0, 0x86, 0x0C, 0x30, 0x40, 0x86, 0x04, 0x20, 0x23, 0x01, 0x10, 0x09,
  0x80, 0x48, 0x02, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x00, 0xC0, 0x20,
  0x1E, 0x03, 0x00, 0xF0, 0x1C, 0x05, 0x81, 0xE0, 0x6C, 0x0F, 0x02, 0x60,
  0x58, 0x33, 0x06, 0xC1, 0x98, 0x26, 0x08, 0xC3, 0x30, 0xC6, 0x11, 0x84,
  0x31, 0x8C, 0x61, 0x88, 0x62, 0x0C, 0xC3, 0x30, 0x66, 0x19, 0x83, 0x20,
  0xC8, 0x1B, 0x06, 0xC0, 0xD0, 0x34, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x01,
  0xC0, 0x30, 0x0C, 0x01, 0x80, 0x00, 0x06, 0x01, 0x81, 0x01, 0x80, 0xC0,
  0xC0, 0x60, 0xC0, 0x10, 0xC0, 0x08, 0x40, 0x06, 0x60, 0x03, 0x60, 0x00,
  0xA0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x36, 0x00, 0x13, 0x00,
  0x18, 0x80, 0x18, 0x40, 0x08, 0x30, 0x0C, 0x18, 0x0C, 0x04, 0x0C, 0x03,
  0x0E, 0x01, 0x80, 0x80, 0x3C, 0x02, 0xC0, 0x6C, 0x0C, 0x40, 0xC4, 0x18,
  0x63, 0x06, 0x30, 0x66, 0x02, 0x40, 0x2C, 0x03, 0x80, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x00, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0xFF, 0xF0, 0x07, 0xC1, 0xF0, 0x40, 0x30, 0x0C, 0x02,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00,
  0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0xF8,
  0x3E, 0x00, 0x86, 0x31, 0x84, 0x21, 0x0C, 0x63, 0x08, 0x42, 0x10, 0xC6,
  0x30, 0x84, 0x21, 0x80, 0x07, 0xE0, 0xFC, 0x01, 0x00, 0x20, 0x0C, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0xFC, 0x1F, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xA0, 0x0D, 0x00, 0xCC,
  0x04, 0x20, 0x61, 0x02, 0x0C, 0x30, 0x21, 0x01, 0x98, 0x05, 0x80, 0x30,
  0xFF, 0xE0, 0xC6, 0x23, 0x03, 0x00, 0x7E, 0xC6, 0x1E, 0x60, 0x63, 0x03,
  0x30, 0x19, 0x80, 0xC8, 0x04, 0xC0, 0x26, 0x03, 0x30, 0x19, 0x80, 0xCC,
  0x0C, 0x60, 0xA1, 0x8D, 0x07, 0x98, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x43, 0x02, 0x7C, 0x34, 0x31, 0xC0, 0x8C, 0x04,
  0x60, 0x32, 0x01, 0x30, 0x09, 0x80, 0x4C, 0x06, 0x40, 0x32, 0x03, 0x30,
  0x19, 0xC1, 0x8B, 0x18, 0x4F, 0x80, 0x03, 0xC1, 0xFC, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x1C, 0x41, 0xF8, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x00, 0xC2, 0x07, 0xEC, 0x18, 0x78, 0x60, 0x70, 0xC0,
  0xC3, 0x01, 0x86, 0x03, 0x08, 0x06, 0x30, 0x08, 0x60, 0x30, 0xC0, 0x61,
  0x80, 0xC3, 0x03, 0x86, 0x0E, 0x06, 0x34, 0x07, 0xC8, 0x00, 0x03, 0x81,
  0xF8, 0x61, 0x98, 0x12, 0x06, 0xC0, 0xD8, 0x32, 0xFC, 0xFC, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x1C, 0x21, 0xFC, 0x00, 0x1E, 0x00, 0x64,
  0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x32, 0x01, 0xF8, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x20, 0x05, 0xC0,
  0x0F, 0x00, 0x00, 0x01, 0x80, 0x1F, 0x90, 0xC3, 0xC6, 0x07, 0x18, 0x18,
  0xC0, 0x63, 0x01, 0x88, 0x06, 0x60, 0x11, 0x80, 0xC6, 0x03, 0x18, 0x0C,
  0x60, 0x71, 0x83, 0x83, 0x1A, 0x07, 0xD8, 0x00, 0x60, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x81, 0x83, 0xDC, 0x07, 0xE0, 0x00, 0x0C, 0x00, 0xC0, 0x08,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0xC1, 0x3E, 0x34, 0x33, 0x83, 0x30,
  0x33, 0x03, 0x20, 0x36, 0x03, 0x60, 0x26, 0x06, 0x40, 0x64, 0x06, 0xC0,
  0x4C, 0x04, 0xC0, 0xC8, 0x0C, 0x0C, 0x70, 0x00, 0x00, 0x01, 0x0C, 0x30,
  0xC2, 0x08, 0x61, 0x86, 0x10, 0x43, 0x0C, 0x20, 0x80, 0x00, 0x60, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x02, 0xE0, 0x78, 0x00,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x11, 0x06,
  0x30, 0xC3, 0x08, 0x31, 0x02, 0x30, 0x26, 0x06, 0xC0, 0x76, 0x06, 0x60,
  0x42, 0x04, 0x30, 0xC3, 0x0C, 0x10, 0xC1, 0x88, 0x18, 0x0C, 0x30, 0x86,
  0x18, 0x61, 0x04, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30,
  0xC2, 0x00, 0x01, 0xC1, 0xC1, 0x7E, 0x7E, 0x3C, 0x2C, 0x23, 0x83, 0x83,
  0x30, 0x30, 0x33, 0x03, 0x02, 0x20, 0x20, 0x26, 0x06, 0x06, 0x60, 0x60,
  0x66, 0x06, 0x06, 0x40, 0x40, 0x44, 0x04, 0x0C, 0xC0, 0xC0, 0xCC, 0x0C,
  0x0C, 0xC0, 0xC0, 0x88, 0x08, 0x08, 0x01, 0xC1, 0x7F, 0x3C, 0x33, 0x83,
  0x30, 0x33, 0x03, 0x20, 0x36, 0x03, 0x60, 0x26, 0x06, 0x40, 0x6C, 0x06,
  0xC0, 0x4C, 0x04, 0xC0, 0xC8, 0x0C, 0x03, 0x80, 0xFE, 0x18, 0x33, 0x03,
  0x20, 0x36, 0x01, 0x60, 0x14, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x06,
  0xC0, 0x64, 0x0C, 0x71, 0x83, 0xF0, 0x00, 0x30, 0x09, 0xF0, 0x34, 0x30,
  0x70, 0x20, 0xC0, 0x61, 0x80, 0xC2, 0x01, 0x0C, 0x02, 0x18, 0x04, 0x30,
  0x18, 0x40, 0x30, 0x80, 0xC3, 0x01, 0x87, 0x06, 0x0B, 0x18, 0x13, 0xE0,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x03, 0x00, 0x7E, 0x46, 0x1E, 0x60, 0x73, 0x03, 0x30, 0x19,
  0x80, 0xC8, 0x06, 0xC0, 0x26, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E, 0x60,
  0xE1, 0x8D, 0x07, 0xD8, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x01, 0xC5, 0xF3, 0x40, 0xE0, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00,
  0x07, 0x03, 0xFC, 0xC0, 0x98, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x30, 0xC7, 0xF0, 0x08, 0x08,
  0x18, 0x10, 0x7F, 0x30, 0x30, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0x78, 0x10, 0x19, 0x80, 0x8C, 0x04, 0x40, 0x62,
  0x03, 0x30, 0x19, 0x80, 0x8C, 0x04, 0x40, 0x62, 0x03, 0x30, 0x39, 0x81,
  0x8C, 0x14, 0x31, 0xE1, 0xF3, 0x00, 0x80, 0x70, 0x1A, 0x06, 0x40, 0xCC,
  0x31, 0x86, 0x31, 0x86, 0x30, 0xCC, 0x19, 0x83, 0x60, 0x2C, 0x07, 0x00,
  0xE0, 0x18, 0x00, 0x81, 0x81, 0xC0, 0xC0, 0xA0, 0xE0, 0xD0, 0x50, 0x48,
  0x68, 0x64, 0x24, 0x22, 0x33, 0x31, 0x11, 0x98, 0x98, 0xC8, 0x48, 0x6C,
  0x24, 0x34, 0x16, 0x1E, 0x0A, 0x0E, 0x07, 0x07, 0x03, 0x03, 0x00, 0x18,
  0x1C, 0x30, 0xC0, 0xC2, 0x01, 0x18, 0x06, 0xC0, 0x1E, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x36, 0x01, 0x98, 0x04, 0x20, 0x30, 0xC1, 0x81, 0x0C,
  0x06, 0x00, 0x04, 0x03, 0x04, 0x06, 0x06, 0x04, 0x06, 0x0C, 0x06, 0x08,
  0x06, 0x18, 0x06, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40,
  0x02, 0xC0, 0x02, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x02, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0xB8, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x02, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0xFF, 0x80, 0x00, 0x40, 0xF0,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x01, 0x80, 0xC0,
  0xE0, 0x38, 0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x38, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x04, 0x03,
  0xC0, 0x18, 0x06, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20,
  0x0C, 0x01, 0xC0, 0xF0, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08,
  0x06, 0x01, 0x80, 0xC0, 0xE0, 0x20, 0x00, 0x38, 0x1F, 0xE1, 0x83, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 21, 7, 1, -21 },
  { 17, 7, 8, 10, 3, -21 },
  { 24, 15, 21, 16, 1, -21 },
  { 64, 13, 24, 14, 1, -22 },
  { 103, 17, 21, 20, 2, -21 },
  { 148, 15, 21, 16, 1, -21 },
  { 188, 3, 8, 5, 3, -21 },
  { 191, 9, 26, 8, 1, -21 },
  { 221, 9, 26, 8, -2, -21 },
  { 251, 11, 11, 14, 3, -22 },
  { 267, 12, 14, 15, 2, -17 },
  { 288, 4, 7, 6, -1, -3 },
  { 292, 7, 2, 9, 1, -9 },
  { 294, 2, 3, 6, 1, -3 },
  { 295, 13, 21, 9, -1, -21 },
  { 330, 13, 21, 14, 1, -21 },
  { 365, 7, 21, 14, 4, -21 },
  { 384, 13, 21, 14, 0, -21 },
  { 419, 14, 21, 14, 0, -21 },
  { 456, 13, 21, 14, 0, -21 },
  { 491, 14, 21, 14, 0, -21 },
  { 528, 13, 21, 14, 1, -21 },
  { 563, 13, 21, 14, 2, -21 },
  { 598, 13, 21, 14, 1, -21 },
  { 633, 12, 21, 14, 1, -21 },
  { 665, 6, 16, 6, 0, -16 },
  { 677, 7, 20, 6, -1, -16 },
  { 695, 12, 13, 15, 2, -17 },
  { 715, 12, 7, 15, 2, -14 },
  { 726, 12, 13, 15, 2, -17 },
  { 746, 9, 21, 10, 2, -21 },
  { 770, 20, 24, 21, 1, -21 },
  { 830, 14, 21, 14, -2, -21 },
  { 867, 14, 21, 15, 1, -21 },
  { 904, 14, 21, 15, 2, -21 },
  { 941, 15, 21, 17, 1, -21 },
  { 981, 13, 21, 13, 1, -21 },
  { 1016, 13, 21, 12, 1, -21 },
  { 1051, 15, 21, 18, 2, -21 },
  { 1091, 17, 21, 17, 1, -21 },
  { 1136, 10, 21, 8, -1, -21 },
  { 1163, 12, 26, 7, -5, -21 },
  { 1202, 16, 21, 14, 1, -21 },
  { 1244, 9, 21, 12, 1, -21 },
  { 1268, 21, 21, 22, 1, -21 },
  { 1324, 17, 21, 18, 1, -21 },
  { 1369, 15, 21, 18, 2, -21 },
  { 1409, 14, 21, 14, 1, -21 },
  { 1446, 15, 26, 18, 2, -21 },
  { 1495, 14, 21, 15, 1, -21 },
  { 1532, 14, 21, 13, 0, -21 },
  { 1569, 12, 21, 12, 3, -21 },
  { 1601, 16, 21, 17, 2, -21 },
  { 1643, 13, 21, 14, 3, -21 },
  { 1678, 21, 21, 22, 3, -21 },
  { 1734, 17, 21, 13, -2, -21 },
  { 1779, 12, 21, 13, 3, -21 },
  { 1811, 16, 21, 13, -1, -21 },
  { 1853, 10, 26, 8, 0, -21 },
  { 1886, 5, 21, 10, 3, -21 },
  { 1900, 11, 26, 8, -2, -21 },
  { 1936, 13, 12, 15, 1, -21 },
  { 1956, 11, 1, 10, -3, 3 },
  { 1958, 4, 4, 7, 4, -22 },
  { 1960, 13, 16, 15, 1, -16 },
  { 1986, 13, 22, 15, 1, -22 },
  { 2022, 11, 16, 11, 1, -16 },
  { 2044, 15, 22, 15, 1, -22 },
  { 2086, 11, 16, 13, 1, -16 },
  { 2108, 15, 29, 8, -4, -22 },
  { 2163, 14, 23, 15, 0, -16 },
  { 2204, 12, 22, 14, 1, -22 },
  { 2237, 6, 21, 6, 1, -21 },
  { 2253, 11, 28, 6, -4, -21 },
  { 2292, 12, 22, 12, 1, -22 },
  { 2325, 6, 22, 6, 1, -22 },
  { 2342, 20, 16, 22, 1, -16 },
  { 2382, 12, 16, 14, 1, -16 },
  { 2406, 12, 16, 14, 1, -16 },
  { 2430, 15, 23, 15, -1, -16 },
  { 2474, 13, 23, 15, 1, -16 },
  { 2512, 10, 16, 10, 1, -16 },
  { 2532, 11, 16, 11, 0, -16 },
  { 2554, 8, 19, 8, 1, -19 },
  { 2573, 13, 15, 15, 1, -15 },
  { 2598, 11, 15, 11, 2, -15 },
  { 2619, 17, 15, 18, 2, -15 },
  { 2651, 14, 15, 12, -1, -15 },
  { 2678, 16, 22, 11, -3, -15 },
  { 2722, 12, 15, 11, -1, -15 },
  { 2745, 10, 26, 10, 1, -21 },
  { 2778, 1, 29, 14, 7, -22 },
  { 2782, 10, 26, 10, -1, -21 },
  { 2815, 12, 3, 15, 2, -12 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC29PT7B_H_
