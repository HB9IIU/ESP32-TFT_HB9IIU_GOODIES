#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x12, 0x22, 0x22, 0x44, 0x00, 0xC0, 0x9A, 0xAA, 0x09, 0x04, 0x84,
  0x8F, 0xF1, 0x20, 0x90, 0x91, 0xFE, 0x24, 0x24, 0x12, 0x00, 0x04, 0x1E,
  0x29, 0x28, 0x28, 0x38, 0x08, 0x14, 0x12, 0x14, 0xF8, 0x20, 0x20, 0x20,
  0x94, 0x44, 0x92, 0x48, 0x94, 0x25, 0x6A, 0xA5, 0x31, 0x14, 0x89, 0x22,
  0x49, 0x1C, 0x0C, 0x09, 0x04, 0x82, 0x41, 0x40, 0xC0, 0xA2, 0x92, 0x85,
  0x43, 0x21, 0x8F, 0x20, 0xF0, 0x08, 0x88, 0x44, 0x21, 0x08, 0x84, 0x10,
  0x84, 0x20, 0x10, 0x82, 0x10, 0x84, 0x42, 0x10, 0x88, 0x84, 0x40, 0x12,
  0x47, 0xC8, 0x52, 0x40, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x29,
  0x40, 0xF0, 0xC0, 0x02, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x82,
  0x00, 0x18, 0x49, 0x12, 0x18, 0x30, 0xA1, 0x42, 0x85, 0x12, 0x23, 0x80,
  0x3D, 0x12, 0x22, 0x22, 0x44, 0x40, 0x0C, 0x64, 0x08, 0x10, 0x20, 0x41,
  0x04, 0x10, 0x41, 0x07, 0xE0, 0x0C, 0x32, 0x01, 0x02, 0x02, 0x04, 0x3C,
  0x04, 0x02, 0x04, 0x04, 0xF8, 0x02, 0x0C, 0x28, 0x92, 0x44, 0x91, 0x7F,
  0x04, 0x10, 0x20, 0x1F, 0x20, 0x20, 0x20, 0x3C, 0x04, 0x02, 0x02, 0x02,
  0x04, 0xF8, 0x0E, 0x20, 0x82, 0x04, 0x17, 0x31, 0x42, 0x85, 0x0A, 0x23,
  0x80, 0x7E, 0x08, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x82, 0x00, 0x0C,
  0x12, 0x21, 0x21, 0x22, 0x14, 0x3C, 0x44, 0x82, 0x82, 0x44, 0x78, 0x0C,
  0x24, 0x8A, 0x14, 0x28, 0x49, 0x8D, 0x04, 0x08, 0x27, 0x80, 0x24, 0x00,
  0x00, 0xC0, 0x11, 0x00, 0x00, 0x02, 0x44, 0x80, 0x06, 0x31, 0x86, 0x03,
  0x01, 0x80, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0xC0, 0x60, 0x30, 0x31, 0x8C,
  0x20, 0x00, 0x32, 0x42, 0x10, 0x88, 0x88, 0x40, 0x01, 0x00, 0x1F, 0x88,
  0x14, 0x05, 0x3D, 0x92, 0x64, 0x9A, 0x26, 0x89, 0x9F, 0xA0, 0x08, 0x01,
  0xF8, 0x06, 0x06, 0x0A, 0x0A, 0x12, 0x12, 0x3E, 0x21, 0x41, 0x41, 0x81,
  0x1F, 0x21, 0x21, 0x21, 0x22, 0x3E, 0x42, 0x41, 0x42, 0x42, 0xFC, 0x06,
  0x19, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x40, 0x7C, 0x1F,
  0x10, 0xC8, 0x24, 0x12, 0x09, 0x05, 0x02, 0x82, 0x43, 0x23, 0x3E, 0x00,
  0x1F, 0x20, 0x20, 0x20, 0x22, 0x3C, 0x40, 0x40, 0x40, 0x40, 0xFC, 0x1F,
  0x20, 0x20, 0x20, 0x20, 0x3E, 0x40, 0x40, 0x40, 0x40, 0xC0, 0x06, 0x0C,
  0xC8, 0x08, 0x04, 0x04, 0x02, 0x3D, 0x02, 0x82, 0x41, 0x10, 0x8F, 0xC0,
  0x10, 0x48, 0x22, 0x08, 0x82, 0x20, 0x8F, 0xC4, 0x11, 0x04, 0x41, 0x10,
  0x4C, 0x20, 0x38, 0x88, 0x42, 0x10, 0x88, 0x42, 0x38, 0x02, 0x08, 0x10,
  0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x1C, 0x00, 0x11, 0x91,
  0x09, 0x05, 0x03, 0x81, 0x41, 0x20, 0x88, 0x44, 0x22, 0x30, 0x80, 0x10,
  0x82, 0x08, 0x20, 0x84, 0x10, 0x41, 0x0F, 0xC0, 0x10, 0x33, 0x03, 0x28,
  0x62, 0x86, 0x28, 0xA2, 0x92, 0x49, 0x24, 0xA4, 0x4A, 0x44, 0xC4, 0x84,
  0x40, 0x10, 0x4A, 0x12, 0x88, 0xA2, 0x28, 0x89, 0x24, 0x49, 0x14, 0x43,
  0x10, 0xC8, 0x30, 0x0C, 0x19, 0x88, 0x48, 0x14, 0x0C, 0x06, 0x05, 0x02,
  0x81, 0x41, 0x30, 0x8F, 0x80, 0x1E, 0x21, 0x21, 0x21, 0x22, 0x3E, 0x40,
  0x40, 0x40, 0x40, 0xC0, 0x0C, 0x19, 0x88, 0x48, 0x14, 0x0C, 0x06, 0x05,
  0x02, 0x81, 0x41, 0x30, 0x8F, 0x80, 0x80, 0x40, 0x10, 0x1E, 0x21, 0x21,
  0x21, 0x22, 0x3C, 0x48, 0x44, 0x44, 0x44, 0xC2, 0x0C, 0x64, 0x81, 0x02,
  0x06, 0x06, 0x02, 0x04, 0x08, 0x17, 0xC0, 0xFE, 0x20, 0x40, 0x82, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x00, 0x20, 0xA0, 0x90, 0x48, 0x24, 0x14, 0x0A,
  0x09, 0x04, 0x82, 0x42, 0x1E, 0x00, 0xC1, 0x42, 0x42, 0x44, 0x44, 0x48,
  0x48, 0x50, 0x50, 0x60, 0x60, 0x84, 0x31, 0x86, 0x31, 0x4A, 0x29, 0x49,
  0x49, 0x29, 0x45, 0x28, 0xC5, 0x18, 0xC2, 0x18, 0x00, 0x10, 0x88, 0x82,
  0x81, 0x40, 0xC0, 0x60, 0x50, 0x28, 0x24, 0x21, 0x20, 0x80, 0xC2, 0x89,
  0x12, 0x45, 0x06, 0x08, 0x10, 0x20, 0x81, 0x00, 0x3F, 0x02, 0x04, 0x04,
  0x08, 0x10, 0x30, 0x20, 0x40, 0x80, 0xFC, 0x3C, 0x82, 0x08, 0x21, 0x04,
  0x10, 0x41, 0x08, 0x20, 0x83, 0x80, 0xAA, 0xA5, 0x54, 0x1C, 0x10, 0x82,
  0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x23, 0x80, 0x10, 0x50, 0xA2, 0x28,
  0x50, 0xC0, 0xF8, 0xD0, 0x12, 0xD5, 0x14, 0x28, 0x50, 0xA2, 0x44, 0xF8,
  0x10, 0x40, 0x81, 0x63, 0x24, 0x58, 0xA1, 0x42, 0x85, 0x15, 0xC0, 0x1D,
  0x84, 0x20, 0x82, 0x08, 0x20, 0x70, 0x03, 0x02, 0x02, 0x1A, 0x66, 0x44,
  0x84, 0x84, 0x84, 0x8C, 0x88, 0xF8, 0x19, 0x94, 0x62, 0xF2, 0x08, 0x20,
  0x78, 0x07, 0x04, 0x08, 0x1E, 0x08, 0x08, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x20, 0x20, 0xC0, 0x0D, 0x33, 0x22, 0x42, 0x42, 0x42, 0x46,
  0x44, 0x7C, 0x04, 0x04, 0x88, 0x70, 0x10, 0x40, 0x81, 0x63, 0x24, 0x50,
  0xA1, 0x42, 0x89, 0x14, 0x20, 0x13, 0x02, 0x22, 0x44, 0x44, 0x48, 0x04,
  0x10, 0x02, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x20, 0x82, 0x30, 0x10,
  0x40, 0x81, 0x12, 0x45, 0x14, 0x38, 0x50, 0x91, 0x24, 0x20, 0x12, 0x22,
  0x22, 0x44, 0x44, 0x48, 0x2C, 0xC6, 0x64, 0x88, 0xA1, 0x14, 0x22, 0x88,
  0x51, 0x0A, 0x22, 0x84, 0x40, 0x2C, 0x64, 0x8A, 0x14, 0x28, 0x51, 0x22,
  0x84, 0x19, 0x94, 0x61, 0x86, 0x18, 0x62, 0xF0, 0x2C, 0x64, 0x8B, 0x14,
  0x28, 0x50, 0xA2, 0xB9, 0x02, 0x04, 0x08, 0x00, 0x1A, 0xCD, 0x14, 0x28,
  0x50, 0xA3, 0x44, 0xF8, 0x10, 0x20, 0x41, 0x00, 0x2C, 0xC2, 0x10, 0x41,
  0x04, 0x10, 0x80, 0x39, 0x14, 0x10, 0x30, 0x60, 0x82, 0xF0, 0x24, 0xF4,
  0x48, 0x88, 0x88, 0xC0, 0x42, 0x89, 0x14, 0x28, 0x50, 0xA2, 0x4C, 0xE8,
  0x86, 0x18, 0xA4, 0x92, 0x8A, 0x30, 0x40, 0x88, 0x62, 0x29, 0x8A, 0x64,
  0xA9, 0x29, 0x8C, 0x63, 0x10, 0x84, 0x00, 0x21, 0x12, 0x14, 0x14, 0x08,
  0x18, 0x28, 0x24, 0xC4, 0x10, 0x88, 0x44, 0x42, 0x21, 0x20, 0x90, 0x50,
  0x18, 0x08, 0x04, 0x04, 0x04, 0x0E, 0x00, 0x3C, 0x10, 0x84, 0x10, 0x84,
  0x20, 0xF8, 0x0C, 0x41, 0x04, 0x10, 0x8C, 0x08, 0x21, 0x04, 0x10, 0x40,
  0xC0, 0xFF, 0xFF, 0x18, 0x20, 0x82, 0x08, 0x20, 0xC4, 0x10, 0x42, 0x08,
  0x62, 0x00, 0x61, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 2, -11 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 8, 13, 8, 0, -12 },
  { 35, 10, 12, 11, 1, -12 },
  { 50, 9, 12, 9, 0, -12 },
  { 64, 1, 4, 3, 2, -11 },
  { 65, 5, 14, 4, 0, -11 },
  { 74, 5, 14, 4, -1, -11 },
  { 83, 6, 6, 7, 2, -12 },
  { 88, 7, 7, 8, 1, -9 },
  { 95, 3, 4, 3, -1, -2 },
  { 97, 4, 1, 5, 0, -5 },
  { 98, 2, 1, 3, 0, -1 },
  { 99, 7, 11, 5, -1, -11 },
  { 109, 7, 12, 8, 1, -12 },
  { 120, 4, 11, 8, 2, -11 },
  { 126, 7, 12, 8, 0, -12 },
  { 137, 8, 12, 8, 0, -12 },
  { 149, 7, 11, 8, 0, -11 },
  { 159, 8, 11, 8, 0, -11 },
  { 170, 7, 12, 8, 1, -12 },
  { 181, 7, 11, 8, 1, -11 },
  { 191, 8, 12, 8, 0, -12 },
  { 203, 7, 12, 8, 0, -12 },
  { 214, 3, 9, 3, 0, -9 },
  { 218, 4, 11, 3, -1, -9 },
  { 224, 7, 7, 8, 1, -9 },
  { 231, 7, 4, 8, 1, -8 },
  { 235, 7, 7, 8, 1, -9 },
  { 242, 5, 12, 6, 1, -12 },
  { 250, 10, 12, 12, 1, -11 },
  { 265, 8, 11, 8, -1, -11 },
  { 276, 8, 11, 8, 0, -11 },
  { 287, 8, 12, 8, 1, -12 },
  { 299, 9, 11, 9, 0, -11 },
  { 312, 8, 11, 7, 0, -11 },
  { 323, 8, 11, 7, 0, -11 },
  { 334, 9, 12, 10, 1, -12 },
  { 348, 10, 11, 10, 0, -11 },
  { 362, 5, 11, 4, 0, -11 },
  { 369, 7, 14, 4, -3, -11 },
  { 382, 9, 11, 8, 0, -11 },
  { 395, 6, 11, 7, 0, -11 },
  { 404, 12, 11, 12, 0, -11 },
  { 421, 10, 11, 10, 0, -11 },
  { 435, 9, 12, 10, 1, -12 },
  { 449, 8, 11, 8, 0, -11 },
  { 460, 9, 15, 10, 1, -12 },
  { 477, 8, 11, 8, 0, -11 },
  { 488, 7, 12, 7, 0, -12 },
  { 499, 7, 11, 7, 1, -11 },
  { 509, 9, 11, 10, 1, -11 },
  { 522, 8, 11, 8, 1, -11 },
  { 533, 11, 11, 12, 2, -11 },
  { 549, 9, 11, 7, -1, -11 },
  { 562, 7, 11, 7, 1, -11 },
  { 572, 8, 11, 7, 0, -11 },
  { 583, 6, 14, 5, 0, -11 },
  { 594, 2, 11, 5, 2, -11 },
  { 597, 6, 14, 5, -1, -11 },
  { 608, 7, 6, 8, 1, -11 },
  { 614, 5, 1, 6, -1, 1 },
  { 615, 2, 2, 4, 2, -12 },
  { 616, 7, 9, 8, 1, -9 },
  { 624, 7, 12, 8, 0, -12 },
  { 635, 6, 9, 6, 1, -9 },
  { 642, 8, 12, 8, 1, -12 },
  { 654, 6, 9, 7, 1, -9 },
  { 661, 8, 16, 4, -2, -12 },
  { 677, 8, 13, 8, 0, -9 },
  { 690, 7, 12, 8, 0, -12 },
  { 701, 4, 12, 3, 0, -12 },
  { 707, 6, 16, 3, -2, -12 },
  { 719, 7, 12, 7, 0, -12 },
  { 730, 4, 12, 3, 0, -12 },
  { 736, 11, 9, 12, 0, -9 },
  { 749, 7, 9, 8, 0, -9 },
  { 757, 6, 9, 8, 1, -9 },
  { 764, 7, 13, 8, 0, -9 },
  { 776, 7, 13, 8, 1, -9 },
  { 788, 6, 9, 5, 0, -9 },
  { 795, 6, 9, 6, 0, -9 },
  { 802, 4, 11, 4, 1, -11 },
  { 808, 7, 9, 8, 1, -9 },
  { 816, 6, 9, 6, 1, -9 },
  { 823, 10, 9, 10, 1, -9 },
  { 835, 8, 9, 7, -1, -9 },
  { 844, 9, 13, 6, -2, -9 },
  { 859, 6, 9, 6, 0, -9 },
  { 866, 6, 14, 5, 0, -11 },
  { 877, 1, 16, 8, 4, -12 },
  { 879, 6, 14, 5, -1, -11 },
  { 890, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC16PT7B_H_
