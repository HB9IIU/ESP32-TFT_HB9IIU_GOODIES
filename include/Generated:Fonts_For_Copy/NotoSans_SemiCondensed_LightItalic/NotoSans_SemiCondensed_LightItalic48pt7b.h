#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x00,
  0x38, 0x73, 0x87, 0x30, 0x63, 0x06, 0x70, 0xE7, 0x0E, 0x60, 0xC6, 0x0C,
  0x60, 0xCE, 0x0C, 0xC1, 0x8C, 0x18, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x01,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x1C, 0x0E, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x00, 0x60, 0x70,
  0x00, 0x30, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80, 0x01, 0xC0,
  0xE0, 0x00, 0x60, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x01, 0x80, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x18, 0x0C, 0x00,
  0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xF0, 0x3C, 0x63, 0x80, 0xE1, 0x80, 0x07, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x60, 0x00,
  0x71, 0x80, 0x01, 0xE6, 0x00, 0x03, 0xD8, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xCE, 0x00, 0x02, 0x1C,
  0x00, 0x18, 0x70, 0x00, 0x60, 0xC0, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x30, 0x70, 0x00, 0xC1, 0xC0, 0x03, 0x0E, 0x0C, 0x0C, 0x70, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0x03, 0xDE, 0x00, 0x70, 0x38, 0x30, 0x03, 0x01,
  0x81, 0x80, 0x30, 0x1C, 0x0C, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x06, 0x03,
  0x01, 0x80, 0x70, 0x18, 0x1C, 0x03, 0x00, 0xC0, 0xC0, 0x18, 0x06, 0x0C,
  0x00, 0xC0, 0x70, 0xE0, 0x06, 0x03, 0x86, 0x00, 0x70, 0x18, 0x70, 0x03,
  0x80, 0xC7, 0x0F, 0x1C, 0x0E, 0x31, 0xFC, 0xE0, 0x63, 0x9C, 0x77, 0x07,
  0x39, 0xC1, 0x98, 0x71, 0x8C, 0x0C, 0xF7, 0x1C, 0xE0, 0x73, 0xF1, 0xC6,
  0x03, 0x86, 0x0C, 0x30, 0x18, 0x00, 0xE3, 0x80, 0xC0, 0x06, 0x1C, 0x06,
  0x00, 0x60, 0xC0, 0x30, 0x07, 0x06, 0x01, 0x80, 0x30, 0x30, 0x1C, 0x03,
  0x01, 0x80, 0xC0, 0x38, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x03,
  0x03, 0x01, 0xC0, 0x18, 0x38, 0x0C, 0x00, 0xC3, 0x80, 0xC0, 0x07, 0xF8,
  0x0E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x03, 0x00,
  0x0E, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x60, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x38, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x06, 0x3C, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xE3, 0x80, 0x71, 0xC1,
  0xC0, 0x31, 0xC0, 0x70, 0x38, 0xC0, 0x18, 0x18, 0xE0, 0x0E, 0x1C, 0x60,
  0x03, 0x8C, 0x70, 0x01, 0xCE, 0x38, 0x00, 0x7E, 0x1C, 0x00, 0x3E, 0x0E,
  0x00, 0x0F, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0xC0, 0xE0, 0x0F, 0x70,
  0x78, 0x1E, 0x38, 0x1F, 0xFE, 0x0E, 0x07, 0xFC, 0x07, 0x80, 0x39, 0xCC,
  0x67, 0x39, 0x8C, 0x63, 0x31, 0x80, 0x00, 0x1E, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x60, 0x60, 0x1E, 0x18, 0x0F, 0xC6, 0x00, 0x3D, 0x07, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3E, 0x00, 0x1D, 0x80, 0x0E, 0x30, 0x07, 0x0C, 0x07, 0x83,
  0x80, 0xC0, 0x60, 0x10, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70,
  0x60, 0xC0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0x81, 0xC0,
  0x38, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xC1, 0xC0, 0x06, 0x0E, 0x00,
  0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x03, 0x1C,
  0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03,
  0x9C, 0x00, 0x1C, 0xC0, 0x00, 0xE6, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x03, 0x9C, 0x00, 0x18, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x70, 0x30, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0x38, 0x3C, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x1E,
  0x07, 0xE0, 0xFE, 0x3C, 0xE7, 0x8C, 0xF1, 0xCC, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xF8, 0x0E, 0x01,
  0x80, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1E, 0x01,
  0xE0, 0x10, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x40, 0x01, 0xC0, 0xF0, 0x0F, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0x60, 0x00,
  0x33, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x30, 0x00, 0x70, 0xC0, 0x01, 0x87,
  0x00, 0x0C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x81, 0x80, 0x1C, 0x0E, 0x00,
  0x60, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x00,
  0x70, 0x18, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x18, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3B, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x08, 0x00, 0xF0, 0x38, 0x07, 0x80, 0xFF, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE3, 0xF8, 0x07, 0x3F, 0xF0, 0x37, 0x83, 0xC3, 0xF0,
  0x0E, 0x1F, 0x00, 0x30, 0xF0, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00, 0x71,
  0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x0F,
  0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x78, 0x1E, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0x70, 0x30, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0x80, 0xC0, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x1C, 0x1C, 0x00, 0x3D, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0xF0, 0x03, 0xE1, 0xE0, 0x1E, 0x03, 0x80, 0xE0, 0x07, 0x03,
  0x80, 0x0E, 0x1C, 0x00, 0x38, 0x60, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0xE0, 0x3C, 0x0F, 0x80, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0x81, 0xE0, 0x38,
  0x07, 0x03, 0x80, 0x1C, 0x18, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x18,
  0xE0, 0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8C, 0x00,
  0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x07, 0x83,
  0x80, 0x6C, 0x1F, 0x1E, 0xE0, 0x7F, 0xE7, 0x00, 0xFC, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x80, 0x78, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x07, 0x07, 0x0F, 0x0F,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF0, 0xE0, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x01, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x30, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x06, 0x07, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x07,
  0x0E, 0x00, 0x78, 0x03, 0x1C, 0x01, 0xFF, 0x03, 0x18, 0x07, 0x8F, 0x03,
  0x38, 0x0E, 0x07, 0x03, 0x30, 0x1C, 0x06, 0x03, 0x30, 0x18, 0x06, 0x03,
  0x70, 0x30, 0x0E, 0x03, 0x60, 0x30, 0x0E, 0x03, 0x60, 0x70, 0x0C, 0x07,
  0x60, 0x60, 0x0C, 0x06, 0xE0, 0x60, 0x1C, 0x06, 0xE0, 0xE0, 0x1C, 0x06,
  0xE0, 0xE0, 0x18, 0x0E, 0xC0, 0xC0, 0x38, 0x0C, 0xC0, 0xE0, 0x38, 0x1C,
  0xC0, 0xE0, 0x78, 0x18, 0xC0, 0xE0, 0xD8, 0x30, 0xE0, 0x71, 0x9C, 0xF0,
  0xE0, 0x3F, 0x0F, 0xC0, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xD8, 0x00,
  0x01, 0x98, 0x00, 0x03, 0x98, 0x00, 0x03, 0x18, 0x00, 0x07, 0x18, 0x00,
  0x06, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x1C, 0x1C, 0x00,
  0x18, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x0C, 0x00,
  0x60, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0x80, 0x0E, 0x03, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x06,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x06, 0x38, 0x00, 0x06, 0x70, 0x00, 0x06, 0x70, 0x00, 0x06, 0xE0,
  0x00, 0x07, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xC0, 0x3E, 0x01,
  0xC0, 0x0E, 0x01, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x38, 0x06, 0x00, 0xF0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0E, 0x03, 0xE0, 0x0C, 0x00, 0x70, 0x1C,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x30, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x03, 0xE0, 0x70,
  0x3F, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xF8, 0x06, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x01, 0x80, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x1C, 0x07, 0xC0, 0x07, 0x00, 0x78, 0x01, 0x80, 0x0F, 0x00, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1,
  0x80, 0x00, 0x70, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0x83, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00,
  0x03, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x38,
  0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xC0, 0x01, 0xE0,
  0x30, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x7C, 0x01, 0xC3, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xE0,
  0x0E, 0x01, 0xE0, 0x00, 0x80, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x4E, 0x00,
  0x3F, 0xE3, 0x80, 0x0F, 0xF8, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x60, 0x70, 0x00, 0x18, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xE0, 0x1F, 0x00, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x06, 0x01, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0C, 0x03, 0x80,
  0x00, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0x80, 0x60, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0xFF, 0x80, 0x3F, 0x80, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x70,
  0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x00, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x1E,
  0x00, 0x01, 0x8F, 0x00, 0x00, 0x67, 0x80, 0x00, 0x3B, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xE6, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0x70, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x60, 0x1C,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01,
  0xC0, 0x03, 0x80, 0x60, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0,
  0x1B, 0x00, 0x00, 0xEC, 0x07, 0x60, 0x00, 0x1F, 0x80, 0xEC, 0x00, 0x07,
  0x70, 0x1D, 0x80, 0x00, 0xEE, 0x03, 0x30, 0x00, 0x39, 0x80, 0x67, 0x00,
  0x06, 0x70, 0x1C, 0xE0, 0x01, 0xCE, 0x03, 0x9C, 0x00, 0x31, 0xC0, 0x73,
  0x80, 0x0E, 0x38, 0x0C, 0x30, 0x01, 0x86, 0x01, 0x86, 0x00, 0x71, 0xC0,
  0x70, 0xC0, 0x0C, 0x38, 0x0E, 0x18, 0x03, 0x87, 0x01, 0x83, 0x00, 0x60,
  0xC0, 0x30, 0x70, 0x1C, 0x18, 0x0E, 0x0E, 0x07, 0x07, 0x01, 0xC1, 0xC0,
  0xE0, 0xE0, 0x38, 0x38, 0x38, 0x1C, 0x06, 0x03, 0x07, 0x03, 0x00, 0xC0,
  0x61, 0xC0, 0xE0, 0x38, 0x0C, 0x30, 0x1C, 0x07, 0x01, 0x8E, 0x03, 0x80,
  0xE0, 0x31, 0x80, 0x70, 0x18, 0x07, 0x70, 0x0C, 0x03, 0x00, 0xEC, 0x03,
  0x80, 0xE0, 0x1F, 0x80, 0x70, 0x1C, 0x03, 0xE0, 0x0E, 0x03, 0x80, 0x3C,
  0x01, 0x80, 0x60, 0x07, 0x00, 0x30, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x0C, 0x03, 0xE0,
  0x00, 0xE0, 0x1F, 0x00, 0x07, 0x01, 0xD8, 0x00, 0x38, 0x0E, 0xE0, 0x01,
  0x80, 0x77, 0x00, 0x0C, 0x03, 0x18, 0x00, 0xE0, 0x18, 0xE0, 0x07, 0x01,
  0xC7, 0x00, 0x38, 0x0E, 0x18, 0x01, 0x80, 0x70, 0xE0, 0x0C, 0x03, 0x07,
  0x00, 0xE0, 0x18, 0x18, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x1C, 0x03, 0x00, 0xE0, 0xE0, 0x38, 0x07, 0x07, 0x01,
  0xC0, 0x38, 0x38, 0x0E, 0x00, 0xC1, 0x80, 0x60, 0x07, 0x1C, 0x03, 0x00,
  0x38, 0xE0, 0x38, 0x00, 0xC7, 0x01, 0xC0, 0x07, 0x30, 0x0E, 0x00, 0x39,
  0x80, 0x60, 0x00, 0xDC, 0x03, 0x00, 0x07, 0xE0, 0x38, 0x00, 0x3F, 0x01,
  0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0x60, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x70,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB8, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E,
  0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x3C, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x07, 0x03, 0xE0, 0x0E, 0x01, 0xE0, 0x18, 0x01, 0xE0,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x06,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xC0,
  0x03, 0x81, 0x80, 0x0E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0xF0, 0x1C, 0x3F,
  0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xC0, 0x78,
  0x03, 0xC0, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0x87, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x07, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x18, 0x01, 0xE0, 0x70, 0x01,
  0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x81,
  0x80, 0x0E, 0x07, 0x00, 0x78, 0x0E, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x01,
  0xC0, 0x0C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x03, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x60, 0x00, 0xE1, 0xC0, 0x01, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x78, 0x07, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x20, 0x01,
  0xE0, 0xF0, 0x1F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x60,
  0x00, 0x1C, 0x18, 0x00, 0x06, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x18, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x30, 0x00, 0x0E, 0x0C,
  0x00, 0x03, 0x07, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C,
  0x18, 0x00, 0x07, 0x0E, 0x00, 0x01, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x1E, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xEC, 0x00, 0x03, 0xB0, 0x00, 0x1C, 0xC0, 0x00, 0x73, 0x80, 0x03, 0x8E,
  0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00,
  0x38, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0x80, 0x38, 0x06, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0x60, 0x1C, 0x01, 0x80, 0xE0, 0x06, 0x03, 0x80, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x30,
  0x00, 0x71, 0xC0, 0x01, 0xC6, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xC0, 0x00,
  0x37, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C,
  0x00, 0x1B, 0x80, 0x07, 0x80, 0x07, 0x70, 0x00, 0xF0, 0x00, 0xEE, 0x00,
  0x3E, 0x00, 0x39, 0xC0, 0x06, 0xC0, 0x07, 0x38, 0x01, 0xD8, 0x01, 0xC7,
  0x00, 0x33, 0x00, 0x38, 0xE0, 0x0E, 0x60, 0x06, 0x1C, 0x01, 0x8C, 0x01,
  0xC3, 0x80, 0x31, 0x80, 0x38, 0x70, 0x0E, 0x30, 0x0E, 0x0E, 0x01, 0x86,
  0x01, 0xC1, 0xC0, 0x70, 0xC0, 0x70, 0x38, 0x0C, 0x18, 0x0E, 0x07, 0x03,
  0x83, 0x01, 0x80, 0xE0, 0x60, 0x60, 0x70, 0x1C, 0x1C, 0x0C, 0x0E, 0x03,
  0x83, 0x81, 0x83, 0x80, 0x70, 0x60, 0x30, 0x70, 0x0E, 0x1C, 0x06, 0x1C,
  0x01, 0xC3, 0x00, 0xC3, 0x80, 0x18, 0xE0, 0x1C, 0x60, 0x03, 0x18, 0x03,
  0x9C, 0x00, 0x67, 0x00, 0x73, 0x00, 0x0C, 0xC0, 0x0E, 0xE0, 0x01, 0xB8,
  0x01, 0xDC, 0x00, 0x37, 0x00, 0x3B, 0x00, 0x06, 0xC0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x38,
  0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x01,
  0x80, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x70,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xD8, 0x00, 0x00, 0x39, 0x80, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0E, 0x0C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x06, 0x00,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3B,
  0x00, 0x03, 0x9C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x18, 0x01,
  0xC0, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x06,
  0x07, 0x00, 0x30, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0,
  0x01, 0x9C, 0x00, 0x0E, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x00, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x70, 0x70, 0x70, 0x30,
  0x30, 0x30, 0x30, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1C, 0x1C,
  0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x07, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xD8, 0x00, 0x0E, 0x60, 0x00,
  0x63, 0x00, 0x07, 0x1C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x38, 0x1C,
  0x01, 0x80, 0x60, 0x1C, 0x03, 0x80, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60,
  0x03, 0x87, 0x00, 0x0C, 0x70, 0x00, 0x63, 0x00, 0x03, 0xB8, 0x00, 0x0D,
  0x80, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0x87, 0x0C, 0x38,
  0x60, 0xC3, 0x00, 0x7C, 0x18, 0x0F, 0xF8, 0xC0, 0xF9, 0xEE, 0x0F, 0x03,
  0x60, 0xE0, 0x0B, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x00, 0x1E, 0x38,
  0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC6, 0x00, 0x0E,
  0x70, 0x00, 0x63, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x07, 0xC1,
  0xC0, 0x6C, 0x0F, 0x0E, 0x60, 0x3F, 0xE3, 0x00, 0xFE, 0x18, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18,
  0x00, 0x01, 0xC3, 0xE0, 0x0E, 0x3F, 0xC0, 0x77, 0x9F, 0x03, 0x70, 0x38,
  0x3B, 0x00, 0xE1, 0xF0, 0x07, 0x0F, 0x00, 0x18, 0x78, 0x00, 0xC3, 0x80,
  0x06, 0x3C, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x1C, 0x60, 0x00, 0xE3,
  0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00,
  0xE3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x6C,
  0x03, 0x87, 0x70, 0x78, 0x31, 0xFF, 0x81, 0x87, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x3E, 0x38, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x30, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x7C, 0x18, 0x01, 0xFF, 0x18, 0x03, 0xE7, 0xB8,
  0x07, 0x01, 0xB8, 0x0E, 0x00, 0xF8, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0x60,
  0x70, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0,
  0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0,
  0xE0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x80, 0x70, 0x1B, 0x80,
  0x78, 0x73, 0x80, 0x3F, 0xE3, 0x00, 0x1F, 0xC3, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xE0, 0x3E, 0x78, 0x1C, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0x71, 0xC0,
  0x1C, 0xE0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0xF1, 0xC1, 0xF8,
  0x7F, 0xF8, 0x3F, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x38, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x86, 0x00, 0xFF, 0x8C,
  0x03, 0xE7, 0x98, 0x0F, 0x03, 0x70, 0x38, 0x03, 0xE0, 0xE0, 0x07, 0x81,
  0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x30, 0x70,
  0x00, 0x60, 0xE0, 0x01, 0xC1, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0, 0xE0, 0x03,
  0xC1, 0xC0, 0x0F, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x7C, 0x07, 0x01, 0xB8,
  0x0F, 0x0E, 0x70, 0x0F, 0xF8, 0xC0, 0x0F, 0xE3, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x01, 0x00, 0x1C, 0x03, 0x80, 0x78, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC3,
  0xF0, 0x0E, 0x7F, 0xC0, 0x77, 0x9F, 0x03, 0x70, 0x38, 0x3F, 0x00, 0xE1,
  0xF0, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x38, 0x00,
  0x61, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x0C,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01, 0x87, 0x00,
  0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x3C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0,
  0x38, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x0E,
  0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x0E, 0x00, 0x38, 0xE0, 0x01,
  0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x6F, 0x80, 0x03, 0xEE, 0x00, 0x3E, 0x70,
  0x01, 0xE1, 0x80, 0x0E, 0x0E, 0x00, 0x60, 0x70, 0x03, 0x01, 0x80, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x60, 0x0E, 0x07, 0x00, 0x70,
  0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38,
  0x0E, 0x03, 0x80, 0x07, 0x0F, 0x80, 0x7C, 0x03, 0x1F, 0xE0, 0xFF, 0x81,
  0x9E, 0x78, 0xF3, 0xC0, 0xD8, 0x1C, 0xE0, 0x70, 0x78, 0x07, 0xC0, 0x38,
  0x78, 0x03, 0xE0, 0x1C, 0x3C, 0x01, 0xE0, 0x0E, 0x1C, 0x00, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0x03, 0x8E, 0x00, 0x30, 0x01, 0xC7, 0x00, 0x38, 0x00,
  0xC3, 0x80, 0x1C, 0x00, 0xE1, 0x80, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x00,
  0x38, 0xE0, 0x03, 0x00, 0x18, 0x70, 0x03, 0x80, 0x0C, 0x38, 0x01, 0xC0,
  0x0E, 0x18, 0x00, 0xE0, 0x07, 0x0C, 0x00, 0x60, 0x03, 0x8E, 0x00, 0x30,
  0x01, 0x87, 0x00, 0x38, 0x00, 0xC3, 0x80, 0x1C, 0x00, 0xE1, 0x80, 0x0E,
  0x00, 0x71, 0xC0, 0x06, 0x00, 0x38, 0xE0, 0x07, 0x00, 0x18, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x07, 0x0F, 0xC0, 0x31, 0xFF, 0x01, 0x9F, 0x7C, 0x0D,
  0xC0, 0xE0, 0xFC, 0x03, 0x87, 0xC0, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x0C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00,
  0xE1, 0x80, 0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xE7, 0xC0, 0x70, 0x1E, 0x0E, 0x00,
  0xE1, 0xC0, 0x06, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x06, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE,
  0x00, 0x1C, 0xE0, 0x03, 0x86, 0x00, 0x70, 0x70, 0x0F, 0x03, 0x81, 0xE0,
  0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x01, 0xC3, 0xE0, 0x03, 0x0F, 0xF0, 0x06,
  0x79, 0xF0, 0x0D, 0xC0, 0xE0, 0x1B, 0x00, 0xE0, 0x7C, 0x01, 0xC0, 0xF0,
  0x01, 0x81, 0xE0, 0x03, 0x03, 0x80, 0x06, 0x0F, 0x00, 0x0C, 0x1C, 0x00,
  0x18, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0x87, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xE0,
  0xF0, 0x01, 0xC1, 0xE0, 0x07, 0x03, 0xC0, 0x1E, 0x06, 0xC0, 0x38, 0x0D,
  0xC1, 0xE0, 0x39, 0xFF, 0x80, 0x71, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x18, 0x0F, 0xF8, 0xC0, 0xF9, 0xE6,
  0x0E, 0x03, 0x70, 0xE0, 0x0F, 0x8E, 0x00, 0x78, 0x70, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x01, 0xC6,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x38, 0xE0, 0x01,
  0xC7, 0x00, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70,
  0x07, 0xC1, 0xC0, 0x6E, 0x0F, 0x0E, 0x70, 0x3F, 0xE3, 0x00, 0xFE, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x0F, 0x83, 0x1F, 0xC1, 0x9F,
  0xC0, 0xDC, 0x00, 0x6C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x78, 0x78, 0x38, 0x02, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x88, 0x01, 0xC3, 0x80, 0xF0, 0xFF, 0xF8, 0x1F, 0xF8,
  0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x7F,
  0xEF, 0xFE, 0x7F, 0xF0, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xFC, 0x0F, 0xE0, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00,
  0x0C, 0x38, 0x00, 0x61, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3,
  0x00, 0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60, 0x01,
  0xC3, 0x00, 0x0C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x60,
  0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78,
  0x70, 0x07, 0x83, 0x80, 0x6C, 0x0E, 0x0E, 0x60, 0x7F, 0xE7, 0x01, 0xFE,
  0x38, 0x00, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x07, 0x30, 0x00, 0xC6,
  0x00, 0x38, 0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x30, 0x70, 0x0E, 0x0E,
  0x01, 0x81, 0xC0, 0x70, 0x38, 0x0C, 0x03, 0x03, 0x80, 0x60, 0x60, 0x0C,
  0x1C, 0x01, 0x87, 0x00, 0x30, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C,
  0xC0, 0x03, 0xB8, 0x00, 0x76, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0x78, 0x03, 0xB0,
  0x03, 0xC0, 0x1D, 0x80, 0x3E, 0x00, 0xCC, 0x01, 0xB0, 0x0E, 0x60, 0x1D,
  0x80, 0x63, 0x80, 0xCC, 0x07, 0x1C, 0x06, 0x60, 0x30, 0xE0, 0x63, 0x03,
  0x87, 0x03, 0x18, 0x1C, 0x38, 0x38, 0xC1, 0xC1, 0xC1, 0x86, 0x0E, 0x0E,
  0x1C, 0x30, 0x60, 0x70, 0xC1, 0x87, 0x03, 0x8E, 0x0C, 0x30, 0x1C, 0x60,
  0x63, 0x80, 0xE7, 0x03, 0x18, 0x07, 0x30, 0x19, 0xC0, 0x3B, 0x80, 0xCE,
  0x01, 0xD8, 0x06, 0x60, 0x0E, 0xC0, 0x37, 0x00, 0x7E, 0x01, 0xB0, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x06, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x18, 0x1C, 0x00, 0x38, 0x70, 0x00,
  0x70, 0xE0, 0x00, 0x63, 0x80, 0x00, 0xEE, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x76,
  0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x18, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0x60, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x70, 0x01, 0xC1, 0xE0, 0x03, 0x80, 0x00, 0xC0, 0x01, 0xC0, 0x38, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x60, 0x1C, 0x00,
  0x18, 0x07, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x31,
  0xC0, 0x00, 0x0C, 0x70, 0x00, 0x03, 0x38, 0x00, 0x00, 0xCE, 0x00, 0x00,
  0x37, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0,
  0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x20, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFC, 0x01, 0xFF,
  0xF0, 0x3C, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x30,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 34, 11, 1, -34 },
  { 48, 12, 12, 16, 5, -34 },
  { 66, 26, 34, 26, 1, -34 },
  { 177, 22, 39, 23, 1, -36 },
  { 285, 29, 36, 34, 3, -35 },
  { 416, 25, 35, 27, 1, -35 },
  { 526, 5, 12, 9, 5, -34 },
  { 534, 15, 42, 12, 1, -34 },
  { 613, 14, 42, 12, -3, -34 },
  { 687, 18, 18, 22, 5, -36 },
  { 728, 20, 22, 25, 3, -28 },
  { 783, 8, 11, 10, -2, -5 },
  { 794, 12, 2, 14, 1, -14 },
  { 797, 4, 4, 10, 1, -4 },
  { 799, 21, 34, 16, -2, -34 },
  { 889, 21, 35, 23, 2, -35 },
  { 981, 12, 34, 23, 7, -34 },
  { 1032, 22, 35, 23, 0, -35 },
  { 1129, 23, 35, 23, 0, -35 },
  { 1230, 22, 34, 23, 0, -34 },
  { 1324, 22, 34, 23, 1, -34 },
  { 1418, 21, 35, 23, 2, -35 },
  { 1510, 20, 34, 23, 4, -34 },
  { 1595, 22, 35, 23, 1, -35 },
  { 1692, 21, 35, 23, 1, -35 },
  { 1784, 8, 26, 10, 1, -26 },
  { 1810, 11, 32, 10, -2, -26 },
  { 1854, 20, 22, 25, 3, -28 },
  { 1909, 20, 12, 25, 3, -23 },
  { 1939, 20, 22, 25, 3, -28 },
  { 1994, 16, 35, 17, 3, -35 },
  { 2064, 32, 38, 35, 2, -34 },
  { 2216, 24, 34, 23, -3, -34 },
  { 2318, 24, 34, 25, 1, -34 },
  { 2420, 24, 35, 24, 3, -35 },
  { 2525, 26, 34, 28, 1, -34 },
  { 2636, 23, 34, 22, 1, -34 },
  { 2734, 23, 34, 20, 1, -34 },
  { 2832, 26, 35, 29, 3, -35 },
  { 2946, 28, 34, 29, 1, -34 },
  { 3065, 17, 34, 13, -1, -34 },
  { 3138, 18, 43, 11, -7, -34 },
  { 3235, 26, 34, 23, 1, -34 },
  { 3346, 16, 34, 20, 1, -34 },
  { 3414, 35, 34, 36, 1, -34 },
  { 3563, 29, 34, 30, 1, -34 },
  { 3687, 26, 35, 30, 3, -35 },
  { 3801, 23, 34, 24, 1, -34 },
  { 3899, 26, 43, 30, 3, -35 },
  { 4039, 23, 34, 24, 1, -34 },
  { 4137, 22, 35, 22, 0, -35 },
  { 4234, 21, 34, 21, 4, -34 },
  { 4324, 26, 34, 29, 3, -34 },
  { 4435, 22, 34, 23, 5, -34 },
  { 4529, 35, 34, 37, 5, -34 },
  { 4678, 28, 34, 21, -3, -34 },
  { 4797, 21, 34, 21, 4, -34 },
  { 4887, 25, 34, 22, -1, -34 },
  { 4994, 18, 42, 14, -1, -34 },
  { 5089, 8, 34, 16, 5, -34 },
  { 5123, 18, 42, 14, -3, -34 },
  { 5218, 21, 20, 24, 2, -34 },
  { 5271, 17, 2, 17, -4, 5 },
  { 5276, 6, 8, 12, 7, -37 },
  { 5282, 21, 26, 24, 2, -26 },
  { 5351, 21, 36, 24, 1, -36 },
  { 5446, 18, 26, 19, 2, -26 },
  { 5505, 24, 36, 24, 2, -36 },
  { 5613, 18, 26, 21, 2, -26 },
  { 5672, 25, 49, 12, -6, -37 },
  { 5826, 23, 38, 24, 0, -26 },
  { 5936, 21, 36, 24, 1, -36 },
  { 6031, 10, 35, 10, 1, -35 },
  { 6075, 17, 47, 10, -6, -35 },
  { 6175, 21, 36, 20, 1, -36 },
  { 6270, 10, 36, 10, 1, -36 },
  { 6315, 33, 26, 36, 1, -26 },
  { 6423, 21, 26, 24, 1, -26 },
  { 6492, 20, 26, 24, 2, -26 },
  { 6557, 23, 37, 24, -1, -26 },
  { 6664, 21, 37, 24, 2, -26 },
  { 6762, 17, 26, 16, 1, -26 },
  { 6818, 18, 26, 18, 0, -26 },
  { 6877, 13, 32, 13, 2, -32 },
  { 6929, 21, 26, 24, 2, -26 },
  { 6998, 19, 26, 19, 2, -26 },
  { 7060, 29, 26, 30, 3, -26 },
  { 7155, 23, 26, 20, -2, -26 },
  { 7230, 26, 38, 19, -5, -26 },
  { 7354, 19, 26, 18, -1, -26 },
  { 7416, 18, 42, 16, 1, -34 },
  { 7511, 2, 49, 23, 11, -37 },
  { 7524, 17, 42, 16, -2, -34 },
  { 7614, 20, 6, 25, 3, -20 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC48PT7B_H_
