#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x83,
  0x06, 0x08, 0x10, 0x60, 0x00, 0x00, 0x0C, 0x18, 0x30, 0x00, 0x33, 0x23,
  0x63, 0x63, 0x62, 0x42, 0x46, 0xC6, 0x00, 0x82, 0x00, 0xC3, 0x00, 0x61,
  0x80, 0x20, 0x80, 0x10, 0x40, 0x18, 0x60, 0x08, 0x20, 0x7F, 0xFF, 0x06,
  0x18, 0x03, 0x0C, 0x01, 0x04, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x41, 0x03,
  0xFF, 0xF9, 0xFF, 0xFC, 0x10, 0x40, 0x08, 0x20, 0x0C, 0x30, 0x06, 0x18,
  0x02, 0x08, 0x01, 0x0C, 0x01, 0x86, 0x00, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x01, 0xFF, 0x0C, 0xCC, 0x62, 0x01, 0x08, 0x04, 0x20, 0x11, 0x80, 0x64,
  0x01, 0xD0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x26, 0x00, 0x8C, 0x02,
  0x30, 0x18, 0xC0, 0x63, 0x01, 0x18, 0xC4, 0xC3, 0xFE, 0x00, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x0F, 0x00, 0xC3, 0x30, 0x30, 0xC6, 0x04,
  0x10, 0xC1, 0x86, 0x18, 0x60, 0x83, 0x08, 0x10, 0x63, 0x06, 0x08, 0xC0,
  0xC1, 0x10, 0x18, 0x66, 0x7B, 0x0C, 0x9B, 0xE3, 0x36, 0x36, 0xCC, 0x86,
  0xF1, 0x30, 0xC0, 0x66, 0x18, 0x18, 0x83, 0x02, 0x10, 0x60, 0xC6, 0x08,
  0x30, 0xC3, 0x04, 0x18, 0x61, 0x83, 0x08, 0x60, 0x33, 0x18, 0x07, 0xC0,
  0x01, 0xF0, 0x03, 0x38, 0x06, 0x18, 0x04, 0x08, 0x0C, 0x08, 0x0C, 0x18,
  0x0C, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x07, 0xC0, 0x07, 0x00, 0x0F, 0x00,
  0x19, 0x83, 0x31, 0x83, 0x60, 0xC2, 0xC0, 0xC6, 0xC0, 0x6C, 0xC0, 0x3C,
  0x80, 0x38, 0xC0, 0x38, 0xC0, 0x78, 0x73, 0xCC, 0x3F, 0x0E, 0x32, 0x66,
  0x64, 0x4C, 0x01, 0xC0, 0x40, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x18, 0x06, 0x00,
  0xC0, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80,
  0x40, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0xC0,
  0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x00, 0x02, 0x00, 0x20,
  0x86, 0x0C, 0x60, 0x74, 0x01, 0xFF, 0x0C, 0x01, 0xA0, 0x32, 0x0E, 0x30,
  0x41, 0x00, 0x18, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x19, 0x8C, 0x66, 0x33, 0x10, 0xFE, 0xFC, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0xF0, 0x1E, 0xE0, 0xE1, 0x83, 0x03, 0x18,
  0x0C, 0x60, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0D, 0x80, 0x36, 0x00, 0xD8,
  0x03, 0x60, 0x19, 0x00, 0x64, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00, 0xC4,
  0x06, 0x18, 0x18, 0x60, 0xC0, 0xC6, 0x01, 0xF0, 0x00, 0x03, 0x07, 0x1F,
  0x3B, 0xE2, 0x46, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x01, 0xF8, 0x1F, 0x78,
  0x10, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0x78, 0x30, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x70, 0x1F,
  0x80, 0x3E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x88, 0x07, 0x1E, 0x3C, 0x1F, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x50, 0x01, 0xE0, 0x06, 0xC0, 0x19, 0x80,
  0x32, 0x00, 0xC4, 0x03, 0x18, 0x0C, 0x30, 0x10, 0x60, 0x60, 0x81, 0x83,
  0x06, 0x06, 0x18, 0x0C, 0x20, 0x18, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x10, 0x00,
  0xFE, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x80, 0xE3, 0x8F, 0x0F, 0xF0,
  0x00, 0x00, 0xFC, 0x0F, 0x20, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x01, 0xBF, 0x0D, 0xCE, 0x3C, 0x18, 0xE0, 0x33,
  0x00, 0xCC, 0x03, 0x20, 0x0C, 0x80, 0x32, 0x00, 0x88, 0x06, 0x30, 0x18,
  0xC0, 0xC1, 0xCE, 0x03, 0xF0, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x03,
  0xF0, 0x1C, 0xE0, 0xC0, 0xC2, 0x03, 0x18, 0x04, 0x60, 0x31, 0x80, 0xC6,
  0x02, 0x0C, 0x18, 0x19, 0xC0, 0x3C, 0x01, 0xE0, 0x1C, 0xE0, 0xC1, 0x86,
  0x03, 0x30, 0x0C, 0xC0, 0x13, 0x00, 0x4C, 0x03, 0x30, 0x0C, 0xC0, 0x61,
  0xC7, 0x83, 0xF8, 0x00, 0x03, 0xE0, 0x1D, 0xC0, 0xC1, 0x86, 0x02, 0x30,
  0x0C, 0xC0, 0x33, 0x00, 0xC8, 0x03, 0x20, 0x0C, 0x80, 0x73, 0x01, 0x8C,
  0x0E, 0x38, 0xF8, 0x7E, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x82, 0x1C, 0x0F, 0xE0, 0x00, 0x19, 0xC6, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x18, 0xC0, 0x03, 0x03, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x18,
  0x10, 0x30, 0x20, 0x60, 0xC0, 0x00, 0x08, 0x00, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x9E, 0xF4, 0x0C,
  0x01, 0x00, 0x40, 0x10, 0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x0C,
  0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x80, 0x18, 0x07, 0x01, 0xC0, 0x04,
  0x04, 0x00, 0x18, 0x30, 0x00, 0x21, 0x80, 0x00, 0xC4, 0x0F, 0xC3, 0x30,
  0x61, 0x0C, 0x83, 0x0C, 0x36, 0x18, 0x30, 0xD8, 0x40, 0x83, 0x43, 0x06,
  0x09, 0x0C, 0x18, 0x2C, 0x20, 0x61, 0xB0, 0x83, 0x04, 0xC2, 0x0C, 0x33,
  0x0C, 0x59, 0x84, 0x1E, 0x7C, 0x10, 0x20, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x24, 0x00,
  0x64, 0x00, 0x44, 0x00, 0xC4, 0x01, 0x84, 0x01, 0x86, 0x03, 0x06, 0x03,
  0x06, 0x06, 0x06, 0x07, 0xFE, 0x0F, 0xFE, 0x0C, 0x06, 0x18, 0x06, 0x18,
  0x06, 0x30, 0x02, 0x30, 0x02, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0x07,
  0xF0, 0x0F, 0xFC, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x03, 0x08, 0x03, 0x18,
  0x02, 0x18, 0x06, 0x18, 0x06, 0x18, 0x1C, 0x1F, 0xF0, 0x3F, 0xF0, 0x30,
  0x18, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x18, 0x40, 0x18, 0xC0, 0x30, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0xFE, 0x03,
  0xEF, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x3C, 0x60, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xFE, 0x03,
  0x03, 0x81, 0x80, 0xE0, 0xC0, 0x30, 0x40, 0x0C, 0x60, 0x06, 0x30, 0x03,
  0x18, 0x01, 0x8C, 0x00, 0xC4, 0x00, 0x66, 0x00, 0x33, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x18, 0x07, 0x08,
  0x07, 0x0C, 0x07, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x7F, 0xC1, 0xFF, 0x83, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x1F,
  0xF8, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0xFF, 0x83, 0xFF, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFF, 0x01, 0xF7, 0xC1, 0xC0, 0x21, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x0F, 0xEC, 0x07, 0xF6, 0x00, 0x33, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0x60, 0x02, 0x30, 0x03, 0x0C, 0x01, 0x87, 0x00, 0xC1, 0xE1, 0xE0, 0x3F,
  0xC0, 0x06, 0x00, 0x43, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x00,
  0x82, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x41,
  0xFF, 0xF0, 0xFF, 0xFC, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x20, 0x80,
  0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x0C,
  0x30, 0x03, 0x0C, 0x00, 0xC0, 0x07, 0xE0, 0x70, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x3F,
  0x80, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x81, 0xF8, 0x0F, 0x00,
  0x00, 0x06, 0x01, 0x86, 0x01, 0x83, 0x01, 0x81, 0x81, 0x80, 0xC1, 0x80,
  0x41, 0x80, 0x61, 0x80, 0x31, 0x80, 0x19, 0x80, 0x0D, 0xC0, 0x05, 0xC0,
  0x06, 0xA0, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0x60,
  0xC0, 0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x03, 0x06, 0x01, 0x83,
  0x00, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0x06, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xA0, 0xF0, 0x03, 0xC1, 0x60, 0x0D,
  0x86, 0xC0, 0x1B, 0x0D, 0x80, 0x66, 0x19, 0x00, 0xC8, 0x32, 0x03, 0x30,
  0x44, 0x06, 0x61, 0x8C, 0x18, 0xC3, 0x18, 0x31, 0x86, 0x30, 0xC2, 0x08,
  0x61, 0x0C, 0x30, 0xC6, 0x18, 0x60, 0x88, 0x30, 0xC1, 0x30, 0x41, 0x82,
  0x41, 0x82, 0x05, 0x83, 0x0C, 0x0E, 0x06, 0x18, 0x1C, 0x0C, 0x30, 0x30,
  0x30, 0x00, 0x06, 0x00, 0x61, 0xC0, 0x0C, 0x38, 0x01, 0x07, 0x80, 0x60,
  0xF0, 0x0C, 0x12, 0x01, 0x86, 0x60, 0x30, 0xCC, 0x04, 0x18, 0x81, 0x83,
  0x18, 0x30, 0x43, 0x06, 0x18, 0x20, 0xC3, 0x06, 0x10, 0x60, 0xC6, 0x08,
  0x18, 0xC3, 0x01, 0x98, 0x60, 0x32, 0x0C, 0x06, 0x41, 0x80, 0x78, 0x20,
  0x0F, 0x0C, 0x01, 0xE1, 0x80, 0x18, 0x30, 0x03, 0x00, 0x01, 0xFC, 0x01,
  0xEF, 0x03, 0x81, 0xC1, 0x80, 0x61, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06,
  0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x03, 0x0C, 0x03, 0x87, 0x03, 0x81, 0xE7, 0x80, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0xF0, 0x30, 0x30, 0x60, 0x30, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x8C,
  0x03, 0x18, 0x06, 0x30, 0x18, 0x40, 0x71, 0x81, 0xC3, 0xFE, 0x07, 0xE0,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xEF, 0x03, 0x81,
  0xC1, 0x80, 0x61, 0x80, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1B,
  0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03, 0x0C, 0x01,
  0x87, 0x03, 0x81, 0xE7, 0x80, 0x7F, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x30, 0x30,
  0x60, 0x30, 0xC0, 0x61, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x06, 0x30,
  0x18, 0x40, 0x61, 0x87, 0x83, 0xFC, 0x06, 0x18, 0x0C, 0x30, 0x30, 0x60,
  0x60, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x01, 0x0C, 0x03, 0x18, 0x06, 0x30,
  0x0E, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x38, 0x08, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20,
  0x00, 0xC0, 0x01, 0x88, 0x06, 0x1E, 0x78, 0x3F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x18, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06, 0x10, 0x01, 0x8C,
  0x00, 0x43, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x08, 0x00, 0xC6, 0x00,
  0x61, 0x80, 0x18, 0x60, 0x06, 0x18, 0x01, 0x84, 0x00, 0x43, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01, 0x83, 0x00, 0x60, 0x60, 0x30, 0x1E,
  0x38, 0x03, 0xFC, 0x00, 0xC0, 0x07, 0x80, 0x1B, 0x00, 0x36, 0x00, 0xCC,
  0x01, 0x98, 0x06, 0x30, 0x0C, 0x20, 0x30, 0x40, 0x60, 0x81, 0x81, 0x83,
  0x03, 0x04, 0x06, 0x18, 0x0C, 0x20, 0x18, 0xC0, 0x31, 0x00, 0x66, 0x00,
  0xC8, 0x01, 0xB0, 0x03, 0x40, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x18, 0x03, 0xC0, 0x18, 0x06, 0xC0, 0x38, 0x06, 0xC0, 0x28, 0x0C,
  0xC0, 0x68, 0x0C, 0xC0, 0x68, 0x08, 0xC0, 0xC8, 0x18, 0x40, 0xC8, 0x18,
  0x41, 0x88, 0x30, 0x41, 0x88, 0x30, 0x41, 0x08, 0x60, 0x43, 0x08, 0x60,
  0x42, 0x08, 0x40, 0x46, 0x08, 0xC0, 0x46, 0x08, 0xC0, 0x4C, 0x09, 0x80,
  0x4C, 0x09, 0x80, 0x48, 0x09, 0x00, 0x58, 0x0B, 0x00, 0x50, 0x0A, 0x00,
  0x70, 0x0E, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x00, 0xE0,
  0x60, 0x18, 0x0C, 0x06, 0x00, 0x81, 0x80, 0x18, 0x30, 0x03, 0x0C, 0x00,
  0x63, 0x00, 0x06, 0x40, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x40, 0x00, 0xCC, 0x00, 0x11, 0x80, 0x06,
  0x10, 0x01, 0x83, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x03, 0x00, 0x80, 0xC0,
  0x18, 0x38, 0x03, 0x00, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0x10, 0x0C, 0x60,
  0x61, 0x83, 0x06, 0x0C, 0x18, 0x60, 0x21, 0x00, 0xCC, 0x03, 0x60, 0x0D,
  0x80, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x07, 0xF0,
  0x7E, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xC0, 0xC2, 0x10, 0x86, 0x31, 0x8C, 0x21, 0x0C, 0x63,
  0x18, 0xC2, 0x10, 0xC6, 0x31, 0x84, 0x20, 0x03, 0xF0, 0x7E, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x0F,
  0xC0, 0x00, 0x80, 0x07, 0x00, 0x3C, 0x00, 0x90, 0x06, 0x60, 0x11, 0x80,
  0xC2, 0x06, 0x0C, 0x18, 0x10, 0xC0, 0x63, 0x01, 0x98, 0x02, 0xC0, 0x0C,
  0xFF, 0xF0, 0xC4, 0x62, 0x10, 0x07, 0xE4, 0x38, 0x91, 0x81, 0xCE, 0x07,
  0x30, 0x19, 0x80, 0x66, 0x01, 0x98, 0x06, 0x40, 0x1B, 0x00, 0x4C, 0x03,
  0x30, 0x0C, 0xC0, 0x73, 0x01, 0xC6, 0x0A, 0x1C, 0xC8, 0x3E, 0x60, 0x06,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06,
  0x7C, 0x1B, 0x38, 0x50, 0x73, 0x80, 0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x32,
  0x00, 0xD8, 0x03, 0x60, 0x09, 0x80, 0x66, 0x01, 0x98, 0x0C, 0xE0, 0x33,
  0x81, 0x89, 0x9C, 0x27, 0xE0, 0x07, 0xF0, 0xE3, 0x18, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x08, 0x1F, 0x80, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x07, 0xE4, 0x0E,
  0x34, 0x18, 0x1C, 0x38, 0x1C, 0x30, 0x0C, 0x60, 0x18, 0x60, 0x18, 0x60,
  0x18, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0,
  0x70, 0x60, 0xB0, 0x73, 0x20, 0x3E, 0x20, 0x07, 0xE0, 0xE3, 0x18, 0x33,
  0x01, 0x30, 0x36, 0x03, 0x60, 0x66, 0x7C, 0x7F, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x0C, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x03,
  0xFC, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x03, 0xF3, 0x07, 0x1A, 0x0C, 0x0E, 0x1C, 0x0E, 0x18, 0x06, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x18, 0x60,
  0x18, 0x60, 0x38, 0x60, 0x38, 0x30, 0x58, 0x39, 0x90, 0x1F, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xE0, 0x81, 0xC0, 0xFF,
  0x80, 0x1E, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x3E, 0x1B, 0x38, 0xA0, 0xCE, 0x02, 0x70, 0x13, 0x01,
  0x98, 0x0C, 0x80, 0x6C, 0x03, 0x60, 0x13, 0x01, 0x98, 0x0C, 0x80, 0x6C,
  0x03, 0x60, 0x13, 0x01, 0x98, 0x0C, 0x0C, 0x30, 0x40, 0x00, 0x01, 0x86,
  0x10, 0xC3, 0x0C, 0x30, 0x86, 0x18, 0x61, 0x84, 0x30, 0xC3, 0x0C, 0x00,
  0x00, 0x60, 0x0C, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x04, 0x01, 0x81, 0xE0, 0x38, 0x00, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x03, 0x18, 0x30, 0x83, 0x0C,
  0x30, 0x63, 0x03, 0x30, 0x1B, 0x00, 0xB8, 0x0F, 0xC0, 0x73, 0x03, 0x18,
  0x18, 0x40, 0x83, 0x0C, 0x18, 0x60, 0x63, 0x03, 0x18, 0x18, 0x06, 0x18,
  0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06, 0x08, 0x30,
  0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x19, 0xF1, 0xF8, 0x4C, 0xCE,
  0x61, 0x41, 0xE0, 0xCE, 0x07, 0x03, 0x38, 0x18, 0x0C, 0xC0, 0x60, 0x23,
  0x01, 0x81, 0x88, 0x0C, 0x06, 0x60, 0x30, 0x19, 0x80, 0xC0, 0x66, 0x03,
  0x01, 0x18, 0x08, 0x0C, 0x40, 0x60, 0x33, 0x01, 0x80, 0xCC, 0x06, 0x03,
  0x30, 0x18, 0x08, 0xC0, 0xC0, 0x60, 0x19, 0xF0, 0x4C, 0xE1, 0x41, 0x8E,
  0x03, 0x38, 0x08, 0xC0, 0x63, 0x01, 0x88, 0x06, 0x60, 0x19, 0x80, 0x46,
  0x03, 0x18, 0x0C, 0x40, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x18, 0xC0, 0x60,
  0x07, 0xE0, 0x38, 0xC1, 0x81, 0x8C, 0x06, 0x30, 0x0D, 0x80, 0x36, 0x00,
  0xD8, 0x02, 0x40, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x31, 0x00,
  0xC6, 0x06, 0x1C, 0x70, 0x1F, 0x80, 0x06, 0x7C, 0x04, 0xCE, 0x05, 0x03,
  0x0F, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03,
  0x18, 0x02, 0x18, 0x06, 0x18, 0x06, 0x18, 0x0C, 0x38, 0x0C, 0x38, 0x18,
  0x36, 0x70, 0x37, 0xE0, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xE6, 0x1C, 0x68, 0x60, 0x71,
  0xC0, 0xE3, 0x01, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x40, 0x19, 0x80,
  0x33, 0x00, 0xC6, 0x01, 0x8C, 0x07, 0x18, 0x0E, 0x18, 0x2C, 0x39, 0x90,
  0x3E, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x19, 0xE2, 0x64, 0x50, 0x1C, 0x03, 0x80,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0xF1, 0xC2, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xCC, 0x38, 0xFF, 0x00, 0x0C, 0x04, 0x02, 0x03, 0x07,
  0xF8, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x30, 0x1C, 0x87, 0xC0, 0x18, 0x0C, 0x60, 0x31, 0x00,
  0xCC, 0x03, 0x30, 0x08, 0xC0, 0x62, 0x01, 0x98, 0x06, 0x60, 0x11, 0x80,
  0xC6, 0x03, 0x10, 0x0C, 0xC0, 0x73, 0x01, 0x8C, 0x0A, 0x18, 0xD8, 0x3E,
  0x60, 0x80, 0x3C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8C,
  0x30, 0xC3, 0x04, 0x60, 0x46, 0x04, 0xC0, 0x4C, 0x07, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x00, 0xC0, 0xC0, 0x78, 0x18, 0x0B, 0x07, 0x03, 0x60, 0xB0,
  0x6C, 0x36, 0x19, 0x86, 0xC3, 0x30, 0x98, 0xC6, 0x33, 0x18, 0xC4, 0x62,
  0x19, 0x8C, 0xC3, 0x21, 0x90, 0x6C, 0x36, 0x0D, 0x06, 0xC1, 0xE0, 0xF0,
  0x38, 0x1E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x00, 0x0C, 0x06, 0x18, 0x18,
  0x10, 0x60, 0x31, 0x80, 0x63, 0x00, 0x4C, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1A, 0x00, 0x66, 0x01, 0x8C, 0x06, 0x08, 0x0C, 0x18,
  0x30, 0x30, 0xC0, 0x30, 0x06, 0x01, 0x83, 0x00, 0x81, 0x80, 0xC0, 0xC0,
  0x40, 0x60, 0x60, 0x30, 0x60, 0x08, 0x30, 0x04, 0x30, 0x02, 0x18, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1A, 0x00, 0x0F, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x01, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0xFF, 0xC0, 0x00, 0x60, 0x3C, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x81, 0xE0, 0x38, 0x01, 0x80,
  0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0xF0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x00, 0x80, 0x0F, 0x00, 0xF0,
  0x18, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0xC0, 0x78, 0x0F, 0x00, 0x7C, 0x0F, 0xF8, 0x60, 0x7E,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 23, 7, 1, -23 },
  { 22, 8, 8, 11, 3, -23 },
  { 30, 17, 23, 17, 1, -23 },
  { 79, 14, 26, 15, 1, -24 },
  { 125, 19, 23, 22, 2, -23 },
  { 180, 16, 23, 18, 1, -23 },
  { 226, 4, 8, 6, 3, -23 },
  { 230, 10, 28, 8, 1, -23 },
  { 265, 9, 28, 8, -2, -23 },
  { 297, 12, 12, 15, 4, -24 },
  { 315, 13, 15, 16, 2, -19 },
  { 340, 5, 8, 7, -1, -4 },
  { 345, 7, 1, 9, 1, -9 },
  { 346, 2, 3, 7, 1, -3 },
  { 347, 14, 23, 10, -1, -23 },
  { 388, 14, 23, 15, 1, -23 },
  { 429, 8, 23, 15, 4, -23 },
  { 452, 15, 23, 15, 0, -23 },
  { 496, 15, 23, 15, 0, -23 },
  { 540, 15, 23, 15, 0, -23 },
  { 584, 14, 23, 15, 1, -23 },
  { 625, 14, 23, 15, 2, -23 },
  { 666, 14, 23, 15, 2, -23 },
  { 707, 14, 23, 15, 1, -23 },
  { 748, 14, 23, 15, 1, -23 },
  { 789, 5, 17, 7, 1, -17 },
  { 800, 8, 21, 7, -2, -17 },
  { 821, 13, 15, 16, 2, -19 },
  { 846, 13, 8, 16, 2, -15 },
  { 859, 13, 15, 16, 2, -19 },
  { 884, 10, 23, 12, 2, -23 },
  { 913, 22, 26, 23, 1, -23 },
  { 985, 16, 23, 16, -2, -23 },
  { 1031, 16, 23, 17, 1, -23 },
  { 1077, 16, 23, 16, 2, -23 },
  { 1123, 17, 23, 19, 1, -23 },
  { 1172, 15, 23, 15, 1, -23 },
  { 1216, 15, 23, 14, 1, -23 },
  { 1260, 17, 23, 19, 2, -23 },
  { 1309, 18, 23, 19, 1, -23 },
  { 1361, 11, 23, 9, -1, -23 },
  { 1393, 13, 29, 7, -5, -23 },
  { 1441, 17, 23, 16, 1, -23 },
  { 1490, 10, 23, 14, 1, -23 },
  { 1519, 23, 23, 24, 1, -23 },
  { 1586, 19, 23, 20, 1, -23 },
  { 1641, 17, 23, 20, 2, -23 },
  { 1690, 15, 23, 16, 1, -23 },
  { 1734, 17, 28, 20, 2, -23 },
  { 1794, 15, 23, 16, 1, -23 },
  { 1838, 15, 23, 14, 0, -23 },
  { 1882, 13, 23, 14, 3, -23 },
  { 1920, 18, 23, 19, 2, -23 },
  { 1972, 15, 23, 15, 3, -23 },
  { 2016, 24, 23, 24, 3, -23 },
  { 2085, 19, 23, 14, -2, -23 },
  { 2140, 14, 23, 14, 3, -23 },
  { 2181, 17, 23, 15, -1, -23 },
  { 2230, 12, 28, 9, 0, -23 },
  { 2272, 5, 23, 11, 3, -23 },
  { 2287, 12, 28, 9, -2, -23 },
  { 2329, 14, 13, 16, 1, -23 },
  { 2352, 12, 1, 11, -3, 3 },
  { 2354, 4, 5, 8, 5, -24 },
  { 2357, 14, 17, 16, 1, -17 },
  { 2387, 14, 24, 16, 1, -24 },
  { 2429, 12, 17, 13, 1, -17 },
  { 2455, 16, 24, 16, 1, -24 },
  { 2503, 12, 17, 14, 1, -17 },
  { 2529, 16, 32, 8, -4, -24 },
  { 2593, 16, 25, 16, 0, -17 },
  { 2643, 13, 24, 16, 1, -24 },
  { 2682, 6, 23, 7, 1, -23 },
  { 2700, 11, 31, 7, -4, -23 },
  { 2743, 13, 24, 13, 1, -24 },
  { 2782, 7, 24, 7, 1, -24 },
  { 2803, 22, 17, 24, 1, -17 },
  { 2850, 14, 17, 16, 1, -17 },
  { 2880, 14, 17, 16, 1, -17 },
  { 2910, 16, 24, 16, -1, -17 },
  { 2958, 15, 25, 16, 1, -17 },
  { 3005, 11, 17, 11, 1, -17 },
  { 3029, 12, 17, 12, 0, -17 },
  { 3055, 9, 21, 9, 1, -21 },
  { 3079, 14, 17, 16, 1, -17 },
  { 3109, 12, 17, 12, 2, -17 },
  { 3135, 19, 17, 20, 2, -17 },
  { 3176, 15, 17, 13, -1, -17 },
  { 3208, 17, 25, 13, -3, -17 },
  { 3262, 13, 17, 12, -1, -17 },
  { 3290, 11, 28, 11, 1, -23 },
  { 3329, 2, 32, 15, 7, -24 },
  { 3337, 12, 28, 11, -2, -23 },
  { 3379, 13, 3, 16, 2, -13 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC32PT7B_H_
