#ifndef _NOTOSANS_SEMICONDENSED_LIGHTITALIC42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_LIGHTITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-LightItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_LightItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x1C, 0x0E, 0x07, 0x00, 0x38,
  0xE6, 0x1C, 0xC3, 0x18, 0x67, 0x0C, 0xC3, 0x98, 0x63, 0x0C, 0x61, 0x88,
  0x33, 0x04, 0x00, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00,
  0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x30,
  0x30, 0x00, 0xC0, 0xC0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x60, 0x60,
  0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF0, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x02, 0x00, 0x18, 0x18, 0x00,
  0x60, 0x60, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0xC0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xC6, 0x10, 0x70, 0xC0, 0x0C, 0x10, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x06, 0x18, 0x00, 0xC2, 0x00, 0x1C, 0x40, 0x01,
  0xD8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0x70, 0x00,
  0x67, 0x00, 0x0C, 0x70, 0x01, 0x86, 0x00, 0x20, 0xC0, 0x0C, 0x18, 0x01,
  0x87, 0x00, 0x30, 0xC2, 0x06, 0x38, 0x70, 0x9E, 0x0F, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0xC0, 0x06, 0x0F, 0xF0, 0x06, 0x06, 0x18, 0x07, 0x06, 0x0C, 0x03, 0x03,
  0x06, 0x03, 0x03, 0x03, 0x03, 0x81, 0x81, 0x81, 0x80, 0xC0, 0xC1, 0x80,
  0xC0, 0x61, 0xC0, 0x60, 0x30, 0xC0, 0x30, 0x18, 0xC0, 0x18, 0x18, 0xE0,
  0x0C, 0x0C, 0x63, 0xE6, 0x0E, 0x63, 0xFB, 0x06, 0x33, 0x0D, 0x87, 0x33,
  0x87, 0x7F, 0x31, 0x81, 0xBF, 0x19, 0xC0, 0xC0, 0x18, 0xC0, 0xE0, 0x18,
  0x60, 0x60, 0x0C, 0x30, 0x30, 0x0C, 0x38, 0x18, 0x0C, 0x18, 0x0C, 0x06,
  0x0C, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x01, 0x83, 0x03,
  0x00, 0xE3, 0x83, 0x80, 0x3B, 0x83, 0x80, 0x0F, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0xFE, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x70, 0x03, 0x80, 0xC0, 0x0C,
  0x03, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x80, 0x0C, 0x0C,
  0x00, 0x38, 0xE0, 0x00, 0x67, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xD8, 0x00, 0x1C, 0x70, 0x1C, 0xE0, 0xE0, 0x63, 0x01,
  0x83, 0x98, 0x07, 0x0C, 0xE0, 0x0C, 0x73, 0x80, 0x39, 0x8C, 0x00, 0x6C,
  0x30, 0x01, 0xF0, 0xC0, 0x03, 0x83, 0x00, 0x1E, 0x0E, 0x00, 0xFC, 0x1C,
  0x0F, 0x30, 0x7F, 0xF0, 0xE0, 0x7F, 0x81, 0xC0, 0x39, 0x8C, 0x63, 0x31,
  0x8C, 0x62, 0x30, 0x00, 0x38, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x0C, 0x18, 0x1E, 0x30, 0x1E,
  0x60, 0x07, 0xBF, 0x03, 0xFE, 0x0F, 0x00, 0x32, 0x00, 0xC6, 0x03, 0x0C,
  0x0E, 0x0C, 0x08, 0x18, 0x00, 0x38, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x38, 0x61, 0xC0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x38, 0x38,
  0x1C, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x07, 0x38,
  0x01, 0xCC, 0x00, 0x73, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0x98, 0x00,
  0x66, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x03, 0xB8, 0x00, 0xEC, 0x00, 0x33,
  0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x38, 0xC0,
  0x1C, 0x38, 0x06, 0x06, 0x03, 0x81, 0xC1, 0xC0, 0x3F, 0xE0, 0x07, 0xF0,
  0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x7E, 0x39, 0xBC, 0x6C, 0x3A, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0x30, 0x1C, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x0E, 0x07, 0x81, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0x80, 0xE0, 0x20,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x1F, 0xE0, 0x01, 0xF0, 0x00, 0x27, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x0C, 0x01,
  0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xB0, 0x00, 0x6E, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00,
  0xC6, 0x00, 0x31, 0xC0, 0x0E, 0x30, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x18,
  0x18, 0x06, 0x07, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03, 0x00,
  0xE0, 0xE0, 0x1C, 0x38, 0x03, 0x06, 0x00, 0x61, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x02, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x60, 0x1E,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x30, 0x03, 0x3F,
  0xC0, 0xEF, 0x7C, 0x1B, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x03, 0x1C, 0x00,
  0x63, 0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x31, 0x80, 0x06, 0x30, 0x01,
  0xC6, 0x00, 0x30, 0xE0, 0x0E, 0x0C, 0x01, 0x81, 0x80, 0x70, 0x38, 0x1C,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0E, 0x07, 0x03, 0x80, 0x70,
  0x60, 0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x06, 0x00, 0xE0,
  0xC0, 0x18, 0x1C, 0x06, 0x01, 0x83, 0xC0, 0x38, 0xE0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x3D, 0xC0, 0x0E, 0x1C, 0x07, 0x81, 0xC0, 0xC0, 0x1C, 0x38,
  0x01, 0x8E, 0x00, 0x31, 0xC0, 0x07, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xE0,
  0x03, 0x1C, 0x00, 0xE1, 0x80, 0x18, 0x3C, 0x0F, 0x03, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x1C, 0x07, 0x0E,
  0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xCE, 0x00,
  0x33, 0x80, 0x0C, 0xE0, 0x03, 0x38, 0x01, 0xCE, 0x00, 0x71, 0x80, 0x3C,
  0x70, 0x1F, 0x0F, 0x3D, 0x81, 0xFE, 0x60, 0x1C, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x04, 0x1C,
  0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x0E, 0x1C, 0x38, 0x00, 0x00, 0x80, 0x70, 0x1C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0x80,
  0xE0, 0x30, 0x1C, 0x06, 0x03, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xE1,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x07, 0x80,
  0x0E, 0x00, 0x18, 0x03, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x06, 0x00,
  0x00, 0x60, 0xC0, 0x00, 0x06, 0x1C, 0x01, 0x80, 0x31, 0x80, 0xFF, 0x83,
  0x30, 0x1C, 0x38, 0x33, 0x03, 0x83, 0x03, 0x60, 0x70, 0x30, 0x36, 0x06,
  0x03, 0x03, 0x60, 0xC0, 0x70, 0x3E, 0x0C, 0x06, 0x06, 0xC1, 0x80, 0x60,
  0x6C, 0x18, 0x06, 0x06, 0xC1, 0x80, 0xC0, 0x6C, 0x18, 0x0C, 0x0C, 0xC1,
  0x81, 0xC0, 0xCC, 0x18, 0x1C, 0x18, 0xC1, 0x83, 0xC3, 0x8C, 0x0E, 0xE6,
  0x70, 0xC0, 0xFC, 0x7E, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x20, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x6C, 0x00, 0x06,
  0xC0, 0x00, 0xCC, 0x00, 0x1C, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03,
  0x0C, 0x00, 0x70, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xE0, 0x0C, 0x0E, 0x01,
  0xC0, 0xE0, 0x18, 0x06, 0x03, 0x80, 0x60, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0E, 0x00, 0x60, 0xC0, 0x06, 0x1C, 0x00, 0x61, 0x80, 0x06,
  0x38, 0x00, 0x73, 0x00, 0x07, 0x70, 0x00, 0x76, 0x00, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xC0, 0x3C, 0x06,
  0x00, 0xE0, 0x30, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xC0, 0x07,
  0x06, 0x00, 0x38, 0x30, 0x01, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xC0,
  0x1C, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0x81, 0xF0, 0x18, 0x01, 0xC0,
  0xC0, 0x0E, 0x06, 0x00, 0x30, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00,
  0x70, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x18,
  0x01, 0xE0, 0xC0, 0x3E, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xC0, 0x78, 0x0C, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x04, 0x01,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x30,
  0x1F, 0x00, 0xC0, 0x1C, 0x03, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x01,
  0xC1, 0x80, 0x03, 0x06, 0x00, 0x0C, 0x18, 0x00, 0x30, 0xE0, 0x00, 0xC3,
  0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0xC0, 0x00, 0xC7, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0x60, 0x00, 0x71, 0x80, 0x01, 0x8E, 0x00, 0x0E,
  0x38, 0x00, 0x30, 0xC0, 0x01, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x38, 0x70,
  0x01, 0xC1, 0xC0, 0x0E, 0x06, 0x00, 0xF0, 0x18, 0x0F, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xF0, 0x1E, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x30, 0x03, 0xFC, 0xC0, 0x1F, 0xF3, 0x00, 0x01, 0xCC,
  0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x8C, 0x00,
  0x0E, 0x38, 0x00, 0x30, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x07, 0x00, 0x1C,
  0x0F, 0x00, 0x70, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x03,
  0x03, 0x80, 0x03, 0x03, 0x00, 0x03, 0x03, 0x00, 0x07, 0x03, 0x00, 0x07,
  0x07, 0x00, 0x06, 0x07, 0x00, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x0E,
  0x06, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x1C,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x38, 0x00, 0x30, 0x38, 0x00, 0x30,
  0x30, 0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x70, 0x00, 0x60,
  0x70, 0x00, 0x60, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xE0, 0x60, 0x00, 0xC0,
  0xE0, 0x00, 0xC0, 0x03, 0xFE, 0x07, 0xF8, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x30, 0x0E, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x03, 0x80, 0x06, 0x0E, 0x00, 0x0C,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xCE, 0x00, 0x01, 0xBC,
  0x00, 0x07, 0x78, 0x00, 0x0F, 0xB8, 0x00, 0x1E, 0x30, 0x00, 0x38, 0x60,
  0x00, 0x60, 0xE0, 0x01, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x06, 0x03, 0x80,
  0x0C, 0x03, 0x00, 0x18, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x1C, 0x03, 0x00, 0x38, 0x06, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x1B, 0x81, 0xB8, 0x00, 0x36, 0x03, 0x30, 0x00, 0xCC,
  0x06, 0x60, 0x03, 0x98, 0x0C, 0xC0, 0x06, 0x70, 0x39, 0x80, 0x1C, 0xC0,
  0x63, 0x00, 0x31, 0x80, 0xC6, 0x00, 0xE3, 0x01, 0x8C, 0x01, 0x8E, 0x07,
  0x18, 0x07, 0x1C, 0x0E, 0x38, 0x0C, 0x30, 0x18, 0x30, 0x38, 0x60, 0x30,
  0x60, 0x60, 0xC0, 0x60, 0xC1, 0x83, 0x81, 0xC1, 0x83, 0x07, 0x03, 0x83,
  0x0C, 0x0C, 0x06, 0x06, 0x18, 0x18, 0x0C, 0x0C, 0x60, 0x30, 0x18, 0x19,
  0xC0, 0xE0, 0x70, 0x1B, 0x01, 0xC0, 0xC0, 0x3E, 0x03, 0x01, 0x80, 0x78,
  0x06, 0x03, 0x00, 0xF0, 0x1C, 0x06, 0x01, 0xC0, 0x38, 0x1C, 0x03, 0x80,
  0x60, 0x00, 0x03, 0x80, 0x01, 0x81, 0xE0, 0x00, 0xC0, 0xF0, 0x00, 0xE0,
  0x78, 0x00, 0x60, 0x3E, 0x00, 0x30, 0x3F, 0x00, 0x18, 0x19, 0x80, 0x1C,
  0x0C, 0xC0, 0x0E, 0x06, 0x70, 0x06, 0x03, 0x18, 0x03, 0x03, 0x8C, 0x01,
  0x81, 0x87, 0x01, 0xC0, 0xC1, 0x80, 0xE0, 0x60, 0xC0, 0x60, 0x70, 0x70,
  0x30, 0x38, 0x18, 0x18, 0x18, 0x0C, 0x1C, 0x0C, 0x07, 0x0C, 0x06, 0x01,
  0x86, 0x07, 0x00, 0xC3, 0x03, 0x80, 0x73, 0x81, 0x80, 0x19, 0xC0, 0xC0,
  0x0C, 0xC0, 0x60, 0x07, 0x60, 0x70, 0x01, 0xB0, 0x30, 0x00, 0xD8, 0x18,
  0x00, 0x7C, 0x0C, 0x00, 0x3C, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xC0, 0x0E, 0x0E,
  0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x0D, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1B, 0x00,
  0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33, 0x00, 0x01,
  0xCC, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC1, 0x80, 0x07, 0x07,
  0x00, 0x38, 0x0E, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFC, 0x03, 0x03, 0xE0, 0x30, 0x0E, 0x03, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x1C, 0x1C, 0x03,
  0x81, 0xC3, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x01, 0xC0,
  0x0E, 0x0E, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xCE, 0x00, 0x07,
  0x38, 0x00, 0x0D, 0xC0, 0x00, 0x37, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1B, 0x00, 0x00, 0x6C, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0xC0, 0x00, 0x33,
  0x00, 0x01, 0xCC, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xC1, 0x80,
  0x07, 0x07, 0x00, 0x38, 0x0E, 0x03, 0xC0, 0x1F, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xFC, 0x03, 0x03, 0xE0, 0x30, 0x0E, 0x03, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x1C, 0x1C, 0x07, 0x81, 0xFF, 0xF0,
  0x1F, 0xF8, 0x01, 0x81, 0x80, 0x18, 0x18, 0x03, 0x81, 0xC0, 0x38, 0x1C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x70, 0x06, 0x07, 0x00,
  0x60, 0x60, 0x07, 0x06, 0x00, 0x70, 0x60, 0x03, 0x0E, 0x00, 0x38, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xC0, 0x60, 0x70, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x0C, 0x03, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x0E, 0x18, 0x00, 0x18, 0x30, 0x00, 0x30, 0x60, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x03, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x38,
  0x70, 0x00, 0x70, 0xC0, 0x00, 0xC1, 0x80, 0x01, 0x83, 0x00, 0x03, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x30, 0x60, 0x00, 0x60, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x81, 0xC0, 0x06,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0x7C, 0x00, 0x0E, 0xC0, 0x00, 0xCE, 0x00, 0x1C, 0xE0,
  0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x06, 0x00, 0x70, 0x60, 0x06, 0x06,
  0x00, 0xE0, 0x60, 0x0C, 0x06, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80,
  0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x70, 0xC0,
  0x07, 0x0C, 0x00, 0x71, 0x80, 0x03, 0x18, 0x00, 0x33, 0x00, 0x03, 0x30,
  0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F,
  0x80, 0x0E, 0x00, 0x37, 0x00, 0x3C, 0x00, 0xEE, 0x00, 0x78, 0x01, 0x8C,
  0x01, 0xB0, 0x07, 0x18, 0x03, 0x60, 0x0C, 0x30, 0x0E, 0xC0, 0x38, 0x60,
  0x19, 0x80, 0x70, 0xC0, 0x73, 0x00, 0xC1, 0x80, 0xC6, 0x03, 0x83, 0x01,
  0x8C, 0x06, 0x06, 0x06, 0x18, 0x1C, 0x0C, 0x0C, 0x30, 0x30, 0x18, 0x30,
  0x60, 0x60, 0x30, 0x60, 0xC1, 0x80, 0x61, 0xC1, 0x83, 0x00, 0xC3, 0x03,
  0x0E, 0x01, 0x8E, 0x06, 0x18, 0x03, 0x18, 0x0C, 0x70, 0x06, 0x30, 0x18,
  0xC0, 0x0C, 0xC0, 0x31, 0x80, 0x19, 0x80, 0x66, 0x00, 0x36, 0x00, 0xEC,
  0x00, 0x6C, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0x60, 0x01, 0xE0, 0x02, 0xC0,
  0x03, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x00, 0x01, 0x80, 0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x00, 0xC0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x60, 0x00, 0x60,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x37,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xCE, 0x00, 0x01, 0xC6,
  0x00, 0x03, 0x86, 0x00, 0x03, 0x07, 0x00, 0x07, 0x03, 0x00, 0x0E, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x18, 0x03, 0x80, 0x38, 0x01, 0x80, 0x70, 0x01,
  0x80, 0x60, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xC0, 0x01, 0xF0, 0x00, 0xEE,
  0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x18, 0x03, 0x07, 0x01, 0xC1, 0xC0,
  0x60, 0x30, 0x38, 0x0C, 0x1C, 0x03, 0x06, 0x00, 0xE3, 0x80, 0x38, 0xC0,
  0x06, 0x60, 0x01, 0xB8, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x20, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0C, 0xC0, 0x03, 0x98, 0x00,
  0x61, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06,
  0x01, 0xC1, 0xC0, 0x18, 0x30, 0x03, 0x0C, 0x00, 0x33, 0x80, 0x06, 0xE0,
  0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC0,
  0x00, 0xF0, 0x00, 0xFE, 0x30, 0x79, 0xCC, 0x38, 0x1F, 0x1C, 0x03, 0x8E,
  0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x98, 0x00, 0xCE, 0x00,
  0x33, 0x80, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0x63, 0x00, 0x38,
  0xC0, 0x0E, 0x30, 0x07, 0x8C, 0x01, 0xC3, 0x80, 0xF0, 0x60, 0x6C, 0x1F,
  0xF3, 0x03, 0xF0, 0xC0, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC3, 0xC0, 0x39, 0xFC, 0x06, 0x73, 0xC0, 0xD8, 0x1C, 0x1E,
  0x01, 0x83, 0x80, 0x30, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x60,
  0x03, 0x1C, 0x00, 0x63, 0x80, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80,
  0x0C, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x80,
  0xE1, 0xB0, 0x38, 0x33, 0xFE, 0x06, 0x3F, 0x80, 0x00, 0x78, 0x07, 0xFC,
  0x1E, 0x38, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x01, 0x07,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x0F, 0x0C, 0x03, 0xFC, 0xC0, 0x79, 0xEC, 0x0E, 0x06,
  0xC1, 0xC0, 0x3C, 0x38, 0x03, 0x83, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00,
  0x38, 0x60, 0x03, 0x8E, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x70, 0xC0,
  0x07, 0x0C, 0x00, 0x70, 0xC0, 0x0E, 0x0C, 0x00, 0xE0, 0xC0, 0x1E, 0x0C,
  0x01, 0xE0, 0xE0, 0x3C, 0x06, 0x06, 0xC0, 0x7F, 0xCC, 0x03, 0xF8, 0xC0,
  0x00, 0x70, 0x03, 0xFC, 0x07, 0x8E, 0x0E, 0x06, 0x1C, 0x06, 0x38, 0x07,
  0x30, 0x06, 0x70, 0x06, 0x60, 0x0C, 0x60, 0x3C, 0xE1, 0xF8, 0xFF, 0xE0,
  0xFC, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x10, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC2,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0xF3, 0x01, 0xE7, 0xB0, 0x38, 0x1B, 0x07,
  0x00, 0xB0, 0xE0, 0x0E, 0x0C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1,
  0x80, 0x0E, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x30, 0x00, 0xC3, 0x00, 0x1C,
  0x30, 0x01, 0xC3, 0x00, 0x38, 0x30, 0x03, 0x83, 0x00, 0x78, 0x30, 0x07,
  0x83, 0x80, 0xF0, 0x18, 0x3B, 0x01, 0xFF, 0x30, 0x0F, 0xE3, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0xE0, 0x78, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x87, 0x80, 0xE7,
  0xF8, 0x33, 0x8E, 0x0D, 0x81, 0xC3, 0xC0, 0x30, 0xE0, 0x0C, 0x70, 0x03,
  0x1C, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x18, 0xE0, 0x06, 0x38, 0x01, 0x8C,
  0x00, 0xE3, 0x00, 0x38, 0xC0, 0x0C, 0x70, 0x03, 0x1C, 0x00, 0xC6, 0x00,
  0x71, 0x80, 0x18, 0x60, 0x06, 0x38, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x38,
  0x01, 0x01, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x00, 0x00,
  0x02, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x10, 0xE0, 0x18, 0x30, 0x0C,
  0x0C, 0x06, 0x03, 0x03, 0x00, 0xC1, 0x80, 0x70, 0xE0, 0x18, 0x70, 0x06,
  0x38, 0x01, 0x9C, 0x00, 0xEE, 0x00, 0x37, 0xC0, 0x0F, 0xB0, 0x03, 0xCE,
  0x00, 0xE3, 0x80, 0x70, 0x60, 0x1C, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x38, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x70, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0x00, 0x1C, 0x03,
  0xC0, 0x63, 0xF8, 0x7F, 0x83, 0x39, 0xE7, 0x1C, 0x1B, 0x07, 0x60, 0x70,
  0xF0, 0x1E, 0x03, 0x87, 0x00, 0xE0, 0x1C, 0x70, 0x07, 0x00, 0xE3, 0x80,
  0x30, 0x07, 0x18, 0x03, 0x80, 0x30, 0xC0, 0x1C, 0x01, 0x8E, 0x00, 0xC0,
  0x0C, 0x70, 0x06, 0x00, 0xE3, 0x00, 0x30, 0x07, 0x18, 0x03, 0x80, 0x30,
  0xC0, 0x1C, 0x01, 0x8E, 0x00, 0xC0, 0x0C, 0x70, 0x06, 0x00, 0xE3, 0x00,
  0x30, 0x06, 0x18, 0x03, 0x80, 0x30, 0xC0, 0x18, 0x01, 0x8E, 0x00, 0xC0,
  0x1C, 0x60, 0x06, 0x00, 0xE3, 0x00, 0x70, 0x06, 0x00, 0x02, 0x1E, 0x03,
  0x1F, 0xE0, 0xCE, 0x78, 0x36, 0x07, 0x0F, 0x01, 0xC7, 0x80, 0x31, 0xE0,
  0x0C, 0x70, 0x07, 0x1C, 0x01, 0xC6, 0x00, 0x63, 0x80, 0x18, 0xE0, 0x06,
  0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x31, 0xC0, 0x0C, 0x70, 0x07, 0x18,
  0x01, 0xC6, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x06, 0x38, 0x03, 0x8C, 0x00,
  0xE0, 0x00, 0xF0, 0x01, 0xFE, 0x01, 0xE3, 0x81, 0xC0, 0xE1, 0xC0, 0x39,
  0xC0, 0x1C, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x0E, 0xC0,
  0x06, 0x60, 0x07, 0x38, 0x03, 0x1C, 0x03, 0x87, 0x03, 0x81, 0xFF, 0x80,
  0x7F, 0x00, 0x00, 0x07, 0x80, 0x18, 0xFE, 0x00, 0xCE, 0x38, 0x06, 0xC0,
  0xE0, 0x3C, 0x03, 0x01, 0xC0, 0x18, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x38, 0x30, 0x01, 0xC3, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xC0, 0x03,
  0x06, 0x00, 0x38, 0x30, 0x01, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0,
  0x06, 0x07, 0x00, 0x70, 0x3C, 0x07, 0x03, 0xE0, 0x70, 0x19, 0xFF, 0x00,
  0xC7, 0xF0, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x30, 0x79, 0xEC,
  0x38, 0x1B, 0x1C, 0x02, 0xCE, 0x00, 0xE3, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x03, 0x98, 0x00, 0xEE, 0x00, 0x33, 0x80, 0x0C, 0xC0, 0x03, 0x30, 0x01,
  0xCC, 0x00, 0x73, 0x00, 0x38, 0xC0, 0x0E, 0x30, 0x07, 0x8C, 0x01, 0xE3,
  0x80, 0xF0, 0x60, 0x6C, 0x1F, 0xF3, 0x03, 0xF8, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x18, 0xF8,
  0x33, 0xF0, 0x6C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0x0F, 0x1E, 0x1C, 0x02,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x80, 0x70, 0xFF, 0xE0,
  0x7F, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xFF,
  0xFE, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0xF8, 0x3F, 0x00, 0x1C, 0x01, 0xC6, 0x00, 0x71, 0x80, 0x18,
  0x60, 0x06, 0x38, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x0C, 0x70,
  0x03, 0x1C, 0x00, 0xC6, 0x00, 0x71, 0x80, 0x18, 0x60, 0x06, 0x38, 0x01,
  0x8E, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x1C, 0x30, 0x0F, 0x0C, 0x02, 0xC3,
  0x83, 0xB0, 0x7F, 0xCC, 0x0F, 0xC6, 0x00, 0xE0, 0x07, 0xE0, 0x06, 0xE0,
  0x0E, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x38, 0x60, 0x30, 0x60,
  0x70, 0x60, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0x71, 0xC0, 0x71, 0x80, 0x33,
  0x80, 0x33, 0x00, 0x37, 0x00, 0x36, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0xE0, 0x1C, 0x01, 0xF8, 0x07, 0x00, 0xE6, 0x03, 0xC0,
  0x31, 0x80, 0xF0, 0x0C, 0x60, 0x3C, 0x07, 0x18, 0x1B, 0x01, 0x86, 0x06,
  0x60, 0xE1, 0x83, 0x18, 0x30, 0x60, 0xC6, 0x1C, 0x18, 0x61, 0x86, 0x06,
  0x18, 0x63, 0x81, 0x8C, 0x18, 0xC0, 0x63, 0x06, 0x30, 0x19, 0xC1, 0x9C,
  0x06, 0x60, 0x66, 0x01, 0x98, 0x1B, 0x80, 0x6C, 0x06, 0xC0, 0x1B, 0x01,
  0xB0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x30, 0x0E, 0x03, 0x80, 0xC0, 0x18,
  0x18, 0x01, 0x83, 0x80, 0x0C, 0x70, 0x00, 0xC6, 0x00, 0x0E, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x19, 0x80, 0x03, 0x98, 0x00, 0x71, 0xC0, 0x06, 0x0C, 0x00, 0xC0, 0xC0,
  0x1C, 0x0E, 0x03, 0x80, 0x60, 0x30, 0x07, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x03, 0x00, 0x38, 0x06, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x30, 0x0E, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x70, 0x01, 0xC0, 0xC0,
  0x03, 0x83, 0x80, 0x03, 0x06, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0xE0, 0x00, 0x31, 0x80, 0x00, 0x67, 0x00, 0x00, 0xCC, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xC0, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x01, 0xF8, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x7C,
  0x00, 0x78, 0x03, 0xE0, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x01, 0xF0, 0x07, 0xC0, 0x0C, 0x00, 0x00,
  0x1F, 0x00, 0x5F, 0xF0, 0x1E, 0x0F, 0xFE, 0x00, 0xFE,
};

const GFXglyph NotoSans_SemiCondensed_LightItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 9, 30, 10, 1, -30 },
  { 35, 11, 11, 14, 4, -30 },
  { 51, 22, 30, 23, 1, -30 },
  { 134, 19, 34, 20, 1, -32 },
  { 215, 25, 30, 29, 3, -30 },
  { 309, 22, 30, 24, 1, -30 },
  { 392, 5, 11, 8, 4, -30 },
  { 399, 13, 37, 11, 1, -30 },
  { 460, 12, 37, 11, -3, -30 },
  { 516, 15, 16, 20, 5, -32 },
  { 546, 18, 20, 22, 2, -25 },
  { 591, 7, 10, 9, -2, -5 },
  { 600, 10, 2, 12, 1, -12 },
  { 603, 3, 4, 9, 1, -4 },
  { 605, 19, 30, 14, -2, -30 },
  { 677, 18, 30, 20, 2, -30 },
  { 745, 10, 30, 20, 6, -30 },
  { 783, 19, 30, 20, 0, -30 },
  { 855, 20, 30, 20, 0, -30 },
  { 930, 19, 30, 20, 0, -30 },
  { 1002, 19, 30, 20, 1, -30 },
  { 1074, 19, 30, 20, 2, -30 },
  { 1146, 18, 30, 20, 3, -30 },
  { 1214, 19, 30, 20, 1, -30 },
  { 1286, 18, 30, 20, 1, -30 },
  { 1354, 7, 23, 9, 1, -23 },
  { 1375, 10, 28, 9, -2, -23 },
  { 1410, 18, 19, 22, 2, -25 },
  { 1453, 17, 11, 22, 3, -20 },
  { 1477, 18, 19, 22, 2, -25 },
  { 1520, 14, 30, 15, 2, -30 },
  { 1573, 28, 34, 31, 2, -30 },
  { 1692, 20, 30, 20, -2, -30 },
  { 1767, 21, 30, 22, 1, -30 },
  { 1846, 21, 30, 21, 3, -30 },
  { 1925, 22, 30, 25, 1, -30 },
  { 2008, 20, 30, 19, 1, -30 },
  { 2083, 20, 30, 18, 1, -30 },
  { 2158, 22, 30, 25, 3, -30 },
  { 2241, 24, 30, 25, 1, -30 },
  { 2331, 15, 30, 11, -1, -30 },
  { 2388, 17, 38, 9, -7, -30 },
  { 2469, 23, 30, 21, 1, -30 },
  { 2556, 14, 30, 18, 1, -30 },
  { 2609, 31, 30, 31, 1, -30 },
  { 2726, 25, 30, 26, 1, -30 },
  { 2820, 22, 30, 26, 3, -30 },
  { 2903, 20, 30, 21, 1, -30 },
  { 2978, 22, 37, 26, 3, -30 },
  { 3080, 20, 30, 21, 1, -30 },
  { 3155, 20, 30, 19, 0, -30 },
  { 3230, 18, 30, 18, 4, -30 },
  { 3298, 23, 30, 25, 3, -30 },
  { 3385, 20, 30, 20, 4, -30 },
  { 3460, 31, 30, 32, 4, -30 },
  { 3577, 24, 30, 19, -2, -30 },
  { 3667, 18, 30, 18, 4, -30 },
  { 3735, 22, 30, 19, -1, -30 },
  { 3818, 16, 37, 12, -1, -30 },
  { 3892, 7, 30, 14, 4, -30 },
  { 3919, 16, 37, 12, -3, -30 },
  { 3993, 19, 17, 21, 1, -30 },
  { 4034, 15, 2, 15, -4, 4 },
  { 4038, 6, 7, 10, 6, -32 },
  { 4044, 18, 23, 21, 2, -23 },
  { 4096, 19, 32, 21, 1, -32 },
  { 4172, 15, 23, 17, 2, -23 },
  { 4216, 20, 32, 21, 2, -32 },
  { 4296, 16, 23, 19, 2, -23 },
  { 4342, 21, 42, 11, -5, -32 },
  { 4453, 20, 33, 21, 0, -23 },
  { 4536, 18, 32, 21, 1, -32 },
  { 4608, 9, 31, 9, 1, -31 },
  { 4643, 16, 41, 9, -6, -31 },
  { 4725, 18, 32, 17, 1, -32 },
  { 4797, 9, 32, 9, 1, -32 },
  { 4833, 29, 23, 32, 1, -23 },
  { 4917, 18, 23, 21, 1, -23 },
  { 4969, 17, 23, 21, 2, -23 },
  { 5018, 21, 33, 21, -1, -23 },
  { 5105, 18, 33, 21, 2, -23 },
  { 5180, 15, 23, 14, 1, -23 },
  { 5224, 16, 23, 16, 0, -23 },
  { 5270, 11, 28, 12, 2, -28 },
  { 5309, 18, 22, 21, 2, -22 },
  { 5359, 16, 22, 16, 2, -22 },
  { 5403, 26, 22, 26, 2, -22 },
  { 5475, 20, 22, 17, -2, -22 },
  { 5530, 23, 32, 17, -4, -22 },
  { 5622, 17, 22, 16, -1, -22 },
  { 5669, 15, 37, 14, 1, -30 },
  { 5739, 2, 42, 20, 10, -32 },
  { 5750, 15, 37, 14, -2, -30 },
  { 5820, 18, 4, 22, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_LightItalic42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_LightItalic42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_LightItalic42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_LIGHTITALIC42PT7B_H_
