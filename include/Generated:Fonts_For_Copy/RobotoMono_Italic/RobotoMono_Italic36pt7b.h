#ifndef _ROBOTOMONO_ITALIC36PT7B_H_
#define _ROBOTOMONO_ITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xF1, 0xC3,
  0x87, 0x0E, 0x1C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x18, 0x78, 0xF1, 0xC0,
  0x30, 0xDC, 0x77, 0x1D, 0xC7, 0x61, 0x98, 0x66, 0x1B, 0x8E, 0x00, 0x1C,
  0x38, 0x00, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x06, 0x00,
  0x38, 0x70, 0x01, 0x83, 0x00, 0x0C, 0x38, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC0, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x30, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x60, 0xC0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x1C, 0x38, 0x00, 0xC1, 0x80, 0x06, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x06,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3C,
  0x1E, 0x0E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x3C, 0x70, 0x0F, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x1C, 0xF0, 0x07, 0x1C, 0x03, 0xC7, 0x81, 0xE1, 0xFB, 0xF0, 0x3F, 0xF8,
  0x07, 0xFC, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x1C, 0xE0, 0x0C, 0x38, 0x46, 0x1C, 0x37, 0x0E,
  0x3B, 0x87, 0x39, 0xC3, 0x18, 0x63, 0x9C, 0x3F, 0x9C, 0x0F, 0x8C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x3C, 0x07, 0x3F,
  0x03, 0x39, 0xC3, 0xB8, 0x63, 0x9C, 0x31, 0x8C, 0x19, 0x86, 0x0C, 0x43,
  0x06, 0x01, 0xC7, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xC0, 0x0F, 0xF8, 0x03, 0xC3, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x03, 0x81,
  0xC0, 0x78, 0x70, 0x07, 0x1E, 0x00, 0xE7, 0x80, 0x1F, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x39, 0xE7, 0x07, 0x78, 0x71,
  0xCE, 0x0F, 0x3B, 0xC0, 0xEF, 0x70, 0x1F, 0xCE, 0x01, 0xF1, 0xE0, 0x3E,
  0x1C, 0x07, 0xC3, 0xE7, 0xF8, 0x3F, 0xF7, 0x83, 0xFC, 0x78, 0x76, 0x6E,
  0xEE, 0xCC, 0x00, 0x20, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x04, 0x00, 0x04, 0x00,
  0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC1, 0x71, 0xCF, 0xFD, 0xBF, 0x7F, 0xFF,
  0x07, 0xF0, 0x07, 0xC0, 0x0E, 0xC0, 0x1E, 0xE0, 0x1C, 0xE0, 0x38, 0x70,
  0x70, 0x78, 0x30, 0x30, 0x00, 0x20, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1E,
  0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x3C, 0xF0, 0x40, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x27, 0xFF, 0xF7, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x18,
  0xE0, 0x07, 0x38, 0x03, 0xDE, 0x03, 0xE7, 0x01, 0xF9, 0xC1, 0xFE, 0x70,
  0xF3, 0x9C, 0xF8, 0xE7, 0x78, 0x39, 0xFC, 0x1E, 0xFC, 0x07, 0x3E, 0x01,
  0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC0,
  0xF1, 0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x20, 0x3C, 0x1F, 0x1F,
  0xEF, 0xFD, 0xF3, 0xB0, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3C, 0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x1C, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xFF,
  0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x73, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x8F, 0x01, 0xE1, 0xF1, 0xF0,
  0x3F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x03, 0x9C,
  0x00, 0xF3, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x70,
  0x1E, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x38, 0x0F, 0x0F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x78, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3C, 0x3E,
  0x16, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0F, 0x03, 0xC1, 0xF3,
  0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x7E, 0x01, 0xFE,
  0x03, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0xE0, 0x7B, 0xF8, 0x7F, 0xFC, 0x7E, 0x1E, 0x78, 0x0E, 0x70, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E,
  0x70, 0x1E, 0x78, 0x3C, 0x3C, 0x78, 0x1F, 0xF0, 0x0F, 0xE0, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xC0,
  0x3C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x80, 0xE0, 0xE0, 0x70, 0x3F, 0xF8,
  0x07, 0xFC, 0x03, 0xFF, 0x01, 0xE1, 0xE0, 0xE0, 0x3C, 0x78, 0x07, 0x1C,
  0x01, 0xCF, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x07, 0x1C, 0x03, 0xC7, 0x81,
  0xE1, 0xF1, 0xF0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xF8,
  0x1F, 0xFC, 0x1E, 0x1E, 0x38, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x1E,
  0x3C, 0x7E, 0x3F, 0xFE, 0x1F, 0xCE, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7C, 0x00,
  0x0C, 0x1E, 0x1F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0xF8, 0xF8, 0xF8, 0xF0, 0x03, 0x03, 0xC3, 0xE1,
  0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0,
  0x20, 0x00, 0x00, 0x03, 0x00, 0x1F, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x18, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0x80, 0x30, 0x00, 0x3C, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xEF,
  0x01, 0xDC, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x80, 0x78, 0x1C, 0x0E, 0x00, 0xE0, 0xC0, 0x06, 0x1C, 0x7C, 0x61, 0x8F,
  0xE2, 0x31, 0xC6, 0x33, 0x18, 0x63, 0x73, 0x04, 0x36, 0x30, 0xC2, 0x63,
  0x0C, 0x66, 0x70, 0xC6, 0xC6, 0x0C, 0x6C, 0x61, 0x86, 0xC6, 0x18, 0xCC,
  0x63, 0x8C, 0xC7, 0xFF, 0x8E, 0x3C, 0xF0, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC3, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0E, 0xC0, 0x03, 0xDC, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xE0, 0x70, 0x1C, 0x0E,
  0x07, 0x01, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x00, 0xE1, 0xC0, 0x1C,
  0x38, 0x03, 0x8E, 0x00, 0x39, 0xC0, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1C,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0x03, 0xE0, 0xE0, 0x1E,
  0x1C, 0x03, 0xC7, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x38,
  0x70, 0x1E, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFE, 0x0E, 0x03, 0xC1,
  0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x79, 0xE0, 0x0F, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x07, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3C, 0x1E, 0x1E,
  0x03, 0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x0F, 0x3C, 0x03, 0x87, 0x01, 0xE0, 0xF1, 0xF0, 0x3F, 0xF8, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0x07, 0xC0, 0xE0,
  0x3C, 0x3C, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0F, 0x1C, 0x00, 0xE3, 0x80,
  0x1C, 0xF0, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00,
  0x79, 0xC0, 0x0E, 0x78, 0x01, 0xCF, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03,
  0xC7, 0x00, 0x70, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x3C, 0x1E, 0x1E, 0x03,
  0xCF, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x07, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x1F, 0xEE, 0x07, 0xFB, 0x81,
  0xFE, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xF0, 0x07,
  0x1C, 0x01, 0xC7, 0x80, 0xF0, 0xF9, 0xF8, 0x1F, 0xFC, 0x03, 0xFC, 0x00,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x01, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x38,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x70, 0x03, 0x8F, 0x00, 0xF0,
  0xE0, 0x1C, 0x1E, 0x07, 0x81, 0xF7, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00,
  0x07, 0x00, 0x78, 0x78, 0x07, 0x83, 0x80, 0x78, 0x1C, 0x07, 0xC0, 0xE0,
  0x7C, 0x07, 0x07, 0xC0, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x1C, 0x3C, 0x00,
  0xE3, 0xC0, 0x07, 0x3C, 0x00, 0x3B, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xC0, 0x07, 0xCE, 0x00, 0x3C, 0x78, 0x01, 0xC1, 0xC0, 0x1E,
  0x0F, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x3C,
  0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x87, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x83, 0xF1, 0xF8,
  0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x8E, 0xE1, 0x98, 0xEE, 0x39,
  0x9C, 0xE3, 0x9D, 0xDC, 0x39, 0xF9, 0xC3, 0x9F, 0x9C, 0x39, 0xF1, 0xC3,
  0x8F, 0x1C, 0x70, 0xE3, 0xC7, 0x0E, 0x38, 0x70, 0xC3, 0x87, 0x00, 0x38,
  0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF0,
  0x0F, 0x1F, 0x80, 0xE1, 0xF8, 0x0E, 0x1F, 0x80, 0xE1, 0xFC, 0x0E, 0x1D,
  0xC0, 0xE3, 0xDC, 0x1E, 0x3D, 0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0xE1, 0xC3,
  0x8F, 0x1C, 0x38, 0x73, 0xC7, 0x87, 0x3C, 0x70, 0x7B, 0x87, 0x03, 0xB8,
  0x70, 0x3B, 0x87, 0x03, 0xB8, 0x70, 0x1F, 0x8F, 0x01, 0xF0, 0xE0, 0x1F,
  0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x3C,
  0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01,
  0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x1C, 0x07, 0x87, 0x83, 0xC0,
  0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xC0, 0xF0, 0x3E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x0F, 0x1C, 0x00, 0xE1, 0xC0,
  0x1E, 0x1C, 0x07, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0x8F,
  0x00, 0xF3, 0x80, 0x1D, 0xE0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x3C,
  0x03, 0x87, 0x03, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0x01, 0xE0, 0xE0, 0x1E, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0E, 0x01,
  0xE1, 0xC0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x3C, 0x0F, 0x07, 0x00, 0xE0, 0xE0, 0x1C,
  0x1C, 0x03, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1E, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x07, 0xC1, 0xE0, 0xF0, 0x1E, 0x3C, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0x00, 0x38,
  0xF0, 0x0F, 0x1E, 0x03, 0xE1, 0xF9, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x9E, 0x00, 0x73,
  0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCF,
  0x00, 0x39, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xE7, 0x80, 0x3C, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0xE1, 0xE0, 0x3C, 0x1C, 0x0F, 0x03, 0xE7, 0xC0, 0x3F,
  0xF0, 0x01, 0xFC, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80,
  0x1E, 0xE0, 0x07, 0x3C, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0x1C,
  0x1C, 0x07, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x0E, 0x1C, 0x03,
  0x8F, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xEE,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x60, 0xF7, 0x0E, 0x0E, 0x60, 0xE0, 0xEE, 0x0E,
  0x0E, 0xE1, 0xE1, 0xCE, 0x1F, 0x1C, 0xE1, 0xF1, 0xCE, 0x3F, 0x1C, 0xE3,
  0xF3, 0x8E, 0x37, 0x38, 0xE7, 0x73, 0x8E, 0x77, 0x38, 0xE6, 0x77, 0x0E,
  0xE7, 0x70, 0xEE, 0x77, 0x0E, 0xC7, 0x60, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0,
  0xF8, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0xC0, 0xF0, 0x78,
  0x0F, 0x07, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x1C,
  0x00, 0xE0, 0x70, 0x07, 0x81, 0xE0, 0x3C, 0x03, 0x81, 0xE0, 0x0F, 0x07,
  0x80, 0x1C, 0x3C, 0x00, 0x71, 0xE0, 0x01, 0xE7, 0x00, 0x03, 0xBC, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x78, 0xE0,
  0x03, 0xC3, 0x80, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x03, 0xC0, 0x78, 0x0E,
  0x00, 0xE0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x00, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x79, 0xC0, 0x1C, 0x70, 0x0F, 0x1E, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0xF0, 0x38, 0x78, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1D,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8,
  0x07, 0xF0, 0x7F, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0xFE, 0x0F, 0xE0, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x70, 0x70, 0x70,
  0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C,
  0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x03, 0xF8, 0x1F, 0x81, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7E,
  0x07, 0xF0, 0x00, 0x00, 0xC0, 0x0E, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03,
  0xF0, 0x39, 0x81, 0xCE, 0x1C, 0x70, 0xE3, 0x8E, 0x0C, 0x70, 0x77, 0x03,
  0xF8, 0x1C, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0x9C, 0x71, 0x80,
  0x07, 0xF8, 0x0F, 0xFE, 0x1F, 0x1E, 0x3C, 0x0F, 0x38, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0xFF, 0x0F, 0xFF, 0x3F, 0xFF, 0x78, 0x0E, 0xF0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x3E, 0xFD, 0xFC, 0x7F, 0xFC,
  0x3F, 0x9E, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0xFE, 0x07, 0x7F,
  0xC1, 0xFD, 0xF0, 0x78, 0x1E, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x3C,
  0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0E, 0x70,
  0x07, 0x9C, 0x01, 0xC7, 0x80, 0xF1, 0xE0, 0x78, 0x7F, 0x7E, 0x3F, 0xFF,
  0x0E, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xC7, 0xC7, 0x80, 0xE3,
  0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x71, 0xC0, 0x38, 0xF0,
  0x3C, 0x3C, 0x7C, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x07, 0xF3, 0x81, 0xFF, 0x70, 0x7C, 0xFE, 0x1E, 0x07,
  0xC3, 0x80, 0x78, 0xF0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xE0, 0x1C,
  0x1C, 0x07, 0x83, 0xC1, 0xF0, 0x7E, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0x70,
  0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xC7, 0x87, 0x81, 0xE3, 0x80, 0x73,
  0xC0, 0x19, 0xC0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xB8, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x10, 0xF0, 0x1C, 0x3E,
  0x3E, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xF0, 0x0F,
  0xFC, 0x07, 0x81, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xF9, 0xC1,
  0xFF, 0x70, 0xF9, 0xFC, 0x78, 0x1F, 0x1C, 0x03, 0xCF, 0x00, 0xF3, 0x80,
  0x38, 0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x79, 0xC0, 0x1C,
  0x70, 0x07, 0x1E, 0x01, 0xC7, 0x80, 0xF0, 0xF0, 0x7C, 0x3F, 0x7F, 0x07,
  0xFF, 0x80, 0xFE, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x10, 0x07, 0x0E, 0x03,
  0xC3, 0xC3, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x20, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x7E, 0x07, 0x7F, 0xC1, 0xFD, 0xF8, 0x7C,
  0x0E, 0x1C, 0x03, 0x8F, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x1E, 0x70, 0x07, 0x1C, 0x01, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x03, 0xCE, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x03, 0xE3, 0x80, 0xF0, 0x70,
  0x3C, 0x0E, 0x0F, 0x01, 0xC7, 0xC0, 0x39, 0xF0, 0x0F, 0x78, 0x01, 0xDE,
  0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFB, 0x80, 0x3E, 0x78, 0x07, 0x87,
  0x00, 0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x1E, 0x1E, 0x01,
  0xC3, 0x80, 0x3C, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1D, 0xF3,
  0xE1, 0xFF, 0x7F, 0x1E, 0xFE, 0xF3, 0xC7, 0x87, 0x38, 0x38, 0x73, 0x87,
  0x07, 0x38, 0x70, 0x73, 0x87, 0x07, 0x38, 0x70, 0xE7, 0x07, 0x0E, 0x70,
  0x70, 0xE7, 0x0E, 0x0E, 0x70, 0xE0, 0xE7, 0x0E, 0x1E, 0x70, 0xE1, 0xCE,
  0x0E, 0x1C, 0xE0, 0xE1, 0xCE, 0x1C, 0x1C, 0xE1, 0xC1, 0xC0, 0x1C, 0x7E,
  0x07, 0x7F, 0xC1, 0xFD, 0xF8, 0x7C, 0x0E, 0x1C, 0x03, 0x8F, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x39, 0xE0,
  0x1E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07,
  0x3C, 0x03, 0xCE, 0x00, 0xE0, 0x03, 0xF8, 0x07, 0xFE, 0x07, 0xC7, 0x87,
  0x81, 0xE3, 0x80, 0x73, 0x80, 0x3D, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x7B, 0xC0,
  0x38, 0xE0, 0x38, 0x7C, 0x7C, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x0E, 0x7F,
  0x01, 0xDF, 0xF0, 0x3F, 0x3E, 0x07, 0x81, 0xE0, 0xE0, 0x1C, 0x3C, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07,
  0x1E, 0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xE0, 0x78,
  0x3F, 0x3F, 0x0F, 0xFF, 0xC1, 0xCF, 0xE0, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xF3, 0x87, 0xFF, 0xC7, 0xC7, 0xE7, 0x80, 0xF3, 0x80, 0x7B, 0xC0,
  0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0xF0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xDC,
  0x01, 0xCE, 0x00, 0xE7, 0x80, 0x73, 0xC0, 0x38, 0xE0, 0x7C, 0x7C, 0x7E,
  0x1F, 0xFE, 0x07, 0xF7, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x7F, 0x1D, 0xFE,
  0x1F, 0xFE, 0x3F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xFC,
  0x07, 0xFF, 0x07, 0xC7, 0xC3, 0x80, 0xE3, 0x80, 0x79, 0xC0, 0x1C, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xC0,
  0x00, 0xE7, 0x00, 0x7B, 0xC0, 0x38, 0xE0, 0x3C, 0x7C, 0x7C, 0x1F, 0xFE,
  0x03, 0xFC, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x98, 0x07,
  0xF8, 0x03, 0xFC, 0x3C, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73,
  0x80, 0x79, 0xC0, 0x3D, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x78, 0xE0,
  0x7C, 0x7C, 0xFE, 0x1F, 0xF6, 0x07, 0xE7, 0x00, 0xE0, 0x03, 0xF8, 0x01,
  0xE7, 0x00, 0x71, 0xC0, 0x3C, 0x70, 0x0E, 0x1C, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x01, 0x87, 0x00, 0x73, 0x80, 0x1C,
  0xE0, 0x07, 0x70, 0x00, 0xDC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0xE0, 0x60, 0x7E, 0x0E, 0x0E, 0xE0, 0xE0, 0xEE, 0x1E,
  0x0E, 0xE1, 0xE1, 0xCE, 0x1E, 0x1C, 0x63, 0xE1, 0x86, 0x37, 0x38, 0x67,
  0x73, 0x86, 0x67, 0x30, 0x66, 0x77, 0x06, 0xE3, 0x60, 0x6C, 0x36, 0x07,
  0xC3, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x03, 0x80,
  0x70, 0x38, 0x00, 0x1E, 0x00, 0xF8, 0x78, 0x0F, 0x01, 0xC0, 0x70, 0x0F,
  0x07, 0x80, 0x38, 0x78, 0x00, 0xE7, 0x80, 0x07, 0x78, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3D,
  0xC0, 0x03, 0xCE, 0x00, 0x3C, 0x38, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x03,
  0xC0, 0x3C, 0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0xF0,
  0x07, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0xF0, 0x1C, 0x07, 0x80, 0x78, 0x1C,
  0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x3C, 0x70, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF1, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x07, 0xC0, 0x03, 0x00, 0x03, 0x07, 0x07, 0x07, 0x06,
  0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70,
  0x70, 0x60, 0x60, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x03, 0x3F, 0xF0, 0x77,
  0x0F, 0x87, 0x60, 0x3F, 0xEE, 0x01, 0xFC, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoMono_Italic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 26, 21, 7, -26 },
  { 24, 10, 8, 21, 7, -27 },
  { 34, 21, 26, 21, 0, -26 },
  { 103, 18, 34, 21, 2, -30 },
  { 180, 17, 26, 21, 2, -26 },
  { 236, 19, 26, 21, 1, -26 },
  { 298, 4, 8, 21, 10, -27 },
  { 302, 12, 37, 21, 6, -29 },
  { 358, 12, 37, 21, 3, -29 },
  { 414, 16, 18, 21, 4, -26 },
  { 450, 18, 18, 21, 2, -21 },
  { 491, 7, 10, 21, 3, -4 },
  { 500, 13, 3, 21, 4, -13 },
  { 505, 5, 5, 21, 7, -5 },
  { 509, 18, 28, 21, 2, -26 },
  { 572, 18, 26, 21, 2, -26 },
  { 631, 11, 26, 21, 5, -26 },
  { 667, 18, 26, 21, 0, -26 },
  { 726, 18, 26, 21, 1, -26 },
  { 785, 19, 26, 21, 0, -26 },
  { 847, 18, 26, 21, 3, -26 },
  { 906, 16, 26, 21, 2, -26 },
  { 958, 18, 26, 21, 3, -26 },
  { 1017, 18, 26, 21, 2, -26 },
  { 1076, 16, 26, 21, 3, -26 },
  { 1128, 8, 20, 21, 8, -20 },
  { 1148, 9, 26, 21, 6, -20 },
  { 1178, 16, 15, 21, 3, -19 },
  { 1208, 17, 11, 21, 2, -17 },
  { 1232, 16, 16, 21, 2, -19 },
  { 1264, 15, 26, 21, 5, -26 },
  { 1313, 20, 26, 21, 1, -26 },
  { 1378, 19, 26, 21, -1, -26 },
  { 1440, 19, 26, 21, 1, -26 },
  { 1502, 18, 26, 21, 2, -26 },
  { 1561, 19, 26, 21, 1, -26 },
  { 1623, 20, 26, 21, 1, -26 },
  { 1688, 20, 26, 21, 1, -26 },
  { 1753, 18, 26, 21, 2, -26 },
  { 1812, 20, 26, 21, 1, -26 },
  { 1877, 20, 26, 21, 1, -26 },
  { 1942, 19, 26, 21, 1, -26 },
  { 2004, 21, 26, 21, 1, -26 },
  { 2073, 15, 26, 21, 2, -26 },
  { 2122, 20, 26, 21, 1, -26 },
  { 2187, 20, 26, 21, 1, -26 },
  { 2252, 18, 26, 21, 2, -26 },
  { 2311, 20, 26, 21, 1, -26 },
  { 2376, 18, 30, 21, 2, -26 },
  { 2444, 19, 26, 21, 1, -26 },
  { 2506, 19, 26, 21, 1, -26 },
  { 2568, 19, 26, 21, 3, -26 },
  { 2630, 19, 26, 21, 2, -26 },
  { 2692, 18, 26, 21, 4, -26 },
  { 2751, 20, 26, 21, 3, -26 },
  { 2816, 22, 26, 21, 0, -26 },
  { 2888, 18, 26, 21, 4, -26 },
  { 2947, 20, 26, 21, 0, -26 },
  { 3012, 12, 34, 21, 5, -29 },
  { 3063, 8, 28, 21, 7, -26 },
  { 3091, 13, 34, 21, 4, -29 },
  { 3147, 13, 14, 21, 4, -26 },
  { 3170, 16, 3, 21, 0, 0 },
  { 3176, 5, 5, 21, 10, -26 },
  { 3180, 16, 19, 21, 2, -19 },
  { 3218, 18, 27, 21, 1, -27 },
  { 3279, 17, 19, 21, 2, -19 },
  { 3320, 19, 27, 21, 2, -27 },
  { 3385, 17, 19, 21, 2, -19 },
  { 3426, 18, 28, 21, 4, -28 },
  { 3489, 18, 27, 21, 1, -19 },
  { 3550, 18, 27, 21, 1, -27 },
  { 3611, 16, 26, 21, 2, -26 },
  { 3663, 16, 34, 21, 1, -26 },
  { 3731, 19, 27, 21, 1, -27 },
  { 3796, 16, 27, 21, 2, -27 },
  { 3850, 20, 19, 21, 0, -19 },
  { 3898, 18, 19, 21, 1, -19 },
  { 3941, 17, 19, 21, 2, -19 },
  { 3982, 19, 26, 21, 0, -19 },
  { 4044, 17, 26, 21, 2, -19 },
  { 4100, 16, 19, 21, 4, -19 },
  { 4138, 17, 19, 21, 2, -19 },
  { 4179, 16, 24, 21, 3, -24 },
  { 4227, 17, 19, 21, 2, -19 },
  { 4268, 18, 19, 21, 3, -19 },
  { 4311, 20, 19, 21, 2, -19 },
  { 4359, 21, 19, 21, 0, -19 },
  { 4409, 22, 27, 21, -1, -19 },
  { 4484, 18, 19, 21, 1, -19 },
  { 4527, 15, 34, 21, 5, -28 },
  { 4591, 8, 33, 21, 6, -26 },
  { 4624, 14, 34, 21, 3, -28 },
  { 4684, 20, 7, 21, 0, -14 },
};

const GFXfont RobotoMono_Italic36pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic36pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOMONO_ITALIC36PT7B_H_
