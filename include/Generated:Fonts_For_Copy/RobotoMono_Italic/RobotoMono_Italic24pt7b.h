#ifndef _ROBOTOMONO_ITALIC24PT7B_H_
#define _ROBOTOMONO_ITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x10, 0x00, 0x00,
  0x38, 0x60, 0x47, 0x8B, 0x36, 0x6C, 0xD1, 0x00, 0x01, 0x8C, 0x06, 0x60,
  0x31, 0x80, 0xC4, 0x02, 0x30, 0xFF, 0xF0, 0x62, 0x01, 0x18, 0x0C, 0x60,
  0x31, 0x00, 0x8C, 0x3F, 0xFC, 0x18, 0x80, 0x46, 0x03, 0x10, 0x08, 0xC0,
  0x63, 0x00, 0x01, 0x80, 0x18, 0x01, 0x80, 0x7E, 0x1F, 0xE1, 0x87, 0x38,
  0x33, 0x03, 0x38, 0x01, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00,
  0x6E, 0x06, 0x60, 0x66, 0x0E, 0x7F, 0xC3, 0xF0, 0x0C, 0x00, 0xC0, 0x78,
  0x19, 0x82, 0x31, 0x46, 0x68, 0xD9, 0xB2, 0x3C, 0xC0, 0x30, 0x0C, 0x01,
  0x00, 0x6F, 0x1B, 0x32, 0x46, 0xC8, 0xD1, 0x18, 0x36, 0x07, 0x80, 0x0F,
  0x81, 0xFC, 0x18, 0xC1, 0x8C, 0x18, 0xC1, 0x98, 0x1F, 0x00, 0xE0, 0x1C,
  0x07, 0x63, 0x67, 0x3C, 0x33, 0xC3, 0xEC, 0x1C, 0xC1, 0xC7, 0xFE, 0x3E,
  0x60, 0x6D, 0xA5, 0x80, 0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60,
  0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x60, 0x30, 0x10, 0x10, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x02, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C,
  0x18, 0x38, 0x30, 0x60, 0xC0, 0x80, 0x06, 0x01, 0x80, 0x42, 0x11, 0xED,
  0xDF, 0xF1, 0xC0, 0xF8, 0x36, 0x38, 0xC4, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0x07, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x39, 0x8C, 0x67, 0x33, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x00,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0x0F, 0xC1, 0xEE, 0x18, 0x33, 0x03, 0x30, 0x37, 0x07, 0x60,
  0xF6, 0x3B, 0x67, 0x37, 0xC6, 0x78, 0x6E, 0x06, 0x60, 0x66, 0x0C, 0x60,
  0xC7, 0xF8, 0x3F, 0x00, 0x02, 0x3D, 0xFF, 0x30, 0x61, 0xC3, 0x06, 0x0C,
  0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C, 0x38, 0x07, 0xC1, 0xEF, 0x18, 0x33,
  0x03, 0x30, 0x30, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xC3, 0xFC,
  0xC1, 0xB8, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x7C, 0x0F, 0x00, 0x38, 0x03,
  0x00, 0x6C, 0x0D, 0x81, 0xB0, 0x67, 0xFC, 0x3E, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x03, 0x60, 0x36, 0x03, 0xB0, 0x19, 0x81, 0x8C, 0x18, 0x61,
  0x87, 0x1C, 0x30, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x1F, 0xF1, 0xFF, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x6F, 0x07,
  0xF8, 0x61, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0x87,
  0xF8, 0x3E, 0x00, 0x01, 0xC0, 0xF8, 0x38, 0x0C, 0x03, 0x80, 0x60, 0x1B,
  0xE3, 0xFE, 0x70, 0xEC, 0x0D, 0x81, 0xF0, 0x3E, 0x06, 0xC1, 0x98, 0x71,
  0xFC, 0x1F, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0xEE, 0x18, 0x31, 0x83, 0x38,
  0x33, 0x83, 0x18, 0x61, 0xFC, 0x1F, 0x83, 0x8C, 0x70, 0x66, 0x06, 0x60,
  0x66, 0x06, 0x60, 0xC7, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xF9, 0xC3, 0x30,
  0x76, 0x07, 0x80, 0xF0, 0x1F, 0x06, 0x61, 0xCF, 0xF8, 0xFB, 0x00, 0xC0,
  0x18, 0x06, 0x03, 0xC3, 0xE0, 0x70, 0x00, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x00, 0x19, 0xEE, 0x00, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x0C, 0x71, 0x86, 0x30, 0xC0, 0x00, 0x20, 0x38, 0x1F, 0x1F, 0x0F, 0x81,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x3F, 0xF7, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x20, 0x07, 0x00, 0xF8,
  0x03, 0xC0, 0x1E, 0x00, 0xC0, 0xF8, 0xF8, 0x7C, 0x1C, 0x02, 0x00, 0x00,
  0x1F, 0x1F, 0xE6, 0x1F, 0x03, 0x00, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x07, 0xC0,
  0x77, 0x06, 0x0C, 0x62, 0x26, 0x7D, 0xB6, 0x6D, 0x22, 0x7B, 0x13, 0x98,
  0x94, 0xCC, 0xA4, 0x45, 0x36, 0x49, 0xDE, 0x60, 0x03, 0x00, 0x0E, 0x60,
  0x3F, 0x00, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x66, 0x06,
  0x60, 0xC6, 0x0C, 0x61, 0x86, 0x18, 0x63, 0xFE, 0x3F, 0xE7, 0x03, 0x60,
  0x3E, 0x03, 0xC0, 0x30, 0x1F, 0xC3, 0xFE, 0x30, 0x73, 0x03, 0x30, 0x33,
  0x03, 0x30, 0x67, 0xFC, 0x7F, 0xC6, 0x0E, 0x60, 0x66, 0x06, 0x60, 0x6C,
  0x06, 0xC0, 0xCF, 0xFC, 0xFF, 0x00, 0x07, 0xC0, 0xF7, 0x0E, 0x0C, 0x60,
  0x67, 0x03, 0xB0, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x06, 0x70, 0x31, 0x83, 0x0F, 0xF0, 0x1F, 0x00, 0x3F, 0x83,
  0xFC, 0x30, 0x63, 0x07, 0x30, 0x33, 0x03, 0x70, 0x36, 0x03, 0x60, 0x36,
  0x03, 0x60, 0x36, 0x06, 0xC0, 0x6C, 0x0C, 0xC3, 0xCF, 0xF0, 0xFE, 0x00,
  0x1F, 0xF8, 0xFF, 0xCC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07,
  0xFC, 0x7F, 0xC3, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xCE, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x04, 0x7F, 0xC3, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x00, 0x07, 0xC0, 0xFF, 0x0E,
  0x0C, 0x60, 0x67, 0x03, 0xB0, 0x01, 0x80, 0x0C, 0x00, 0xE1, 0xF6, 0x1F,
  0xB0, 0x0D, 0x80, 0xCC, 0x06, 0x30, 0x31, 0x81, 0x87, 0xF8, 0x1F, 0x80,
  0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x06, 0x18, 0x18, 0xC0, 0x63, 0x01,
  0x8F, 0xFE, 0x3F, 0xF8, 0xC0, 0xC3, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x18, 0xC0, 0x60, 0x1F, 0xF9, 0xFF, 0x80, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xCC, 0x0C, 0x60, 0x63, 0x87, 0x0F, 0xF0,
  0x3E, 0x00, 0x18, 0x1C, 0xE0, 0xC3, 0x07, 0x0C, 0x38, 0x31, 0xC0, 0xCE,
  0x03, 0x70, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0x30, 0x18, 0xE0, 0x61,
  0x83, 0x87, 0x0C, 0x0C, 0x30, 0x38, 0xC0, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xC0, 0x1C, 0x1C, 0x70, 0x71,
  0xC3, 0xC7, 0x8F, 0x1E, 0x68, 0xD9, 0xE3, 0x6D, 0x8D, 0xB6, 0x37, 0x98,
  0xCE, 0x63, 0x33, 0x18, 0xCC, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x1C,
  0xE0, 0x60, 0x1C, 0x0C, 0x70, 0x31, 0xC1, 0xC7, 0x86, 0x1E, 0x18, 0xF8,
  0x63, 0x31, 0x8C, 0xC6, 0x33, 0x38, 0xC6, 0xC3, 0x1B, 0x1C, 0x6C, 0x60,
  0xF1, 0x83, 0xC6, 0x0F, 0x18, 0x18, 0xE0, 0x60, 0x07, 0xC1, 0xFE, 0x18,
  0x73, 0x03, 0x70, 0x36, 0x03, 0x60, 0x36, 0x03, 0xE0, 0x3C, 0x03, 0xC0,
  0x3C, 0x06, 0xC0, 0x66, 0x0E, 0x61, 0xC7, 0xF8, 0x1F, 0x00, 0x1F, 0xC0,
  0xFF, 0x8E, 0x0C, 0x60, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0xE6, 0x0E, 0x7F,
  0xE3, 0xFE, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00,
  0xC0, 0x00, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03, 0x70, 0x36, 0x03, 0x60,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xC0, 0x6E, 0x0E, 0x61,
  0xC7, 0xF8, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x04, 0x1F, 0xC1, 0xFE, 0x30,
  0x73, 0x03, 0x30, 0x33, 0x03, 0x30, 0x37, 0x06, 0x7F, 0xC7, 0xF8, 0x61,
  0x86, 0x18, 0x61, 0x8E, 0x1C, 0xC0, 0xCC, 0x0C, 0xC0, 0xE0, 0x0F, 0xC0,
  0xFF, 0x8E, 0x0C, 0x60, 0x63, 0x03, 0x98, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xCC, 0x06, 0x60, 0x31, 0x83, 0x8F, 0xF8,
  0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60,
  0x73, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x33, 0x03, 0x98, 0x19,
  0x80, 0xCC, 0x06, 0x70, 0x71, 0x87, 0x0F, 0xF0, 0x3F, 0x00, 0xE0, 0x3B,
  0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x0E, 0x30, 0x61, 0x87, 0x06, 0x30, 0x31,
  0x81, 0x98, 0x0C, 0xC0, 0x6C, 0x03, 0x60, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC3, 0x1E, 0x38, 0xF1, 0xCD, 0x8E, 0x6C, 0xF3, 0x67, 0x9B,
  0x2D, 0x9B, 0x6C, 0xDB, 0x66, 0x9A, 0x3C, 0xF1, 0xE7, 0x8E, 0x3C, 0x71,
  0xC3, 0x8E, 0x18, 0x70, 0xC3, 0x00, 0x18, 0x0E, 0x38, 0x38, 0x30, 0xE0,
  0x61, 0x80, 0x66, 0x00, 0xDC, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x66, 0x01, 0xCC, 0x07, 0x1C, 0x0C, 0x18, 0x38, 0x38,
  0xE0, 0x30, 0xE0, 0x3B, 0x03, 0x98, 0x18, 0x61, 0xC3, 0x0C, 0x18, 0xC0,
  0xEE, 0x03, 0x60, 0x1E, 0x00, 0xF0, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x0F, 0x0F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0xF8, 0xF8,
  0xC1, 0x86, 0x18, 0x61, 0x83, 0x0C, 0x30, 0xC3, 0x06, 0x18, 0x61, 0x86,
  0x0C, 0x30, 0x0F, 0x1F, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xF8, 0xF0, 0x06, 0x0E, 0x1E, 0x1E, 0x32, 0x33, 0x63, 0x63, 0xC3, 0xFF,
  0xFF, 0xFC, 0xE3, 0x10, 0x0F, 0x83, 0xF8, 0xC3, 0xB8, 0x30, 0x06, 0x1F,
  0xCF, 0xFB, 0x87, 0xE0, 0xD8, 0x1B, 0x87, 0x3F, 0xE3, 0xEC, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x6F, 0x0F, 0xF1, 0xC7, 0x70, 0x6C, 0x0D,
  0x81, 0xB0, 0x36, 0x06, 0xC0, 0xF8, 0x3F, 0x0E, 0xFF, 0x9B, 0xE0, 0x07,
  0x81, 0xFC, 0x38, 0x67, 0x06, 0x60, 0x66, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x06, 0x0E, 0x60, 0xC3, 0xF8, 0x1F, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x07, 0x98, 0x7E, 0xC7, 0x1E, 0x70, 0x63, 0x03, 0x18,
  0x18, 0xC0, 0xCE, 0x06, 0x70, 0x71, 0x83, 0x0C, 0x38, 0x7F, 0xC1, 0xF6,
  0x00, 0x07, 0x81, 0xFC, 0x38, 0xE7, 0x06, 0x60, 0x66, 0x06, 0xFF, 0xEC,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0xC3, 0xFC, 0x1F, 0x00, 0x00, 0x40, 0x1F,
  0xC1, 0xE4, 0x0C, 0x00, 0xE0, 0x06, 0x01, 0xFF, 0x9F, 0xFC, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x0F, 0x31, 0xFB, 0x38, 0xF7, 0x06, 0x60, 0x66,
  0x06, 0x60, 0x6E, 0x06, 0xE0, 0xE6, 0x0C, 0x61, 0xC7, 0xFC, 0x3E, 0xC0,
  0x0C, 0x81, 0x8C, 0x38, 0xFF, 0x03, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0x67, 0x0F, 0xF9, 0xC3, 0x70, 0x6C, 0x0D, 0x81, 0xB0, 0x36,
  0x06, 0xC0, 0xF0, 0x3E, 0x06, 0xC0, 0xD8, 0x18, 0x01, 0x80, 0x30, 0x00,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x87, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x00, 0xFE, 0x1F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x87,
  0xE1, 0xF8, 0x00, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x07,
  0x30, 0xE3, 0x1C, 0x73, 0x86, 0x70, 0x6C, 0x07, 0xE0, 0x76, 0x06, 0x70,
  0xC3, 0x0C, 0x18, 0xC1, 0xCC, 0x0E, 0x1F, 0xC3, 0xF0, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xF8, 0x37, 0x71, 0xFF, 0xCC, 0xE6,
  0xC6, 0x36, 0x31, 0xB1, 0x8D, 0x8C, 0x6C, 0x63, 0x63, 0x36, 0x31, 0xB1,
  0x8D, 0x8C, 0x6C, 0x63, 0x00, 0x33, 0x87, 0xFC, 0xE1, 0xB8, 0x36, 0x06,
  0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x78, 0x1B, 0x03, 0x60, 0x6C, 0x0C, 0x0F,
  0x81, 0xFC, 0x38, 0xE7, 0x06, 0x60, 0x6E, 0x07, 0xC0, 0x6C, 0x06, 0xC0,
  0x6E, 0x0E, 0x60, 0xC7, 0xF8, 0x3F, 0x00, 0x1B, 0xC1, 0xFE, 0x1C, 0x73,
  0x83, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x36, 0x06, 0x70, 0xE7,
  0xFC, 0x6F, 0x86, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0x31,
  0xFF, 0x38, 0x77, 0x06, 0x60, 0x66, 0x06, 0x60, 0x6E, 0x06, 0xE0, 0xE6,
  0x0C, 0x61, 0xC7, 0xFC, 0x3E, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x33, 0xCF, 0xF7, 0xC5, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x07, 0x83, 0xFC, 0xE1, 0x98, 0x33,
  0x00, 0x70, 0x07, 0xE0, 0x1E, 0x00, 0xFC, 0x0D, 0x83, 0x3F, 0xE3, 0xF8,
  0x0C, 0x01, 0x80, 0x30, 0x3F, 0xFF, 0xFC, 0x38, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x70, 0x07, 0xE0, 0x7C, 0x60, 0x6C,
  0x0D, 0x83, 0xF0, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC1, 0xD8, 0x33,
  0x0E, 0x7F, 0xC7, 0xD8, 0xC0, 0x7C, 0x06, 0x60, 0xE6, 0x0C, 0x61, 0x86,
  0x18, 0x23, 0x03, 0x30, 0x36, 0x03, 0x60, 0x3C, 0x01, 0xC0, 0x18, 0x00,
  0x86, 0x1C, 0x31, 0xA3, 0x8D, 0x14, 0x48, 0xE6, 0x4D, 0x32, 0x49, 0x16,
  0x58, 0xB2, 0x85, 0x1C, 0x38, 0xE1, 0x86, 0x0C, 0x30, 0x00, 0x38, 0x1C,
  0x60, 0xE0, 0xC7, 0x03, 0x38, 0x06, 0xC0, 0x1E, 0x00, 0x30, 0x01, 0xE0,
  0x0F, 0x80, 0x73, 0x03, 0x8C, 0x1C, 0x18, 0xE0, 0x70, 0x30, 0x0C, 0xC0,
  0x63, 0x81, 0x86, 0x0C, 0x18, 0x70, 0x61, 0x81, 0xCE, 0x03, 0x30, 0x0D,
  0x80, 0x36, 0x00, 0xF0, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFE, 0xFF,
  0xC0, 0x00, 0x81, 0xC1, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x1C, 0x0E, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x70, 0x08, 0xC6, 0x31, 0x8C, 0x42, 0x31, 0x8C, 0x62, 0x11,
  0x8C, 0x63, 0x18, 0x8C, 0x60, 0x08, 0x0E, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x70, 0x78, 0x70, 0x30, 0x38, 0x18,
  0x0C, 0x06, 0x03, 0x03, 0x03, 0x83, 0x80, 0x3E, 0x0D, 0xFC, 0x24, 0x3F,
  0xB0, 0x7C,
};

const GFXglyph RobotoMono_Italic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 17, 14, 4, -17 },
  { 14, 7, 6, 14, 5, -18 },
  { 20, 14, 17, 14, 0, -17 },
  { 50, 12, 22, 14, 1, -20 },
  { 83, 11, 17, 14, 2, -17 },
  { 107, 12, 17, 14, 1, -17 },
  { 133, 3, 6, 14, 6, -18 },
  { 136, 8, 25, 14, 4, -19 },
  { 161, 8, 25, 14, 2, -19 },
  { 186, 10, 11, 14, 3, -17 },
  { 200, 12, 12, 14, 1, -14 },
  { 218, 5, 7, 14, 2, -3 },
  { 223, 9, 1, 14, 2, -8 },
  { 225, 3, 3, 14, 5, -3 },
  { 227, 12, 18, 14, 1, -17 },
  { 254, 12, 17, 14, 1, -17 },
  { 280, 7, 17, 14, 3, -17 },
  { 295, 12, 17, 14, 0, -17 },
  { 321, 11, 17, 14, 1, -17 },
  { 345, 13, 17, 14, 0, -17 },
  { 373, 12, 17, 14, 2, -17 },
  { 399, 11, 17, 14, 1, -17 },
  { 423, 12, 17, 14, 2, -17 },
  { 449, 12, 17, 14, 1, -17 },
  { 475, 11, 17, 14, 2, -17 },
  { 499, 5, 13, 14, 5, -13 },
  { 508, 6, 17, 14, 4, -13 },
  { 521, 11, 11, 14, 2, -13 },
  { 537, 12, 7, 14, 1, -11 },
  { 548, 11, 11, 14, 1, -13 },
  { 564, 10, 17, 14, 3, -17 },
  { 586, 13, 17, 14, 1, -17 },
  { 614, 12, 17, 14, 0, -17 },
  { 640, 12, 17, 14, 1, -17 },
  { 666, 13, 17, 14, 1, -17 },
  { 694, 12, 17, 14, 1, -17 },
  { 720, 13, 17, 14, 1, -17 },
  { 748, 13, 17, 14, 1, -17 },
  { 776, 13, 17, 14, 1, -17 },
  { 804, 14, 17, 14, 0, -17 },
  { 834, 13, 17, 14, 1, -17 },
  { 862, 13, 17, 14, 1, -17 },
  { 890, 14, 17, 14, 1, -17 },
  { 920, 11, 17, 14, 1, -17 },
  { 944, 14, 17, 14, 0, -17 },
  { 974, 14, 17, 14, 0, -17 },
  { 1004, 12, 17, 14, 1, -17 },
  { 1030, 13, 17, 14, 1, -17 },
  { 1058, 12, 20, 14, 1, -17 },
  { 1088, 12, 17, 14, 1, -17 },
  { 1114, 13, 17, 14, 1, -17 },
  { 1142, 13, 17, 14, 2, -17 },
  { 1170, 13, 17, 14, 1, -17 },
  { 1198, 13, 17, 14, 2, -17 },
  { 1226, 13, 17, 14, 2, -17 },
  { 1254, 15, 17, 14, 0, -17 },
  { 1286, 13, 17, 14, 2, -17 },
  { 1314, 14, 17, 14, 0, -17 },
  { 1344, 8, 24, 14, 3, -20 },
  { 1368, 6, 18, 14, 4, -17 },
  { 1382, 8, 24, 14, 3, -20 },
  { 1406, 8, 9, 14, 3, -17 },
  { 1415, 11, 2, 14, 0, 0 },
  { 1418, 4, 3, 14, 6, -17 },
  { 1420, 11, 13, 14, 1, -13 },
  { 1438, 11, 18, 14, 1, -18 },
  { 1463, 12, 13, 14, 1, -13 },
  { 1483, 13, 18, 14, 1, -18 },
  { 1513, 12, 13, 14, 1, -13 },
  { 1533, 13, 19, 14, 2, -19 },
  { 1564, 12, 18, 14, 1, -13 },
  { 1591, 11, 18, 14, 1, -18 },
  { 1616, 11, 17, 14, 1, -17 },
  { 1640, 11, 22, 14, 0, -17 },
  { 1671, 12, 18, 14, 1, -18 },
  { 1698, 11, 18, 14, 1, -18 },
  { 1723, 13, 13, 14, 0, -13 },
  { 1745, 11, 13, 14, 1, -13 },
  { 1763, 12, 13, 14, 1, -13 },
  { 1783, 12, 18, 14, 0, -13 },
  { 1810, 12, 18, 14, 1, -13 },
  { 1837, 10, 13, 14, 3, -13 },
  { 1854, 11, 13, 14, 1, -13 },
  { 1872, 11, 16, 14, 2, -16 },
  { 1894, 11, 13, 14, 2, -13 },
  { 1912, 12, 13, 14, 2, -13 },
  { 1932, 13, 13, 14, 2, -13 },
  { 1954, 14, 13, 14, 0, -13 },
  { 1977, 14, 18, 14, 0, -13 },
  { 2009, 12, 13, 14, 1, -13 },
  { 2029, 9, 23, 14, 4, -19 },
  { 2055, 5, 22, 14, 4, -17 },
  { 2069, 9, 23, 14, 2, -19 },
  { 2095, 14, 4, 14, 0, -9 },
};

const GFXfont RobotoMono_Italic24pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic24pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOMONO_ITALIC24PT7B_H_
