#ifndef _ROBOTOMONO_ITALIC62PT7B_H_
#define _ROBOTOMONO_ITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF0,
  0x00, 0x3C, 0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0xF3,
  0xC0, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3C, 0x07,
  0x9E, 0x03, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF0, 0x00, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xC3, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x03, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0,
  0x3C, 0x02, 0x0F, 0x01, 0xE0, 0x1C, 0xF0, 0x0F, 0x01, 0xF7, 0x80, 0x78,
  0x1F, 0x3C, 0x03, 0xC1, 0xF1, 0xE0, 0x1E, 0x0F, 0x0F, 0x01, 0xF0, 0xF8,
  0x78, 0x0F, 0x0F, 0x83, 0xE0, 0x78, 0x78, 0x0F, 0x8F, 0x87, 0x80, 0x7F,
  0xFC, 0x7C, 0x01, 0xFF, 0xC7, 0xC0, 0x07, 0xFC, 0x3C, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x7F, 0x80, 0x07, 0x8F, 0xFE, 0x00, 0x7C,
  0xFF, 0xF8, 0x07, 0xC7, 0xC3, 0xE0, 0x3C, 0x7C, 0x0F, 0x03, 0xC3, 0xC0,
  0x78, 0x3E, 0x1E, 0x03, 0xC1, 0xE1, 0xF0, 0x1E, 0x1E, 0x0F, 0x80, 0xF1,
  0xF0, 0x78, 0x07, 0x8F, 0x03, 0xC0, 0x3C, 0x30, 0x1E, 0x01, 0xE0, 0x00,
  0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xE0, 0x1F, 0x1F, 0xE7, 0xE0, 0x1F,
  0x1F, 0x83, 0xF0, 0x1F, 0x3F, 0x03, 0xF0, 0x3E, 0x7F, 0x01, 0xF8, 0x3E,
  0x7E, 0x00, 0xFC, 0x7E, 0xFC, 0x00, 0xFC, 0x7C, 0xFC, 0x00, 0x7E, 0xFC,
  0xFC, 0x00, 0x7E, 0xF8, 0xFC, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x3F, 0xF0,
  0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x7F, 0xE0, 0x7F, 0x81, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0x80, 0xFC,
  0x00, 0x18, 0x00, 0x00, 0x3E, 0x78, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x78,
  0xF3, 0xE7, 0xCF, 0x1E, 0x3C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x03, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x20, 0x0F, 0x80, 0x27, 0x80, 0xF0,
  0x0E, 0x7E, 0x0F, 0x07, 0xEF, 0xF8, 0xF1, 0xFE, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xF3, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xC0, 0x07, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x87,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83,
  0xE0, 0xFC, 0x3F, 0x07, 0xC0, 0x30, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x3F,
  0xBF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFF, 0x3E, 0x00, 0x07,
  0xFC, 0xF8, 0x00, 0x7F, 0xE3, 0xE0, 0x03, 0xFF, 0x9F, 0x80, 0x3F, 0xFE,
  0x7E, 0x01, 0xFC, 0xF9, 0xF8, 0x1F, 0xE7, 0xE7, 0xC0, 0xFE, 0x1F, 0x9F,
  0x0F, 0xF0, 0x7E, 0x7C, 0x7F, 0x01, 0xF1, 0xF3, 0xF8, 0x07, 0xCF, 0xFF,
  0xC0, 0x1F, 0x3F, 0xFC, 0x00, 0xFC, 0xFF, 0xE0, 0x03, 0xF3, 0xFE, 0x00,
  0x0F, 0xCF, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x07,
  0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0x1F, 0xBE, 0x07,
  0xCE, 0x01, 0xF2, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x07, 0xDF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x3F, 0x3F, 0xF8, 0x07, 0xCF, 0xFF,
  0xC0, 0xFB, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFE, 0x03, 0xF8, 0xFF,
  0x80, 0x3F, 0x1F, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81,
  0xFE, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x80, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3F,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0x9F, 0x80, 0x07, 0xF3, 0xF0, 0x01, 0xFE, 0x3F, 0x00, 0xFF, 0xC7, 0xFC,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xE7, 0xC0, 0x7F, 0xF9, 0xF0,
  0x03, 0xFC, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x81, 0xFC, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x07, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x1F, 0x80, 0x20, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0,
  0x04, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xC3, 0xF8, 0x03,
  0xF9, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x1F, 0x81, 0xE0,
  0x78, 0x1F, 0xF8, 0x38, 0x3E, 0x0F, 0xFF, 0x0E, 0x0F, 0x07, 0xFF, 0xC3,
  0x87, 0x83, 0xF0, 0xE0, 0xE1, 0xE0, 0xF0, 0x38, 0x38, 0x70, 0x78, 0x0E,
  0x0E, 0x3C, 0x1E, 0x07, 0x83, 0x8F, 0x0F, 0x01, 0xE0, 0xE3, 0x83, 0xC0,
  0x70, 0x39, 0xE0, 0xE0, 0x1C, 0x0E, 0x78, 0x78, 0x0F, 0x03, 0x9E, 0x1E,
  0x03, 0xC0, 0xE7, 0x07, 0x80, 0xE0, 0x7B, 0xC1, 0xC0, 0x38, 0x1C, 0xF0,
  0x70, 0x1E, 0x07, 0x3C, 0x3C, 0x07, 0x81, 0xCF, 0x0F, 0x01, 0xC0, 0xF3,
  0xC3, 0xC0, 0xF0, 0x38, 0xF0, 0xF0, 0x7C, 0x0E, 0x3C, 0x3E, 0x3F, 0x07,
  0x0F, 0x07, 0xFF, 0xE3, 0xC3, 0xC1, 0xFF, 0x7F, 0xE0, 0xF0, 0x7F, 0x9F,
  0xF0, 0x1C, 0x0F, 0xC3, 0xF8, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x80, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0x80, 0x03, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xF0, 0x7C, 0x00, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x80, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0xF8, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x0F,
  0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x1F, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0xFF,
  0xFC, 0xFC, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x3F,
  0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xC3, 0xF8, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFB, 0xF0,
  0x00, 0x00, 0xFF, 0x8F, 0xC0, 0x00, 0x07, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xEF, 0x01, 0xF7,
  0xC0, 0x3E, 0xF0, 0x1F, 0x7C, 0x03, 0xEF, 0x03, 0xE7, 0xC0, 0x7C, 0xF0,
  0x3E, 0xF8, 0x07, 0xCF, 0x87, 0xCF, 0x80, 0x7C, 0xF8, 0x7C, 0xF8, 0x07,
  0xCF, 0x8F, 0x8F, 0x80, 0x7C, 0x78, 0xF8, 0xF8, 0x07, 0xC7, 0x9F, 0x1F,
  0x80, 0xFC, 0x79, 0xF1, 0xF0, 0x0F, 0x87, 0xBE, 0x1F, 0x00, 0xF8, 0x7F,
  0xE1, 0xF0, 0x0F, 0x87, 0xFC, 0x1F, 0x00, 0xF8, 0x7F, 0xC3, 0xF0, 0x0F,
  0x87, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x83, 0xE0, 0x1F, 0x83, 0xF0, 0x3E,
  0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x3E,
  0x07, 0xE0, 0x1F, 0x03, 0xC0, 0x7E, 0x03, 0xF0, 0x3C, 0x07, 0xC0, 0x3F,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x80,
  0x00, 0x7C, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x1F,
  0xE0, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x7F, 0x80, 0x01, 0xF0,
  0x1F, 0xF8, 0x00, 0x3E, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0xE0, 0x01,
  0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x01, 0xF7, 0xC0, 0x07, 0xC0, 0x7E, 0xF8,
  0x00, 0xF8, 0x0F, 0xDF, 0x80, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xE0, 0x3F,
  0x3E, 0x00, 0xFC, 0x07, 0xC7, 0xE0, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE0,
  0x3F, 0x0F, 0x80, 0x7C, 0x07, 0xE1, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x03,
  0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x07,
  0xC1, 0xF0, 0x1F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x01, 0xF1, 0xF8, 0x0F, 0x80, 0x3E, 0x3F, 0x01, 0xF0, 0x07, 0xE7, 0xC0,
  0x3E, 0x00, 0x7C, 0xF8, 0x0F, 0xC0, 0x0F, 0xBF, 0x01, 0xF8, 0x01, 0xFF,
  0xE0, 0x3F, 0x00, 0x1F, 0xFC, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0xFC,
  0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0xC0,
  0x7C, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x03, 0xF8, 0x07,
  0xC0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x01, 0xFE, 0x03, 0xF0,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x0F, 0xF8,
  0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x0C, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01,
  0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00,
  0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0x83, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xDF, 0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xC0,
  0x3E, 0x7C, 0x03, 0xF0, 0x1F, 0x9F, 0x01, 0xFC, 0x07, 0xC7, 0xC0, 0x7F,
  0x01, 0xF1, 0xF0, 0x1F, 0xC0, 0x7C, 0x7C, 0x0F, 0xF0, 0x3E, 0x1F, 0x03,
  0xFC, 0x0F, 0x87, 0xC0, 0xFF, 0x03, 0xE1, 0xF0, 0x7F, 0xC0, 0xF8, 0x7C,
  0x1E, 0xF0, 0x7C, 0x1F, 0x07, 0xBC, 0x1F, 0x07, 0xC3, 0xEF, 0x07, 0xC1,
  0xF0, 0xF3, 0xC1, 0xF0, 0x78, 0x3C, 0xF0, 0xF8, 0x1E, 0x1F, 0x3C, 0x3E,
  0x0F, 0x87, 0x8F, 0x0F, 0x83, 0xE1, 0xE3, 0xC3, 0xC0, 0xF8, 0xF8, 0xF1,
  0xF0, 0x3E, 0x3C, 0x3C, 0x7C, 0x0F, 0x8F, 0x0F, 0x1F, 0x03, 0xE7, 0xC3,
  0xCF, 0x80, 0xF9, 0xE0, 0xF3, 0xE0, 0x3E, 0x78, 0x3C, 0xF8, 0x0F, 0xBE,
  0x0F, 0x3E, 0x03, 0xEF, 0x83, 0xDF, 0x00, 0xFB, 0xC0, 0xF7, 0xC0, 0x3F,
  0xF0, 0x3D, 0xF0, 0x0F, 0xFC, 0x0F, 0x78, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x7F, 0x00,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xF3, 0xC0, 0x07, 0xE7, 0xC0, 0x0F,
  0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x1E, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x01, 0xE1, 0xF8, 0x03,
  0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x0F, 0x7C, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03,
  0xC0, 0xF8, 0x1F, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x7E,
  0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0x00, 0x3E, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00,
  0x3F, 0xCF, 0xE0, 0x0F, 0xF8, 0x7F, 0x87, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xEF, 0x81, 0xFF, 0xF8, 0xFC, 0x07, 0xFE, 0x0F, 0xC0, 0x0F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x1F, 0xF0, 0x01, 0xF9,
  0xFF, 0xE0, 0x07, 0xEF, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0x80, 0x7F, 0xF9,
  0xFF, 0x01, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x80, 0x0F, 0xE1,
  0xFF, 0x00, 0x7F, 0x07, 0xFF, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFD,
  0xFF, 0xFE, 0x03, 0xE3, 0xFF, 0xF0, 0x0F, 0x83, 0xFF, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x0F,
  0xC0, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xE0,
  0xF8, 0x00, 0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0xFD, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFC, 0x7F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF8, 0x1F, 0xC0, 0x07,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFF,
  0x80, 0x3F, 0xC3, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xDF,
  0x00, 0x0F, 0xFF, 0x9F, 0x00, 0x03, 0xFE, 0x1F, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x08, 0x0F,
  0xC0, 0x01, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xF8, 0x06, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0x00, 0x1F, 0xFF,
  0x1F, 0x00, 0x3F, 0xFF, 0x9F, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x8F,
  0xFF, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x7F,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFB, 0xE0, 0x01, 0xFF, 0xF3,
  0xE0, 0x00, 0x7F, 0xC3, 0xE0, 0x00, 0x0E, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x10, 0x00, 0x0F,
  0xC0, 0x38, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x0F, 0xF8, 0x01, 0xF8, 0xFF, 0xF0, 0x07, 0xC7, 0xFF,
  0xE0, 0x1F, 0x7F, 0xFF, 0xC0, 0x7D, 0xF9, 0xFF, 0x81, 0xFF, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x0F, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x07, 0xE0, 0x01, 0xFE, 0x07, 0xE0, 0x03, 0xFC, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x07, 0xC0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x0F, 0xC3, 0xFC,
  0x00, 0x0F, 0x87, 0xF8, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x0F, 0x9F, 0xC0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xE7, 0xE0,
  0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3E, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3F,
  0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xC7, 0xF0, 0x7E, 0x00, 0xFB, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0xEF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xBF, 0xFD, 0xFC, 0x1F, 0x81,
  0xFC, 0x0F, 0x83, 0xF0, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x3E, 0x0F,
  0x80, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE0, 0x1F,
  0x0F, 0xC0, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0x1F, 0x87, 0xC0, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0xC0, 0x7C, 0x3F, 0x01,
  0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x1F,
  0x00, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x3E,
  0x1F, 0x80, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0x1F, 0x0F, 0xC0, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x3E,
  0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0xFF, 0x80, 0x1F, 0x0F, 0xFF, 0x00, 0x7C, 0xFF, 0xFE,
  0x01, 0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0x8F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xC1, 0xFE, 0x03,
  0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x01, 0xFC,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x7F,
  0xC0, 0x01, 0xF1, 0xFF, 0xE0, 0x01, 0xF7, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xC7, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xE0, 0x07,
  0xF0, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF,
  0x80, 0x3F, 0x3F, 0xFF, 0x00, 0x3F, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0xF8, 0x07, 0xFF, 0xC7, 0xC0, 0x7F, 0xFF, 0xBE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFF, 0x87, 0xF0, 0x07, 0xFC, 0x7F,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E,
  0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F,
  0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xF3, 0xE0, 0x03, 0xFF, 0x1F,
  0x00, 0x03, 0x81, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0xFF, 0xE0, 0xF8, 0x7F, 0xFC, 0x1F, 0x1F, 0xFF, 0x03, 0xEF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0x83, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0xFE, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC1, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF0, 0xFC,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0xE0, 0x7F, 0x83,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFD, 0xF0, 0x03, 0xFF, 0xC7,
  0xC0, 0x07, 0xFE, 0x1F, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x01, 0xF0,
  0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x01, 0xC0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0x00, 0xFB, 0xE0, 0x0F, 0x80, 0x3C, 0xF8, 0x07, 0xE0, 0x1F, 0x3E, 0x01,
  0xF8, 0x07, 0xCF, 0x80, 0xFE, 0x01, 0xE3, 0xE0, 0x3F, 0x80, 0xF8, 0xF8,
  0x1F, 0xE0, 0x3C, 0x3E, 0x07, 0xF8, 0x1F, 0x0F, 0x81, 0xFE, 0x07, 0xC3,
  0xE0, 0xF7, 0x81, 0xE0, 0xF8, 0x3D, 0xE0, 0xF8, 0x3E, 0x1F, 0x78, 0x3E,
  0x0F, 0x87, 0x9E, 0x0F, 0x01, 0xE1, 0xE3, 0x87, 0xC0, 0x78, 0xF0, 0xF1,
  0xE0, 0x1E, 0x3C, 0x3C, 0x78, 0x07, 0x9E, 0x0F, 0x3E, 0x01, 0xE7, 0x83,
  0xCF, 0x00, 0x7B, 0xE0, 0xF3, 0xC0, 0x1E, 0xF0, 0x3D, 0xF0, 0x07, 0xBC,
  0x0F, 0x78, 0x01, 0xFE, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F,
  0xE0, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0xE0, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xF1, 0xFF, 0xF8, 0x00, 0x3C, 0xFF, 0xFF, 0x00, 0x0F,
  0x3F, 0xFF, 0xE0, 0x07, 0x9F, 0x81, 0xFE, 0x03, 0xE7, 0xC0, 0x3F, 0xC1,
  0xFB, 0xE0, 0x07, 0xFF, 0xFC, 0xF0, 0x00, 0xFF, 0xFE, 0x3C, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoMono_Italic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 13, 44, 36, 12, -44 },
  { 73, 17, 15, 36, 13, -47 },
  { 105, 36, 44, 36, 1, -44 },
  { 303, 30, 57, 36, 4, -51 },
  { 517, 29, 46, 36, 4, -45 },
  { 684, 32, 46, 36, 2, -45 },
  { 868, 7, 15, 36, 17, -47 },
  { 882, 20, 64, 36, 10, -50 },
  { 1042, 20, 64, 36, 5, -50 },
  { 1202, 28, 30, 36, 7, -44 },
  { 1307, 31, 33, 36, 3, -37 },
  { 1435, 11, 17, 36, 6, -7 },
  { 1459, 23, 5, 36, 6, -22 },
  { 1474, 9, 9, 36, 12, -8 },
  { 1485, 32, 48, 36, 3, -44 },
  { 1677, 30, 46, 36, 4, -45 },
  { 1850, 18, 44, 36, 9, -44 },
  { 1949, 32, 45, 36, 0, -45 },
  { 2129, 31, 46, 36, 1, -45 },
  { 2308, 32, 44, 36, 1, -44 },
  { 2484, 32, 45, 36, 4, -44 },
  { 2664, 27, 45, 36, 4, -44 },
  { 2816, 30, 44, 36, 6, -44 },
  { 2981, 30, 46, 36, 4, -45 },
  { 3154, 27, 45, 36, 6, -45 },
  { 3306, 13, 36, 36, 14, -35 },
  { 3365, 16, 45, 36, 10, -35 },
  { 3455, 28, 27, 36, 5, -33 },
  { 3550, 29, 17, 36, 4, -28 },
  { 3612, 29, 27, 36, 3, -33 },
  { 3710, 26, 45, 36, 8, -45 },
  { 3857, 34, 44, 36, 2, -44 },
  { 4044, 32, 44, 36, -1, -44 },
  { 4220, 32, 44, 36, 2, -44 },
  { 4396, 32, 46, 36, 3, -45 },
  { 4580, 34, 44, 36, 1, -44 },
  { 4767, 34, 44, 36, 2, -44 },
  { 4954, 34, 44, 36, 2, -44 },
  { 5141, 32, 46, 36, 3, -45 },
  { 5325, 35, 44, 36, 1, -44 },
  { 5518, 33, 44, 36, 2, -44 },
  { 5700, 33, 45, 36, 2, -44 },
  { 5886, 37, 44, 36, 2, -44 },
  { 6090, 27, 44, 36, 3, -44 },
  { 6239, 36, 44, 36, 1, -44 },
  { 6437, 35, 44, 36, 1, -44 },
  { 6630, 31, 46, 36, 3, -45 },
  { 6809, 34, 44, 36, 2, -44 },
  { 6996, 32, 52, 36, 3, -45 },
  { 7204, 33, 44, 36, 2, -44 },
  { 7386, 32, 46, 36, 3, -45 },
  { 7570, 32, 44, 36, 6, -44 },
  { 7746, 33, 45, 36, 3, -44 },
  { 7932, 32, 44, 36, 6, -44 },
  { 8108, 34, 44, 36, 5, -44 },
  { 8295, 38, 44, 36, 0, -44 },
  { 8504, 32, 44, 36, 6, -44 },
  { 8680, 34, 44, 36, 1, -44 },
  { 8867, 21, 59, 36, 8, -50 },
  { 9022, 15, 48, 36, 11, -44 },
  { 9112, 21, 59, 36, 8, -50 },
  { 9267, 23, 24, 36, 7, -44 },
  { 9336, 27, 5, 36, 1, 0 },
  { 9353, 10, 8, 36, 17, -45 },
  { 9363, 28, 34, 36, 3, -33 },
  { 9482, 30, 48, 36, 2, -47 },
  { 9662, 28, 34, 36, 4, -33 },
  { 9781, 32, 48, 36, 4, -47 },
  { 9973, 29, 34, 36, 3, -33 },
  { 10097, 32, 48, 36, 6, -48 },
  { 10289, 32, 46, 36, 1, -33 },
  { 10473, 30, 47, 36, 2, -47 },
  { 10650, 27, 45, 36, 3, -45 },
  { 10802, 28, 58, 36, 1, -45 },
  { 11005, 32, 47, 36, 2, -47 },
  { 11193, 27, 47, 36, 3, -47 },
  { 11352, 35, 33, 36, 0, -33 },
  { 11497, 30, 33, 36, 2, -33 },
  { 11621, 29, 34, 36, 3, -33 },
  { 11745, 32, 46, 36, 0, -33 },
  { 11929, 29, 46, 36, 4, -33 },
  { 12096, 27, 33, 36, 7, -33 },
  { 12208, 28, 34, 36, 4, -33 },
  { 12327, 27, 42, 36, 6, -41 },
  { 12469, 30, 34, 36, 4, -33 },
  { 12597, 30, 33, 36, 5, -33 },
  { 12721, 34, 33, 36, 4, -33 },
  { 12862, 36, 33, 36, 0, -33 },
  { 13011, 38, 46, 36, -1, -33 },
  { 13230, 31, 33, 36, 2, -33 },
  { 13358, 25, 59, 36, 9, -48 },
  { 13543, 13, 56, 36, 11, -44 },
  { 13634, 25, 59, 36, 5, -48 },
  { 13819, 34, 12, 36, 1, -24 },
};

const GFXfont RobotoMono_Italic62pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic62pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic62pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _ROBOTOMONO_ITALIC62PT7B_H_
