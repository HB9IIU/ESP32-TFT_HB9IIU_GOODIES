#ifndef _ROBOTOMONO_ITALIC14PT7B_H_
#define _ROBOTOMONO_ITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x25, 0xA0, 0x10, 0x99, 0xAA, 0x09, 0x0A, 0x12, 0x7F, 0x14,
  0x24, 0xFE, 0x28, 0x48, 0x58, 0x08, 0x10, 0xF3, 0x24, 0x68, 0x0C, 0x0C,
  0x05, 0x0A, 0x33, 0xC2, 0x00, 0x61, 0x2A, 0x97, 0x41, 0x04, 0x0F, 0x29,
  0xD4, 0x38, 0x1C, 0x36, 0x26, 0x3C, 0x18, 0x39, 0x4A, 0xCE, 0x44, 0x7A,
  0xF0, 0x08, 0x88, 0xC4, 0x23, 0x18, 0x84, 0x30, 0x84, 0x10, 0x20, 0x84,
  0x30, 0x84, 0x63, 0x10, 0x8C, 0x44, 0x40, 0x08, 0x21, 0x5D, 0xC2, 0x8D,
  0x13, 0x00, 0x10, 0x20, 0x47, 0xF3, 0x04, 0x08, 0x00, 0x6D, 0x60, 0xFC,
  0xB0, 0x06, 0x08, 0x30, 0x41, 0x02, 0x08, 0x10, 0x40, 0x82, 0x00, 0x3C,
  0x89, 0x1E, 0x39, 0xD4, 0xB1, 0x42, 0x88, 0xF0, 0x1F, 0xB3, 0x22, 0x22,
  0x66, 0x3C, 0x45, 0x08, 0x10, 0x41, 0x04, 0x10, 0x41, 0xFC, 0x1C, 0x45,
  0x88, 0x11, 0xC1, 0x81, 0xE2, 0x44, 0xF0, 0x06, 0x0C, 0x28, 0xB2, 0x4C,
  0x91, 0x7F, 0x0C, 0x18, 0x3E, 0x41, 0x82, 0x87, 0xC0, 0x81, 0x42, 0x8C,
  0xF0, 0x1C, 0xC4, 0x14, 0xFA, 0x18, 0x61, 0x89, 0xC0, 0x7F, 0x0C, 0x10,
  0x40, 0x82, 0x0C, 0x10, 0x61, 0x80, 0x3C, 0xCD, 0x1A, 0x23, 0xCD, 0xA1,
  0x42, 0x8C, 0xF0, 0x39, 0x14, 0x71, 0xC5, 0x33, 0x42, 0x19, 0x80, 0x6C,
  0x00, 0x36, 0x33, 0x00, 0x00, 0x66, 0x4C, 0x04, 0x33, 0x30, 0x70, 0x70,
  0x40, 0xFC, 0x0F, 0xFF, 0x81, 0x83, 0x81, 0x3B, 0x88, 0x00, 0x7B, 0x20,
  0xC2, 0x18, 0x86, 0x00, 0x01, 0x00, 0x1E, 0x21, 0x2D, 0x55, 0x55, 0xA5,
  0xA9, 0x96, 0x40, 0x38, 0x0C, 0x18, 0x70, 0xA3, 0x44, 0x8F, 0xA1, 0x43,
  0x04, 0x3E, 0x23, 0x23, 0x22, 0x7C, 0x46, 0x42, 0x42, 0x46, 0xFC, 0x3C,
  0x8D, 0x0C, 0x08, 0x10, 0x20, 0x42, 0x8C, 0xF0, 0x3C, 0x22, 0x23, 0x61,
  0x61, 0x43, 0x42, 0x42, 0x4C, 0xF8, 0x3F, 0x20, 0x20, 0x20, 0x7E, 0x60,
  0x40, 0x40, 0x40, 0xFE, 0x7E, 0x81, 0x02, 0x04, 0x1F, 0xA0, 0x40, 0x81,
  0x00, 0x3C, 0xCF, 0x0C, 0x08, 0x13, 0xE1, 0x42, 0xC4, 0xF0, 0x21, 0x21,
  0x21, 0x63, 0x7E, 0x42, 0x42, 0x42, 0xC2, 0x86, 0x3F, 0x08, 0x08, 0x08,
  0x08, 0x18, 0x18, 0x10, 0x10, 0xFC, 0x01, 0x03, 0x03, 0x02, 0x02, 0x02,
  0x02, 0xC6, 0x44, 0x78, 0x21, 0x91, 0x09, 0x05, 0x07, 0x83, 0x41, 0x20,
  0x88, 0x44, 0x63, 0x00, 0x61, 0x04, 0x10, 0x43, 0x08, 0x20, 0x83, 0xF0,
  0x31, 0x33, 0x37, 0x75, 0x5F, 0x5A, 0x5A, 0x42, 0x42, 0xC6, 0x21, 0x31,
  0x31, 0x73, 0x5A, 0x4A, 0x4A, 0x4E, 0xC6, 0xC6, 0x3C, 0xC9, 0x1C, 0x18,
  0x70, 0xE1, 0x42, 0x88, 0xE0, 0x7C, 0x8D, 0x0A, 0x14, 0x7F, 0x20, 0x40,
  0x81, 0x00, 0x3C, 0xCB, 0x0C, 0x18, 0x30, 0xE1, 0x42, 0x88, 0xE0, 0x30,
  0x40, 0x3E, 0x23, 0x21, 0x23, 0x62, 0x7C, 0x44, 0x44, 0x44, 0xC6, 0x3C,
  0x8D, 0x0A, 0x07, 0x03, 0x81, 0x42, 0x8C, 0xF0, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x42, 0x85, 0x0E, 0x38, 0x50, 0xA1,
  0x42, 0x88, 0xE0, 0xC3, 0x42, 0x44, 0x44, 0x4C, 0x48, 0x78, 0x30, 0x30,
  0x20, 0xDB, 0x9A, 0x9A, 0xAA, 0xAE, 0xAC, 0xCC, 0xCC, 0xC8, 0x88, 0x21,
  0x99, 0x85, 0x82, 0x81, 0x80, 0xC0, 0xF0, 0x48, 0x44, 0x63, 0x00, 0xC3,
  0x46, 0x44, 0x28, 0x38, 0x30, 0x20, 0x20, 0x20, 0x20, 0x3F, 0x02, 0x06,
  0x0C, 0x08, 0x10, 0x30, 0x60, 0x40, 0xFE, 0x39, 0x08, 0xC4, 0x21, 0x08,
  0x46, 0x21, 0x0E, 0x00, 0x92, 0x4C, 0x92, 0x4C, 0x80, 0x31, 0x11, 0x13,
  0x22, 0x22, 0x26, 0xC0, 0x31, 0x94, 0xA9, 0x80, 0xFC, 0x90, 0x11, 0xBC,
  0x47, 0xE6, 0x38, 0xBE, 0x30, 0x40, 0x81, 0x43, 0xEC, 0x50, 0xA1, 0x42,
  0x8B, 0xF0, 0x11, 0xBC, 0x60, 0x82, 0x08, 0xDE, 0x02, 0x04, 0x18, 0xB7,
  0xD8, 0xA1, 0x42, 0x8D, 0x19, 0xE0, 0x11, 0xBC, 0x61, 0xFE, 0x08, 0xDE,
  0x0F, 0x19, 0x10, 0x12, 0xFC, 0x20, 0x20, 0x20, 0x20, 0x20, 0x60, 0x09,
  0x3E, 0x62, 0x42, 0x42, 0x46, 0x46, 0x3C, 0x04, 0xCC, 0x78, 0x30, 0x40,
  0x81, 0x23, 0xEC, 0x50, 0xA1, 0x42, 0x8F, 0x10, 0x08, 0x00, 0x9C, 0x10,
  0x41, 0x04, 0x33, 0xF0, 0x06, 0x00, 0x01, 0xE0, 0x41, 0x83, 0x04, 0x08,
  0x10, 0x20, 0x8E, 0x00, 0x30, 0x20, 0x20, 0x21, 0x26, 0x6C, 0x50, 0x78,
  0x48, 0x4C, 0xC6, 0x79, 0xE0, 0x86, 0x10, 0x41, 0x04, 0x10, 0xCF, 0xC0,
  0x12, 0x7F, 0x49, 0x4B, 0x5A, 0xD2, 0x92, 0x92, 0x08, 0x7D, 0x8A, 0x14,
  0x28, 0x51, 0xE2, 0x11, 0xFC, 0x61, 0x86, 0x18, 0x9E, 0x08, 0x7D, 0x8A,
  0x14, 0x28, 0x51, 0x3E, 0xC1, 0x02, 0x00, 0x12, 0xDB, 0x14, 0x28, 0x51,
  0xA3, 0x3C, 0x08, 0x10, 0x20, 0x06, 0x79, 0x82, 0x04, 0x08, 0x10, 0x60,
  0x11, 0xF4, 0x50, 0x38, 0x18, 0xDE, 0x10, 0xCF, 0xC8, 0x20, 0x82, 0x08,
  0x38, 0x47, 0x8B, 0x14, 0x28, 0xD1, 0x9E, 0x00, 0xC6, 0x89, 0x22, 0x45,
  0x06, 0x08, 0x00, 0x93, 0x66, 0xD5, 0xAD, 0x59, 0x22, 0x00, 0x63, 0x34,
  0x18, 0x18, 0x38, 0x64, 0xC6, 0x63, 0x22, 0x26, 0x24, 0x38, 0x18, 0x10,
  0x30, 0x20, 0xC0, 0x7E, 0x08, 0x20, 0xC3, 0x0C, 0x3F, 0x80, 0x0C, 0x41,
  0x04, 0x30, 0x8C, 0x10, 0x20, 0x86, 0x08, 0x20, 0x40, 0x55, 0x5A, 0xAA,
  0x80, 0x20, 0x41, 0x04, 0x10, 0x40, 0xC6, 0x30, 0x82, 0x08, 0x42, 0x00,
  0x00, 0x71, 0x8E,
};

const GFXglyph RobotoMono_Italic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 10, 8, 3, -10 },
  { 5, 4, 4, 8, 3, -11 },
  { 7, 8, 10, 8, 0, -10 },
  { 17, 7, 13, 8, 1, -12 },
  { 29, 7, 10, 8, 1, -10 },
  { 38, 8, 10, 8, 0, -10 },
  { 48, 1, 4, 8, 4, -11 },
  { 49, 5, 14, 8, 2, -11 },
  { 58, 5, 14, 8, 1, -11 },
  { 67, 7, 7, 8, 1, -10 },
  { 74, 7, 7, 8, 1, -8 },
  { 81, 3, 4, 8, 1, -2 },
  { 83, 6, 1, 8, 1, -5 },
  { 84, 2, 2, 8, 3, -2 },
  { 85, 7, 11, 8, 1, -10 },
  { 95, 7, 10, 8, 1, -10 },
  { 104, 4, 10, 8, 2, -10 },
  { 109, 7, 10, 8, 0, -10 },
  { 118, 7, 10, 8, 0, -10 },
  { 127, 7, 10, 8, 0, -10 },
  { 136, 7, 10, 8, 1, -10 },
  { 145, 6, 10, 8, 1, -10 },
  { 153, 7, 10, 8, 1, -10 },
  { 162, 7, 10, 8, 1, -10 },
  { 171, 6, 10, 8, 1, -10 },
  { 179, 3, 8, 8, 3, -8 },
  { 182, 4, 10, 8, 2, -8 },
  { 187, 6, 7, 8, 1, -8 },
  { 193, 6, 4, 8, 1, -6 },
  { 196, 6, 7, 8, 1, -8 },
  { 202, 6, 10, 8, 2, -10 },
  { 210, 8, 10, 8, 0, -10 },
  { 220, 7, 10, 8, 0, -10 },
  { 229, 8, 10, 8, 0, -10 },
  { 239, 7, 10, 8, 1, -10 },
  { 248, 8, 10, 8, 0, -10 },
  { 258, 8, 10, 8, 0, -10 },
  { 268, 7, 10, 8, 1, -10 },
  { 277, 7, 10, 8, 1, -10 },
  { 286, 8, 10, 8, 0, -10 },
  { 296, 8, 10, 8, 0, -10 },
  { 306, 8, 10, 8, 0, -10 },
  { 316, 9, 10, 8, 0, -10 },
  { 328, 6, 10, 8, 1, -10 },
  { 336, 8, 10, 8, 0, -10 },
  { 346, 8, 10, 8, 0, -10 },
  { 356, 7, 10, 8, 1, -10 },
  { 365, 7, 10, 8, 1, -10 },
  { 374, 7, 12, 8, 1, -10 },
  { 385, 8, 10, 8, 0, -10 },
  { 395, 7, 10, 8, 1, -10 },
  { 404, 8, 10, 8, 1, -10 },
  { 414, 7, 10, 8, 1, -10 },
  { 423, 8, 10, 8, 1, -10 },
  { 433, 8, 10, 8, 1, -10 },
  { 443, 9, 10, 8, 0, -10 },
  { 455, 8, 10, 8, 1, -10 },
  { 465, 8, 10, 8, 0, -10 },
  { 475, 5, 13, 8, 2, -11 },
  { 484, 3, 11, 8, 3, -10 },
  { 489, 4, 13, 8, 2, -11 },
  { 496, 5, 5, 8, 2, -10 },
  { 500, 6, 1, 8, 0, 0 },
  { 501, 2, 2, 8, 4, -10 },
  { 502, 6, 8, 8, 1, -8 },
  { 508, 7, 11, 8, 0, -11 },
  { 518, 6, 8, 8, 1, -8 },
  { 524, 7, 11, 8, 1, -11 },
  { 534, 6, 8, 8, 1, -8 },
  { 540, 8, 11, 8, 1, -11 },
  { 551, 8, 11, 8, 0, -8 },
  { 562, 7, 11, 8, 0, -11 },
  { 572, 6, 10, 8, 1, -10 },
  { 580, 7, 13, 8, 0, -10 },
  { 592, 8, 11, 8, 0, -11 },
  { 603, 6, 11, 8, 1, -11 },
  { 612, 8, 8, 8, 0, -8 },
  { 620, 7, 8, 8, 0, -8 },
  { 627, 6, 8, 8, 1, -8 },
  { 633, 7, 11, 8, 0, -8 },
  { 643, 7, 11, 8, 1, -8 },
  { 653, 7, 8, 8, 1, -8 },
  { 660, 6, 8, 8, 1, -8 },
  { 666, 6, 9, 8, 1, -9 },
  { 673, 7, 7, 8, 1, -7 },
  { 680, 7, 7, 8, 1, -7 },
  { 687, 7, 7, 8, 1, -7 },
  { 694, 8, 7, 8, 0, -7 },
  { 701, 8, 10, 8, 0, -7 },
  { 711, 7, 7, 8, 0, -7 },
  { 718, 6, 14, 8, 2, -11 },
  { 729, 2, 13, 8, 3, -10 },
  { 733, 6, 14, 8, 1, -11 },
  { 744, 8, 3, 8, 0, -6 },
};

const GFXfont RobotoMono_Italic14pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic14pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOMONO_ITALIC14PT7B_H_
