#ifndef _ROBOTOMONO_ITALIC52PT7B_H_
#define _ROBOTOMONO_ITALIC52PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic52pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0x78, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0E, 0x70,
  0x39, 0xC1, 0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0x81, 0xCE, 0x07, 0x38,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x03,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0x3E, 0x07,
  0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E,
  0x0F, 0x80, 0x07, 0x83, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07,
  0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x21, 0xC0, 0xF0, 0x38, 0xE0, 0x78, 0x3E, 0xF0, 0x3C, 0x1E,
  0x78, 0x1E, 0x1E, 0x3C, 0x0F, 0x1E, 0x1E, 0x07, 0x0E, 0x07, 0x07, 0x8F,
  0x03, 0xE7, 0x8F, 0x00, 0xFF, 0xCF, 0x00, 0x3F, 0xC7, 0x80, 0x0F, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x01, 0xE3, 0xFC, 0x01,
  0xE3, 0xFF, 0x00, 0xF3, 0xE7, 0x80, 0xF3, 0xC1, 0xE0, 0xF1, 0xE0, 0xF0,
  0x70, 0xE0, 0x78, 0x78, 0x70, 0x3C, 0x78, 0x78, 0x1E, 0x78, 0x3C, 0x0F,
  0x0C, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFE, 0x7E, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x1F,
  0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3E,
  0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0xF3, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x1F, 0x1F, 0xCF, 0x81, 0xE1, 0xF0, 0xF8, 0x1E, 0x3F, 0x07,
  0xC1, 0xE3, 0xE0, 0x3E, 0x3E, 0x7C, 0x03, 0xE3, 0xC7, 0xC0, 0x1F, 0x7C,
  0x78, 0x01, 0xFF, 0x87, 0x80, 0x0F, 0xF8, 0x78, 0x00, 0xFF, 0x07, 0xC0,
  0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0xE0, 0x3F, 0x8F, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x8F, 0x80, 0x3F, 0xE0, 0xFC, 0x00,
  0x20, 0x00, 0x00, 0x3C, 0xF3, 0x9E, 0x79, 0xE7, 0x9C, 0x73, 0xCF, 0x3C,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x30, 0x1E, 0x03, 0x78, 0x3C, 0x1F, 0xFC,
  0x71, 0xFF, 0xFE, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x3C,
  0x00, 0x3E, 0x3C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x0C, 0x01, 0xC0, 0x08, 0x02, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x87,
  0xC3, 0xE1, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x83, 0x80, 0x80, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xC7, 0xE0, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x8F, 0x80,
  0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0,
  0x01, 0xFC, 0xF8, 0x01, 0xFE, 0x78, 0x01, 0xFF, 0x3C, 0x03, 0xFF, 0xBE,
  0x03, 0xF7, 0xDF, 0x07, 0xE3, 0xEF, 0x87, 0xE1, 0xE7, 0xCF, 0xE0, 0xF3,
  0xCF, 0xC0, 0xF9, 0xFF, 0xC0, 0x7C, 0xFF, 0x80, 0x3E, 0xFF, 0x80, 0x1F,
  0x7F, 0x00, 0x0F, 0x3F, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0xE3, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x1E,
  0x00, 0x7E, 0x03, 0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xBE, 0x7E, 0x3C,
  0xF0, 0x3C, 0x80, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xE3, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0xFC, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0xC1, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x78, 0x0F,
  0x80, 0x3C, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x1F, 0x01, 0xE0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xCF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xF0,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0x7C,
  0x03, 0xF0, 0x1F, 0xC3, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC7, 0xF0, 0x0F,
  0x3F, 0xF8, 0x1E, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0x01, 0xF1, 0xFC,
  0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0x7F, 0x1F, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x07,
  0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0x81, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x7E,
  0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1, 0xE0, 0x01,
  0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFE, 0x7F, 0x03, 0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x3E, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF3, 0xE0, 0x0F, 0xE7, 0xE0, 0x3F,
  0xC7, 0xE1, 0xFF, 0x0F, 0xFF, 0xDE, 0x0F, 0xFF, 0x7C, 0x07, 0xFC, 0xF0,
  0x01, 0xC1, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0x80, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x03, 0xF0, 0x7E,
  0x1F, 0xE3, 0xFC, 0x3F, 0x07, 0xE0, 0x20, 0x00, 0x00, 0x30, 0x03, 0xE0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0x80, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x70,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x10, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0x80, 0xF9, 0xF0, 0x03,
  0xEF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x0E, 0x0F, 0x07, 0xF0, 0xE0, 0xE0, 0xFF, 0x86, 0x1C, 0x1F, 0xF8,
  0x71, 0xC3, 0xC3, 0x87, 0x38, 0x78, 0x38, 0x73, 0x87, 0x03, 0x87, 0x78,
  0xF0, 0x30, 0x77, 0x0E, 0x07, 0x07, 0x70, 0xE0, 0x70, 0x6F, 0x1E, 0x07,
  0x06, 0xE1, 0xC0, 0x60, 0xEE, 0x1C, 0x0E, 0x0E, 0xE1, 0xC0, 0xE0, 0xEE,
  0x1C, 0x0E, 0x0C, 0xE1, 0xC0, 0xC1, 0xCE, 0x1C, 0x1C, 0x1C, 0xE1, 0xC3,
  0xC3, 0x8E, 0x1F, 0xFE, 0x78, 0xE1, 0xFE, 0xFF, 0x0E, 0x0F, 0xCF, 0xE0,
  0xE0, 0x70, 0x78, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x80, 0x03, 0xF0, 0x38, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1E, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01,
  0xF0, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x1F,
  0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x03, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x0F, 0x87, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0xC3, 0xC0, 0x03,
  0xF0, 0xF8, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x13, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xC1, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xF8, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xC0, 0x3F, 0x80, 0x3C, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x1F,
  0x00, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x83,
  0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00,
  0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0x7C, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xFC, 0xF0,
  0x07, 0xFF, 0x9E, 0x00, 0xFF, 0xF3, 0xC0, 0x1F, 0xFC, 0xF8, 0x00, 0x07,
  0x9F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x78,
  0x3E, 0x00, 0x1F, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF0,
  0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xE0, 0x1F, 0x80,
  0x07, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3C, 0x3F, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0x80,
  0x00, 0xFF, 0x3E, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x80, 0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0xE0,
  0x7B, 0xC0, 0x7B, 0x81, 0xEF, 0x03, 0xEF, 0x0F, 0x3C, 0x0F, 0x3C, 0x3C,
  0xF0, 0x3C, 0xF1, 0xE7, 0xC0, 0xF3, 0xC7, 0x9E, 0x03, 0xCF, 0x3C, 0x78,
  0x0F, 0x1C, 0xF1, 0xE0, 0x7C, 0x77, 0x87, 0x81, 0xF1, 0xFE, 0x3E, 0x07,
  0x87, 0xF0, 0xF8, 0x1E, 0x1F, 0xC3, 0xC0, 0x78, 0x7E, 0x0F, 0x01, 0xE1,
  0xF8, 0x3C, 0x0F, 0x83, 0xC1, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0x38,
  0x1E, 0x03, 0xC0, 0xE0, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xE0, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0xF8, 0x1F, 0xE0, 0x03, 0xE0, 0x7F, 0x80, 0x0F, 0x01, 0xFE, 0x00,
  0x3C, 0x07, 0xFC, 0x01, 0xF0, 0x1E, 0xF0, 0x07, 0xC0, 0xFB, 0xC0, 0x1F,
  0x03, 0xEF, 0x80, 0x7C, 0x0F, 0xBE, 0x01, 0xE0, 0x3E, 0x78, 0x07, 0x80,
  0xF1, 0xF0, 0x3E, 0x03, 0xC7, 0xC0, 0xF8, 0x1F, 0x0F, 0x03, 0xE0, 0x7C,
  0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x3C, 0x07, 0xC1, 0xE1, 0xF0, 0x1E, 0x07,
  0xC7, 0xC0, 0x78, 0x1F, 0x1F, 0x03, 0xE0, 0x3C, 0x7C, 0x0F, 0x80, 0xF9,
  0xE0, 0x3E, 0x03, 0xE7, 0x80, 0xF8, 0x07, 0xBE, 0x03, 0xC0, 0x1F, 0xF8,
  0x0F, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0xFF, 0x81, 0xF0, 0x03, 0xFC, 0x07,
  0xC0, 0x0F, 0xF0, 0x1E, 0x00, 0x1F, 0xC0, 0x78, 0x00, 0x7F, 0x03, 0xE0,
  0x01, 0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x7C, 0x01,
  0xF0, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xE3, 0xE0,
  0x00, 0x78, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xBC, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0x7C, 0x01,
  0xF8, 0x0F, 0x80, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03,
  0xC0, 0x0F, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE0, 0xF0, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0xC1, 0xF0, 0x01, 0xF8,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xC1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBC,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xE0,
  0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7C, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8,
  0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x0F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x01, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x3F,
  0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x03, 0xFD,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0x80,
  0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x01,
  0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF8,
  0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0xFB, 0xC0, 0x7C, 0x07, 0x9E, 0x03, 0xE0, 0x3C, 0xF0, 0x1F, 0x03, 0xE7,
  0x81, 0xF8, 0x1E, 0x3C, 0x0F, 0xC0, 0xF1, 0xE0, 0x7E, 0x0F, 0x8F, 0x07,
  0xF0, 0x7C, 0x78, 0x3F, 0x83, 0xC3, 0xC1, 0xDC, 0x1E, 0x1E, 0x1E, 0xE1,
  0xF0, 0xF0, 0xF7, 0x0F, 0x07, 0x87, 0x38, 0x78, 0x3C, 0x79, 0xC3, 0xC1,
  0xE3, 0xCE, 0x3E, 0x0F, 0x1C, 0x71, 0xE0, 0x79, 0xE3, 0x8F, 0x03, 0xCF,
  0x1C, 0x78, 0x3E, 0x78, 0xE7, 0xC1, 0xE7, 0x87, 0x3C, 0x0F, 0x3C, 0x39,
  0xE0, 0x79, 0xE1, 0xCF, 0x03, 0xDE, 0x0E, 0xF0, 0x1E, 0xF0, 0x77, 0x80,
  0xF7, 0x83, 0xBC, 0x07, 0xF8, 0x1D, 0xE0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x03, 0xF8, 0x0F,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x78, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x1E, 0x3F, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x3F, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F, 0x1E,
  0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x80, 0xF1, 0xF0, 0x1E,
  0x3C, 0x03, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0xFC, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xF8, 0x7C,
  0x7C, 0x3E, 0x1E, 0x0F, 0x0F, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x3F, 0x80, 0x1E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x7C,
  0x00, 0xFC, 0x7E, 0x03, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFE, 0x7C, 0x07, 0xFC, 0x7C, 0x00, 0x40, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0xF9, 0xFF,
  0x80, 0x7B, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xE0, 0xFC, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xE0,
  0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE7,
  0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0xC0, 0x7E, 0x1F, 0xFD, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0x9F, 0xFF, 0x03, 0xC3, 0xFE, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x3E, 0x01,
  0xF8, 0x3F, 0x8F, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0x87, 0xC0, 0x1F, 0xFC, 0xF8,
  0x07, 0xFF, 0xDF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0x80,
  0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x7C,
  0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF8,
  0x0F, 0xE0, 0x1F, 0xEF, 0xFC, 0x01, 0xFF, 0xF7, 0x80, 0x3F, 0xFD, 0xF0,
  0x01, 0xFE, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0x7C, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x10, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0xFC, 0x3F, 0xC7, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xF8, 0x04, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x3C, 0x03, 0xFF, 0xEF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0x03,
  0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x07, 0xC0,
  0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0,
  0x3C, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x0F, 0xF7,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0xF8, 0x00, 0xFF, 0x1F, 0x00,
  0x03, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0x00, 0x07,
  0xC0, 0x30, 0x00, 0xF8, 0x0F, 0x00, 0x7E, 0x03, 0xF8, 0x1F, 0xC0, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0xF8, 0xFF, 0xC0, 0x79, 0xFF, 0xF0, 0x3D, 0xFF, 0xF8,
  0x1F, 0xE0, 0xFE, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x07, 0x87, 0xC0, 0x03,
  0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3C, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x8F, 0x00,
  0x07, 0xC7, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xE3,
  0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x10, 0xF8, 0x01, 0xFC, 0x1F, 0x00,
  0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x78, 0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x03,
  0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x8F, 0xE0, 0x01, 0xF3, 0xF8,
  0x00, 0x3C, 0xFC, 0x00, 0x07, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xCF, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x3F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x9F, 0x07, 0xC0, 0x7B,
  0xFC, 0x7F, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xF8, 0x7F,
  0x0F, 0x87, 0x81, 0xF0, 0x7C, 0x7C, 0x0F, 0x01, 0xE3, 0xE0, 0x78, 0x1F,
  0x1E, 0x03, 0xC0, 0xF8, 0xF0, 0x3E, 0x07, 0xC7, 0x81, 0xF0, 0x3C, 0x7C,
  0x0F, 0x81, 0xE3, 0xE0, 0x78, 0x0F, 0x1F, 0x03, 0xC0, 0xF8, 0xF0, 0x1E,
  0x07, 0xC7, 0x81, 0xF0, 0x3E, 0x3C, 0x0F, 0x81, 0xE3, 0xE0, 0x78, 0x0F,
  0x1F, 0x03, 0xC0, 0x78, 0xF0, 0x1E, 0x07, 0xC7, 0x80, 0xF0, 0x3E, 0x3C,
  0x0F, 0x81, 0xF1, 0xE0, 0x7C, 0x0F, 0x1F, 0x03, 0xC0, 0x78, 0xF8, 0x1E,
  0x03, 0xC7, 0x80, 0xF0, 0x3E, 0x3C, 0x07, 0x81, 0xF1, 0xE0, 0x7C, 0x0F,
  0x80, 0x07, 0x83, 0xF0, 0x07, 0x8F, 0xFE, 0x03, 0xCF, 0xFF, 0x81, 0xEF,
  0xFF, 0xC0, 0xFF, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x3C, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3C, 0x00,
  0x1F, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x3F, 0x8F, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE1, 0xF8, 0x00,
  0x79, 0xFF, 0xC0, 0x0F, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1,
  0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F, 0xF1, 0xFE, 0x07, 0xFF, 0xFF, 0x80,
  0xFB, 0xFF, 0xC0, 0x1E, 0x1F, 0xF0, 0x03, 0xC0, 0x20, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xE3, 0xC0, 0xFF, 0xFB, 0xE0, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xF0,
  0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x78, 0xF8, 0x00,
  0x3C, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xFC, 0x07, 0xF0, 0x3F,
  0x8F, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xBE, 0x00, 0xFF, 0x1E, 0x00,
  0x0C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x41,
  0xFE, 0x0F, 0x0F, 0xFC, 0x1E, 0x7F, 0xF8, 0x3D, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE1, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0,
  0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x7F, 0x7F, 0xF0, 0x7F,
  0xFE, 0xF0, 0x3F, 0xF9, 0xF0, 0x1F, 0xF1, 0xE0, 0x01, 0x00, 0x00, 0xB8,
  0x00, 0x00, 0x5E, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x01,
  0xF0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x78,
  0x07, 0xBC, 0x03, 0xC0, 0x79, 0xE0, 0x3E, 0x03, 0xC7, 0x01, 0xF0, 0x1E,
  0x38, 0x1F, 0x81, 0xE1, 0xC0, 0xFC, 0x0F, 0x0E, 0x07, 0xE0, 0x78, 0x70,
  0x77, 0x07, 0x83, 0x83, 0xB8, 0x3C, 0x1C, 0x3D, 0xE1, 0xC0, 0xE1, 0xCF,
  0x1E, 0x07, 0x1E, 0x78, 0xF0, 0x38, 0xF3, 0xC7, 0x01, 0xC7, 0x0E, 0x78,
  0x0E, 0x78, 0x73, 0x80, 0x73, 0x83, 0x9C, 0x03, 0xBC, 0x1D, 0xE0, 0x1D,
  0xC0, 0xEE, 0x00, 0xEE, 0x07, 0x70, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F,
  0x1F, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0x80, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x40, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x00,
  0x01, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0x3F, 0xFE, 0x00, 0x77, 0xFF, 0xF0, 0x0F, 0x78, 0x3F, 0x81, 0xFF, 0x00,
  0xFE, 0x7E, 0xF0, 0x07, 0xFF, 0xEE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoMono_Italic52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 11, 37, 31, 10, -37 },
  { 52, 14, 12, 31, 11, -39 },
  { 73, 30, 37, 31, 1, -37 },
  { 212, 26, 48, 31, 3, -43 },
  { 368, 25, 39, 31, 3, -38 },
  { 490, 28, 39, 31, 1, -38 },
  { 627, 6, 12, 31, 14, -39 },
  { 636, 18, 54, 31, 8, -42 },
  { 758, 17, 54, 31, 4, -42 },
  { 873, 23, 25, 31, 6, -37 },
  { 945, 25, 27, 31, 3, -31 },
  { 1030, 9, 15, 31, 5, -6 },
  { 1047, 20, 4, 31, 5, -18 },
  { 1057, 7, 8, 31, 10, -7 },
  { 1064, 26, 40, 31, 3, -37 },
  { 1194, 25, 39, 31, 3, -38 },
  { 1316, 16, 37, 31, 7, -37 },
  { 1390, 27, 38, 31, 0, -38 },
  { 1519, 26, 39, 31, 1, -38 },
  { 1646, 26, 37, 31, 1, -37 },
  { 1767, 26, 38, 31, 4, -37 },
  { 1891, 23, 38, 31, 3, -37 },
  { 2001, 25, 37, 31, 5, -37 },
  { 2117, 26, 39, 31, 3, -38 },
  { 2244, 23, 38, 31, 5, -38 },
  { 2354, 11, 30, 31, 11, -29 },
  { 2396, 14, 38, 31, 8, -29 },
  { 2463, 23, 23, 31, 4, -28 },
  { 2530, 25, 15, 31, 3, -24 },
  { 2577, 24, 23, 31, 3, -28 },
  { 2646, 21, 38, 31, 7, -38 },
  { 2746, 28, 37, 31, 2, -37 },
  { 2876, 27, 37, 31, -1, -37 },
  { 3001, 27, 37, 31, 2, -37 },
  { 3126, 26, 39, 31, 3, -38 },
  { 3253, 28, 37, 31, 1, -37 },
  { 3383, 28, 37, 31, 2, -37 },
  { 3513, 29, 37, 31, 2, -37 },
  { 3648, 27, 39, 31, 2, -38 },
  { 3780, 30, 37, 31, 1, -37 },
  { 3919, 28, 37, 31, 2, -37 },
  { 4049, 28, 38, 31, 2, -37 },
  { 4182, 30, 37, 31, 2, -37 },
  { 4321, 23, 37, 31, 2, -37 },
  { 4428, 30, 37, 31, 1, -37 },
  { 4567, 30, 37, 31, 1, -37 },
  { 4706, 26, 39, 31, 3, -38 },
  { 4833, 28, 37, 31, 2, -37 },
  { 4963, 27, 44, 31, 2, -38 },
  { 5112, 27, 37, 31, 2, -37 },
  { 5237, 28, 39, 31, 2, -38 },
  { 5374, 27, 37, 31, 5, -37 },
  { 5499, 28, 38, 31, 3, -37 },
  { 5632, 27, 37, 31, 5, -37 },
  { 5757, 29, 37, 31, 4, -37 },
  { 5892, 32, 37, 31, 0, -37 },
  { 6040, 27, 37, 31, 5, -37 },
  { 6165, 29, 37, 31, 0, -37 },
  { 6300, 18, 50, 31, 7, -42 },
  { 6413, 12, 40, 31, 10, -37 },
  { 6473, 18, 50, 31, 6, -42 },
  { 6586, 19, 20, 31, 6, -37 },
  { 6634, 23, 4, 31, 1, 0 },
  { 6646, 8, 7, 31, 14, -38 },
  { 6653, 24, 29, 31, 2, -28 },
  { 6740, 25, 40, 31, 2, -39 },
  { 6865, 24, 29, 31, 3, -28 },
  { 6952, 27, 40, 31, 3, -39 },
  { 7087, 24, 29, 31, 3, -28 },
  { 7174, 27, 40, 31, 5, -40 },
  { 7309, 27, 39, 31, 1, -28 },
  { 7441, 25, 39, 31, 2, -39 },
  { 7563, 23, 38, 31, 2, -38 },
  { 7673, 23, 49, 31, 1, -38 },
  { 7814, 27, 39, 31, 2, -39 },
  { 7946, 23, 39, 31, 2, -39 },
  { 8059, 29, 28, 31, 0, -28 },
  { 8161, 25, 28, 31, 2, -28 },
  { 8249, 24, 29, 31, 3, -28 },
  { 8336, 27, 39, 31, 0, -28 },
  { 8468, 25, 39, 31, 3, -28 },
  { 8590, 23, 28, 31, 5, -28 },
  { 8671, 24, 29, 31, 3, -28 },
  { 8758, 22, 35, 31, 5, -34 },
  { 8855, 24, 28, 31, 4, -27 },
  { 8939, 26, 28, 31, 4, -28 },
  { 9030, 29, 27, 31, 3, -27 },
  { 9128, 30, 27, 31, 0, -27 },
  { 9230, 32, 38, 31, -1, -27 },
  { 9382, 26, 27, 31, 2, -27 },
  { 9470, 20, 50, 31, 8, -41 },
  { 9595, 11, 47, 31, 9, -37 },
  { 9660, 20, 50, 31, 5, -41 },
  { 9785, 28, 10, 31, 1, -20 },
};

const GFXfont RobotoMono_Italic52pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic52pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOMONO_ITALIC52PT7B_H_
