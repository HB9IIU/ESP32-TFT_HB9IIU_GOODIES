#ifndef _ROBOTOMONO_ITALIC7PT7B_H_
#define _ROBOTOMONO_ITALIC7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic7pt7bBitmaps[] PROGMEM = {
  0x00, 0x54, 0x80, 0xC0, 0x37, 0x6F, 0xA0, 0x27, 0x52, 0x96, 0x40, 0xDE,
  0x27, 0x30, 0x66, 0x4B, 0xF0, 0x80, 0x5A, 0xA9, 0x95, 0x5A, 0x5F, 0x00,
  0x2F, 0x44, 0xC0, 0xC0, 0x80, 0x12, 0x24, 0xC0, 0x75, 0xF9, 0x60, 0xD5,
  0x80, 0x61, 0x24, 0xE0, 0x61, 0x62, 0xE0, 0x32, 0x6F, 0x20, 0x74, 0x79,
  0x60, 0x29, 0xD6, 0xE5, 0x48, 0x75, 0x69, 0x60, 0xD6, 0xAC, 0x90, 0x42,
  0x80, 0x39, 0x00, 0x7F, 0x43, 0xC0, 0xE5, 0x48, 0x7F, 0xFF, 0xE0, 0x22,
  0x66, 0x90, 0x75, 0x69, 0xE0, 0x79, 0x89, 0x60, 0x65, 0x99, 0xE0, 0x74,
  0x68, 0xE0, 0x74, 0x68, 0x80, 0x78, 0xA9, 0x60, 0x59, 0x79, 0x90, 0x72,
  0x24, 0xE0, 0x11, 0x11, 0xE0, 0x56, 0x4A, 0xB0, 0x49, 0x4E, 0x55, 0xBD,
  0x90, 0x55, 0xBB, 0xA0, 0x79, 0x99, 0x60, 0x75, 0x78, 0x80, 0x79, 0x99,
  0x62, 0x75, 0x6A, 0xA0, 0x74, 0x69, 0x60, 0xE9, 0x48, 0x55, 0x99, 0x60,
  0xB7, 0x68, 0xFF, 0xEC, 0x56, 0x26, 0xB0, 0xB7, 0x48, 0x72, 0x24, 0xE0,
  0x5A, 0xA8, 0xA5, 0x40, 0x55, 0x58, 0x7C, 0xE0, 0x80, 0x63, 0xDE, 0x46,
  0x99, 0xE0, 0x69, 0x86, 0x17, 0x99, 0x60, 0x69, 0xE6, 0x7E, 0x48, 0x79,
  0x96, 0xE0, 0x46, 0x99, 0xA0, 0x2C, 0x9E, 0x2C, 0x92, 0x70, 0x45, 0xAE,
  0xA0, 0x64, 0x9E, 0x5B, 0xDD, 0x69, 0x9A, 0x69, 0x96, 0x69, 0x9E, 0x80,
  0x79, 0x96, 0x20, 0xF2, 0x40, 0x65, 0x2E, 0x5E, 0x4C, 0x59, 0x96, 0xB7,
  0x40, 0xBB, 0x6A, 0x56, 0x6A, 0x95, 0x64, 0x48, 0x72, 0x4E, 0x6B, 0x24,
  0x80, 0x56, 0xA0, 0x55, 0xA0, 0xD2,
};

const GFXglyph RobotoMono_Italic7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 5, 4, 1, -5 },
  { 3, 2, 1, 4, 1, -5 },
  { 4, 4, 5, 4, 0, -5 },
  { 7, 4, 7, 4, 0, -6 },
  { 11, 4, 5, 4, 0, -5 },
  { 14, 4, 5, 4, 0, -5 },
  { 17, 1, 1, 4, 2, -5 },
  { 18, 2, 8, 4, 1, -6 },
  { 20, 2, 8, 4, 1, -6 },
  { 22, 3, 3, 4, 1, -5 },
  { 24, 4, 4, 4, 0, -4 },
  { 26, 1, 2, 4, 1, -1 },
  { 27, 2, 1, 4, 1, -3 },
  { 28, 1, 1, 4, 1, -1 },
  { 29, 4, 5, 4, 0, -5 },
  { 32, 4, 5, 4, 0, -5 },
  { 35, 2, 5, 4, 1, -5 },
  { 37, 4, 5, 4, 0, -5 },
  { 40, 4, 5, 4, 0, -5 },
  { 43, 4, 5, 4, 0, -5 },
  { 46, 4, 5, 4, 0, -5 },
  { 49, 3, 5, 4, 0, -5 },
  { 51, 3, 5, 4, 1, -5 },
  { 53, 4, 5, 4, 0, -5 },
  { 56, 3, 5, 4, 1, -5 },
  { 58, 1, 4, 4, 2, -4 },
  { 59, 2, 5, 4, 1, -4 },
  { 61, 3, 3, 4, 1, -4 },
  { 63, 4, 2, 4, 0, -3 },
  { 64, 4, 3, 4, 0, -4 },
  { 66, 3, 5, 4, 1, -5 },
  { 68, 4, 5, 4, 0, -5 },
  { 71, 4, 5, 4, 0, -5 },
  { 74, 4, 5, 4, 0, -5 },
  { 77, 4, 5, 4, 0, -5 },
  { 80, 4, 5, 4, 0, -5 },
  { 83, 4, 5, 4, 0, -5 },
  { 86, 4, 5, 4, 0, -5 },
  { 89, 4, 5, 4, 0, -5 },
  { 92, 4, 5, 4, 0, -5 },
  { 95, 4, 5, 4, 0, -5 },
  { 98, 4, 5, 4, 0, -5 },
  { 101, 4, 5, 4, 0, -5 },
  { 104, 3, 5, 4, 0, -5 },
  { 106, 4, 5, 4, 0, -5 },
  { 109, 4, 5, 4, 0, -5 },
  { 112, 4, 5, 4, 0, -5 },
  { 115, 4, 5, 4, 0, -5 },
  { 118, 4, 6, 4, 0, -5 },
  { 121, 4, 5, 4, 0, -5 },
  { 124, 4, 5, 4, 0, -5 },
  { 127, 3, 5, 4, 1, -5 },
  { 129, 4, 5, 4, 0, -5 },
  { 132, 3, 5, 4, 1, -5 },
  { 134, 3, 5, 4, 1, -5 },
  { 136, 4, 5, 4, 0, -5 },
  { 139, 3, 5, 4, 1, -5 },
  { 141, 4, 5, 4, 0, -5 },
  { 144, 2, 7, 4, 1, -6 },
  { 146, 2, 5, 4, 1, -5 },
  { 148, 2, 7, 4, 1, -6 },
  { 150, 2, 3, 4, 1, -5 },
  { 151, 3, 1, 4, 0, 0 },
  { 152, 1, 1, 4, 2, -5 },
  { 153, 4, 4, 4, 0, -4 },
  { 155, 4, 5, 4, 0, -5 },
  { 158, 4, 4, 4, 0, -4 },
  { 160, 4, 5, 4, 0, -5 },
  { 163, 4, 4, 4, 0, -4 },
  { 165, 3, 5, 4, 1, -5 },
  { 167, 4, 5, 4, 0, -4 },
  { 170, 4, 5, 4, 0, -5 },
  { 173, 3, 5, 4, 0, -5 },
  { 175, 3, 7, 4, 0, -5 },
  { 178, 4, 5, 4, 0, -5 },
  { 181, 3, 5, 4, 0, -5 },
  { 183, 4, 4, 4, 0, -4 },
  { 185, 4, 4, 4, 0, -4 },
  { 187, 4, 4, 4, 0, -4 },
  { 189, 4, 5, 4, 0, -4 },
  { 192, 4, 5, 4, 0, -4 },
  { 195, 3, 4, 4, 1, -4 },
  { 197, 4, 4, 4, 0, -4 },
  { 199, 3, 5, 4, 1, -5 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 3, 4, 4, 1, -4 },
  { 205, 4, 4, 4, 0, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 4, 6, 4, 0, -4 },
  { 212, 4, 4, 4, 0, -4 },
  { 214, 3, 6, 4, 1, -5 },
  { 217, 2, 6, 4, 1, -5 },
  { 219, 2, 6, 4, 1, -5 },
  { 221, 4, 2, 4, 0, -3 },
};

const GFXfont RobotoMono_Italic7pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic7pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic7pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _ROBOTOMONO_ITALIC7PT7B_H_
