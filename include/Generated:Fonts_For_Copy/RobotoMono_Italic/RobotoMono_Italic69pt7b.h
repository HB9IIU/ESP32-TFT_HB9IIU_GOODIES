#ifndef _ROBOTOMONO_ITALIC69PT7B_H_
#define _ROBOTOMONO_ITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x1E, 0x3C,
  0x07, 0xC7, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xC7, 0x80, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xC0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x30, 0x7C, 0x03, 0xC0,
  0x3E, 0x3C, 0x01, 0xE0, 0x1F, 0x1E, 0x00, 0xF0, 0x1F, 0x0F, 0x00, 0x78,
  0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x81, 0xE0, 0x1F,
  0x0F, 0x80, 0xF8, 0x0F, 0x07, 0xC0, 0x7C, 0x0F, 0x87, 0xC0, 0x3F, 0x1F,
  0x87, 0xC0, 0x0F, 0xFF, 0xC7, 0xC0, 0x03, 0xFF, 0xC3, 0xE0, 0x00, 0xFF,
  0x83, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7C, 0x3F, 0xF0, 0x00, 0x7C, 0x3F, 0xFC,
  0x00, 0x3E, 0x3F, 0xFF, 0x00, 0x3E, 0x3F, 0x1F, 0x80, 0x3E, 0x1F, 0x03,
  0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0x80,
  0x7C, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x81, 0xF0,
  0x0F, 0x8F, 0x80, 0xF8, 0x07, 0xC1, 0xC0, 0x7C, 0x03, 0xE0, 0x40, 0x3E,
  0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x03, 0xF7, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0x07, 0xF9, 0xF8, 0x03, 0xF0, 0xFF, 0x1F, 0xC0, 0x3F, 0x1F, 0xE0,
  0xFC, 0x03, 0xE3, 0xFC, 0x0F, 0xE0, 0x3E, 0x3F, 0x80, 0x7E, 0x07, 0xE7,
  0xF0, 0x07, 0xF0, 0x7E, 0x7F, 0x00, 0x3F, 0x8F, 0xC7, 0xE0, 0x03, 0xF8,
  0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0x8F, 0xE0, 0x00, 0xFF, 0xF8, 0xFC, 0x00,
  0x0F, 0xFF, 0x0F, 0xC0, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x07, 0xFE, 0x07,
  0xE0, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF,
  0xC0, 0x3F, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE7, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0x80,
  0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9,
  0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x78, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x10, 0x01, 0xE0, 0x02, 0x3C, 0x01, 0xE0, 0x1E, 0x3F, 0x03, 0xE0,
  0x7E, 0x7F, 0xC3, 0xE3, 0xFE, 0x7F, 0xFB, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x05, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1,
  0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x03,
  0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x3F, 0xE1, 0xF8, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x0F, 0xFE,
  0x3F, 0x00, 0x0F, 0xFF, 0x8F, 0xC0, 0x07, 0xFF, 0xE3, 0xF0, 0x07, 0xFD,
  0xF8, 0xFC, 0x03, 0xFC, 0x7E, 0x3F, 0x03, 0xFE, 0x3F, 0x1F, 0xC1, 0xFE,
  0x0F, 0xC7, 0xE1, 0xFF, 0x03, 0xF1, 0xF8, 0xFF, 0x00, 0xFC, 0x7E, 0x7F,
  0x80, 0x3F, 0x1F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xC0, 0x07, 0xF1, 0xFF,
  0xE0, 0x01, 0xF8, 0xFF, 0xE0, 0x00, 0x7E, 0x3F, 0xF0, 0x00, 0x1F, 0x8F,
  0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F,
  0xFF, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFB, 0xF3,
  0xFE, 0x1F, 0x9F, 0x81, 0xF8, 0xE0, 0x0F, 0xCC, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE3, 0xFF, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xC7,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x0F,
  0xFC, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xC0, 0x03,
  0xF8, 0x00, 0x10, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0,
  0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x0F, 0xF0, 0x01, 0xF8,
  0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xF0, 0x3F, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x0F, 0xFC, 0x01, 0xFE, 0x7F, 0xC0, 0x03,
  0xF9, 0xFE, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x1F,
  0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xF9, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFF, 0x0F, 0xE0,
  0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xEF, 0x80, 0xFF, 0xFF,
  0x3E, 0x01, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0x87, 0xE0, 0x00, 0x70, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3F,
  0x80, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F,
  0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xE3, 0xF8, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x07, 0x80, 0xF8, 0x0F, 0xFC,
  0x1E, 0x07, 0xC0, 0xFF, 0xF8, 0x78, 0x1E, 0x07, 0xFF, 0xE0, 0xE0, 0xF8,
  0x3F, 0x87, 0x83, 0x83, 0xC0, 0xF8, 0x1E, 0x0E, 0x1F, 0x07, 0xC0, 0x70,
  0x38, 0x78, 0x1E, 0x03, 0xC0, 0xE1, 0xE0, 0xF8, 0x0F, 0x03, 0x8F, 0x83,
  0xC0, 0x3C, 0x0E, 0x3C, 0x1F, 0x00, 0xE0, 0x38, 0xF0, 0x78, 0x07, 0x80,
  0xE7, 0xC1, 0xE0, 0x1E, 0x07, 0x9E, 0x0F, 0x80, 0x78, 0x1E, 0x78, 0x3C,
  0x01, 0xC0, 0x79, 0xE0, 0xF0, 0x0F, 0x01, 0xC7, 0x83, 0xC0, 0x3C, 0x07,
  0x1E, 0x0F, 0x00, 0xF0, 0x1C, 0xF8, 0x3C, 0x03, 0x80, 0xF3, 0xC1, 0xF0,
  0x1E, 0x03, 0x8F, 0x07, 0xC0, 0x78, 0x0E, 0x3C, 0x0F, 0x03, 0xE0, 0x78,
  0xF0, 0x3C, 0x1F, 0x83, 0xC3, 0xC0, 0xF9, 0xFE, 0x1E, 0x0F, 0x03, 0xFF,
  0xFF, 0xF8, 0x1E, 0x0F, 0xFC, 0xFF, 0xC0, 0x78, 0x1F, 0xE3, 0xFE, 0x01,
  0xE0, 0x3E, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x80, 0x00, 0x0F, 0xF0, 0x1E,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0x80,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7E,
  0x00, 0x07, 0xFC, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xFF,
  0x80, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x1F,
  0x80, 0x0F, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x03, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0xFC,
  0x7E, 0x00, 0x3F, 0xFF, 0xCF, 0xE0, 0x03, 0xFF, 0xFC, 0xFC, 0x00, 0x3F,
  0xFF, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x00, 0x7F,
  0x80, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x1F,
  0x80, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x7F,
  0x80, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0x01, 0xF8, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xBF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xDF, 0xC0, 0x00, 0x00, 0xFF, 0xC7, 0xF0, 0x00, 0x00, 0xFF, 0xC3, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0xFC, 0x01, 0xF7, 0xC0, 0x3E,
  0xFC, 0x03, 0xF7, 0xC0, 0x7E, 0xFC, 0x03, 0xF7, 0xC0, 0x7C, 0xF8, 0x03,
  0xF7, 0xC0, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0xF9, 0xF8, 0x03, 0xE3, 0xE1,
  0xF9, 0xF8, 0x03, 0xE3, 0xE1, 0xF1, 0xF8, 0x07, 0xE3, 0xE3, 0xF1, 0xF8,
  0x07, 0xE3, 0xE3, 0xE1, 0xF0, 0x07, 0xE3, 0xE7, 0xE3, 0xF0, 0x07, 0xE3,
  0xE7, 0xC3, 0xF0, 0x07, 0xE1, 0xFF, 0xC3, 0xF0, 0x07, 0xC1, 0xFF, 0x83,
  0xF0, 0x0F, 0xC1, 0xFF, 0x83, 0xF0, 0x0F, 0xC1, 0xFF, 0x03, 0xE0, 0x0F,
  0xC1, 0xFF, 0x07, 0xE0, 0x0F, 0xC1, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xFE,
  0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0xFC,
  0x01, 0xFF, 0x80, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x01,
  0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x03,
  0xF3, 0xF0, 0x01, 0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0x03, 0xF3, 0xF0,
  0x03, 0xF8, 0x03, 0xF1, 0xF0, 0x03, 0xF0, 0x07, 0xF1, 0xF8, 0x03, 0xF0,
  0x07, 0xF1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x7C, 0x07,
  0xE0, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x0F,
  0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x1F, 0x80,
  0x0F, 0xDF, 0xC0, 0x1F, 0x80, 0x0F, 0xDF, 0xC0, 0x3F, 0x80, 0x07, 0xDF,
  0x80, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0x00, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0x00, 0x03,
  0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00,
  0x7E, 0x00, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x7E, 0x00,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x00, 0xFF,
  0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFE, 0x03,
  0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0x03, 0xF3, 0xF0,
  0x0F, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x80, 0x7E, 0x3E, 0x00, 0xFE, 0x01,
  0xF8, 0xF8, 0x07, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0xE0, 0x1F, 0x0F, 0x80,
  0x7F, 0x80, 0xFC, 0x3E, 0x03, 0xFE, 0x03, 0xF0, 0xF8, 0x0F, 0xF8, 0x0F,
  0xC3, 0xE0, 0x3F, 0xE0, 0x3E, 0x1F, 0x80, 0xFF, 0x81, 0xF8, 0x7E, 0x07,
  0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0xE0, 0x7F, 0xE0, 0x7C,
  0x1F, 0x83, 0xEF, 0x83, 0xF0, 0x7E, 0x0F, 0xBE, 0x0F, 0xC1, 0xF8, 0x3E,
  0xF8, 0x3E, 0x07, 0xE1, 0xF3, 0xE0, 0xF8, 0x1F, 0x87, 0xCF, 0x87, 0xE0,
  0x7E, 0x1F, 0x3E, 0x1F, 0x81, 0xF0, 0xF8, 0xF8, 0x7C, 0x07, 0xC3, 0xE3,
  0xE1, 0xF0, 0x1F, 0x0F, 0x8F, 0x8F, 0xC0, 0x7C, 0x7C, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0xF8, 0xF8, 0x07, 0xC7, 0xC3, 0xE7, 0xE0, 0x1F, 0x3E, 0x0F,
  0x9F, 0x80, 0x7C, 0xF8, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0xF9, 0xF0, 0x07,
  0xDF, 0x03, 0xEF, 0xC0, 0x1F, 0x7C, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x3E,
  0xF8, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F,
  0x1F, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE,
  0x00, 0x1F, 0x9F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x0F, 0xC1,
  0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x03, 0xF0,
  0x0F, 0x81, 0xF8, 0x07, 0xC1, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x00,
  0x1F, 0xF8, 0x7F, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFD, 0xF8, 0x1F, 0xFF, 0xFB, 0xF8, 0x0F, 0xFF, 0xE3, 0xF8, 0x03, 0xFF,
  0x81, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0xFF, 0x00, 0x03, 0xF1, 0xFF, 0xF0, 0x00, 0xFC, 0xFF, 0xFE, 0x00, 0x3F,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0xC0, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0xE0, 0x1F, 0xBF,
  0xFF, 0xF0, 0x0F, 0xC3, 0xFF, 0xF8, 0x03, 0xF0, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x04,
  0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x81, 0xF8,
  0x00, 0x3F, 0xFE, 0x1F, 0x80, 0x07, 0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xBE, 0x00, 0x07, 0xFF, 0xE3,
  0xE0, 0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x07,
  0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x80, 0x00, 0x3E, 0x3F,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x7F, 0x00, 0x01, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0x80, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0xFC, 0x00, 0xFF, 0xFF, 0x9F,
  0x80, 0x3F, 0xFF, 0xFB, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFB, 0xE0, 0x00, 0xFF, 0xFC, 0xFC,
  0x00, 0x07, 0xFF, 0x1F, 0x80, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x04, 0x00,
  0x00, 0xFE, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x7F, 0x80, 0x03, 0xF0, 0x7F, 0xF8, 0x00, 0xFC, 0x7F, 0xFF, 0x00,
  0x3F, 0x3F, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xFC, 0x03, 0xEF, 0xC1, 0xFF,
  0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x03, 0xE3, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x03, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x03, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x0F, 0xF0, 0x00, 0x7E, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x3F, 0xC0, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x07,
  0xE1, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0xE0, 0x00, 0x0F, 0xC7, 0xF8, 0x00,
  0x00, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0x80, 0x00, 0x1F, 0xF1, 0xFC, 0x00,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0x9F, 0xF8, 0xFF, 0xC0, 0x7E, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0x87, 0xF0, 0x7F,
  0x03, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x03,
  0xF1, 0xF8, 0x03, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x80, 0x3E, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x1F,
  0x87, 0xC0, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0xFC, 0x03,
  0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0xFC, 0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x80, 0x3E, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x7C,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x07, 0xC3, 0xF0, 0x0F, 0xC0, 0x1F, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0x3F,
  0x1F, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0xF8, 0x03, 0xEF, 0xFF, 0xFF, 0x00,
  0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x8F,
  0xFF, 0x80, 0x03, 0xF3, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x1F,
  0xF0, 0x1F, 0xFF, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0xFF,
  0xFF, 0xC0, 0x1F, 0xCF, 0xFF, 0xE0, 0x03, 0xF8, 0x7F, 0xF8, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x0F, 0xC0, 0x1F, 0xFF,
  0xE7, 0xE0, 0x3F, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x7F,
  0xE0, 0x1F, 0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0xF8, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0xFC, 0x7E, 0x00, 0x01, 0xE0,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xC3, 0xFF, 0xF0, 0x1F, 0x9F, 0xFF, 0xE0,
  0x3F, 0x7F, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x06, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x20, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0x7E,
  0x00, 0x3F, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xE7, 0xC0, 0x0F, 0xFF, 0x87, 0xC0, 0x07,
  0xFF, 0x07, 0xC0, 0x00, 0x70, 0x08, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0xFD, 0xF0, 0x03, 0xE0, 0x03, 0xE7, 0xC0, 0x0F,
  0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0x01, 0xF1,
  0xF0, 0x07, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x80, 0x3E, 0x1F, 0x00, 0xFF,
  0x00, 0xF8, 0x7C, 0x07, 0xFC, 0x07, 0xC1, 0xF0, 0x1E, 0xF0, 0x1F, 0x07,
  0xC0, 0xFB, 0xC0, 0x7C, 0x1F, 0x03, 0xEF, 0x03, 0xE0, 0x7C, 0x0F, 0x3C,
  0x0F, 0x81, 0xF0, 0x7C, 0xF0, 0x3E, 0x07, 0xC1, 0xE3, 0xC1, 0xF0, 0x1F,
  0x0F, 0x8F, 0x07, 0xC0, 0x7C, 0x3E, 0x3C, 0x1E, 0x01, 0xF0, 0xF0, 0xF0,
  0xF8, 0x07, 0xC7, 0xC3, 0xC3, 0xE0, 0x1F, 0x1E, 0x0F, 0x1F, 0x00, 0x7C,
  0xF8, 0x3C, 0x7C, 0x01, 0xF3, 0xE0, 0xF1, 0xF0, 0x07, 0xDF, 0x03, 0xEF,
  0x80, 0x1F, 0x7C, 0x0F, 0xBE, 0x00, 0x7D, 0xE0, 0x3E, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x03,
  0xF3, 0xF8, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0x1F,
  0xCF, 0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xC7, 0xFF,
  0xFC, 0x00, 0x1F, 0x3F, 0xFF, 0xF8, 0x00, 0x7C, 0xFF, 0x7F, 0xF0, 0x03,
  0xE7, 0xE0, 0x3F, 0xE0, 0x1F, 0x9F, 0x00, 0x3F, 0xE0, 0xFC, 0xFC, 0x00,
  0x7F, 0xFF, 0xF3, 0xE0, 0x00, 0xFF, 0xFF, 0x8F, 0x80, 0x01, 0xFF, 0xFC,
  0x04, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x40, 0x00,
};

const GFXglyph RobotoMono_Italic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 15, 49, 41, 13, -49 },
  { 93, 19, 16, 41, 14, -52 },
  { 131, 40, 49, 41, 1, -49 },
  { 376, 34, 64, 41, 4, -57 },
  { 648, 33, 51, 41, 4, -50 },
  { 859, 36, 51, 41, 2, -50 },
  { 1089, 7, 16, 41, 19, -52 },
  { 1103, 23, 71, 41, 11, -55 },
  { 1308, 23, 71, 41, 5, -55 },
  { 1513, 32, 33, 41, 7, -49 },
  { 1645, 34, 36, 41, 4, -41 },
  { 1798, 12, 18, 41, 7, -7 },
  { 1825, 26, 5, 41, 7, -24 },
  { 1842, 10, 10, 41, 13, -9 },
  { 1855, 35, 53, 41, 4, -49 },
  { 2087, 34, 51, 41, 4, -50 },
  { 2304, 21, 49, 41, 9, -49 },
  { 2433, 35, 50, 41, 0, -50 },
  { 2652, 34, 51, 41, 2, -50 },
  { 2869, 35, 49, 41, 1, -49 },
  { 3084, 35, 50, 41, 5, -49 },
  { 3303, 30, 50, 41, 4, -49 },
  { 3491, 34, 49, 41, 6, -49 },
  { 3700, 34, 51, 41, 4, -50 },
  { 3917, 30, 50, 41, 7, -50 },
  { 4105, 15, 40, 41, 15, -39 },
  { 4180, 18, 50, 41, 11, -39 },
  { 4293, 31, 30, 41, 5, -37 },
  { 4410, 33, 20, 41, 4, -32 },
  { 4493, 32, 31, 41, 3, -37 },
  { 4617, 28, 50, 41, 9, -50 },
  { 4792, 38, 49, 41, 2, -49 },
  { 5025, 36, 49, 41, -1, -49 },
  { 5246, 36, 49, 41, 2, -49 },
  { 5467, 36, 51, 41, 3, -50 },
  { 5697, 37, 49, 41, 2, -49 },
  { 5924, 38, 49, 41, 2, -49 },
  { 6157, 38, 49, 41, 3, -49 },
  { 6390, 36, 51, 41, 3, -50 },
  { 6620, 40, 49, 41, 1, -49 },
  { 6865, 37, 49, 41, 2, -49 },
  { 7092, 37, 50, 41, 2, -49 },
  { 7324, 41, 49, 41, 2, -49 },
  { 7576, 30, 49, 41, 3, -49 },
  { 7760, 40, 49, 41, 1, -49 },
  { 8005, 40, 49, 41, 1, -49 },
  { 8250, 35, 51, 41, 3, -50 },
  { 8474, 37, 49, 41, 3, -49 },
  { 8701, 36, 58, 41, 3, -50 },
  { 8962, 37, 49, 41, 2, -49 },
  { 9189, 36, 51, 41, 3, -50 },
  { 9419, 36, 49, 41, 7, -49 },
  { 9640, 38, 50, 41, 3, -49 },
  { 9878, 35, 49, 41, 7, -49 },
  { 10093, 38, 49, 41, 5, -49 },
  { 10326, 44, 49, 41, -1, -49 },
  { 10596, 36, 49, 41, 7, -49 },
  { 10817, 38, 49, 41, 1, -49 },
  { 11050, 24, 67, 41, 9, -56 },
  { 11251, 16, 53, 41, 13, -49 },
  { 11357, 24, 67, 41, 8, -56 },
  { 11558, 25, 26, 41, 8, -49 },
  { 11640, 31, 5, 41, 1, 0 },
  { 11660, 12, 9, 41, 18, -50 },
  { 11674, 32, 38, 41, 3, -37 },
  { 11826, 34, 53, 41, 2, -52 },
  { 12052, 32, 38, 41, 4, -37 },
  { 12204, 36, 53, 41, 4, -52 },
  { 12443, 32, 38, 41, 4, -37 },
  { 12595, 35, 53, 41, 7, -53 },
  { 12827, 35, 51, 41, 2, -37 },
  { 13051, 34, 52, 41, 2, -52 },
  { 13272, 31, 50, 41, 3, -50 },
  { 13466, 31, 65, 41, 1, -50 },
  { 13718, 36, 52, 41, 2, -52 },
  { 13952, 31, 52, 41, 3, -52 },
  { 14154, 38, 37, 41, 0, -37 },
  { 14330, 34, 37, 41, 2, -37 },
  { 14488, 33, 38, 41, 3, -37 },
  { 14645, 35, 51, 41, 0, -37 },
  { 14869, 33, 51, 41, 4, -37 },
  { 15080, 31, 37, 41, 7, -37 },
  { 15224, 32, 38, 41, 4, -37 },
  { 15376, 29, 46, 41, 7, -45 },
  { 15543, 32, 37, 41, 5, -36 },
  { 15691, 33, 36, 41, 6, -36 },
  { 15840, 38, 36, 41, 4, -36 },
  { 16011, 40, 36, 41, 0, -36 },
  { 16191, 42, 51, 41, -1, -36 },
  { 16459, 35, 36, 41, 2, -36 },
  { 16617, 27, 66, 41, 10, -54 },
  { 16840, 15, 62, 41, 12, -49 },
  { 16957, 27, 66, 41, 6, -54 },
  { 17180, 38, 14, 41, 1, -27 },
};

const GFXfont RobotoMono_Italic69pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic69pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _ROBOTOMONO_ITALIC69PT7B_H_
